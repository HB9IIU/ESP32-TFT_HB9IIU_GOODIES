#ifndef _NOTOSANS_SEMICONDENSED_BOLD43PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xE7, 0xC0, 0x00, 0x00, 0x18, 0xFF,
  0xFF, 0xFF, 0xEF, 0xDF, 0x88, 0xFE, 0x3F, 0xFC, 0x3F, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0,
  0x01, 0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0,
  0x03, 0xC3, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xC7, 0xC0, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x0F, 0x8F, 0x80,
  0x0F, 0x8F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x7F, 0xF8,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0x9C, 0x33,
  0xF3, 0x80, 0x7E, 0x70, 0x0F, 0xCE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x01, 0xDF, 0xC0, 0x39, 0xF8, 0x07, 0x3F, 0x80, 0xE7, 0xFC,
  0x1D, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE, 0x07,
  0xFE, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xF8, 0x00, 0xF8, 0x03, 0xFF,
  0x00, 0x7C, 0x01, 0xFF, 0xE0, 0x1F, 0x00, 0x7C, 0xF8, 0x0F, 0x80, 0x1F,
  0x1F, 0x03, 0xE0, 0x0F, 0x87, 0xC1, 0xF0, 0x03, 0xE1, 0xF0, 0x7C, 0x00,
  0xF8, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC7, 0xC0,
  0x03, 0xE1, 0xF1, 0xF0, 0x00, 0x78, 0x7C, 0xF8, 0x7C, 0x1F, 0x1F, 0x3E,
  0x7F, 0x87, 0xCF, 0x9F, 0x3F, 0xF1, 0xFF, 0xE7, 0xCF, 0xFE, 0x3F, 0xF3,
  0xE7, 0xEF, 0xC7, 0xF8, 0xF9, 0xF1, 0xF0, 0xFC, 0x7C, 0x7C, 0x7C, 0x00,
  0x1F, 0x1F, 0x1F, 0x00, 0x07, 0x87, 0xC3, 0xC0, 0x03, 0xE1, 0xF0, 0xF0,
  0x00, 0xF0, 0x7C, 0x3C, 0x00, 0x7C, 0x1F, 0x1F, 0x00, 0x1E, 0x07, 0xC7,
  0xC0, 0x0F, 0x81, 0xF1, 0xF0, 0x03, 0xC0, 0x7C, 0x7C, 0x01, 0xF0, 0x0F,
  0xFE, 0x00, 0x78, 0x03, 0xFF, 0x80, 0x3E, 0x00, 0x7F, 0xC0, 0x1F, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x7E, 0x1F, 0xFE,
  0x0F, 0xE3, 0xFF, 0xF0, 0xFC, 0x7F, 0x3F, 0x8F, 0xC7, 0xF1, 0xFD, 0xFC,
  0x7E, 0x1F, 0xFF, 0x8F, 0xE0, 0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0x0F, 0xE0,
  0x3F, 0xF0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFD, 0xFE, 0x07,
  0xFF, 0x0F, 0xF0, 0xFF, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF0, 0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0,
  0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F,
  0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0,
  0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E,
  0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x83,
  0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x04,
  0x0F, 0x02, 0x78, 0xF1, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xBF,
  0x01, 0xF9, 0xF8, 0x3F, 0x0F, 0xC0, 0xF0, 0xF0, 0x06, 0x06, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x78, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x18, 0xFF, 0xFF, 0xFF, 0xEF,
  0xDF, 0x88, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xF8, 0xFE, 0x3F,
  0x07, 0xE7, 0xF0, 0x7E, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7,
  0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03,
  0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x7E, 0x3F, 0x07, 0xE3, 0xF8,
  0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x03,
  0xFE, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1,
  0xFF, 0xC7, 0xFF, 0xBF, 0xFF, 0xFF, 0x7E, 0xF8, 0xFC, 0xE1, 0xF8, 0x83,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE3, 0xF0, 0xFE, 0x3C, 0x07, 0xE1, 0x80, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xC3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0xF0, 0x3F, 0x88, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xEF, 0xC0, 0x1F, 0x7E, 0x00,
  0xF3, 0xF0, 0x0F, 0x9F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x7C, 0x3F,
  0x03, 0xE1, 0xF8, 0x3E, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x03, 0xF1, 0xF0,
  0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF1,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x70, 0x07,
  0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xDC, 0x03, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC3, 0xE0, 0x7C, 0xFF, 0x87, 0xDF, 0xFC, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x7E,
  0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x03, 0xF3,
  0xF8, 0x7F, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xF0, 0x7E,
  0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x7E, 0x03, 0xE3, 0xF0, 0x7E, 0x3F, 0x07,
  0xE3, 0xFD, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x9F, 0xE7, 0xF0, 0x7F, 0x7E,
  0x03, 0xF7, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xF7,
  0xE0, 0x3F, 0x7F, 0x8F, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7E, 0x07, 0xE7, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xF7,
  0xE0, 0x7F, 0x7F, 0x07, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xDF,
  0x1F, 0xFB, 0xF0, 0xFF, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0xFF, 0x83, 0xFF,
  0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x3C, 0xFF, 0xFF,
  0xFF, 0xEF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x31, 0xFB, 0xFF, 0xFF, 0xDF, 0xBF, 0x10, 0x1E, 0x3F, 0x3F, 0x7F, 0x7F,
  0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x78,
  0xF8, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0xF0, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00,
  0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F,
  0x07, 0xF2, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x02, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x03, 0xF8, 0x3E,
  0x3E, 0x0F, 0xFF, 0x3E, 0x7C, 0x1F, 0xFF, 0x1E, 0x7C, 0x3F, 0xFE, 0x1F,
  0x78, 0x7E, 0x1E, 0x1F, 0xF8, 0x7C, 0x1E, 0x1F, 0xF8, 0xF8, 0x1E, 0x0F,
  0xF8, 0xF8, 0x1E, 0x0F, 0xF0, 0xF8, 0x1E, 0x1F, 0xF0, 0xF8, 0x1E, 0x1F,
  0xF0, 0xF8, 0x3E, 0x1F, 0xF0, 0xF8, 0x3E, 0x1E, 0xF8, 0xF8, 0x3E, 0x1E,
  0xF8, 0xF8, 0x7E, 0x3E, 0xF8, 0x7F, 0xFF, 0xFC, 0xF8, 0x7F, 0xFF, 0xFC,
  0x7C, 0x3F, 0xE7, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0x7E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x80,
  0x0F, 0xFE, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F,
  0x3E, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0,
  0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7F, 0x3F,
  0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x7F, 0x0F, 0xFB, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFD, 0xFC, 0x0F, 0xEF, 0xE1, 0xFE, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xBF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7F, 0xC3, 0xE3, 0xFC, 0x01, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x08, 0xFF, 0x80, 0xE1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFE, 0x07, 0xFC, 0xFE, 0x01,
  0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01,
  0xFC, 0xFE, 0x07, 0xF8, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0x07, 0x8F, 0xF8, 0x01, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFB, 0xF0, 0x03, 0xF7,
  0xE0, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0xC0, 0x3F, 0x3F,
  0x80, 0x7E, 0x7F, 0xC0, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x0F, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xA3, 0xFD, 0xFF, 0xEF, 0xFE, 0x7F, 0xE3, 0xFE, 0x1F, 0xC0, 0xFC, 0x01,
  0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0xBF, 0x01, 0xFC, 0xFC, 0x0F, 0xE3,
  0xF0, 0x3F, 0x8F, 0xC1, 0xFC, 0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x83, 0xF1,
  0xFC, 0x0F, 0xCF, 0xE0, 0x3F, 0x7F, 0x00, 0xFD, 0xFC, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFC, 0x7F, 0x03, 0xF0, 0xFE, 0x0F, 0xC1,
  0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0x7F,
  0x3F, 0x01, 0xFC, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xC0,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0x7F, 0xEF, 0x80, 0x7D, 0xFF,
  0xBE, 0x01, 0xF7, 0xFE, 0xF8, 0x0F, 0x9F, 0xFB, 0xF0, 0x3E, 0x7F, 0xE7,
  0xC0, 0xFB, 0xFF, 0x9F, 0x07, 0xCF, 0xFE, 0x7C, 0x1F, 0x3F, 0xF8, 0xF8,
  0x7C, 0xFF, 0xE3, 0xE3, 0xE3, 0xFF, 0x8F, 0x8F, 0x8F, 0xFE, 0x1F, 0x3E,
  0x3F, 0xF8, 0x7C, 0xF8, 0xFF, 0xE1, 0xF7, 0xC3, 0xFF, 0x87, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0xFF, 0xE0, 0xFF, 0x83, 0xFF,
  0x81, 0xFE, 0x0F, 0xFE, 0x07, 0xF0, 0x3F, 0xF8, 0x1F, 0xC0, 0xFF, 0xE0,
  0x7F, 0x03, 0xFF, 0x80, 0xF8, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFD,
  0xF8, 0x0F, 0xFE, 0xFE, 0x07, 0xFF, 0x3F, 0x03, 0xFF, 0x9F, 0xC1, 0xFF,
  0xC7, 0xE0, 0xFF, 0xE3, 0xF8, 0x7F, 0xF0, 0xFC, 0x3F, 0xF8, 0x7F, 0x1F,
  0xFC, 0x1F, 0x8F, 0xFE, 0x0F, 0xE7, 0xFF, 0x03, 0xF3, 0xFF, 0x81, 0xFD,
  0xFF, 0xC0, 0x7E, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0,
  0x07, 0xF3, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xFC, 0x1F, 0xF0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC,
  0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFE, 0x00,
  0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87,
  0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xC7,
  0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x03, 0xF1, 0xFC, 0x07,
  0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC1, 0xFC,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xE3, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F,
  0x87, 0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0xE3, 0xF8,
  0x1F, 0xC7, 0xF0, 0x1F, 0xCF, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F, 0xBF, 0x80,
  0x3F, 0x80, 0x03, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F,
  0xFF, 0x9F, 0xE7, 0xEF, 0xE0, 0x13, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xBF, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0xFF, 0x03,
  0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xE7, 0xE0,
  0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x1F,
  0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x01,
  0xF8, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xE0,
  0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xDF,
  0x80, 0x7F, 0x80, 0x7F, 0x7E, 0x01, 0xFE, 0x01, 0xF9, 0xF8, 0x07, 0xF8,
  0x07, 0xE7, 0xE0, 0x1F, 0xE0, 0x1F, 0x8F, 0xC0, 0xFF, 0xC0, 0x7E, 0x3F,
  0x03, 0xFF, 0x03, 0xF0, 0xFC, 0x0F, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0xF0,
  0x3F, 0x0F, 0xC0, 0xF3, 0xE0, 0xFC, 0x1F, 0x87, 0xCF, 0x87, 0xE0, 0x7E,
  0x1F, 0x3E, 0x1F, 0x81, 0xF8, 0x7C, 0xF8, 0x7E, 0x07, 0xE1, 0xF3, 0xE1,
  0xF8, 0x0F, 0x8F, 0xC7, 0xC7, 0xE0, 0x3F, 0x3E, 0x1F, 0x3F, 0x00, 0xFC,
  0xF8, 0x7C, 0xFC, 0x03, 0xF3, 0xE1, 0xF3, 0xF0, 0x07, 0xDF, 0x83, 0xEF,
  0xC0, 0x1F, 0x7C, 0x0F, 0xBE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0x80,
  0x1F, 0x8F, 0xE0, 0x07, 0xF3, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFD, 0xFC,
  0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xC1, 0xFC, 0x07, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F,
  0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x3F,
  0x9F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xF1,
  0xF8, 0x01, 0xF9, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E,
  0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xBE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x0F, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x03, 0xFC, 0x03, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x38, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7, 0xDF,
  0xFC, 0xF8, 0xFE, 0x1F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0xFC, 0xFF, 0x0F, 0xDF, 0xF8, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xF0, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0x9F, 0xF8,
  0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF3,
  0xFF, 0xF3, 0xFC, 0x39, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x6F, 0xFF, 0xF3, 0xFF, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x3F, 0x0F, 0xF3, 0xF1, 0xFF, 0xBF,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x8F, 0xF7, 0xE0, 0x7F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1,
  0xFF, 0x9F, 0x0F, 0xF1, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF0, 0x7E, 0x7E, 0x07, 0xEF, 0xE0,
  0x3E, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x47, 0xFC, 0x7C, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFE, 0x1F, 0xFE, 0x1F, 0xC2, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x07,
  0xE1, 0xF0, 0xFF, 0x1F, 0x1F, 0xF9, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7,
  0xF0, 0xFF, 0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x7F, 0x07, 0xF7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFB, 0xF0, 0xFF, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x70, 0x0F, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x01, 0xFF, 0xC0,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC3,
  0xE0, 0xFC, 0xFF, 0x8F, 0xDF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0x8F, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x33,
  0xFF, 0xFF, 0xFF, 0xF3, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0x60, 0x00, 0x00,
  0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xDF, 0xF3, 0xFC, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x2F, 0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xE3,
  0xF0, 0x7F, 0x0F, 0xC3, 0xF8, 0x3F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF3,
  0xF0, 0x0F, 0xDF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFE, 0x7F, 0x03, 0xF0, 0xFE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7F, 0x3F, 0x00, 0xFE, 0xFC, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x7E, 0x03, 0xF0,
  0x7C, 0xFF, 0xC3, 0xFE, 0x3E, 0xFF, 0xF7, 0xFF, 0x9F, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xF8, 0xFF, 0xE3, 0xFB, 0xF8, 0x3F, 0xC0,
  0xFD, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x07, 0xF0, 0x3F, 0xFE, 0x03, 0xF0,
  0x1F, 0xFF, 0x01, 0xF8, 0x0F, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0xC0, 0x7E,
  0x03, 0xFF, 0xE0, 0x3F, 0x01, 0xFF, 0xF0, 0x1F, 0x80, 0xFF, 0xF8, 0x0F,
  0xC0, 0x7F, 0xFC, 0x07, 0xE0, 0x3F, 0xFE, 0x03, 0xF0, 0x1F, 0xFF, 0x01,
  0xF8, 0x0F, 0xFF, 0x80, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0x03, 0xFF, 0xE0,
  0x3F, 0x01, 0xFF, 0xF0, 0x1F, 0x80, 0xFF, 0xF8, 0x0F, 0xC0, 0x7F, 0xF8,
  0x7E, 0x0F, 0x8F, 0xF8, 0xF9, 0xFF, 0xCF, 0xBF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xF8, 0xFE, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE,
  0x3F, 0x87, 0xF1, 0xF8, 0x1F, 0xDF, 0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0xC1,
  0xFC, 0x7F, 0xBF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x7F, 0xC0, 0xF8, 0x7E, 0x0F, 0x8F, 0xF0, 0xF9, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xEF, 0xF0, 0xFE, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFD, 0xFF, 0x8F,
  0xCF, 0xF0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0xFF, 0x9F, 0x1F, 0xFD, 0xF3, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xF8, 0xFF, 0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0x7F, 0x07, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFB,
  0xF0, 0xFF, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x3F, 0xE3, 0xFF, 0x9F, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xF0,
  0x3F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x0C, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F,
  0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xE0, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xBF, 0x3F, 0xF9,
  0xF1, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xDF,
  0x80, 0x7E, 0x7F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xC0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xF1, 0xF8,
  0x0F, 0xC7, 0xC0, 0x3F, 0x3F, 0x00, 0x7C, 0xFC, 0x01, 0xFB, 0xE0, 0x07,
  0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x07, 0xF8,
  0x1F, 0xDF, 0x81, 0xFE, 0x07, 0xE7, 0xE0, 0x7F, 0x81, 0xF9, 0xF8, 0x1F,
  0xE0, 0x7E, 0x3F, 0x0F, 0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0x0F, 0xC3, 0xF0,
  0xF7, 0xC3, 0xF0, 0xFC, 0x3C, 0xF0, 0xFC, 0x1F, 0x8F, 0x3C, 0x7E, 0x07,
  0xE7, 0xCF, 0x9F, 0x81, 0xF9, 0xF3, 0xE7, 0xE0, 0x7E, 0x78, 0x79, 0xF8,
  0x0F, 0x9E, 0x1E, 0x7C, 0x03, 0xF7, 0x87, 0xBF, 0x00, 0xFF, 0xE1, 0xEF,
  0xC0, 0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0x01, 0xFC, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x1F, 0xCF,
  0xE0, 0x3F, 0xBF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x3F,
  0x81, 0xF8, 0x7F, 0x0F, 0xE0, 0xFC, 0x3F, 0x03, 0xF9, 0xFC, 0x07, 0xEF,
  0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF,
  0x80, 0x7E, 0x7F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8,
  0x0F, 0xC7, 0xC0, 0x1F, 0x3F, 0x00, 0x7E, 0xFC, 0x01, 0xFB, 0xE0, 0x03,
  0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F,
  0xE0, 0x3F, 0x80, 0xFF, 0x83, 0xFF, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xE0, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x03, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0x3F, 0xC0, 0xFF, 0x0F, 0xFC, 0x3F, 0xE1,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFE, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x2F, 0xF8, 0x07, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x0F, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Bold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 32, 12, 2, -31 },
  { 29, 16, 11, 20, 2, -31 },
  { 51, 24, 31, 26, 1, -31 },
  { 144, 19, 36, 23, 2, -33 },
  { 230, 34, 31, 37, 1, -31 },
  { 362, 28, 31, 29, 1, -31 },
  { 471, 7, 11, 11, 2, -31 },
  { 481, 11, 38, 14, 2, -31 },
  { 534, 11, 38, 14, 1, -31 },
  { 587, 20, 19, 22, 1, -33 },
  { 635, 19, 21, 23, 2, -26 },
  { 685, 8, 11, 12, 1, -5 },
  { 696, 11, 5, 14, 1, -14 },
  { 703, 7, 8, 12, 2, -7 },
  { 710, 17, 31, 18, 0, -31 },
  { 776, 20, 31, 23, 1, -31 },
  { 854, 15, 31, 23, 2, -31 },
  { 913, 20, 31, 23, 1, -31 },
  { 991, 19, 31, 23, 2, -31 },
  { 1065, 21, 31, 23, 1, -31 },
  { 1147, 19, 31, 23, 2, -31 },
  { 1221, 20, 31, 23, 1, -31 },
  { 1299, 20, 31, 23, 1, -31 },
  { 1377, 20, 31, 23, 1, -31 },
  { 1455, 20, 31, 23, 1, -31 },
  { 1533, 7, 25, 12, 2, -24 },
  { 1555, 8, 30, 12, 1, -24 },
  { 1585, 19, 21, 23, 2, -26 },
  { 1635, 19, 13, 23, 2, -22 },
  { 1666, 19, 21, 23, 2, -26 },
  { 1716, 18, 32, 19, 0, -31 },
  { 1788, 32, 34, 36, 2, -31 },
  { 1924, 27, 31, 27, 0, -31 },
  { 2029, 21, 31, 26, 3, -31 },
  { 2111, 22, 31, 25, 2, -31 },
  { 2197, 24, 31, 29, 3, -31 },
  { 2290, 16, 31, 22, 4, -31 },
  { 2352, 16, 31, 22, 4, -31 },
  { 2414, 23, 31, 29, 2, -31 },
  { 2504, 23, 31, 30, 4, -31 },
  { 2594, 13, 31, 16, 1, -31 },
  { 2645, 13, 40, 13, -3, -31 },
  { 2710, 22, 31, 26, 4, -31 },
  { 2796, 18, 31, 22, 3, -31 },
  { 2866, 30, 31, 38, 4, -31 },
  { 2983, 25, 31, 32, 4, -31 },
  { 3080, 27, 31, 31, 2, -31 },
  { 3185, 20, 31, 25, 3, -31 },
  { 3263, 27, 38, 31, 2, -31 },
  { 3392, 23, 31, 26, 3, -31 },
  { 3482, 18, 31, 22, 2, -31 },
  { 3552, 21, 31, 22, 1, -31 },
  { 3634, 23, 31, 30, 3, -31 },
  { 3724, 26, 31, 26, 0, -31 },
  { 3825, 38, 31, 38, 0, -31 },
  { 3973, 26, 31, 26, 0, -31 },
  { 4074, 25, 31, 25, 0, -31 },
  { 4171, 20, 31, 22, 1, -31 },
  { 4249, 10, 38, 14, 3, -31 },
  { 4297, 17, 31, 18, 0, -31 },
  { 4363, 10, 38, 14, 1, -31 },
  { 4411, 22, 20, 24, 1, -31 },
  { 4466, 18, 3, 18, 0, 4 },
  { 4473, 11, 7, 15, 2, -33 },
  { 4483, 19, 24, 24, 2, -24 },
  { 4540, 20, 33, 25, 3, -33 },
  { 4623, 17, 24, 20, 2, -24 },
  { 4674, 20, 33, 25, 2, -33 },
  { 4757, 20, 24, 23, 2, -24 },
  { 4817, 16, 33, 15, 1, -33 },
  { 4883, 20, 34, 25, 2, -24 },
  { 4968, 20, 33, 26, 3, -33 },
  { 5051, 6, 33, 12, 3, -33 },
  { 5076, 11, 43, 12, -2, -33 },
  { 5136, 22, 33, 25, 3, -33 },
  { 5227, 6, 33, 12, 3, -33 },
  { 5252, 33, 24, 38, 3, -24 },
  { 5351, 20, 24, 26, 3, -24 },
  { 5411, 21, 24, 25, 2, -24 },
  { 5474, 20, 34, 25, 3, -24 },
  { 5559, 20, 34, 25, 2, -24 },
  { 5644, 14, 24, 18, 3, -24 },
  { 5686, 16, 24, 20, 2, -24 },
  { 5734, 15, 28, 17, 1, -28 },
  { 5787, 20, 24, 26, 3, -24 },
  { 5847, 22, 24, 23, 0, -24 },
  { 5913, 34, 23, 34, 0, -23 },
  { 6011, 22, 23, 22, 0, -23 },
  { 6075, 22, 34, 23, 0, -24 },
  { 6169, 17, 24, 19, 1, -24 },
  { 6220, 14, 38, 16, 1, -31 },
  { 6287, 4, 43, 22, 9, -33 },
  { 6309, 14, 38, 16, 2, -31 },
  { 6376, 19, 7, 23, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_Bold43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold43pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD43PT7B_H_
