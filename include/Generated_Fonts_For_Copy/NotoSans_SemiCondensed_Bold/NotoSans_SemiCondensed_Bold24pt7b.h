#ifndef _NOTOSANS_SEMICONDENSED_BOLD24PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x77, 0x77, 0x77, 0x70, 0x02, 0xFF, 0x70, 0xF7, 0xF9,
  0xDC, 0xEE, 0x76, 0x3B, 0x18, 0x0E, 0x60, 0x67, 0x03, 0x38, 0x39, 0x81,
  0xCC, 0x7F, 0xFF, 0xFF, 0xE3, 0x38, 0x19, 0xC1, 0xCC, 0x3F, 0xFD, 0xFF,
  0xE3, 0x38, 0x19, 0xC0, 0xCE, 0x0E, 0x60, 0x73, 0x00, 0x04, 0x00, 0x80,
  0xFF, 0xBF, 0xEF, 0x5D, 0xC8, 0x3D, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0x02, 0xF0, 0x5F, 0x0B, 0xFF, 0xF7, 0xFE, 0x3F, 0x00, 0x80, 0x10, 0x00,
  0x7C, 0x0E, 0x1F, 0xC3, 0x83, 0xB8, 0x60, 0x73, 0x1C, 0x0C, 0x63, 0x01,
  0x8C, 0xE0, 0x31, 0x9C, 0x87, 0x77, 0x7C, 0xFE, 0xEF, 0xCF, 0xBB, 0x9C,
  0x07, 0x73, 0x81, 0xCE, 0x70, 0x39, 0xCE, 0x0E, 0x39, 0xC1, 0xC7, 0x30,
  0x70, 0x7E, 0x0E, 0x07, 0x80, 0x1F, 0x80, 0x7F, 0x81, 0xEF, 0x03, 0x8E,
  0x07, 0x1C, 0x0F, 0x78, 0x0F, 0xE0, 0x0F, 0x80, 0x7F, 0x1E, 0xFE, 0x3B,
  0xDE, 0xF7, 0x1F, 0xCE, 0x1F, 0x9E, 0x1E, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F,
  0x9E, 0xFF, 0x77, 0x66, 0x1C, 0xE3, 0x9C, 0x71, 0xCE, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8F, 0x1C, 0x71, 0xE3, 0x87, 0x1C, 0xE1, 0xC7, 0x0E, 0x38,
  0xE3, 0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0x8E, 0x39, 0xC7, 0x38, 0xE0,
  0x0E, 0x01, 0x80, 0x30, 0x76, 0xEF, 0xFC, 0xFF, 0xC7, 0x81, 0xF8, 0x73,
  0x86, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x77, 0xFE, 0xEE, 0xFF, 0xFF, 0xC0,
  0x2F, 0xF7, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38,
  0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xF0, 0x00,
  0x3F, 0x0F, 0xF1, 0xFF, 0x78, 0xEF, 0x1D, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0x1C, 0xE3, 0x9F, 0xF1, 0xFC, 0x1F, 0x00,
  0x07, 0x0F, 0x3F, 0x7F, 0xF7, 0x67, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x3F, 0x9F, 0xFB, 0xFF, 0x30, 0xE0, 0x1E,
  0x03, 0x80, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x9F, 0xF9, 0xFF, 0x20, 0xE0, 0x1C,
  0x03, 0x80, 0xE1, 0xF8, 0x3F, 0x87, 0xF8, 0x07, 0x80, 0xF0, 0x1F, 0x03,
  0xFF, 0xF7, 0xFE, 0xFF, 0x00, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x0F,
  0xC0, 0xDC, 0x1D, 0xC1, 0x9C, 0x39, 0xC7, 0x1C, 0x71, 0xCF, 0xFF, 0xFF,
  0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x7F, 0xCF, 0xF9, 0xFF, 0x38,
  0x07, 0x00, 0xE0, 0x1F, 0xC7, 0xFC, 0xFF, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x1F, 0x03, 0xBF, 0xF7, 0xFC, 0xFF, 0x00, 0x0F, 0xC7, 0xF9, 0xFD, 0x38,
  0x07, 0x01, 0xC0, 0x3B, 0xE7, 0xFE, 0xFF, 0xDE, 0x3F, 0x83, 0xF0, 0x7E,
  0x1F, 0xE3, 0xDF, 0xF1, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x01,
  0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x78, 0x00, 0x3F, 0x8F, 0xFB, 0xEF, 0x78,
  0xEF, 0x1C, 0xE3, 0x9F, 0xF1, 0xF8, 0x3F, 0x0F, 0xFB, 0xC7, 0x70, 0xFE,
  0x0F, 0xC3, 0xFE, 0xFB, 0xFE, 0x3F, 0x80, 0x3F, 0x0F, 0xF3, 0xFF, 0x78,
  0xEE, 0x1F, 0xC3, 0xF8, 0x7F, 0x8F, 0xFF, 0xEF, 0xDC, 0xF3, 0x80, 0xE0,
  0x1C, 0x07, 0x9F, 0xE3, 0xF8, 0x7E, 0x00, 0x7F, 0xF2, 0x00, 0x00, 0x02,
  0xFF, 0x70, 0x7F, 0xF2, 0x00, 0x00, 0x00, 0x77, 0xFE, 0xEE, 0x00, 0x20,
  0x1C, 0x0F, 0x87, 0xE3, 0xF1, 0xF8, 0x3C, 0x07, 0xE0, 0x3F, 0x01, 0xFC,
  0x07, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x80, 0x18, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x3F,
  0x1F, 0x9F, 0x83, 0xC0, 0x60, 0x00, 0x7F, 0x3F, 0xE7, 0xFD, 0x07, 0x01,
  0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x02, 0x01,
  0xC0, 0x78, 0x1C, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xC0, 0x70, 0xE0,
  0x0E, 0x70, 0xF1, 0x9C, 0xFE, 0x76, 0x79, 0x9F, 0x9C, 0x67, 0xE6, 0x19,
  0xF9, 0x8E, 0x7E, 0x63, 0x9F, 0x98, 0xE6, 0xE7, 0xFF, 0x98, 0xF3, 0xC7,
  0x00, 0x00, 0xE0, 0x00, 0x3E, 0x1C, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x77, 0x00, 0xEE, 0x01, 0xDE, 0x07, 0x9C,
  0x0E, 0x38, 0x1C, 0x70, 0x78, 0xF0, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0xCF,
  0x07, 0x9E, 0x07, 0x78, 0x0F, 0xF0, 0x1E, 0xFF, 0x8F, 0xFC, 0xFF, 0xEE,
  0x1E, 0xE0, 0xEE, 0x1E, 0xE3, 0xEF, 0xFC, 0xFF, 0xCE, 0x7E, 0xE0, 0xEE,
  0x0F, 0xE0, 0xFE, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x80, 0x0F, 0xF1, 0xFF,
  0x3F, 0xF7, 0x81, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x07, 0xC1, 0x3F, 0xF1, 0xFF, 0x0F, 0xE0, 0xFF,
  0x87, 0xFE, 0x3F, 0xF9, 0xC3, 0xEE, 0x0F, 0x70, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xEE, 0x0F, 0x70, 0xFB, 0xFF, 0x9F,
  0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0xCF, 0xFE,
  0xF8, 0x17, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x0E, 0xE0, 0x77, 0x83, 0xBC, 0x1C, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x78, 0xFF, 0xFD, 0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x1F, 0x7F, 0xFE, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x7F, 0xFF,
  0xDF, 0x00, 0xE0, 0xFF, 0x07, 0xB8, 0x79, 0xC7, 0x8E, 0x78, 0x73, 0xC3,
  0xBC, 0x1D, 0xC0, 0xFF, 0x07, 0xF8, 0x3D, 0xE1, 0xC7, 0x8E, 0x3C, 0x70,
  0xF3, 0x87, 0x9C, 0x1E, 0xE0, 0xF8, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0x60, 0xDF, 0xB8, 0xEF, 0xDC, 0x77, 0xEE, 0x3B, 0xF3, 0xB9, 0xF9,
  0xDC, 0xFC, 0xEE, 0x7E, 0x3E, 0x3F, 0x1F, 0x1F, 0x8F, 0x8F, 0xC7, 0x87,
  0xE1, 0xC3, 0x80, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x1F,
  0xB8, 0x7E, 0xF1, 0xF9, 0xC7, 0xE7, 0x9F, 0x8E, 0x7E, 0x3D, 0xF8, 0x77,
  0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7C, 0x0F, 0xE0, 0x7F,
  0xF0, 0xFF, 0xF3, 0xC1, 0xE7, 0x81, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B, 0x80, 0xF7, 0x81, 0xCF, 0x07, 0x8F,
  0xFE, 0x0F, 0xFC, 0x0F, 0xE0, 0xFF, 0x1F, 0xFB, 0xFF, 0x70, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x1E, 0xFF, 0xDF, 0xF3, 0xF8, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xC1,
  0xE7, 0x81, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7B, 0x80, 0xF7, 0x81, 0xCF, 0x07, 0x8F, 0xFE, 0x0F, 0xFC, 0x0F,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0x0F, 0xFC,
  0xFF, 0xCE, 0x1E, 0xE1, 0xEE, 0x1E, 0xE1, 0xEE, 0x3C, 0xFF, 0x8F, 0xF0,
  0xE7, 0x8E, 0x38, 0xE3, 0xCE, 0x1C, 0xE1, 0xEE, 0x0F, 0xE0, 0xF0, 0x3F,
  0x9F, 0xFF, 0xFF, 0xC2, 0xF0, 0x3C, 0x07, 0x81, 0xF8, 0x3F, 0x83, 0xE0,
  0x7C, 0x07, 0x01, 0xF0, 0xFF, 0xFF, 0xFE, 0x7F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x79, 0xFF, 0xCF,
  0xFC, 0x1F, 0xC0, 0xF0, 0x1F, 0xC0, 0xF7, 0x03, 0xDC, 0x0E, 0x78, 0x38,
  0xE1, 0xE3, 0x87, 0x0F, 0x1C, 0x1C, 0xF0, 0x73, 0x81, 0xCE, 0x03, 0xB8,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0xE0, 0x70, 0x3F,
  0x83, 0xC1, 0xDC, 0x3E, 0x1E, 0xE1, 0xF0, 0xF7, 0x0F, 0x87, 0x3C, 0x6E,
  0x39, 0xE7, 0x73, 0xC7, 0x3B, 0x9E, 0x39, 0xDC, 0xE1, 0xCE, 0x77, 0x0F,
  0x63, 0xB8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC3, 0xE0, 0x7C, 0x1F,
  0x01, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0xF8, 0x3D, 0xE1, 0xE3, 0xC7, 0x0F,
  0x3C, 0x1E, 0xE0, 0x3F, 0x80, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x3F, 0x00,
  0xFC, 0x07, 0xF8, 0x1C, 0xF0, 0xF3, 0xC7, 0x87, 0x9E, 0x0E, 0xF0, 0x3C,
  0xF0, 0x3D, 0xE1, 0xE7, 0x87, 0x0E, 0x3C, 0x3C, 0xE0, 0x77, 0x81, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x1E,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF9, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xFF, 0x80, 0xF0, 0x1C,
  0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0,
  0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC0, 0xFF, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xFF, 0xFF, 0x80, 0x0E, 0x00,
  0xE0, 0x1F, 0x01, 0xF0, 0x3B, 0x83, 0xB8, 0x71, 0xC7, 0x1C, 0x60, 0xEE,
  0x0E, 0xC0, 0x70, 0xFF, 0xFF, 0xF0, 0xF0, 0xE1, 0xC0, 0x3F, 0x8F, 0xF8,
  0xCF, 0x00, 0xF0, 0x1E, 0x7F, 0xDF, 0xFF, 0x8F, 0xE1, 0xFC, 0x3F, 0xCF,
  0xFF, 0x77, 0xCE, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xDF, 0x3F,
  0xF7, 0xFE, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F,
  0xFE, 0xFF, 0xD9, 0xF0, 0x1F, 0xCF, 0xE7, 0xFB, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x17, 0xF9, 0xFE, 0x1F, 0x80, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x7D, 0xDF, 0xFB, 0xFF, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3B, 0xFF, 0x7F, 0xE7, 0xCC, 0x1F, 0x8F,
  0xF9, 0xE7, 0xF8, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x1E, 0x01,
  0xF7, 0x1F, 0xE1, 0xFC, 0x1F, 0xC7, 0xE3, 0xF8, 0xF0, 0x3C, 0x1F, 0xCF,
  0xF3, 0xFC, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x00, 0x3E, 0xEF, 0xFD, 0xFF, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1D, 0xFF, 0xBF, 0xF3, 0xEE, 0x01, 0xC0, 0x3A,
  0x0F, 0x7F, 0xCF, 0xF8, 0xF8, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xDF, 0x3F, 0xF7, 0xFE, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3C, 0x7F, 0x70, 0x07, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x1C, 0xF1, 0xC0, 0x00, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x3F, 0xFF, 0xBC, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x1E, 0xE3, 0xCE, 0x38, 0xE7, 0x0E,
  0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0x78, 0xE3, 0x8E, 0x3C, 0xE1, 0xEE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xCF, 0x9F, 0xBF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xC7, 0x8F, 0xE1, 0xE3, 0xF8, 0x70, 0xFE, 0x1C, 0x3F,
  0x87, 0x0F, 0xE1, 0xC3, 0xF8, 0x70, 0xFE, 0x1C, 0x3F, 0x87, 0x0F, 0xE1,
  0xC3, 0xC0, 0xCF, 0x9F, 0xFB, 0xFF, 0x78, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1E, 0x1F, 0x87, 0xFC, 0x7B,
  0xEF, 0x0E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x0E, 0x7F,
  0xE3, 0xFC, 0x1F, 0x80, 0xEF, 0x9F, 0xFB, 0xEF, 0x70, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x3F, 0xFF, 0x7F, 0xEE, 0xF9, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x3E, 0xEF, 0xFD, 0xFF, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1D, 0xFF, 0xBF, 0xF3,
  0xEE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xCF, 0xFE,
  0xFE, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x7F,
  0xFF, 0xFC, 0xDC, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xFF, 0xFF,
  0xEF, 0xE0, 0x18, 0x0C, 0x0E, 0x0F, 0xFF, 0xFF, 0xFC, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFC, 0xFE, 0x3F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0xFF, 0xFF,
  0x77, 0xCE, 0xF0, 0x7B, 0x87, 0x9C, 0x3C, 0xF1, 0xC3, 0x8E, 0x1C, 0xF0,
  0xE7, 0x03, 0xB8, 0x1F, 0xC0, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x00,
  0xF1, 0xF1, 0xEE, 0x3E, 0x39, 0xC7, 0xC7, 0x38, 0xD8, 0xE7, 0x9B, 0x3C,
  0x77, 0x77, 0x0E, 0xEE, 0xE1, 0xD8, 0xDC, 0x3B, 0x1B, 0x83, 0xE3, 0xE0,
  0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xE1, 0xE0, 0xF0, 0xF7, 0x8E, 0x39, 0xE3,
  0xDC, 0x1F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0xC3, 0xDC, 0x39, 0xE7,
  0x8F, 0xF0, 0xF0, 0xF0, 0x7B, 0x83, 0x9C, 0x3C, 0xF1, 0xC3, 0x8E, 0x1C,
  0xF0, 0xF7, 0x03, 0xB8, 0x1D, 0xC0, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x7E, 0x03, 0xE0, 0x1C, 0x00, 0xFF, 0xFF,
  0xFF, 0xE1, 0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x38, 0x3F, 0xFF, 0xFF,
  0xF8, 0x0F, 0x1F, 0x1F, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0xF8, 0xF0,
  0xFC, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x0F, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xF8, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x3C, 0x1F, 0x0F, 0x3F, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0xF8, 0xF0,
  0xE0, 0xFC, 0x3F, 0xFE, 0x3F, 0xC0, 0x40,
};

const GFXglyph NotoSans_SemiCondensed_Bold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 17, 7, 1, -17 },
  { 10, 9, 6, 11, 1, -17 },
  { 17, 13, 17, 14, 1, -17 },
  { 45, 11, 19, 13, 1, -18 },
  { 72, 19, 17, 21, 1, -17 },
  { 113, 15, 17, 16, 1, -17 },
  { 145, 4, 6, 6, 1, -17 },
  { 148, 6, 21, 8, 1, -17 },
  { 164, 6, 21, 8, 1, -17 },
  { 180, 11, 10, 12, 1, -18 },
  { 194, 11, 11, 13, 1, -14 },
  { 210, 4, 6, 7, 1, -3 },
  { 213, 6, 3, 8, 1, -8 },
  { 216, 4, 4, 7, 1, -4 },
  { 218, 10, 17, 10, 0, -17 },
  { 240, 11, 17, 13, 1, -17 },
  { 264, 8, 17, 13, 1, -17 },
  { 281, 11, 17, 13, 1, -17 },
  { 305, 11, 17, 13, 1, -17 },
  { 329, 12, 17, 13, 0, -17 },
  { 355, 11, 17, 13, 1, -17 },
  { 379, 11, 17, 13, 1, -17 },
  { 403, 11, 17, 13, 1, -17 },
  { 427, 11, 17, 13, 1, -17 },
  { 451, 11, 17, 13, 1, -17 },
  { 475, 4, 13, 7, 1, -13 },
  { 482, 4, 16, 7, 1, -13 },
  { 490, 11, 12, 13, 1, -15 },
  { 507, 11, 7, 13, 1, -12 },
  { 517, 11, 12, 13, 1, -15 },
  { 534, 10, 17, 11, 0, -17 },
  { 556, 18, 19, 20, 1, -17 },
  { 599, 15, 17, 15, 0, -17 },
  { 631, 12, 17, 15, 2, -17 },
  { 657, 12, 17, 14, 1, -17 },
  { 683, 13, 17, 16, 2, -17 },
  { 711, 9, 17, 12, 2, -17 },
  { 731, 9, 17, 12, 2, -17 },
  { 751, 13, 17, 16, 1, -17 },
  { 779, 13, 17, 17, 2, -17 },
  { 807, 7, 17, 9, 1, -17 },
  { 822, 7, 22, 7, -2, -17 },
  { 842, 13, 17, 15, 2, -17 },
  { 870, 9, 17, 12, 2, -17 },
  { 890, 17, 17, 21, 2, -17 },
  { 927, 14, 17, 18, 2, -17 },
  { 957, 15, 17, 17, 1, -17 },
  { 989, 11, 17, 14, 2, -17 },
  { 1013, 15, 21, 17, 1, -17 },
  { 1053, 12, 17, 14, 2, -17 },
  { 1079, 10, 17, 12, 1, -17 },
  { 1101, 12, 17, 13, 0, -17 },
  { 1127, 13, 17, 17, 2, -17 },
  { 1155, 14, 17, 14, 0, -17 },
  { 1185, 21, 17, 21, 0, -17 },
  { 1230, 14, 17, 14, 0, -17 },
  { 1260, 14, 17, 14, 0, -17 },
  { 1290, 12, 17, 12, 0, -17 },
  { 1316, 5, 21, 8, 2, -17 },
  { 1330, 10, 17, 10, 0, -17 },
  { 1352, 5, 21, 8, 1, -17 },
  { 1366, 12, 11, 13, 1, -17 },
  { 1383, 10, 2, 10, 0, 2 },
  { 1386, 6, 3, 8, 1, -18 },
  { 1389, 11, 13, 13, 1, -13 },
  { 1407, 11, 18, 14, 2, -18 },
  { 1432, 10, 13, 11, 1, -13 },
  { 1449, 11, 18, 14, 1, -18 },
  { 1474, 11, 13, 13, 1, -13 },
  { 1492, 10, 18, 9, 0, -18 },
  { 1515, 11, 19, 14, 1, -13 },
  { 1542, 11, 18, 14, 2, -18 },
  { 1567, 4, 18, 7, 1, -18 },
  { 1576, 6, 24, 7, -1, -18 },
  { 1594, 12, 18, 14, 2, -18 },
  { 1621, 3, 18, 7, 2, -18 },
  { 1628, 18, 13, 21, 2, -13 },
  { 1658, 11, 13, 14, 2, -13 },
  { 1676, 12, 13, 14, 1, -13 },
  { 1696, 11, 19, 14, 2, -13 },
  { 1723, 11, 19, 14, 1, -13 },
  { 1750, 8, 13, 10, 2, -13 },
  { 1763, 9, 13, 11, 1, -13 },
  { 1778, 9, 16, 10, 0, -16 },
  { 1796, 11, 13, 14, 2, -13 },
  { 1814, 13, 13, 13, 0, -13 },
  { 1836, 19, 13, 19, 0, -13 },
  { 1867, 12, 13, 13, 0, -13 },
  { 1887, 13, 19, 13, 0, -13 },
  { 1918, 9, 13, 11, 1, -13 },
  { 1933, 8, 21, 9, 0, -17 },
  { 1954, 2, 24, 12, 5, -18 },
  { 1960, 8, 21, 9, 1, -17 },
  { 1981, 11, 4, 13, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_Bold24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold24pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD24PT7B_H_
