#ifndef _NOTOSANS_SEMICONDENSED_BOLD11PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xBA, 0xA0, 0x2C, 0xA7, 0xCA, 0x2B, 0xF5, 0x14, 0x33, 0xF8,
  0xE3, 0x97, 0xE4, 0x20, 0x62, 0x6B, 0x35, 0x1B, 0xE6, 0xA8, 0xD4, 0x4A,
  0x67, 0x38, 0xD1, 0xE1, 0x87, 0x7B, 0xF3, 0x3F, 0xE0, 0x2D, 0x2D, 0x92,
  0x64, 0xC9, 0x92, 0x4B, 0x58, 0x27, 0xCC, 0xF3, 0x00, 0x31, 0x8D, 0xF3,
  0x18, 0x70, 0xFC, 0xC0, 0x11, 0x32, 0x64, 0x4C, 0x72, 0xD3, 0x9C, 0xE5,
  0x6F, 0x3E, 0x92, 0x49, 0x76, 0xC2, 0x31, 0x11, 0x1F, 0xFA, 0xC2, 0xE7,
  0x86, 0x7F, 0x18, 0xE3, 0x96, 0x5B, 0xF1, 0x86, 0xFF, 0x8F, 0x31, 0xBF,
  0x3B, 0x11, 0xFC, 0xE5, 0x2F, 0xFF, 0xC6, 0x31, 0x18, 0x8C, 0x7A, 0x52,
  0xE7, 0xE7, 0x2F, 0x72, 0xF3, 0x97, 0x84, 0x6E, 0xCC, 0x50, 0x1C, 0x08,
  0xD9, 0xC1, 0x84, 0xFF, 0xC1, 0xF0, 0x87, 0x06, 0x3E, 0x40, 0xF4, 0xC6,
  0x66, 0x01, 0x8C, 0x1E, 0x11, 0x93, 0xCA, 0x9D, 0x4A, 0xA9, 0x6C, 0xC4,
  0x1E, 0x00, 0x38, 0x50, 0xA3, 0x66, 0xCF, 0xB1, 0x63, 0xF4, 0xE7, 0xEF,
  0xC6, 0x7E, 0x7E, 0x71, 0x08, 0x43, 0x2F, 0xF3, 0xE8, 0xE3, 0x8E, 0x39,
  0xBC, 0xFC, 0xCF, 0xFC, 0xCF, 0xF8, 0x88, 0xF8, 0x88, 0x7F, 0xAC, 0x20,
  0x9E, 0x3C, 0xDF, 0xCF, 0x3C, 0xFF, 0xFF, 0x3C, 0xF3, 0xF6, 0x66, 0x66,
  0x6F, 0x33, 0x33, 0x33, 0x33, 0x2E, 0xCF, 0x6F, 0x38, 0xF3, 0x4D, 0xB3,
  0x88, 0x88, 0x88, 0x8F, 0xC7, 0xC7, 0xE7, 0xA7, 0xAF, 0xBB, 0x9B, 0x9B,
  0xC7, 0x9E, 0x6D, 0x96, 0x78, 0xE3, 0x7B, 0x38, 0xE1, 0x86, 0x3C, 0xDE,
  0xF5, 0xE7, 0x3F, 0x42, 0x10, 0x7B, 0x38, 0xE1, 0x86, 0x3C, 0xDE, 0x18,
  0x30, 0xF2, 0x69, 0xA6, 0xF2, 0xC9, 0xA3, 0x7B, 0x50, 0xC3, 0x8E, 0x7E,
  0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x8E, 0x38, 0xE3, 0x8E, 0x3C, 0xDE,
  0xC7, 0x89, 0x33, 0x66, 0x87, 0x0E, 0x18, 0xCC, 0xF3, 0x24, 0xC9, 0x76,
  0x57, 0x9C, 0xE7, 0x30, 0xCC, 0xCC, 0xD9, 0xE1, 0xC3, 0x0F, 0x1B, 0x67,
  0xCD, 0x36, 0x8E, 0x30, 0xC3, 0x0C, 0xF8, 0x46, 0x62, 0x33, 0x1F, 0xEA,
  0xAA, 0xB0, 0xC4, 0x46, 0x22, 0x31, 0xED, 0xB6, 0xDB, 0x7C, 0x30, 0xC7,
  0x92, 0xCC, 0xF8, 0xE0, 0x7A, 0x4E, 0x9C, 0xBC, 0x84, 0x2D, 0xB9, 0xCF,
  0x7E, 0x7B, 0x71, 0x84, 0xBC, 0x0C, 0x37, 0xD3, 0xCF, 0x34, 0xDF, 0x79,
  0x2F, 0xF0, 0x45, 0xE0, 0x76, 0xF6, 0x66, 0x66, 0x7D, 0x3C, 0xF3, 0x4D,
  0xF0, 0xDE, 0x70, 0x84, 0x3D, 0xB9, 0xCE, 0x73, 0xBF, 0x45, 0x55, 0x78,
  0x84, 0x27, 0x6E, 0x7A, 0x53, 0xFF, 0xF7, 0xDB, 0x99, 0x99, 0x99, 0x99,
  0xF6, 0xE7, 0x39, 0xCC, 0x79, 0x3C, 0xF3, 0x4D, 0xE0, 0xB6, 0xE7, 0x3D,
  0xFA, 0x10, 0x80, 0x7D, 0x3C, 0xF3, 0x4D, 0xF0, 0xC3, 0x0C, 0xBA, 0x49,
  0x00, 0x7E, 0x18, 0x69, 0xF8, 0x4F, 0x44, 0x46, 0x70, 0x9C, 0xE7, 0x39,
  0xFC, 0xCD, 0x25, 0x9E, 0x30, 0xC0, 0xD9, 0xEE, 0x95, 0xCA, 0xE7, 0x61,
  0x30, 0xCD, 0xE3, 0x0C, 0x7B, 0x30, 0xCD, 0x25, 0x9E, 0x30, 0xC3, 0x38,
  0xC0, 0xF8, 0x8C, 0xC4, 0x7C, 0x36, 0x66, 0xEE, 0x66, 0x63, 0xFF, 0xE0,
  0xC6, 0x66, 0x37, 0x66, 0x6C, 0x6D, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Bold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 4, 3, 5, 1, -8 },
  { 4, 6, 8, 7, 0, -8 },
  { 10, 5, 9, 6, 0, -8 },
  { 16, 9, 8, 9, 0, -8 },
  { 25, 7, 8, 7, 0, -8 },
  { 32, 1, 3, 3, 1, -8 },
  { 33, 3, 10, 4, 0, -8 },
  { 37, 3, 10, 4, 0, -8 },
  { 41, 5, 5, 6, 0, -8 },
  { 45, 5, 6, 6, 0, -7 },
  { 49, 2, 2, 3, 0, -1 },
  { 50, 3, 2, 3, 0, -4 },
  { 51, 1, 2, 3, 1, -2 },
  { 52, 4, 8, 5, 0, -8 },
  { 56, 5, 8, 6, 0, -8 },
  { 61, 3, 8, 6, 1, -8 },
  { 64, 5, 8, 6, 0, -8 },
  { 69, 5, 8, 6, 0, -8 },
  { 74, 6, 8, 6, 0, -8 },
  { 80, 4, 8, 6, 1, -8 },
  { 84, 5, 8, 6, 0, -8 },
  { 89, 5, 8, 6, 0, -8 },
  { 94, 5, 8, 6, 0, -8 },
  { 99, 5, 8, 6, 0, -8 },
  { 104, 1, 6, 3, 1, -6 },
  { 105, 2, 7, 3, 0, -6 },
  { 107, 5, 6, 6, 0, -7 },
  { 111, 5, 4, 6, 0, -6 },
  { 114, 5, 6, 6, 0, -7 },
  { 118, 5, 8, 5, 0, -8 },
  { 123, 9, 9, 9, 0, -8 },
  { 134, 7, 8, 7, 0, -8 },
  { 141, 5, 8, 7, 1, -8 },
  { 146, 5, 8, 6, 1, -8 },
  { 151, 6, 8, 7, 1, -8 },
  { 157, 4, 8, 6, 1, -8 },
  { 161, 4, 8, 6, 1, -8 },
  { 165, 6, 8, 7, 1, -8 },
  { 171, 6, 8, 8, 1, -8 },
  { 177, 4, 8, 4, 0, -8 },
  { 181, 4, 10, 3, -1, -8 },
  { 186, 6, 8, 7, 1, -8 },
  { 192, 4, 8, 6, 1, -8 },
  { 196, 8, 8, 10, 1, -8 },
  { 204, 6, 8, 8, 1, -8 },
  { 210, 6, 8, 8, 1, -8 },
  { 216, 5, 8, 6, 1, -8 },
  { 221, 6, 10, 8, 1, -8 },
  { 229, 6, 8, 7, 1, -8 },
  { 235, 5, 8, 6, 0, -8 },
  { 240, 6, 8, 6, 0, -8 },
  { 246, 6, 8, 8, 1, -8 },
  { 252, 7, 8, 7, 0, -8 },
  { 259, 10, 8, 10, 0, -8 },
  { 269, 7, 8, 7, 0, -8 },
  { 276, 6, 8, 6, 0, -8 },
  { 282, 5, 8, 6, 0, -8 },
  { 287, 2, 10, 4, 1, -8 },
  { 290, 4, 8, 5, 0, -8 },
  { 294, 3, 10, 4, 0, -8 },
  { 298, 6, 5, 6, 0, -8 },
  { 302, 5, 1, 5, 0, 1 },
  { 303, 3, 1, 4, 0, -8 },
  { 304, 5, 6, 6, 0, -6 },
  { 308, 5, 8, 6, 1, -8 },
  { 313, 5, 6, 5, 0, -6 },
  { 317, 6, 8, 6, 0, -8 },
  { 323, 6, 6, 6, 0, -6 },
  { 328, 4, 8, 4, 0, -8 },
  { 332, 6, 9, 6, 0, -6 },
  { 339, 5, 8, 7, 1, -8 },
  { 344, 1, 8, 3, 1, -8 },
  { 345, 2, 11, 3, 0, -8 },
  { 348, 5, 8, 6, 1, -8 },
  { 353, 1, 8, 3, 1, -8 },
  { 354, 8, 6, 10, 1, -6 },
  { 360, 5, 6, 7, 1, -6 },
  { 364, 6, 6, 6, 0, -6 },
  { 369, 5, 9, 6, 1, -6 },
  { 375, 6, 9, 6, 0, -6 },
  { 382, 3, 6, 5, 1, -6 },
  { 385, 5, 6, 5, 0, -6 },
  { 389, 4, 7, 4, 0, -7 },
  { 393, 5, 6, 7, 1, -6 },
  { 397, 6, 6, 6, 0, -6 },
  { 402, 9, 6, 9, 0, -6 },
  { 409, 6, 6, 6, 0, -6 },
  { 414, 6, 9, 6, 0, -6 },
  { 421, 5, 6, 5, 0, -6 },
  { 425, 4, 10, 4, 0, -8 },
  { 430, 1, 11, 6, 2, -8 },
  { 432, 4, 10, 4, 0, -8 },
  { 437, 5, 2, 6, 0, -5 },
};

const GFXfont NotoSans_SemiCondensed_Bold11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold11pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD11PT7B_H_
