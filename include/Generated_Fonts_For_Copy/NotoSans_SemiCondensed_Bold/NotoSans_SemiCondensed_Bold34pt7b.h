#ifndef _NOTOSANS_SEMICONDENSED_BOLD34PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x1F, 0xF1, 0xFF,
  0x1F, 0xF0, 0xEF, 0x0E, 0x70, 0xE0, 0x03, 0xC7, 0x00, 0x71, 0xE0, 0x0E,
  0x3C, 0x01, 0xC7, 0x00, 0x78, 0xE0, 0x0F, 0x1C, 0x1F, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x3C, 0x70, 0x07, 0x8E, 0x00, 0xF3,
  0xC0, 0x1C, 0x78, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC3, 0xC7,
  0x00, 0x79, 0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x80, 0x38, 0xE0, 0x0F, 0x1C,
  0x01, 0xE7, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0F, 0xFC, 0x3F,
  0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7D, 0x84, 0xF9, 0x80, 0x79, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0x9F, 0x01, 0x9F, 0xC1, 0x9F, 0xF9, 0xBE, 0xFF, 0xFE, 0xFF,
  0xFC, 0x7F, 0xF8, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0E,
  0x00, 0x00, 0x07, 0xF0, 0x0F, 0x01, 0xFE, 0x01, 0xC0, 0x3F, 0xE0, 0x78,
  0x0F, 0x1C, 0x0E, 0x01, 0xE3, 0xC3, 0xC0, 0x3C, 0x78, 0x78, 0x07, 0x8F,
  0x1E, 0x00, 0xF1, 0xE3, 0xC0, 0x1E, 0x3C, 0xF0, 0x03, 0xC7, 0x9E, 0x7C,
  0x78, 0xE7, 0x9F, 0xC7, 0xFC, 0xF7, 0xFC, 0xFF, 0xBC, 0xF7, 0x8F, 0xE7,
  0xBC, 0x78, 0x61, 0xE7, 0x8F, 0x00, 0x3C, 0xF1, 0xE0, 0x0F, 0x1E, 0x3C,
  0x01, 0xE3, 0xC7, 0x80, 0x78, 0x78, 0xF0, 0x0F, 0x0F, 0x1E, 0x03, 0xC0,
  0xF3, 0x80, 0x78, 0x1F, 0xF0, 0x1E, 0x01, 0xFC, 0x03, 0xC0, 0x1F, 0x00,
  0x00, 0xC0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F,
  0x7E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x7C,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xF8,
  0xFF, 0xC3, 0xE7, 0xFF, 0x0F, 0x9F, 0x3E, 0x7C, 0xFC, 0x7D, 0xF3, 0xE0,
  0xFF, 0x8F, 0x83, 0xFE, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0x7E, 0x0F, 0xF0, 0xFC, 0xFF, 0xFF, 0xEF,
  0x7B, 0xDE, 0x70, 0x07, 0x87, 0x83, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0x78,
  0xF0, 0x3C, 0x0F, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x83,
  0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0,
  0x78, 0x7C, 0x3C, 0x3E, 0x1E, 0x0F, 0x0F, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x04, 0x38, 0x7F, 0x77, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0xF7, 0x83, 0xE7, 0x87, 0x8F, 0x83,
  0x08, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x3D, 0xF7,
  0xDF, 0x79, 0xEF, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x0F,
  0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7C, 0x3E, 0x7C, 0x3E, 0x78,
  0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x03,
  0xE0, 0xFC, 0x3F, 0x8F, 0xF3, 0xFE, 0xFB, 0xFE, 0xFB, 0x9F, 0x23, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x1F, 0xF0,
  0x3F, 0xFC, 0xFF, 0xFC, 0x7F, 0xFE, 0x38, 0x3E, 0x20, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00,
  0x3F, 0xF0, 0xFF, 0xFC, 0x7F, 0xFC, 0x7E, 0xFE, 0x20, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0xC0, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x1E, 0xF8, 0x0F, 0x7C, 0x0F, 0x3E, 0x07, 0x1F, 0x07,
  0x8F, 0x87, 0x87, 0xC3, 0xC3, 0xE3, 0xC1, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF9, 0x01, 0xFF, 0xC3, 0xFF, 0xE7,
  0xFF, 0xC7, 0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF4, 0x07, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F, 0xFC, 0x7F, 0xE0,
  0x00, 0x18, 0x03, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xC4, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0xF0, 0xFB, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFE, 0x3E, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x01, 0x80, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x3E,
  0x7C, 0x3E, 0x78, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3F, 0xFC,
  0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x7E, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7E, 0x7E, 0x7F, 0xFE,
  0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC,
  0x7F, 0xFC, 0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0x7E, 0x7F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xDF,
  0x06, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0xFC, 0x3F, 0xF8,
  0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x39, 0xF7, 0xDF, 0x7C, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x7D, 0xF7, 0xDE, 0x7B, 0xCF, 0x00,
  0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0xFE, 0x00,
  0xF0, 0x00, 0xC0, 0x00, 0x03, 0x00, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x7F,
  0xFC, 0x81, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3E, 0x00,
  0xF8, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC3, 0xC1, 0xFE, 0x78, 0xE1,
  0xFF, 0x8E, 0x78, 0xFF, 0xE3, 0xDE, 0x3C, 0x78, 0xF7, 0x1E, 0x1E, 0x3D,
  0xC7, 0x87, 0x8F, 0x71, 0xE1, 0xE3, 0xFC, 0x78, 0x78, 0xFF, 0x1E, 0x1E,
  0x3D, 0xC7, 0x87, 0x8E, 0x71, 0xE3, 0xE7, 0x9C, 0x3F, 0xFF, 0xC7, 0x8F,
  0xF7, 0xF1, 0xE1, 0xF8, 0xF8, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x01, 0x00, 0x3F, 0x87, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x07, 0xFC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xF9,
  0xE0, 0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x80,
  0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x0F, 0x80, 0x7C, 0xFC, 0x03, 0xE7, 0xC0, 0x1F, 0x3E,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFE, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8,
  0x3E, 0xFF, 0xFE, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFE, 0xF8, 0xFE, 0xF8,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x00, 0x60, 0x03, 0xFF, 0x83,
  0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xF3, 0xF8, 0x19, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x31, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE,
  0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x3F,
  0x3E, 0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x3F, 0xF8, 0x0F, 0xBE, 0x07, 0xEF, 0x81, 0xFB, 0xE3, 0xFC, 0xFF, 0xFE,
  0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xBF,
  0xFD, 0xFF, 0xEF, 0xFF, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3F, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x10, 0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF,
  0x8F, 0xC0, 0x27, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0x7D, 0xF8, 0x1F, 0x7F, 0x07,
  0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xFB, 0xFE, 0xFF, 0x3F, 0xCF,
  0xC0, 0xF8, 0x0F, 0xFE, 0x07, 0xEF, 0x83, 0xF3, 0xE0, 0xF8, 0xF8, 0x7C,
  0x3E, 0x3F, 0x0F, 0x9F, 0x83, 0xE7, 0xC0, 0xFB, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xDF, 0x03, 0xE3,
  0xE0, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xE0, 0xF8, 0xF8, 0x3F,
  0x3E, 0x07, 0xCF, 0x81, 0xFB, 0xE0, 0x3F, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xEF, 0xF7, 0x81, 0xEF, 0xF7, 0x81,
  0xEF, 0xF7, 0x83, 0xCF, 0xF3, 0xC3, 0xDF, 0xF3, 0xC3, 0xDF, 0xF3, 0xC7,
  0x9F, 0xF3, 0xE7, 0x9F, 0xF1, 0xE7, 0x9F, 0xF1, 0xE7, 0x1F, 0xF1, 0xEF,
  0x1F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFE, 0x1F, 0xF0, 0x7E,
  0x1F, 0xF0, 0x7E, 0x1F, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C, 0x1F, 0xFC, 0x01,
  0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0x81, 0xFF, 0x7C, 0x1F, 0xF7, 0xE1, 0xFF, 0x3E, 0x1F, 0xF3,
  0xF1, 0xFF, 0x1F, 0x1F, 0xF1, 0xF9, 0xFF, 0x0F, 0x9F, 0xF0, 0xFD, 0xFF,
  0x07, 0xDF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x70,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F,
  0x03, 0xF1, 0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xF7, 0xE0, 0x0F, 0x9F, 0x00, 0xFC,
  0xFC, 0x07, 0xE7, 0xF0, 0x7E, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF,
  0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1,
  0xFF, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F, 0xF8, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x00, 0x70, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFE, 0x3F, 0x03, 0xF1, 0xF0, 0x0F, 0xDF, 0x80, 0x3E, 0xF8, 0x01,
  0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xF7, 0xE0, 0x0F,
  0xBF, 0x00, 0xFC, 0xFC, 0x07, 0xE7, 0xF0, 0x7E, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8, 0x7E, 0x3E, 0x0F,
  0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x8F, 0xC3,
  0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xE7, 0xE0, 0xF8,
  0xF8, 0x3E, 0x3F, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x07,
  0xCF, 0x81, 0xFB, 0xE0, 0x3F, 0x01, 0x80, 0x1F, 0xF8, 0xFF, 0xF9, 0xFF,
  0xE7, 0xFF, 0xCF, 0x81, 0x9F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFB, 0xF0,
  0x7E, 0x7F, 0xFF, 0x9F, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xE0, 0xF8, 0x01,
  0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0,
  0x3E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x1E, 0x07, 0xC1, 0xF0, 0x78, 0x1F,
  0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF9, 0xF0, 0x07, 0x9F, 0x00,
  0x79, 0xE0, 0x07, 0xDE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x7F, 0xE0, 0x3F, 0x01, 0xF7, 0x80, 0xFC, 0x07, 0xDF, 0x03, 0xF0,
  0x1E, 0x7C, 0x0F, 0xC0, 0xF9, 0xF0, 0x7F, 0x83, 0xE7, 0xC1, 0xFE, 0x0F,
  0x8F, 0x07, 0xF8, 0x3C, 0x3E, 0x1F, 0xE1, 0xF0, 0xF8, 0xF3, 0xC7, 0xC3,
  0xE3, 0xCF, 0x1F, 0x07, 0x8F, 0x3C, 0x7C, 0x1E, 0x3C, 0xF1, 0xE0, 0x7C,
  0xF3, 0xEF, 0x81, 0xF7, 0x87, 0xBE, 0x03, 0xDE, 0x1E, 0xF8, 0x0F, 0x78,
  0x7B, 0xC0, 0x3D, 0xE1, 0xEF, 0x00, 0xF7, 0x03, 0xBC, 0x01, 0xFC, 0x0F,
  0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xF8,
  0x01, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xF3, 0xE0, 0x7E, 0x3E, 0x07, 0xC1,
  0xF0, 0xFC, 0x1F, 0x0F, 0x80, 0xF9, 0xF8, 0x0F, 0x9F, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xDF, 0x00, 0xF9,
  0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0xFC, 0x3E, 0x07, 0xC7, 0xE0, 0x7E, 0x7C,
  0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xEF, 0x80, 0xFD, 0xF8, 0x1F, 0x1F,
  0x07, 0xE3, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC7, 0xC0, 0x7C, 0xF8, 0x0F,
  0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x3C, 0xF0,
  0x1E, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0xF7, 0x80,
  0x7B, 0xC0, 0x1E, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xE0,
  0x78, 0x07, 0xF0, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xF1, 0x83, 0xE0, 0x07,
  0xC0, 0x07, 0x80, 0x7F, 0x1F, 0xFE, 0x7F, 0xFD, 0xFE, 0x7F, 0xE0, 0xFF,
  0x81, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x7F, 0x7F, 0xFE, 0xFF, 0xBC, 0xFE,
  0x38, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0xF0, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE,
  0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFB, 0xFC, 0xF1, 0xF8, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE,
  0x7F, 0x19, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x4F, 0xFF, 0x3F, 0xFC, 0x7F,
  0xF0, 0x7F, 0x80, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x0F, 0x1F, 0x1F, 0xEF, 0x9F, 0xFF,
  0xCF, 0xFF, 0xEF, 0xC7, 0xF7, 0xC1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xDE, 0x03, 0xEF, 0x81, 0xF7, 0xC1, 0xFB,
  0xF0, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xEF, 0x87, 0xE3, 0xC0, 0x03,
  0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7E, 0x1E, 0x7C, 0x1F, 0x7C,
  0x0F, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7E, 0x02, 0x3F, 0x9E, 0x3F, 0xFE, 0x1F, 0xFE, 0x07,
  0xFC, 0x07, 0xF1, 0xFF, 0x1F, 0xF3, 0xFF, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xE3, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x07, 0x8F, 0x8F, 0xF7, 0xCF, 0xFF, 0xE7, 0xFF,
  0xF7, 0xE3, 0xFB, 0xE0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xEF, 0x01, 0xF7, 0xC0, 0xFB, 0xE0, 0xFD, 0xF8, 0x7E,
  0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xF7, 0xC3, 0xF3, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF9, 0x80, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x07,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x77, 0xFF, 0xF7, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0x07, 0xC3, 0xE1, 0xF0, 0x78, 0x00, 0x00, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7F, 0xFF, 0xFE, 0xFF,
  0x7E, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x3E,
  0x1F, 0x9F, 0x1F, 0x8F, 0x8F, 0x87, 0xCF, 0x83, 0xEF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x9F, 0x0F, 0x87, 0xC7, 0xC3,
  0xE3, 0xE0, 0xF9, 0xF0, 0x7E, 0xF8, 0x1F, 0x7C, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0xF8, 0x3E, 0x3C, 0xFF, 0x3F, 0xCF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x8F, 0xFF, 0x0F, 0xC1, 0xFF, 0xC1,
  0xF0, 0x7F, 0xE0, 0x7C, 0x1F, 0xF8, 0x1F, 0x07, 0xFE, 0x07, 0xC1, 0xFF,
  0x81, 0xF0, 0x7F, 0xE0, 0x7C, 0x1F, 0xF8, 0x1F, 0x07, 0xFE, 0x07, 0xC1,
  0xFF, 0x81, 0xF0, 0x7F, 0xE0, 0x7C, 0x1F, 0xF8, 0x1F, 0x07, 0xFE, 0x07,
  0xC1, 0xFF, 0x81, 0xF0, 0x7C, 0xF0, 0xF8, 0xF3, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x03, 0xF0, 0x07, 0xFE, 0x07,
  0xFF, 0x87, 0xFF, 0xC7, 0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0x3E, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0,
  0x7D, 0xF8, 0x7C, 0x7F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFE, 0x00,
  0xF0, 0xF0, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x3F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFB, 0xFC,
  0xF9, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0x8F, 0x8F, 0xF7, 0xCF, 0xFF,
  0xE7, 0xFF, 0xF7, 0xE3, 0xFB, 0xE0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xEF, 0x01, 0xF7, 0xC0, 0xFB, 0xE0, 0xFD,
  0xF8, 0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xF7, 0xC3, 0xF3, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0xF0, 0xFF, 0x3E, 0xF3, 0xEF, 0xFE, 0xFF, 0xEF,
  0xE0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0xC1, 0xFF,
  0xDF, 0xFE, 0xFF, 0xEF, 0x81, 0x7C, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x83, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3F, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xFF, 0x3F, 0xF1,
  0xFF, 0x0F, 0xE0, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0x7F, 0xFF, 0x7F,
  0xFF, 0x3F, 0xEF, 0x1F, 0xCF, 0xF8, 0x07, 0xFE, 0x03, 0xE7, 0xC0, 0xF9,
  0xF0, 0x3E, 0x7C, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x1E,
  0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x7C, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0xF8, 0x1F, 0x03, 0xEF, 0x03, 0xE0, 0x79, 0xF0, 0xFE, 0x1F, 0x3E, 0x1F,
  0xC3, 0xE7, 0xC3, 0xB8, 0x7C, 0x78, 0x77, 0x0F, 0x0F, 0x9E, 0xE3, 0xE1,
  0xF3, 0xDE, 0x7C, 0x3E, 0x73, 0xCF, 0x83, 0xCE, 0x39, 0xE0, 0x79, 0xC7,
  0x7C, 0x0F, 0xF8, 0xEF, 0x81, 0xFF, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x0F, 0x9F, 0x07, 0xE3, 0xE1, 0xF0,
  0xF8, 0xFC, 0x1F, 0x3E, 0x07, 0xDF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xDF,
  0x01, 0xF3, 0xE0, 0xF8, 0xFC, 0x3E, 0x1F, 0x1F, 0x07, 0xEF, 0xC0, 0xFC,
  0xF8, 0x07, 0xFF, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x78, 0x1F, 0x3E, 0x07, 0xCF, 0x80, 0xF3,
  0xC0, 0x3C, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0xFC, 0x1F,
  0x87, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC3, 0xF1, 0xFE, 0x3E, 0x07, 0xF0, 0x7F, 0x01, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xFC, 0x1F,
  0xC0, 0x78, 0x7F, 0x1F, 0xE3, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x07, 0xC3, 0xF8, 0x7F, 0x0F, 0xC0, 0x3C, 0x01, 0x7F,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFE, 0x80, 0x78,
};

const GFXglyph NotoSans_SemiCondensed_Bold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 24, 9, 2, -24 },
  { 16, 12, 9, 16, 2, -24 },
  { 30, 19, 24, 20, 1, -24 },
  { 87, 16, 28, 18, 1, -26 },
  { 143, 27, 25, 29, 1, -25 },
  { 228, 22, 25, 23, 1, -25 },
  { 297, 5, 9, 9, 2, -24 },
  { 303, 9, 29, 11, 1, -24 },
  { 336, 9, 29, 11, 1, -24 },
  { 369, 15, 15, 17, 1, -26 },
  { 398, 16, 16, 18, 1, -20 },
  { 430, 6, 8, 9, 1, -4 },
  { 436, 9, 4, 11, 1, -11 },
  { 441, 5, 5, 9, 2, -5 },
  { 445, 14, 25, 14, 0, -25 },
  { 489, 16, 25, 18, 1, -25 },
  { 539, 11, 24, 18, 2, -24 },
  { 572, 16, 25, 18, 1, -25 },
  { 622, 16, 25, 18, 1, -25 },
  { 672, 17, 24, 18, 1, -24 },
  { 723, 15, 24, 18, 2, -24 },
  { 768, 16, 25, 18, 1, -25 },
  { 818, 16, 24, 18, 1, -24 },
  { 866, 16, 25, 18, 1, -25 },
  { 916, 16, 25, 18, 1, -25 },
  { 966, 5, 19, 9, 2, -19 },
  { 978, 6, 23, 9, 1, -19 },
  { 996, 16, 17, 18, 1, -21 },
  { 1030, 16, 10, 18, 1, -17 },
  { 1050, 16, 17, 18, 1, -21 },
  { 1084, 14, 25, 15, 0, -25 },
  { 1128, 26, 27, 28, 1, -24 },
  { 1216, 21, 24, 21, 0, -24 },
  { 1279, 16, 24, 21, 3, -24 },
  { 1327, 17, 25, 20, 2, -25 },
  { 1381, 18, 24, 23, 3, -24 },
  { 1435, 13, 24, 17, 3, -24 },
  { 1474, 13, 24, 17, 3, -24 },
  { 1513, 18, 25, 23, 2, -25 },
  { 1570, 18, 24, 24, 3, -24 },
  { 1624, 10, 24, 12, 1, -24 },
  { 1654, 10, 31, 11, -2, -24 },
  { 1693, 18, 24, 21, 3, -24 },
  { 1747, 13, 24, 17, 3, -24 },
  { 1786, 24, 24, 30, 3, -24 },
  { 1858, 20, 24, 25, 3, -24 },
  { 1918, 21, 25, 24, 2, -25 },
  { 1984, 15, 24, 19, 3, -24 },
  { 2029, 21, 31, 24, 2, -25 },
  { 2111, 18, 24, 21, 3, -24 },
  { 2165, 15, 25, 17, 1, -25 },
  { 2212, 16, 24, 18, 1, -24 },
  { 2260, 18, 24, 23, 3, -24 },
  { 2314, 20, 24, 20, 0, -24 },
  { 2374, 30, 24, 30, 0, -24 },
  { 2464, 20, 24, 20, 0, -24 },
  { 2524, 19, 24, 19, 0, -24 },
  { 2581, 16, 24, 18, 1, -24 },
  { 2629, 8, 29, 11, 2, -24 },
  { 2658, 14, 25, 14, 0, -25 },
  { 2702, 8, 29, 11, 1, -24 },
  { 2731, 17, 15, 19, 1, -24 },
  { 2763, 14, 2, 14, 0, 3 },
  { 2767, 9, 5, 12, 1, -26 },
  { 2773, 15, 19, 19, 1, -19 },
  { 2809, 16, 26, 20, 2, -26 },
  { 2861, 14, 19, 16, 1, -19 },
  { 2895, 17, 26, 20, 1, -26 },
  { 2951, 16, 19, 19, 1, -19 },
  { 2989, 12, 26, 12, 1, -26 },
  { 3028, 17, 27, 20, 1, -19 },
  { 3086, 16, 26, 20, 2, -26 },
  { 3138, 5, 26, 9, 2, -26 },
  { 3155, 9, 34, 9, -2, -26 },
  { 3194, 17, 26, 19, 2, -26 },
  { 3250, 5, 26, 9, 2, -26 },
  { 3267, 26, 19, 30, 2, -19 },
  { 3329, 16, 19, 20, 2, -19 },
  { 3367, 17, 19, 20, 1, -19 },
  { 3408, 16, 27, 20, 2, -19 },
  { 3462, 17, 27, 20, 1, -19 },
  { 3520, 12, 19, 14, 2, -19 },
  { 3549, 13, 19, 15, 1, -19 },
  { 3580, 12, 23, 13, 1, -23 },
  { 3615, 16, 19, 20, 2, -19 },
  { 3653, 18, 19, 18, 0, -19 },
  { 3696, 27, 19, 27, 0, -19 },
  { 3761, 18, 19, 18, 0, -19 },
  { 3804, 18, 27, 18, 0, -19 },
  { 3865, 13, 19, 15, 1, -19 },
  { 3896, 11, 29, 13, 0, -24 },
  { 3936, 4, 34, 17, 7, -26 },
  { 3953, 11, 29, 13, 1, -24 },
  { 3993, 16, 6, 18, 1, -15 },
};

const GFXfont NotoSans_SemiCondensed_Bold34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold34pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD34PT7B_H_
