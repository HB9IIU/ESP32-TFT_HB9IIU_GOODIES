#ifndef _NOTOSANS_SEMICONDENSED_BOLD31PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xC0, 0x03,
  0xBF, 0xFF, 0xF8, 0xF3, 0xFE, 0x7F, 0xCF, 0xF8, 0xEF, 0x1D, 0xE3, 0xBC,
  0x77, 0x8E, 0x07, 0x9E, 0x03, 0xCE, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71,
  0xC0, 0x39, 0xE1, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0x1C, 0x03,
  0x8E, 0x01, 0xCF, 0x01, 0xE7, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE,
  0x1C, 0x70, 0x0E, 0x78, 0x0F, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x03, 0xFE, 0x3F, 0xFD, 0xFF, 0xE7,
  0xF7, 0xBE, 0xC2, 0xFB, 0x01, 0xEC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0xDF, 0x03, 0x3E, 0x0C, 0xFE, 0x33, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xC0, 0x78, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F,
  0x00, 0xE0, 0x3F, 0xC0, 0xF0, 0x1F, 0xE0, 0x70, 0x1E, 0x70, 0x78, 0x0F,
  0x3C, 0x38, 0x07, 0x1E, 0x3C, 0x03, 0x8F, 0x1C, 0x01, 0xC7, 0x9E, 0x00,
  0xF3, 0xCE, 0x30, 0x79, 0xCF, 0x7F, 0x1F, 0xE7, 0x3F, 0x8F, 0xF7, 0xBD,
  0xE3, 0xF3, 0x9C, 0x70, 0x03, 0xCE, 0x38, 0x01, 0xC7, 0x1E, 0x01, 0xE3,
  0x8F, 0x00, 0xE1, 0xC7, 0x00, 0xF0, 0xE3, 0x80, 0x70, 0x79, 0xC0, 0x78,
  0x3F, 0xE0, 0x38, 0x0F, 0xE0, 0x3C, 0x03, 0xE0, 0x0F, 0xE0, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xC7, 0x80, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x3C,
  0x78, 0x03, 0xEF, 0x80, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC1, 0xE3,
  0xFC, 0x3E, 0x7F, 0xE3, 0xEF, 0x9F, 0x3C, 0xF8, 0xFF, 0xCF, 0x87, 0xF8,
  0xF8, 0x3F, 0x8F, 0x81, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE1, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x0E, 0x1E, 0x1C, 0x3C,
  0x3C, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0x78, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0xF0, 0x78,
  0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x78, 0x70,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0xC7, 0x0B, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x7F, 0x01, 0xDE, 0x0F, 0x3C, 0x7C, 0xF0,
  0x21, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x7D, 0xF7, 0x9E, 0x7B, 0xCF, 0x38, 0xFF,
  0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x00, 0x0F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x9F, 0x3E, 0x78, 0x79, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0x78,
  0x7D, 0xE1, 0xF7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0x03, 0xC1,
  0xF1, 0xFC, 0xFF, 0x7F, 0xFE, 0xFF, 0x3D, 0x8F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x1F, 0xE1, 0xFF, 0xCF, 0xFF, 0x9F, 0x3F, 0x30, 0x7C, 0x81,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xE3, 0xFF, 0xC7, 0xFF, 0x9E, 0x3F,
  0x20, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x01, 0xF0, 0x7F, 0x81, 0xFC,
  0x07, 0xFC, 0x03, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x7E, 0x01,
  0xFF, 0x1F, 0xFF, 0xFE, 0xFF, 0xF1, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0x7C,
  0x0F, 0x7C, 0x1E, 0x7C, 0x1C, 0x7C, 0x3C, 0x7C, 0x38, 0x7C, 0x78, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x3F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x8F,
  0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7E, 0x01, 0xFF,
  0xBF, 0xBF, 0xFE, 0xFF, 0xF1, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xE1, 0xFF,
  0x8F, 0xE2, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF3, 0xF3, 0xDF,
  0xEF, 0xFF, 0xFF, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x3D, 0xE1, 0xF7, 0xEF, 0xCF, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9F, 0x1F, 0x78, 0x3D, 0xE0, 0xF7,
  0x87, 0xDF, 0x3E, 0x3F, 0xF8, 0x7F, 0x80, 0xFC, 0x0F, 0xFC, 0x7F, 0xF9,
  0xE1, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x87, 0xDF, 0xFF,
  0x3F, 0xF8, 0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9F, 0x3E, 0xF8,
  0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0xDF,
  0xFF, 0x7F, 0xFC, 0x7E, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE4,
  0x7F, 0x1F, 0xFC, 0x7F, 0xC1, 0xFE, 0x00, 0xF7, 0xFF, 0xF7, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x7F, 0xFF, 0xF0, 0x79, 0xF7, 0xDF, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF7, 0xDE, 0x79, 0xE7, 0x3C, 0xF0, 0x00, 0x04,
  0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xF0, 0x00,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x80, 0x0F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0xFC,
  0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFE, 0x03, 0xE0, 0x0E, 0x00, 0x20, 0x00,
  0x3F, 0xE7, 0xFF, 0x9F, 0xFC, 0xF3, 0xF4, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xCF, 0xC0, 0x78, 0x03, 0xC1,
  0xE0, 0x03, 0xC7, 0x81, 0x83, 0x8E, 0x1F, 0xE7, 0xBC, 0x7F, 0xC7, 0x71,
  0xE3, 0x8E, 0xE3, 0x87, 0x1F, 0xCF, 0x0E, 0x3F, 0x9E, 0x1C, 0x7F, 0x3C,
  0x38, 0xFE, 0x78, 0x71, 0xFC, 0xF1, 0xE3, 0xB8, 0xE3, 0xEE, 0x71, 0xFF,
  0xFC, 0xE1, 0xF9, 0xF1, 0xE0, 0xC0, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x02,
  0x03, 0xF8, 0x78, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7B, 0xC0,
  0x07, 0xBE, 0x00, 0xF9, 0xE0, 0x0F, 0x9E, 0x00, 0xF1, 0xF0, 0x0F, 0x0F,
  0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC7, 0xC0, 0x7C, 0x7C, 0x03, 0xC7, 0xC0, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x1F, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xFC, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0,
  0x07, 0xFC, 0x3F, 0xFC, 0xFF, 0xF9, 0xF9, 0xE7, 0xC0, 0x4F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x05, 0xFF, 0xF1,
  0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0xCF, 0x83, 0xF7, 0xC0, 0xFB, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x1F, 0xBF, 0xFF, 0x9F, 0xFF,
  0x8F, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xFE, 0x0F, 0xFF, 0x1F,
  0xFF, 0x3F, 0x9E, 0x7E, 0x02, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0x7C, 0x0F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F,
  0xFF, 0x07, 0xFE, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x9F, 0xFF, 0xFF, 0xFC,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x3E, 0x1F, 0x9F, 0xFF, 0xBF, 0xDF, 0x82, 0x00, 0xF0, 0x3F, 0xF0,
  0x3E, 0xF0, 0x7C, 0xF0, 0xF8, 0xF0, 0xF8, 0xF1, 0xF0, 0xF3, 0xE0, 0xF3,
  0xE0, 0xF7, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFB,
  0xE0, 0xF1, 0xF0, 0xF1, 0xF0, 0xF0, 0xF8, 0xF0, 0xF8, 0xF0, 0x7C, 0xF0,
  0x3E, 0xF0, 0x3E, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xB8, 0x0E, 0xFE, 0xF0, 0x3B,
  0xFB, 0xC1, 0xEF, 0xF7, 0x07, 0xBF, 0xDE, 0x1C, 0xFF, 0x78, 0xF7, 0xFD,
  0xE3, 0xDF, 0xF3, 0x8E, 0x7F, 0xCF, 0x79, 0xFF, 0x3D, 0xE7, 0xFC, 0x77,
  0x1F, 0xF1, 0xFC, 0x7F, 0xC7, 0xF1, 0xFF, 0x1F, 0x87, 0xFC, 0x3E, 0x1F,
  0xF0, 0xF8, 0x7F, 0xC3, 0xC1, 0xF0, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFE, 0xF8, 0x7F, 0xBE, 0x1F,
  0xF7, 0xC7, 0xFD, 0xF1, 0xFF, 0x3E, 0x7F, 0xC7, 0x8F, 0xF1, 0xF3, 0xFC,
  0x3C, 0xFF, 0x0F, 0xBF, 0xC1, 0xEF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0xC0, 0xFF, 0xFC, 0x3F, 0x9F, 0xC7, 0xC0, 0xF9, 0xF0, 0x0F, 0xBE, 0x01,
  0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xF7, 0xC0, 0x3E, 0xFC, 0x07,
  0xCF, 0x81, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF0,
  0x00, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xEF, 0x87, 0xDF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3D, 0xF0, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF,
  0xFF, 0x1F, 0xFC, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xC0,
  0xFF, 0xFC, 0x3F, 0x9F, 0xC7, 0xC0, 0xF9, 0xF0, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x1E, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xF7, 0xC0, 0x3E, 0xFC, 0x07, 0xCF,
  0x81, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80,
  0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0x87, 0xE7, 0xC1,
  0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3C, 0x7C, 0x3E, 0x3F, 0xFE, 0x1F,
  0xFE, 0x0F, 0xFE, 0x07, 0xCF, 0x83, 0xE3, 0xC1, 0xF1, 0xF0, 0xF8, 0x7C,
  0x7C, 0x3E, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x81, 0xF7, 0xC0, 0xFC, 0x1F,
  0xF1, 0xFF, 0xDF, 0xFE, 0xFD, 0xF7, 0x81, 0x7C, 0x01, 0xE0, 0x0F, 0x80,
  0x7E, 0x01, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x03, 0xE0,
  0x0F, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x3F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0x78, 0x0F, 0xBE, 0x0F, 0x9F, 0xFF, 0xC7, 0xFF, 0xC1,
  0xFF, 0xC0, 0x7F, 0xC0, 0xF8, 0x03, 0xFF, 0x00, 0x79, 0xE0, 0x1F, 0x3C,
  0x03, 0xC7, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E,
  0x0F, 0x03, 0xC3, 0xE0, 0x78, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x1E,
  0x78, 0x03, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x01,
  0xFF, 0x81, 0xF0, 0x1E, 0xF8, 0x1F, 0x01, 0xE7, 0x81, 0xF8, 0x3E, 0x78,
  0x1F, 0x83, 0xE7, 0xC3, 0xF8, 0x3C, 0x7C, 0x3F, 0x83, 0xC3, 0xC3, 0xBC,
  0x7C, 0x3C, 0x3B, 0xC7, 0xC3, 0xC7, 0xBC, 0x78, 0x3E, 0x79, 0xC7, 0x81,
  0xE7, 0x9E, 0x78, 0x1E, 0x71, 0xEF, 0x81, 0xEF, 0x1E, 0xF0, 0x1E, 0xF0,
  0xEF, 0x00, 0xFF, 0x0E, 0xF0, 0x0F, 0xE0, 0xEF, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C,
  0x07, 0xE0, 0xFC, 0x07, 0xDF, 0x03, 0xE3, 0xE0, 0xF0, 0x78, 0x7C, 0x1F,
  0x1E, 0x03, 0xCF, 0x80, 0xFB, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xC0,
  0x3E, 0xF8, 0x1F, 0x3E, 0x07, 0x87, 0xC3, 0xE1, 0xF1, 0xF0, 0x3E, 0x7C,
  0x07, 0xFE, 0x01, 0xF0, 0xF8, 0x07, 0xDF, 0x03, 0xE7, 0xC0, 0xF0, 0xF0,
  0x7C, 0x3E, 0x1E, 0x07, 0x8F, 0x81, 0xF3, 0xC0, 0x3D, 0xF0, 0x0F, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xFF, 0xF8, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0xFF, 0xFF, 0xF8,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xF0, 0x1C,
  0x70, 0x3C, 0x78, 0x38, 0x38, 0x78, 0x3C, 0x70, 0x1C, 0xF0, 0x1E, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7C, 0x3E, 0x1E, 0x07, 0x1F, 0xE0,
  0xFF, 0xE3, 0xFF, 0x86, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x1F, 0xC7, 0xFF,
  0x7F, 0xFD, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xE3, 0xF7, 0xFF,
  0xDF, 0xEF, 0x3F, 0x1C, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x79, 0xF8, 0xF7, 0xF9, 0xFF, 0xF3, 0xFB,
  0xF7, 0xC3, 0xEF, 0x83, 0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xF7, 0xC3, 0xEF, 0xEF, 0xDF, 0xFF, 0x3D, 0xFE, 0x79,
  0xF8, 0x0F, 0xF0, 0xFF, 0xCF, 0xFC, 0xFE, 0xE7, 0xC0, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0xBF, 0x38,
  0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x87, 0xCF, 0x3F, 0xDE, 0x7F, 0xFD,
  0xFB, 0xFB, 0xE1, 0xF7, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3D, 0xE0, 0xFB, 0xE1, 0xF7, 0xE7, 0xE7, 0xFF, 0xCF, 0xF7,
  0x8F, 0xCF, 0x0F, 0xE0, 0x3F, 0xF0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xCF,
  0x07, 0xBE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x0F, 0xC1, 0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8, 0x03, 0xE0,
  0xFF, 0x1F, 0xF1, 0xFE, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xFE, 0xFF, 0xEF,
  0xFE, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x9E,
  0x7F, 0xBC, 0xFF, 0xFB, 0xF3, 0xF7, 0xC3, 0xEF, 0x07, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7B, 0xC1, 0xF7, 0xC3, 0xEF, 0xCF,
  0xCF, 0xFF, 0x9F, 0xEF, 0x1F, 0x9E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF7,
  0x07, 0xCF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF8, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0xFC, 0xF7, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0x27, 0xFF, 0xF7, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x04, 0x1E, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xBE, 0xFE, 0xFE, 0xFC, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0xF9, 0xF0, 0xFB,
  0xE0, 0xFF, 0xC0, 0xF7, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFD, 0xE0, 0xF9,
  0xF0, 0xF8, 0xF8, 0xF8, 0x78, 0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xF1, 0xF8, 0xF7, 0xFB, 0xFC, 0xFF, 0xFF, 0xFE, 0xFE,
  0xFF, 0xFE, 0xF8, 0x7E, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8,
  0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8,
  0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8,
  0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF3, 0xF3, 0xDF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3C, 0x0F,
  0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xF3, 0xE7, 0xC3, 0xEF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7B, 0xC0, 0xF7, 0xC3, 0xEF,
  0xCF, 0x8F, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0xF3, 0xF1, 0xEF, 0xF3, 0xFF,
  0xE7, 0xF7, 0xEF, 0x87, 0xDF, 0x07, 0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xEF, 0x87, 0xDF, 0xDF, 0xBF, 0xFE, 0x7B,
  0xFC, 0xF3, 0xF1, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x9E, 0x7F, 0xBC, 0xFF, 0xFB, 0xF7, 0xF7,
  0xC3, 0xEF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7B, 0xC1, 0xF7, 0xC3, 0xEF, 0xCF, 0xCF, 0xFF, 0x9F, 0xEF, 0x1F, 0x9E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0xF3, 0xFD, 0xFF, 0x7F, 0xFF, 0xFE, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x1F,
  0xE7, 0xFF, 0x7F, 0xEF, 0x86, 0xF0, 0x0F, 0x80, 0x7E, 0x07, 0xF8, 0x3F,
  0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x1F, 0xFF, 0xEF, 0xFE, 0x7F,
  0x80, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x93,
  0xFC, 0xFF, 0x1F, 0xC0, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE,
  0x0F, 0xF8, 0x7F, 0xF3, 0xF7, 0xFF, 0xDF, 0xF7, 0x3F, 0x9C, 0xF8, 0x1F,
  0x78, 0x1F, 0x78, 0x1E, 0x7C, 0x1E, 0x3C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x78,
  0x7E, 0x0F, 0x78, 0x7E, 0x1F, 0x78, 0x7E, 0x1E, 0x7C, 0x7F, 0x1E, 0x3C,
  0x77, 0x1E, 0x3C, 0xF7, 0x3E, 0x3C, 0xE7, 0x3C, 0x3E, 0xE7, 0xBC, 0x1E,
  0xE3, 0xBC, 0x1E, 0xE3, 0xBC, 0x1F, 0xE3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F,
  0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0xFC,
  0x1F, 0x7C, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x1F, 0x78, 0x0F, 0xF8, 0x0F,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1E,
  0x78, 0x3E, 0x7C, 0x3C, 0x3E, 0x7C, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0x78,
  0x1F, 0x78, 0x1E, 0x7C, 0x1E, 0x3C, 0x3E, 0x3C, 0x3C, 0x3E, 0x3C, 0x1E,
  0x7C, 0x1E, 0x78, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0,
  0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0xFC, 0xFE, 0x3E, 0x0F, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0x0F, 0xC1, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x3F, 0x0F, 0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x7E, 0x0F, 0xC0, 0xF0, 0xFC, 0x7C, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0x00, 0x00,
  0x05, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFE, 0x00, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Bold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 22, 8, 2, -22 },
  { 15, 11, 8, 14, 2, -22 },
  { 26, 17, 22, 18, 1, -22 },
  { 73, 14, 26, 17, 1, -24 },
  { 119, 25, 22, 26, 1, -22 },
  { 188, 20, 22, 21, 1, -22 },
  { 243, 4, 8, 8, 2, -22 },
  { 247, 8, 27, 10, 1, -22 },
  { 274, 8, 27, 10, 1, -22 },
  { 301, 14, 14, 16, 1, -24 },
  { 326, 14, 15, 16, 1, -18 },
  { 353, 6, 8, 8, 1, -4 },
  { 359, 8, 4, 10, 1, -10 },
  { 363, 5, 5, 8, 2, -5 },
  { 367, 13, 22, 13, 0, -22 },
  { 403, 14, 22, 16, 1, -22 },
  { 442, 10, 22, 16, 2, -22 },
  { 470, 14, 22, 16, 1, -22 },
  { 509, 14, 22, 16, 1, -22 },
  { 548, 16, 22, 16, 0, -22 },
  { 592, 14, 22, 16, 1, -22 },
  { 631, 14, 22, 16, 1, -22 },
  { 670, 14, 22, 16, 1, -22 },
  { 709, 14, 22, 16, 1, -22 },
  { 748, 14, 22, 16, 1, -22 },
  { 787, 5, 17, 8, 2, -17 },
  { 798, 6, 21, 9, 1, -17 },
  { 814, 14, 16, 16, 1, -19 },
  { 842, 14, 10, 16, 1, -16 },
  { 860, 14, 16, 16, 1, -19 },
  { 888, 13, 22, 14, 0, -22 },
  { 924, 23, 24, 26, 1, -22 },
  { 993, 20, 22, 20, 0, -22 },
  { 1048, 16, 22, 19, 2, -22 },
  { 1092, 15, 22, 18, 2, -22 },
  { 1134, 17, 22, 21, 2, -22 },
  { 1181, 11, 22, 16, 3, -22 },
  { 1212, 11, 22, 16, 3, -22 },
  { 1243, 16, 22, 21, 2, -22 },
  { 1287, 16, 22, 22, 3, -22 },
  { 1331, 9, 22, 11, 1, -22 },
  { 1356, 9, 29, 10, -2, -22 },
  { 1389, 16, 22, 19, 3, -22 },
  { 1433, 13, 22, 16, 2, -22 },
  { 1469, 22, 22, 27, 3, -22 },
  { 1530, 18, 22, 23, 3, -22 },
  { 1580, 19, 22, 22, 2, -22 },
  { 1633, 15, 22, 18, 2, -22 },
  { 1675, 19, 27, 22, 2, -22 },
  { 1740, 17, 22, 19, 2, -22 },
  { 1787, 13, 22, 16, 1, -22 },
  { 1823, 15, 22, 16, 1, -22 },
  { 1865, 17, 22, 21, 2, -22 },
  { 1912, 19, 22, 19, 0, -22 },
  { 1965, 28, 22, 27, 0, -22 },
  { 2042, 18, 22, 19, 0, -22 },
  { 2092, 18, 22, 18, 0, -22 },
  { 2142, 14, 22, 16, 1, -22 },
  { 2181, 7, 27, 10, 2, -22 },
  { 2205, 13, 22, 13, 0, -22 },
  { 2241, 7, 27, 10, 1, -22 },
  { 2265, 16, 14, 17, 1, -22 },
  { 2293, 13, 2, 13, 0, 3 },
  { 2297, 8, 5, 11, 1, -24 },
  { 2302, 14, 17, 17, 1, -17 },
  { 2332, 15, 24, 18, 2, -24 },
  { 2377, 13, 17, 15, 1, -17 },
  { 2405, 15, 24, 18, 1, -24 },
  { 2450, 15, 17, 17, 1, -17 },
  { 2482, 12, 24, 11, 0, -24 },
  { 2518, 15, 24, 18, 1, -17 },
  { 2563, 14, 24, 18, 2, -24 },
  { 2605, 5, 24, 9, 2, -24 },
  { 2620, 8, 31, 9, -1, -24 },
  { 2651, 16, 24, 18, 2, -24 },
  { 2699, 5, 24, 9, 2, -24 },
  { 2714, 24, 17, 28, 2, -17 },
  { 2765, 14, 17, 18, 2, -17 },
  { 2795, 15, 17, 18, 1, -17 },
  { 2827, 15, 24, 18, 2, -17 },
  { 2872, 15, 24, 18, 1, -17 },
  { 2917, 10, 17, 13, 2, -17 },
  { 2939, 12, 17, 14, 1, -17 },
  { 2965, 10, 21, 12, 1, -21 },
  { 2992, 14, 17, 18, 2, -17 },
  { 3022, 16, 17, 16, 0, -17 },
  { 3056, 24, 17, 25, 0, -17 },
  { 3107, 16, 17, 16, 0, -17 },
  { 3141, 16, 24, 16, 0, -17 },
  { 3189, 12, 17, 14, 1, -17 },
  { 3215, 10, 27, 12, 0, -22 },
  { 3249, 4, 31, 16, 6, -24 },
  { 3265, 10, 27, 12, 1, -22 },
  { 3299, 14, 6, 16, 1, -14 },
};

const GFXfont NotoSans_SemiCondensed_Bold31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold31pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD31PT7B_H_
