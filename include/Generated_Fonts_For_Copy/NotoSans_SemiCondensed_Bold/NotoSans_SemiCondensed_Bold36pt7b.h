#ifndef _NOTOSANS_SEMICONDENSED_BOLD36PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE0, 0x00, 0x23, 0xEF, 0xFF, 0xFD, 0xE0, 0xF8, 0xFF, 0xC7,
  0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0x7C, 0x7B, 0xE3, 0xCF, 0x1E, 0x78, 0xF3,
  0x87, 0x80, 0x01, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78,
  0x03, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0x8F, 0x07, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x70, 0xE0, 0x07, 0x1E, 0x00, 0xF1,
  0xE0, 0x0F, 0x1E, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE1, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0x80, 0x1E, 0x38, 0x01,
  0xC7, 0x80, 0x1C, 0x78, 0x03, 0xC7, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0xE0, 0x1F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xF9, 0x84, 0xF9,
  0x80, 0xF9, 0x80, 0xFD, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xBF, 0x01, 0x9F, 0x81, 0x9F, 0xC1,
  0xBF, 0xFD, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x1F, 0x00, 0x1E, 0x01, 0xFE, 0x01, 0xE0,
  0x1F, 0xF0, 0x0F, 0x00, 0xF7, 0xC0, 0xF0, 0x0F, 0x9E, 0x07, 0x80, 0x78,
  0xF0, 0x78, 0x03, 0xC7, 0xC3, 0xC0, 0x1E, 0x1E, 0x3C, 0x00, 0xF0, 0xF1,
  0xE0, 0x07, 0x8F, 0x9E, 0x00, 0x3C, 0x78, 0xF1, 0xE1, 0xF3, 0xCF, 0x3F,
  0x87, 0xBE, 0x7B, 0xFE, 0x3F, 0xE7, 0x9F, 0xF8, 0xFF, 0x3C, 0xF3, 0xC3,
  0xE3, 0xCF, 0x1E, 0x00, 0x1E, 0x78, 0xF8, 0x01, 0xE3, 0xC3, 0xC0, 0x0F,
  0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0xF0, 0x07, 0x87, 0x8F, 0x80, 0x78, 0x3E,
  0x78, 0x03, 0xC0, 0xF3, 0xC0, 0x3C, 0x07, 0xFE, 0x01, 0xE0, 0x1F, 0xE0,
  0x1E, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0,
  0x1F, 0x0F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFE, 0x07, 0xE7, 0xFE, 0x0F, 0x8F, 0xFE, 0x1F, 0x3F,
  0x7E, 0x7E, 0x7C, 0x7E, 0xF9, 0xF8, 0x7F, 0xF3, 0xF0, 0x7F, 0xC7, 0xE0,
  0xFF, 0x8F, 0xC0, 0xFE, 0x0F, 0xC3, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFE, 0xFC, 0x1F, 0xF0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0x7B, 0x80, 0x07, 0x87, 0x87, 0xC3, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0x78,
  0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0xC3, 0xE0, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xF8,
  0x3C, 0x0F, 0xF0, 0x3C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F,
  0x07, 0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x87, 0x87, 0xC3, 0xC3, 0xE1,
  0xE1, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x63, 0xC7,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0,
  0x1F, 0x78, 0x3E, 0x7C, 0x3E, 0x3E, 0x0C, 0x38, 0x04, 0x20, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x3E,
  0xFD, 0xF3, 0xE7, 0xCF, 0x1E, 0x78, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x33, 0xEF, 0xFF, 0xFD, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0xC3, 0xE3, 0xE3, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E,
  0x7C, 0x1F, 0x7E, 0x0F, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xBE, 0x0F, 0xDF, 0x07, 0xCF,
  0x83, 0xE7, 0xC1, 0xF1, 0xF1, 0xF8, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC,
  0x03, 0xF8, 0x00, 0x00, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x1F, 0xF3, 0xFF,
  0x7F, 0xFF, 0xDF, 0x79, 0xF2, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x07, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF,
  0x9F, 0xFF, 0xC7, 0xE7, 0xF1, 0xC0, 0xF8, 0x40, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xC7,
  0xF1, 0x80, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x7F, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x01,
  0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x78,
  0xF8, 0x3C, 0x3E, 0x0F, 0x0F, 0x87, 0x83, 0xE1, 0xE0, 0xF8, 0xF0, 0x3E,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x7F, 0xFC, 0x7F,
  0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x80, 0x3E, 0xE0, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F,
  0xE0, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFC, 0x11,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x78, 0x1E, 0x7F,
  0x1F, 0x7F, 0xCF, 0xFF, 0xF7, 0xFB, 0xFB, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xEF, 0x81, 0xF7, 0xC1, 0xFB, 0xF1, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F,
  0xFF, 0xE7, 0xE3, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F,
  0x1F, 0x9F, 0x0F, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xFF,
  0xF8, 0xFC, 0xFE, 0x7C, 0x1F, 0x7C, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x07, 0xFC,
  0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0xE7, 0xF3,
  0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07,
  0xFF, 0x83, 0xF7, 0xE3, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xDF, 0x0F,
  0xCF, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xF0,
  0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x7B, 0xFF, 0xFF,
  0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x3E, 0xFF, 0xFF, 0xDE,
  0x3C, 0xFD, 0xFB, 0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x7D, 0xF3, 0xE7, 0xCF, 0x1E, 0x78, 0xF0, 0x00, 0x00,
  0x80, 0x01, 0xC0, 0x03, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xF0,
  0x00, 0x60, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xE7,
  0xC7, 0xE4, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x01, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0x83, 0xF8, 0x1F, 0x80, 0x1F, 0x07, 0x80, 0x03,
  0xC3, 0xC0, 0x00, 0x79, 0xE0, 0xFF, 0x8E, 0x78, 0x7F, 0xE3, 0xFC, 0x3F,
  0xF8, 0xFF, 0x1F, 0x1E, 0x1F, 0xC7, 0x87, 0x87, 0xF1, 0xE1, 0xE1, 0xF8,
  0xF0, 0x78, 0x7E, 0x3C, 0x1E, 0x1F, 0x8F, 0x07, 0x87, 0xE3, 0xC1, 0xE3,
  0xF8, 0x78, 0x78, 0xFF, 0x1E, 0x3F, 0x7B, 0xC7, 0xFD, 0xFE, 0xF0, 0xFE,
  0x7F, 0x1E, 0x0F, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x18, 0x07, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xE0,
  0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x3F, 0x3E, 0x00,
  0x7E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFC, 0xFF, 0xC0, 0x7F, 0xFE, 0x3F,
  0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xBE, 0x1F, 0xDF, 0xFF, 0xCF, 0xFF, 0x87, 0xFF,
  0xF3, 0xFF, 0xFD, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFC,
  0x7F, 0xF8, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE,
  0x3F, 0xCF, 0x8F, 0xC0, 0x27, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x4F, 0xE0, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF9, 0xF0, 0x3F, 0xBE, 0x03, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0x7C,
  0x07, 0xEF, 0x81, 0xFD, 0xF3, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF,
  0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xBF,
  0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBE, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFE, 0x7C, 0x7F, 0x00, 0x9F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x0F, 0xBF, 0x01, 0xF7, 0xE0, 0x3E, 0x7F,
  0x07, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xF0, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x0F, 0xFF, 0xEF, 0xFB, 0xFC, 0xFE, 0x08, 0x00, 0xF8, 0x07, 0xFF, 0x01,
  0xFB, 0xE0, 0x3E, 0x7C, 0x0F, 0xCF, 0x83, 0xF1, 0xF0, 0xFC, 0x3E, 0x1F,
  0x87, 0xC7, 0xE0, 0xF9, 0xF8, 0x1F, 0x3F, 0x03, 0xEF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFC, 0xFC,
  0x1F, 0x1F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xF1, 0xF0, 0x3F,
  0x3E, 0x07, 0xE7, 0xC0, 0x7E, 0xF8, 0x0F, 0xDF, 0x00, 0xFC, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x78, 0x07, 0xFF, 0xDE, 0x03, 0xFF, 0xFF, 0x80,
  0xF7, 0xFF, 0xF0, 0x3D, 0xFF, 0xBC, 0x1F, 0x7F, 0xEF, 0x07, 0x9F, 0xFB,
  0xE1, 0xE7, 0xFE, 0x78, 0x79, 0xFF, 0x9E, 0x3C, 0x7F, 0xE7, 0xCF, 0x1F,
  0xF8, 0xF3, 0xC7, 0xFE, 0x3D, 0xE1, 0xFF, 0x8F, 0x78, 0x7F, 0xE3, 0xFE,
  0x1F, 0xF8, 0x7F, 0x07, 0xFE, 0x1F, 0xC1, 0xFF, 0x87, 0xF0, 0x7F, 0xE0,
  0xFC, 0x1F, 0xF8, 0x3E, 0x07, 0xFE, 0x0F, 0x81, 0xF0, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x03, 0xFE, 0xF8, 0x1F, 0xF7, 0xE0, 0xFF, 0xDF, 0x07, 0xFE,
  0xFC, 0x3F, 0xF3, 0xE1, 0xFF, 0x9F, 0x8F, 0xFC, 0x7C, 0x7F, 0xE3, 0xF3,
  0xFF, 0x0F, 0x9F, 0xF8, 0x7E, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xCF, 0xF1, 0xFC, 0x0F, 0xE7, 0xE0,
  0x1F, 0x9F, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0x9F, 0x80,
  0x7E, 0x7E, 0x03, 0xF8, 0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xCF, 0xF1,
  0xFC, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x7E, 0x03, 0xF8, 0xFE, 0x1F, 0xC3, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F,
  0xFF, 0xF1, 0xF0, 0x7E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F,
  0x03, 0xE3, 0xE0, 0xFC, 0x7C, 0x3F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F,
  0xFC, 0x07, 0xFF, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x83, 0xE1, 0xF0, 0x7C,
  0x3F, 0x0F, 0x83, 0xF1, 0xF0, 0x7E, 0x3E, 0x07, 0xE7, 0xC0, 0xFC, 0xF8,
  0x0F, 0xDF, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFE,
  0x7F, 0xFE, 0x7C, 0x04, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x3F, 0xF8, 0x7E,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x1F, 0x9F, 0xFF, 0xF1, 0xFF,
  0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDF,
  0x00, 0x3E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x3E,
  0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xC0, 0x3E, 0x3E, 0x00, 0xF1, 0xF0,
  0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x00, 0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8,
  0x07, 0xE0, 0x3F, 0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0x3E, 0x7C,
  0x0F, 0xF0, 0x3E, 0x7C, 0x0F, 0xF0, 0x7E, 0x3E, 0x0F, 0xF0, 0x7C, 0x3E,
  0x0F, 0xF0, 0x7C, 0x3E, 0x1F, 0xF8, 0x7C, 0x3E, 0x1E, 0x78, 0x7C, 0x3E,
  0x1E, 0x78, 0xF8, 0x1F, 0x1E, 0x78, 0xF8, 0x1F, 0x3E, 0x78, 0xF8, 0x1F,
  0x3E, 0x7C, 0xF8, 0x1F, 0x3C, 0x3C, 0xF8, 0x0F, 0x3C, 0x3D, 0xF0, 0x0F,
  0xBC, 0x3D, 0xF0, 0x0F, 0xFC, 0x3D, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xF0, 0x1F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x7C,
  0x01, 0xFB, 0xF0, 0x1F, 0x8F, 0x80, 0xFC, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E,
  0x0F, 0xC7, 0xE0, 0x3E, 0x3E, 0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3E, 0xF8, 0x03, 0xF7,
  0xE0, 0x1F, 0x1F, 0x81, 0xF8, 0x7C, 0x0F, 0x83, 0xF0, 0xFC, 0x0F, 0x8F,
  0xC0, 0x7E, 0x7E, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xFB, 0xE0,
  0x1F, 0x9F, 0x80, 0xF8, 0x7C, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xE0,
  0x7C, 0x3F, 0x03, 0xF1, 0xF0, 0x0F, 0x9F, 0x80, 0x7E, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0xF7, 0x80, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF0,
  0x7C, 0x3C, 0x0F, 0x1E, 0x03, 0xE7, 0x80, 0x7B, 0xC0, 0x1F, 0xF0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x80, 0xF0, 0x07, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x1C,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0xFF, 0x3F, 0xFF, 0x7F,
  0xFF, 0x7E, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0x7F,
  0xFF, 0x7F, 0xFF, 0x3F, 0xEF, 0x1F, 0xC7, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF9, 0xF0,
  0xF9, 0xFE, 0x7D, 0xFF, 0xBF, 0xFF, 0xDF, 0xE7, 0xFF, 0xC1, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0x7D, 0xFF, 0x3E, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0xF3, 0xFF, 0xDF, 0xFE,
  0x7E, 0x3B, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x83, 0x7F, 0xFD, 0xFF,
  0xF3, 0xFF, 0xC3, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x1F, 0x3F, 0x3F, 0xCF, 0xBF,
  0xF7, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0xE0, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xF7, 0xC7,
  0xF3, 0xE0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x02, 0x7F, 0xFE,
  0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x00, 0x80, 0x7F, 0xC7, 0xFE, 0x3F,
  0xF3, 0xFF, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3F, 0xF7, 0xFF, 0xBF, 0xFD,
  0xFF, 0xE3, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x8F, 0x9F, 0xE7, 0xCF, 0xFB, 0xEF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x7F, 0x7F, 0xFF, 0xBF, 0xF7, 0xCF, 0xFF, 0xE3, 0xFB, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x80, 0x7E, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F,
  0xFF, 0x0F, 0xFF, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF9, 0xF8, 0xF9,
  0xFE, 0x7D, 0xFF, 0xBF, 0xFF, 0xDF, 0xE7, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xE0, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFB, 0xFE, 0xFF, 0xBF, 0xCF, 0xE1, 0xE0, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x7E, 0xF8, 0x1F, 0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xE3,
  0xF0, 0xF9, 0xF8, 0x3E, 0xFC, 0x0F, 0xBE, 0x03, 0xDF, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xF7, 0xE0, 0xF8, 0xF8, 0x3E, 0x3F, 0x0F,
  0x87, 0xE3, 0xE0, 0xF8, 0xF8, 0x3F, 0x3E, 0x07, 0xEF, 0x81, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xFC, 0x1F, 0x8F,
  0xBF, 0xE7, 0xFC, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0x3F,
  0xE7, 0xFF, 0xC1, 0xFC, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x1F,
  0xFC, 0x1F, 0x81, 0xFF, 0xC1, 0xF8, 0x1F, 0xFC, 0x1F, 0x81, 0xFF, 0xC1,
  0xF8, 0x1F, 0xFC, 0x1F, 0x81, 0xFF, 0xC1, 0xF8, 0x1F, 0xFC, 0x1F, 0x81,
  0xFF, 0xC1, 0xF8, 0x1F, 0xFC, 0x1F, 0x81, 0xFF, 0xC1, 0xF8, 0x1F, 0xFC,
  0x1F, 0x81, 0xFF, 0xC1, 0xF8, 0x1F, 0xF0, 0xFC, 0x7D, 0xFF, 0x3E, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xF0, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xE3, 0xF7,
  0xE0, 0xFB, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xF0, 0x7C, 0xF8, 0x7E, 0x7F,
  0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFE, 0x00, 0xF8, 0xF8, 0x7C, 0xFF,
  0x3E, 0xFF, 0xDF, 0xFF, 0xEF, 0xF3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xBE, 0xFF,
  0x9F, 0xBF, 0x8F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x0F, 0x8F,
  0x9F, 0xF7, 0xCF, 0xFB, 0xEF, 0xFF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F, 0x7F, 0xFF, 0xBF, 0xF7,
  0xCF, 0xFB, 0xE3, 0xFB, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0xF0, 0xFF, 0x9F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0xFF, 0xF7, 0xFF, 0x9F,
  0xFE, 0xFC, 0x1B, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0x1F, 0xF8, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F,
  0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7E, 0xFC, 0x7F, 0x7F, 0xFF, 0xBF, 0xFF, 0xCF, 0xF9, 0xE3, 0xF8, 0xF0,
  0xF8, 0x07, 0xFF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xE0, 0xF8,
  0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0,
  0x7C, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x0F, 0x78, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00,
  0xF8, 0x1F, 0x81, 0xF7, 0xC1, 0xF8, 0x1F, 0x7C, 0x1F, 0xC1, 0xF7, 0xC1,
  0xFC, 0x3E, 0x7C, 0x3F, 0xC3, 0xE3, 0xE3, 0xFC, 0x3E, 0x3E, 0x3D, 0xC3,
  0xE3, 0xE3, 0xDE, 0x7C, 0x3E, 0x39, 0xE7, 0xC1, 0xF7, 0x9E, 0x7C, 0x1F,
  0x78, 0xE7, 0xC1, 0xF7, 0x8E, 0x78, 0x1F, 0x70, 0xFF, 0x80, 0xF7, 0x0F,
  0xF8, 0x0F, 0x70, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00,
  0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0xFC, 0x07,
  0xCF, 0xC1, 0xF8, 0xF8, 0x7E, 0x1F, 0x8F, 0xC1, 0xF3, 0xF0, 0x3F, 0x7C,
  0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xEF, 0x80, 0xF9, 0xF8,
  0x3F, 0x1F, 0x87, 0xC1, 0xF1, 0xF8, 0x3F, 0x7E, 0x03, 0xF0, 0xFC, 0x07,
  0xFF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x83, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0x78,
  0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x3F, 0x07, 0xF0, 0x7F,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x0F, 0x81, 0xF8, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0xF8,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C,
  0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xF0, 0x3F,
  0x03, 0xF0, 0xFF, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0xFF, 0x0F, 0xE0, 0xFC, 0x0C, 0x00,
  0x0C, 0x00, 0xBF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x03,
  0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Bold36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 26, 10, 2, -26 },
  { 21, 13, 10, 17, 2, -26 },
  { 38, 20, 26, 21, 1, -26 },
  { 103, 16, 29, 19, 2, -27 },
  { 161, 29, 26, 31, 1, -26 },
  { 256, 23, 26, 24, 1, -26 },
  { 331, 5, 10, 9, 2, -26 },
  { 338, 9, 32, 12, 2, -26 },
  { 374, 9, 32, 12, 1, -26 },
  { 410, 16, 16, 18, 1, -27 },
  { 442, 17, 17, 19, 1, -21 },
  { 479, 7, 9, 10, 1, -4 },
  { 487, 9, 5, 11, 1, -12 },
  { 493, 6, 6, 10, 2, -6 },
  { 498, 15, 26, 15, 0, -26 },
  { 547, 17, 26, 19, 1, -26 },
  { 603, 12, 26, 19, 2, -26 },
  { 642, 17, 26, 19, 1, -26 },
  { 698, 17, 26, 19, 1, -26 },
  { 754, 18, 26, 19, 1, -26 },
  { 813, 16, 26, 19, 2, -26 },
  { 865, 17, 26, 19, 1, -26 },
  { 921, 17, 26, 19, 1, -26 },
  { 977, 17, 26, 19, 1, -26 },
  { 1033, 17, 26, 19, 1, -26 },
  { 1089, 6, 20, 10, 2, -20 },
  { 1104, 7, 25, 10, 1, -20 },
  { 1126, 17, 18, 19, 1, -22 },
  { 1165, 17, 11, 19, 1, -18 },
  { 1189, 17, 18, 19, 1, -22 },
  { 1228, 15, 26, 16, 0, -26 },
  { 1277, 26, 29, 30, 2, -26 },
  { 1372, 23, 26, 23, 0, -26 },
  { 1447, 17, 26, 22, 3, -26 },
  { 1503, 18, 26, 21, 2, -26 },
  { 1562, 19, 26, 24, 3, -26 },
  { 1624, 14, 26, 19, 3, -26 },
  { 1670, 13, 26, 18, 3, -26 },
  { 1713, 19, 26, 24, 2, -26 },
  { 1775, 19, 26, 25, 3, -26 },
  { 1837, 11, 26, 13, 1, -26 },
  { 1873, 10, 34, 11, -2, -26 },
  { 1916, 19, 26, 22, 3, -26 },
  { 1978, 14, 26, 18, 3, -26 },
  { 2024, 26, 26, 32, 3, -26 },
  { 2109, 21, 26, 27, 3, -26 },
  { 2178, 22, 26, 26, 2, -26 },
  { 2250, 16, 26, 21, 3, -26 },
  { 2302, 22, 32, 26, 2, -26 },
  { 2390, 19, 26, 22, 3, -26 },
  { 2452, 16, 26, 18, 1, -26 },
  { 2504, 17, 26, 19, 1, -26 },
  { 2560, 19, 26, 25, 3, -26 },
  { 2622, 21, 26, 21, 0, -26 },
  { 2691, 32, 26, 32, 0, -26 },
  { 2795, 21, 26, 22, 0, -26 },
  { 2864, 21, 26, 21, 0, -26 },
  { 2933, 17, 26, 19, 1, -26 },
  { 2989, 9, 32, 12, 2, -26 },
  { 3025, 15, 26, 15, 0, -26 },
  { 3074, 8, 32, 12, 1, -26 },
  { 3106, 18, 17, 20, 1, -26 },
  { 3145, 15, 3, 15, 0, 3 },
  { 3151, 10, 6, 12, 1, -28 },
  { 3159, 16, 20, 20, 1, -20 },
  { 3199, 17, 27, 21, 2, -27 },
  { 3257, 14, 20, 17, 2, -20 },
  { 3292, 17, 27, 21, 2, -27 },
  { 3350, 16, 20, 20, 2, -20 },
  { 3390, 13, 28, 13, 1, -28 },
  { 3436, 17, 29, 21, 2, -20 },
  { 3498, 17, 27, 21, 2, -27 },
  { 3556, 6, 27, 10, 2, -27 },
  { 3577, 10, 36, 10, -2, -27 },
  { 3622, 18, 27, 21, 3, -27 },
  { 3683, 6, 27, 10, 2, -27 },
  { 3704, 28, 20, 32, 2, -20 },
  { 3774, 17, 20, 21, 2, -20 },
  { 3817, 17, 20, 21, 2, -20 },
  { 3860, 17, 29, 21, 2, -20 },
  { 3922, 17, 29, 21, 2, -20 },
  { 3984, 12, 20, 15, 2, -20 },
  { 4014, 14, 20, 16, 1, -20 },
  { 4049, 12, 24, 14, 1, -24 },
  { 4085, 17, 20, 21, 2, -20 },
  { 4128, 19, 20, 19, 0, -20 },
  { 4176, 28, 20, 28, 0, -20 },
  { 4246, 19, 20, 19, 0, -20 },
  { 4294, 19, 29, 19, 0, -20 },
  { 4363, 14, 20, 16, 1, -20 },
  { 4398, 12, 32, 14, 0, -26 },
  { 4446, 4, 35, 18, 7, -27 },
  { 4464, 12, 32, 14, 1, -26 },
  { 4512, 17, 6, 19, 1, -16 },
};

const GFXfont NotoSans_SemiCondensed_Bold36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold36pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD36PT7B_H_
