#ifndef _NOTOSANS_SEMICONDENSED_BOLD32PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x7B, 0xDE, 0x00,
  0x1D, 0xFF, 0xFF, 0xC0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0x03, 0x8E, 0x01, 0xC7, 0x01, 0xE7, 0x80, 0xF3, 0xC0,
  0x71, 0xC0, 0x38, 0xE1, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0xC3, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x87, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x9E, 0x03, 0xCF, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0x01, 0x80, 0x03, 0x00, 0x1F, 0xC0, 0xFF, 0xE7,
  0xFF, 0xCF, 0xFF, 0xBE, 0x62, 0x7C, 0xC0, 0xF9, 0x80, 0xFB, 0x01, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xBF,
  0x03, 0x7F, 0x86, 0xFF, 0xFF, 0xEF, 0xFF, 0x8F, 0xFE, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x3F, 0x00, 0xF0, 0x3F, 0xC0, 0x70, 0x1F,
  0xE0, 0x78, 0x1E, 0x78, 0x38, 0x0F, 0x3C, 0x3C, 0x07, 0x8E, 0x1C, 0x03,
  0xC7, 0x1E, 0x01, 0xE3, 0x8E, 0x00, 0xF3, 0xCF, 0x00, 0x79, 0xE7, 0x1E,
  0x3C, 0xF7, 0x9F, 0xCF, 0xF3, 0x9F, 0xE7, 0xFB, 0xCE, 0x78, 0xF9, 0xCF,
  0x3C, 0x01, 0xE7, 0x8E, 0x00, 0xE3, 0xC7, 0x00, 0xF1, 0xE3, 0x80, 0x70,
  0xF1, 0xC0, 0x78, 0x78, 0xE0, 0x3C, 0x1C, 0xF0, 0x3C, 0x0F, 0xF8, 0x1E,
  0x03, 0xF8, 0x1E, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xF8, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF1, 0xF0, 0x07,
  0xCF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x83,
  0xE7, 0xFE, 0x1E, 0x3E, 0xF9, 0xF3, 0xE3, 0xEF, 0x9F, 0x0F, 0xF8, 0xF8,
  0x7F, 0xC7, 0xC1, 0xFC, 0x3F, 0x07, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x3F, 0xC7, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x87,
  0x87, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE0, 0xF0,
  0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E,
  0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x20, 0xE1, 0xF3, 0xBF, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8,
  0x0F, 0xC0, 0x7F, 0x83, 0xEF, 0x1F, 0x3E, 0x3C, 0x70, 0x21, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x7D, 0xF7, 0x9E, 0x79, 0xCF, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xC7, 0xC7, 0xCF, 0x07, 0x9E, 0x0F, 0x7C, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0x78, 0x3C, 0xF0, 0x79, 0xF1, 0xF3, 0xFF, 0xE3, 0xFF, 0x83,
  0xFE, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x3F, 0x8F, 0xF3, 0xFE, 0xFF,
  0xFE, 0xFB, 0x9F, 0x23, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE7, 0xFF, 0xE7, 0x87, 0xC4, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0xF3,
  0xFF, 0xE3, 0xFF, 0xE2, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xF7, 0xDF, 0xEF, 0xFF, 0x9F,
  0xFF, 0x1F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0x78, 0x0F, 0xF8, 0x0E, 0xF8, 0x1E, 0xF8,
  0x3C, 0xF8, 0x38, 0xF8, 0x78, 0xF8, 0xF0, 0xF8, 0xF0, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x3F, 0xFC, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0xF3, 0x03, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0x61,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE8, 0x0F, 0xBF,
  0xFE, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xF8, 0x7F,
  0xF1, 0xFF, 0xE3, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF9, 0xE1,
  0xEF, 0xF3, 0xDF, 0xF7, 0xFF, 0xEF, 0xC3, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3E, 0xF0, 0x7D, 0xF0, 0xFB, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF,
  0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F,
  0xE0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F,
  0x3E, 0x3E, 0x3E, 0xF8, 0x7F, 0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xFF, 0x8F,
  0xDF, 0x9E, 0x1F, 0x7C, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3,
  0xE7, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF,
  0xE3, 0xFF, 0xCF, 0x87, 0xDF, 0x07, 0xBE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xE1, 0xFB, 0xFF, 0xF7, 0xFD, 0xE7, 0xFB, 0xC7, 0xEF, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE3, 0x3F, 0xC7, 0xFF, 0x0F, 0xFC,
  0x1F, 0xE0, 0x00, 0x77, 0xFF, 0xFF, 0x90, 0x00, 0x00, 0x00, 0x00, 0x3B,
  0xFF, 0xFF, 0x80, 0x39, 0xF7, 0xDF, 0x7C, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xDF, 0x7D, 0xE7, 0x9E, 0xF3, 0xC0, 0x00, 0x02, 0x00, 0x1C,
  0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F,
  0x80, 0x07, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x3E, 0x01, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F,
  0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x1F, 0xC3, 0xFF, 0x9F, 0xFE,
  0xFF, 0xF6, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x0F, 0x81,
  0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x3C,
  0x1C, 0x00, 0x1E, 0x3C, 0x3F, 0x8E, 0x38, 0x7F, 0xCF, 0x78, 0xFF, 0xC7,
  0x71, 0xE3, 0xC7, 0x71, 0xC3, 0xC7, 0xF3, 0xC3, 0xC7, 0xF3, 0xC3, 0xC7,
  0xF3, 0xC3, 0xC7, 0xF3, 0xC3, 0xC7, 0xF1, 0xC3, 0xCF, 0x71, 0xEF, 0xFE,
  0x71, 0xFE, 0xFE, 0x78, 0xFC, 0xFC, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x20, 0x0F, 0xC3, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x28, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07,
  0x9F, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xF0, 0x78, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0x1F, 0xF8, 0x01,
  0xF0, 0xFF, 0xE0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x3F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF8, 0xFF, 0xFE, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0x03,
  0xFC, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x7E, 0x06, 0x7C, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x02, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xF8, 0x3F, 0x3E, 0x07, 0xEF, 0x80,
  0xFB, 0xE0, 0x3E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE,
  0x07, 0xEF, 0x83, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x03,
  0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0xE7, 0xF0, 0x33, 0xF0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x1F, 0xFF, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xBE,
  0x07, 0xDF, 0x83, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xF8,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3E, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0xCF, 0xFF,
  0xDF, 0xEF, 0xE7, 0xC0, 0xF0, 0x1F, 0xF8, 0x1F, 0xBC, 0x0F, 0x9E, 0x0F,
  0x8F, 0x0F, 0x87, 0x87, 0xC3, 0xC7, 0xC1, 0xE7, 0xC0, 0xF7, 0xE0, 0x7B,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xE7, 0xC1,
  0xE3, 0xE0, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x1F, 0x1E, 0x0F, 0xCF, 0x03,
  0xE7, 0x80, 0xFB, 0xC0, 0x7E, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xF7, 0x03, 0xBF, 0xEF, 0x0F, 0x7F,
  0xDE, 0x1E, 0xFF, 0xBC, 0x39, 0xFF, 0x3C, 0xF3, 0xFE, 0x79, 0xE7, 0xFC,
  0xF3, 0x8F, 0xF8, 0xEF, 0x1F, 0xF1, 0xFE, 0x3F, 0xE3, 0xFC, 0x7F, 0xC7,
  0xF0, 0xFF, 0x87, 0xE1, 0xFF, 0x0F, 0xC3, 0xFE, 0x1F, 0x07, 0xFC, 0x1E,
  0x0F, 0x80, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xF7, 0xC3, 0xFD, 0xF0,
  0xFF, 0x3E, 0x3F, 0xCF, 0x8F, 0xF1, 0xF3, 0xFC, 0x3C, 0xFF, 0x0F, 0xBF,
  0xC1, 0xEF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0xBE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x80,
  0xF9, 0xF8, 0x3F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0xC1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF, 0x87, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF, 0xEF,
  0xFF, 0x9F, 0xFE, 0x3F, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0xBE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xEF, 0x80, 0xF9, 0xF8, 0x3F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F,
  0xFE, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF,
  0xCF, 0x87, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C,
  0x1F, 0x3E, 0x7F, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xE3, 0xC1,
  0xF1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x81,
  0xF7, 0xC0, 0xFB, 0xE0, 0x3E, 0x0F, 0xF0, 0x7F, 0xF3, 0xFF, 0xDF, 0xFE,
  0x7C, 0x19, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01,
  0xFE, 0x07, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xC3, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0x78, 0x07, 0x9F, 0x03, 0xE7, 0xC0,
  0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0xF8, 0x03,
  0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0x3E, 0x01, 0xE7, 0xC0, 0x7C, 0x78, 0x0F,
  0x0F, 0x01, 0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0x7C, 0x3C,
  0x0F, 0x8F, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xEF, 0x80, 0x3D, 0xE0,
  0x07, 0xBC, 0x00, 0xF7, 0x80, 0x0E, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x0F, 0x00, 0xFF, 0x80, 0xF8, 0x0F,
  0xF8, 0x0F, 0x81, 0xF7, 0x81, 0xF8, 0x1F, 0x78, 0x1F, 0x81, 0xE7, 0xC1,
  0xFC, 0x1E, 0x7C, 0x1F, 0xC3, 0xE3, 0xC3, 0xFC, 0x3E, 0x3C, 0x3D, 0xC3,
  0xE3, 0xC3, 0xDE, 0x3C, 0x3E, 0x39, 0xE3, 0xC1, 0xE7, 0x9E, 0x7C, 0x1E,
  0x79, 0xE7, 0xC1, 0xE7, 0x8E, 0x78, 0x1E, 0x78, 0xF7, 0x81, 0xFF, 0x0F,
  0x78, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00,
  0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0,
  0x3E, 0x00, 0x7C, 0x07, 0xEF, 0x80, 0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC1,
  0xF1, 0xF0, 0x3E, 0x3E, 0x03, 0xEF, 0x80, 0x3D, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F,
  0x07, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0xBE, 0x01, 0xF8, 0xF8, 0x07, 0xDF,
  0x01, 0xF7, 0xC0, 0xF8, 0xF0, 0x3E, 0x3E, 0x1F, 0x07, 0x87, 0xC1, 0xF3,
  0xE0, 0x3C, 0xF8, 0x0F, 0xBC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x1E, 0xF0, 0x1E, 0x70, 0x1C, 0x78, 0x3C, 0x3C,
  0x38, 0x3C, 0x78, 0x1E, 0x70, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x03, 0xC0, 0x7F,
  0xF0, 0xFF, 0xF0, 0xFF, 0xE1, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x83, 0xFF,
  0x3F, 0xFE, 0xFF, 0xFD, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xFF,
  0x3F, 0xBF, 0xFF, 0x7F, 0xDE, 0x7E, 0x3C, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x78, 0x7D, 0xFC, 0xFF, 0xFD,
  0xFF, 0xFB, 0xF1, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0xFF, 0xDF, 0xFF,
  0xBD, 0xFE, 0x79, 0xF8, 0x03, 0xE0, 0x7F, 0xC7, 0xFE, 0x7F, 0xF7, 0xE1,
  0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x05, 0xFD, 0xE7, 0xFF, 0x1F, 0xF8, 0x7F, 0x80, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x07, 0x1F,
  0x1F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7E, 0x3F, 0x7C, 0x1F, 0x78, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F,
  0x7C, 0x3F, 0x7F, 0x7F, 0x3F, 0xFF, 0x3F, 0xDF, 0x0F, 0x8F, 0x03, 0xC0,
  0x1F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE7, 0xC3, 0xEF, 0x03, 0xDE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x1F, 0x83, 0x1F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x0F, 0xF1, 0xFE, 0x3F,
  0xE3, 0xE2, 0x3E, 0x03, 0xC0, 0x3C, 0x0F, 0xFC, 0xFF, 0xCF, 0xFC, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x07, 0x0F, 0x1F, 0xDF,
  0x3F, 0xFF, 0x7F, 0xFF, 0x7C, 0x3F, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x3F,
  0x7F, 0x7F, 0x3F, 0xFF, 0x3F, 0xDF, 0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x70, 0x7E, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF0, 0x07, 0x80,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x78, 0x7D, 0xFC, 0xFF, 0xFD, 0xFF, 0xFB, 0xF1, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x3F, 0xFE, 0xFE, 0xFC, 0x70, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x3E,
  0xF8, 0x7C, 0xF8, 0xF8, 0xF8, 0xF8, 0xF9, 0xF0, 0xFB, 0xE0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFD, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xE0, 0x78, 0xF7, 0xF9, 0xFE, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0x1F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8,
  0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8,
  0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8,
  0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF1, 0xF1, 0xE7, 0xF3, 0xDF, 0xF7, 0xFF,
  0xFF, 0xC7, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7C, 0x03, 0xE0, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x7C,
  0x3E, 0x7C, 0x1E, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x7C, 0x3E, 0x3E, 0x7E, 0x3F, 0xFC, 0x1F,
  0xF8, 0x07, 0xF0, 0xF1, 0xE1, 0xE7, 0xF3, 0xDF, 0xF7, 0xFF, 0xEF, 0xC7,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xF9, 0xF7,
  0xE3, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x07, 0x8F, 0x1F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF,
  0x7C, 0x3F, 0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x3F, 0x7F, 0x7F, 0x3F, 0xFF,
  0x3F, 0xDF, 0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0xFE, 0x7F, 0xDF,
  0xFF, 0xFF, 0xFD, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x0F, 0x83, 0xFF,
  0x7F, 0xFF, 0xFE, 0xF8, 0x2F, 0x80, 0xFC, 0x07, 0xF0, 0x7F, 0xC1, 0xFE,
  0x07, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC,
  0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xF9, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0xEC, 0xFF, 0x8F, 0xF0, 0xFE, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0x7F,
  0xDE, 0x3F, 0x3C, 0xF8, 0x0F, 0xFC, 0x07, 0x9E, 0x07, 0xCF, 0x83, 0xE7,
  0xC1, 0xE1, 0xE0, 0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x1E, 0x3C, 0x0F, 0x3E,
  0x07, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x3E, 0x0F, 0xBC, 0x1F, 0x87,
  0xDE, 0x1F, 0xC3, 0xCF, 0x8F, 0xE1, 0xE3, 0xC7, 0x71, 0xF1, 0xE3, 0xBC,
  0xF8, 0xF1, 0xDE, 0x78, 0x7D, 0xE7, 0x3C, 0x1E, 0xE3, 0xBE, 0x0F, 0x71,
  0xDE, 0x07, 0xB8, 0xEF, 0x03, 0xDC, 0x7F, 0x80, 0xEE, 0x1F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x00,
  0xFC, 0x1F, 0x1F, 0x1F, 0x0F, 0x8F, 0x83, 0xEF, 0x81, 0xF7, 0x80, 0x7F,
  0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x03,
  0xFF, 0x01, 0xF7, 0xC1, 0xF1, 0xE0, 0xF8, 0xF8, 0xF8, 0x3E, 0xF8, 0x1F,
  0x80, 0xF8, 0x0F, 0xFC, 0x07, 0x9E, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xE1,
  0xE0, 0xF0, 0xF8, 0xF8, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0xBE, 0x03, 0xDE,
  0x01, 0xEF, 0x00, 0xF7, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7E, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF0,
  0x1F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x8F, 0xF1, 0xFC, 0x3F, 0x07, 0xF8, 0x1F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0xC1, 0xFC,
  0x1F, 0x81, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x1F, 0x83, 0xF8, 0x7F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81,
  0xFE, 0x0F, 0xC1, 0xF8, 0x7F, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x7E, 0x1F, 0xC3, 0xF0, 0x7C, 0x00, 0x3E, 0x03,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Bold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 23, 9, 2, -23 },
  { 16, 11, 8, 15, 2, -23 },
  { 27, 17, 23, 19, 1, -23 },
  { 76, 15, 26, 17, 1, -24 },
  { 125, 25, 23, 27, 1, -23 },
  { 197, 21, 23, 22, 1, -23 },
  { 258, 4, 8, 8, 2, -23 },
  { 262, 9, 28, 11, 1, -23 },
  { 294, 8, 28, 11, 1, -23 },
  { 322, 14, 14, 16, 1, -24 },
  { 347, 15, 15, 17, 1, -19 },
  { 376, 6, 8, 9, 1, -4 },
  { 382, 8, 4, 10, 1, -11 },
  { 386, 5, 5, 9, 2, -5 },
  { 390, 13, 23, 13, 0, -23 },
  { 428, 15, 23, 17, 1, -23 },
  { 472, 11, 23, 17, 2, -23 },
  { 504, 15, 23, 17, 1, -23 },
  { 548, 15, 23, 17, 1, -23 },
  { 592, 16, 23, 17, 1, -23 },
  { 638, 14, 23, 17, 2, -23 },
  { 679, 15, 23, 17, 1, -23 },
  { 723, 15, 23, 17, 1, -23 },
  { 767, 15, 23, 17, 1, -23 },
  { 811, 15, 23, 17, 1, -23 },
  { 855, 5, 18, 9, 2, -18 },
  { 867, 6, 22, 9, 1, -18 },
  { 884, 15, 17, 17, 1, -20 },
  { 916, 15, 10, 17, 1, -16 },
  { 935, 15, 17, 17, 1, -20 },
  { 967, 13, 23, 14, 0, -23 },
  { 1005, 24, 26, 27, 1, -23 },
  { 1083, 20, 23, 20, 0, -23 },
  { 1141, 16, 23, 20, 2, -23 },
  { 1187, 16, 23, 19, 2, -23 },
  { 1233, 18, 23, 21, 2, -23 },
  { 1285, 12, 23, 16, 3, -23 },
  { 1320, 12, 23, 16, 3, -23 },
  { 1355, 17, 23, 21, 2, -23 },
  { 1404, 17, 23, 22, 3, -23 },
  { 1453, 10, 23, 12, 1, -23 },
  { 1482, 9, 30, 10, -2, -23 },
  { 1516, 17, 23, 19, 3, -23 },
  { 1565, 13, 23, 16, 2, -23 },
  { 1603, 23, 23, 28, 3, -23 },
  { 1670, 18, 23, 24, 3, -23 },
  { 1722, 19, 23, 23, 2, -23 },
  { 1777, 15, 23, 18, 2, -23 },
  { 1821, 19, 28, 23, 2, -23 },
  { 1888, 17, 23, 19, 2, -23 },
  { 1937, 14, 23, 16, 1, -23 },
  { 1978, 15, 23, 17, 1, -23 },
  { 2022, 18, 23, 22, 2, -23 },
  { 2074, 19, 23, 19, 0, -23 },
  { 2129, 28, 23, 28, 0, -23 },
  { 2210, 19, 23, 19, 0, -23 },
  { 2265, 18, 23, 18, 0, -23 },
  { 2317, 15, 23, 17, 1, -23 },
  { 2361, 8, 28, 10, 2, -23 },
  { 2389, 13, 23, 13, 0, -23 },
  { 2427, 7, 28, 10, 1, -23 },
  { 2452, 16, 15, 18, 1, -23 },
  { 2482, 13, 2, 13, 0, 3 },
  { 2486, 9, 6, 11, 1, -25 },
  { 2493, 15, 18, 18, 1, -18 },
  { 2527, 15, 24, 19, 2, -24 },
  { 2572, 13, 18, 15, 1, -18 },
  { 2602, 16, 24, 19, 1, -24 },
  { 2650, 15, 18, 17, 1, -18 },
  { 2684, 12, 24, 11, 1, -24 },
  { 2720, 16, 26, 19, 1, -18 },
  { 2772, 15, 24, 19, 2, -24 },
  { 2817, 5, 24, 9, 2, -24 },
  { 2832, 8, 32, 9, -1, -24 },
  { 2864, 16, 24, 18, 2, -24 },
  { 2912, 5, 24, 9, 2, -24 },
  { 2927, 24, 18, 29, 2, -18 },
  { 2981, 15, 18, 19, 2, -18 },
  { 3015, 16, 18, 18, 1, -18 },
  { 3051, 15, 26, 19, 2, -18 },
  { 3100, 16, 26, 19, 1, -18 },
  { 3152, 11, 18, 13, 2, -18 },
  { 3177, 12, 18, 15, 1, -18 },
  { 3204, 11, 21, 13, 1, -21 },
  { 3233, 15, 18, 19, 2, -18 },
  { 3267, 17, 18, 17, 0, -18 },
  { 3306, 25, 17, 25, 0, -17 },
  { 3360, 17, 17, 17, 0, -17 },
  { 3397, 17, 26, 17, 0, -18 },
  { 3453, 12, 18, 14, 1, -18 },
  { 3480, 11, 28, 12, 0, -23 },
  { 3519, 4, 31, 16, 6, -24 },
  { 3535, 11, 28, 12, 1, -23 },
  { 3574, 15, 5, 17, 1, -14 },
};

const GFXfont NotoSans_SemiCondensed_Bold32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold32pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD32PT7B_H_
