#ifndef _NOTOSANS_SEMICONDENSED_BOLD45PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold45pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0xFC, 0x7F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x07,
  0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x3F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8,
  0x1F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xC3, 0xE0,
  0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF0, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x0F, 0x0F, 0x80, 0x0F, 0x87,
  0x80, 0x07, 0xC3, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0,
  0xF8, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xEF, 0xCF, 0xE6, 0x0C,
  0xFC, 0x60, 0x0F, 0xC6, 0x00, 0xFE, 0x60, 0x0F, 0xF6, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x06, 0xFF, 0x00, 0x67, 0xF0, 0x06, 0x3F, 0x80,
  0x63, 0xFC, 0x06, 0x3F, 0xF8, 0x67, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x08,
  0x00, 0xFE, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x01, 0xF0, 0x03, 0xFF, 0x80,
  0x3E, 0x00, 0x7F, 0xFC, 0x03, 0xE0, 0x07, 0xC7, 0xC0, 0x7C, 0x00, 0x7C,
  0x7C, 0x07, 0xC0, 0x07, 0xC7, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x0F, 0x80,
  0x0F, 0x83, 0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xE3,
  0xE0, 0x00, 0xF8, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xE7, 0xC1, 0xE0, 0x7C,
  0x7C, 0x7C, 0x7F, 0x87, 0xC7, 0xCF, 0x8F, 0xFC, 0x7F, 0xFC, 0xF9, 0xFF,
  0xE3, 0xFF, 0x9F, 0x1F, 0xFE, 0x1F, 0xF1, 0xF3, 0xE3, 0xE0, 0xFE, 0x3E,
  0x3E, 0x1F, 0x01, 0x03, 0xE3, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x1F, 0x00,
  0x07, 0xC3, 0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xE1,
  0xF0, 0x01, 0xF0, 0x3E, 0x1F, 0x00, 0x1F, 0x03, 0xE1, 0xF0, 0x03, 0xE0,
  0x3E, 0x1F, 0x00, 0x3E, 0x03, 0xF3, 0xE0, 0x07, 0xC0, 0x1F, 0xFE, 0x00,
  0x7C, 0x01, 0xFF, 0xC0, 0x0F, 0x80, 0x0F, 0xFC, 0x00, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x07, 0xE1, 0xFF, 0xE0, 0x7F, 0x1F, 0xFF, 0x83, 0xF8, 0xFE, 0xFE,
  0x1F, 0x8F, 0xE3, 0xF9, 0xFC, 0x7F, 0x0F, 0xEF, 0xE3, 0xF0, 0x7F, 0xFE,
  0x1F, 0x81, 0xFF, 0xF0, 0xFC, 0x07, 0xFF, 0x07, 0xF0, 0x1F, 0xF0, 0x3F,
  0x80, 0x7F, 0x81, 0xFF, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF3, 0xFC, 0x07, 0xFE, 0x0F,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0x80, 0x03, 0xF0,
  0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x01,
  0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8,
  0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x30, 0x7C, 0x19,
  0xF3, 0xC7, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0x7E, 0x03,
  0xF3, 0xF0, 0x3F, 0x8F, 0xC0, 0xF8, 0x7C, 0x01, 0xC1, 0xC0, 0x02, 0x08,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3F, 0x9F, 0x8F, 0xC7,
  0xE3, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F,
  0x7E, 0x08, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0x0F, 0xE7, 0xE0, 0xFE, 0xFE, 0x07,
  0xEF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xF7, 0xE0, 0x7E, 0x7E, 0x0F, 0xE7, 0xF0, 0xFE,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F,
  0xFF, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x7F, 0x3C, 0x7F, 0x18,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x70, 0x00, 0xFF, 0xE0, 0x3F, 0xFF,
  0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7E, 0x0F, 0xE3, 0x80,
  0x7E, 0x30, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x38, 0x0F, 0xE2, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFE,
  0x01, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3E, 0xFE, 0x01, 0xF3, 0xF8,
  0x07, 0xCF, 0xE0, 0x3E, 0x3F, 0x80, 0xF8, 0xFE, 0x07, 0xC3, 0xF8, 0x3F,
  0x0F, 0xE0, 0xF8, 0x3F, 0x87, 0xC0, 0xFE, 0x1F, 0x03, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE2,
  0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F,
  0xFF, 0xE1, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0xFE,
  0xF0, 0x1F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x3E, 0x07, 0xE7,
  0xFC, 0x3F, 0x7F, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xC7, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00,
  0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7F, 0x01, 0xF9, 0xF8, 0x1F, 0xCF,
  0xE1, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xE7, 0xF8, 0xFC, 0x0F, 0xCF, 0xE0, 0x7E,
  0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC,
  0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xBF, 0xC3, 0xF8, 0x7F, 0x3F, 0x81,
  0xFD, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xDF,
  0x80, 0x7E, 0xFE, 0x07, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xC3, 0xF9, 0xFC, 0x0F,
  0xCF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xFC, 0x1F, 0xEF, 0xF1, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0x7E, 0x1F, 0xF3, 0xF0, 0x3E,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F,
  0x7E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x1E, 0x1F, 0x8F, 0xE7,
  0xF3, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F,
  0x1F, 0x1F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0x03, 0xF9, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x10, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x3F, 0x03, 0xFE,
  0x1F, 0x0F, 0x83, 0xFF, 0xE3, 0xE7, 0xC1, 0xFF, 0xF8, 0xF9, 0xF0, 0xFF,
  0xFE, 0x3E, 0x7C, 0x3F, 0x0F, 0x87, 0x9E, 0x1F, 0x03, 0xE1, 0xEF, 0x87,
  0xC0, 0xF8, 0x7B, 0xE1, 0xF0, 0x3C, 0x1F, 0xF8, 0xF8, 0x0F, 0x07, 0xBE,
  0x3E, 0x07, 0xC1, 0xEF, 0x8F, 0x81, 0xF0, 0x7B, 0xE3, 0xE0, 0x7C, 0x1E,
  0xF8, 0xF8, 0x1F, 0x0F, 0xBE, 0x1F, 0x07, 0xC3, 0xEF, 0x87, 0xE3, 0xF9,
  0xF3, 0xE1, 0xFF, 0xFF, 0xFC, 0x7C, 0x3F, 0xF7, 0xFE, 0x1F, 0x07, 0xF8,
  0xFF, 0x07, 0xC0, 0x7C, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1C, 0x00, 0x1F,
  0xFC, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xDF, 0x80,
  0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0x7E,
  0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F,
  0xE0, 0x3F, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0x80, 0x1F, 0xC3,
  0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0xC0, 0xFF, 0xBF, 0x80, 0xFF, 0x7F, 0x00, 0xFE, 0xFE,
  0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xE7, 0xF0, 0x1F, 0xCF, 0xE0,
  0x7F, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF3, 0xF8, 0x0F, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F,
  0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0xFF, 0x00, 0x7E, 0xFE, 0x01, 0xFD,
  0xFC, 0x03, 0xFB, 0xF8, 0x3F, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x87, 0xFC, 0x0E, 0x1F, 0xE0, 0x04, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x10, 0xFF, 0x81, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xF0,
  0xFF, 0xE3, 0xF8, 0x0F, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFF, 0x7F,
  0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07,
  0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x01, 0xFC, 0xFE, 0x01,
  0xFE, 0x7F, 0x01, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xE0,
  0x38, 0x3F, 0xC0, 0x04, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xEF, 0xC0, 0xFF, 0xF7, 0xE0, 0x7F, 0xFB, 0xF8, 0x01, 0xFD,
  0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F,
  0xCF, 0xF0, 0x0F, 0xE3, 0xFE, 0x07, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x0F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x1F, 0xC0, 0xFF, 0x1F, 0xFF, 0xFF, 0x7F, 0xFB, 0xFF, 0x9F, 0xF8,
  0xFF, 0x80, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC, 0x03, 0xFC, 0xFC,
  0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x0F, 0xF0, 0xFC, 0x0F, 0xE0, 0xFC,
  0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0xFC, 0x7F, 0x80, 0xFC, 0x7F, 0x00, 0xFC,
  0xFE, 0x00, 0xFD, 0xFE, 0x00, 0xFD, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0x7F, 0x00, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC,
  0x1F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC,
  0x03, 0xF8, 0xFC, 0x03, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFE, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFB, 0xE0, 0x07, 0xFF, 0xFB, 0xE0,
  0x0F, 0xFF, 0xFB, 0xE0, 0x0F, 0xBF, 0xFB, 0xF0, 0x0F, 0xBF, 0xF9, 0xF0,
  0x1F, 0xBF, 0xFD, 0xF0, 0x1F, 0x3F, 0xFD, 0xF8, 0x1F, 0x3F, 0xFC, 0xF8,
  0x3F, 0x3F, 0xFC, 0xF8, 0x3E, 0x3F, 0xFC, 0xF8, 0x3E, 0x3F, 0xFC, 0xFC,
  0x3E, 0x3F, 0xFC, 0x7C, 0x7C, 0x3F, 0xFC, 0x7C, 0x7C, 0x3F, 0xFC, 0x7E,
  0x7C, 0x3F, 0xFC, 0x3E, 0xFC, 0x3F, 0xFC, 0x3E, 0xF8, 0x3F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xF0, 0x3F, 0xFC, 0x1F,
  0xF0, 0x3F, 0xFC, 0x1F, 0xF0, 0x3F, 0xFC, 0x0F, 0xE0, 0x3F, 0xFC, 0x0F,
  0xE0, 0x3F, 0xFC, 0x0F, 0xE0, 0x3F, 0xFC, 0x0F, 0xC0, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFB, 0xF0, 0x0F, 0xFE, 0xFE, 0x03, 0xFF, 0x9F, 0x80, 0xFF, 0xE7, 0xF0,
  0x3F, 0xF8, 0xFC, 0x0F, 0xFE, 0x3F, 0x83, 0xFF, 0xC7, 0xE0, 0xFF, 0xF1,
  0xFC, 0x3F, 0xFC, 0x3F, 0x8F, 0xFF, 0x0F, 0xE3, 0xFF, 0xC1, 0xFC, 0xFF,
  0xF0, 0x7F, 0x3F, 0xFC, 0x0F, 0xEF, 0xFF, 0x03, 0xFB, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0x80,
  0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFF,
  0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x01,
  0xFE, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x7F, 0x0F, 0xFB, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0E, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F,
  0xE0, 0x7F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xE7, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x3F,
  0xC1, 0xFF, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFE, 0x1F, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFF, 0x00, 0x60, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7,
  0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xC1, 0xE7, 0xF0, 0x04, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFE, 0x1F, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFE, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xE1, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80,
  0x03, 0xE7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0x00, 0x7E, 0x7E, 0x00, 0xFF, 0x00, 0x7E, 0x7E, 0x00, 0xFF,
  0x00, 0x7E, 0x7E, 0x00, 0xFF, 0x00, 0xFE, 0x7F, 0x01, 0xFF, 0x00, 0xFE,
  0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x3F, 0x01,
  0xFF, 0x81, 0xFC, 0x3F, 0x83, 0xFF, 0x81, 0xFC, 0x1F, 0x83, 0xEF, 0xC1,
  0xF8, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x1F,
  0x87, 0xE7, 0xC3, 0xF8, 0x1F, 0xC7, 0xE7, 0xE3, 0xF0, 0x0F, 0xC7, 0xC7,
  0xE3, 0xF0, 0x0F, 0xC7, 0xC3, 0xE3, 0xF0, 0x0F, 0xC7, 0xC3, 0xE3, 0xF0,
  0x0F, 0xCF, 0xC3, 0xE7, 0xF0, 0x07, 0xEF, 0x83, 0xF7, 0xE0, 0x07, 0xEF,
  0x81, 0xF7, 0xE0, 0x07, 0xEF, 0x81, 0xF7, 0xE0, 0x07, 0xEF, 0x81, 0xF7,
  0xE0, 0x03, 0xFF, 0x81, 0xF7, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0xC7, 0xF0, 0x07, 0xF0,
  0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x1F, 0xC1,
  0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF3, 0xF8, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xC0,
  0x07, 0xF7, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xE7,
  0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xF8,
  0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F,
  0x80, 0x1F, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x7E,
  0x07, 0xC0, 0x7C, 0x1F, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF9,
  0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE1, 0xE0, 0xFE, 0x10, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x07, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xE0, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFB, 0xF3, 0xFF,
  0x1F, 0x1F, 0xE1, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x3F, 0xE1, 0xFB, 0xFF, 0x8F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFE, 0x3F, 0xDF, 0xE0, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0x9F, 0xBF, 0xFC, 0xFD, 0xFF, 0xC7, 0xC3, 0xF8, 0x00, 0x01, 0xFE,
  0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xF1, 0xE7,
  0xF0, 0x09, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x05, 0xFE, 0x07, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x8F, 0xC3, 0xFE, 0x7E,
  0x3F, 0xFB, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0x7F, 0xEF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7E, 0xFE, 0x07, 0xF7, 0xF0, 0x7F, 0xBF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xBF, 0x1F, 0xFC, 0xF8, 0x3F, 0x87,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x3F, 0x83, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x43, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0xC3,
  0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF,
  0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xF8, 0x7F,
  0xC7, 0xC7, 0xFF, 0x7E, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xC7, 0xFD,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xDF, 0xC0, 0xFE, 0xFE, 0x0F,
  0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xF7, 0xE3, 0xFF, 0x3F, 0x07,
  0xF1, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xB0, 0x03, 0xFD, 0xFE, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x3F, 0xF1,
  0xFB, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0x3F, 0xDF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F,
  0xC0, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0xCF,
  0xF8, 0x7C, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xE7, 0xF0,
  0x3F, 0xCF, 0xE0, 0x7F, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x1F,
  0xC0, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF3, 0xF8, 0x07, 0xEF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0xFF, 0xBF, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xFC, 0xFE,
  0x01, 0xFD, 0xFC, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3F, 0x01, 0xFC, 0x3E,
  0x3F, 0xF0, 0xFF, 0xCF, 0xDF, 0xFE, 0x7F, 0xFB, 0xFF, 0xFF, 0xBF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xDF, 0xFF, 0xF0, 0x7F, 0xC1,
  0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0x80, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0x00, 0xFF, 0xF8, 0x0F, 0xC0, 0x3F, 0xFC, 0x03,
  0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0,
  0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0x0F,
  0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0,
  0x3F, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x3F, 0x07, 0xC7, 0xFE, 0x3F,
  0x7F, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xE7, 0xFB, 0xFC, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F, 0x9F, 0x80, 0x7E, 0xFE, 0x01,
  0xFB, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFD, 0xF8,
  0x07, 0xE7, 0xF0, 0x3F, 0x9F, 0xC1, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xF8, 0x3F, 0x07,
  0xE7, 0xFC, 0x3F, 0x7F, 0xF1, 0xFB, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xC7,
  0xFB, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x0F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xF7, 0xFF, 0x9F, 0x9F, 0xF8,
  0xFC, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0xF8, 0x7F,
  0xC7, 0xC7, 0xFF, 0x7E, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xC7, 0xFD,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xDF, 0xC0, 0xFE, 0xFE, 0x0F,
  0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xF7, 0xE3, 0xFF, 0x3F, 0x07,
  0xF1, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x3F, 0xF0, 0xFF, 0xE3,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0xFF, 0x80, 0xFF, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0xDF, 0xFF,
  0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xE0, 0x73, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x07,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF8, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xFE,
  0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0xC1, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xF7,
  0xE7, 0xFF, 0x3F, 0x0F, 0xF0, 0xF8, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE,
  0x7E, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x3F, 0x01, 0xFC,
  0x3F, 0x81, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0x83, 0xF0,
  0x1F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC7, 0xE0, 0x07, 0xC7, 0xE0,
  0x07, 0xE7, 0xE0, 0x07, 0xEF, 0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xEF, 0xC0,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xF8,
  0x07, 0xEF, 0xC0, 0x7F, 0x80, 0xFD, 0xF8, 0x0F, 0xF0, 0x3F, 0xBF, 0x01,
  0xFE, 0x07, 0xE7, 0xF0, 0x7F, 0xC0, 0xFC, 0x7E, 0x0F, 0xF8, 0x1F, 0x8F,
  0xC1, 0xFF, 0x87, 0xF1, 0xF8, 0x3D, 0xF0, 0xFC, 0x3F, 0x8F, 0xBE, 0x1F,
  0x83, 0xF1, 0xF3, 0xC3, 0xF0, 0x7E, 0x3E, 0x7C, 0xFE, 0x0F, 0xC7, 0x8F,
  0x9F, 0x80, 0xFC, 0xF1, 0xF3, 0xF0, 0x1F, 0xBE, 0x1E, 0x7E, 0x03, 0xF7,
  0xC3, 0xCF, 0xC0, 0x7E, 0xF8, 0x7F, 0xF0, 0x07, 0xDE, 0x0F, 0xFE, 0x00,
  0xFB, 0xC1, 0xFF, 0xC0, 0x1F, 0x78, 0x1F, 0xF0, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0xFE, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x3F, 0x81, 0xF8, 0xFE, 0x03, 0xF9, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xDF, 0xC0, 0x3F, 0x9F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x87,
  0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x3F, 0x80, 0xFE, 0xFF, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F,
  0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F,
  0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xEF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8,
  0x1F, 0xC3, 0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0xFF, 0x03, 0xFF, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0xC1, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0x07, 0xFC, 0x3F, 0xF0,
  0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x17, 0xFC, 0x01, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x7F, 0xE8,
  0x00, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Bold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 33, 12, 2, -32 },
  { 34, 15, 11, 21, 3, -32 },
  { 55, 25, 32, 27, 1, -32 },
  { 155, 20, 37, 24, 2, -34 },
  { 248, 36, 33, 38, 1, -33 },
  { 397, 29, 33, 31, 2, -33 },
  { 517, 6, 11, 11, 3, -32 },
  { 526, 12, 39, 15, 2, -32 },
  { 585, 12, 39, 15, 1, -32 },
  { 644, 21, 20, 23, 1, -34 },
  { 697, 20, 22, 24, 2, -27 },
  { 752, 9, 11, 12, 1, -5 },
  { 765, 12, 6, 14, 1, -15 },
  { 774, 8, 8, 12, 2, -7 },
  { 782, 18, 32, 19, 0, -32 },
  { 854, 20, 33, 24, 2, -33 },
  { 937, 16, 32, 24, 2, -32 },
  { 1001, 20, 33, 24, 2, -33 },
  { 1084, 20, 33, 24, 2, -33 },
  { 1167, 22, 32, 24, 1, -32 },
  { 1255, 20, 32, 24, 2, -32 },
  { 1335, 21, 32, 24, 1, -32 },
  { 1419, 21, 32, 24, 1, -32 },
  { 1503, 21, 33, 24, 1, -33 },
  { 1590, 21, 32, 24, 1, -32 },
  { 1674, 8, 26, 12, 2, -25 },
  { 1700, 9, 31, 12, 1, -25 },
  { 1735, 20, 23, 24, 2, -28 },
  { 1793, 20, 14, 24, 2, -23 },
  { 1828, 20, 23, 24, 2, -28 },
  { 1886, 19, 34, 20, 0, -33 },
  { 1967, 34, 36, 37, 2, -32 },
  { 2120, 28, 32, 28, 0, -32 },
  { 2232, 23, 32, 28, 3, -32 },
  { 2324, 23, 33, 26, 2, -33 },
  { 2419, 25, 32, 30, 3, -32 },
  { 2519, 17, 32, 23, 4, -32 },
  { 2587, 17, 32, 23, 4, -32 },
  { 2655, 25, 33, 30, 2, -33 },
  { 2759, 24, 32, 32, 4, -32 },
  { 2855, 14, 32, 16, 1, -32 },
  { 2911, 13, 41, 14, -3, -32 },
  { 2978, 24, 32, 27, 4, -32 },
  { 3074, 18, 32, 23, 3, -32 },
  { 3146, 32, 32, 40, 4, -32 },
  { 3274, 26, 32, 34, 4, -32 },
  { 3378, 28, 33, 32, 2, -33 },
  { 3494, 21, 32, 26, 3, -32 },
  { 3578, 28, 41, 32, 2, -33 },
  { 3722, 24, 32, 27, 3, -32 },
  { 3818, 19, 33, 23, 2, -33 },
  { 3897, 22, 32, 24, 1, -32 },
  { 3985, 24, 32, 31, 4, -32 },
  { 4081, 27, 32, 27, 0, -32 },
  { 4189, 40, 32, 40, 0, -32 },
  { 4349, 27, 32, 27, 0, -32 },
  { 4457, 26, 32, 26, 0, -32 },
  { 4561, 21, 32, 23, 1, -32 },
  { 4645, 10, 39, 15, 3, -32 },
  { 4694, 18, 32, 19, 0, -32 },
  { 4766, 11, 39, 15, 1, -32 },
  { 4820, 23, 20, 25, 1, -32 },
  { 4878, 19, 3, 18, 0, 4 },
  { 4886, 12, 7, 16, 2, -34 },
  { 4897, 20, 25, 25, 2, -25 },
  { 4960, 21, 34, 26, 3, -34 },
  { 5050, 18, 25, 21, 2, -25 },
  { 5107, 21, 34, 26, 2, -34 },
  { 5197, 21, 25, 25, 2, -25 },
  { 5263, 17, 34, 16, 1, -34 },
  { 5336, 21, 36, 26, 2, -25 },
  { 5431, 21, 34, 27, 3, -34 },
  { 5521, 7, 34, 13, 3, -34 },
  { 5551, 12, 45, 13, -2, -34 },
  { 5619, 23, 34, 26, 3, -34 },
  { 5717, 6, 34, 12, 3, -34 },
  { 5743, 34, 25, 40, 3, -25 },
  { 5850, 21, 25, 27, 3, -25 },
  { 5916, 22, 25, 26, 2, -25 },
  { 5985, 21, 36, 26, 3, -25 },
  { 6080, 21, 36, 26, 2, -25 },
  { 6175, 15, 25, 19, 3, -25 },
  { 6222, 17, 25, 20, 2, -25 },
  { 6276, 16, 30, 18, 1, -30 },
  { 6336, 21, 25, 27, 3, -25 },
  { 6402, 24, 25, 24, 0, -25 },
  { 6477, 35, 25, 36, 0, -25 },
  { 6587, 23, 25, 23, 0, -25 },
  { 6659, 24, 36, 24, 0, -25 },
  { 6767, 18, 25, 20, 1, -25 },
  { 6824, 14, 39, 17, 1, -32 },
  { 6893, 5, 44, 23, 9, -34 },
  { 6921, 14, 39, 17, 2, -32 },
  { 6990, 20, 8, 24, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_Bold45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold45pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD45PT7B_H_
