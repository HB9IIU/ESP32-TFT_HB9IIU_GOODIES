#ifndef _NOTOSANS_SEMICONDENSED_BOLD39PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x1E, 0x7E, 0xFD, 0xFF,
  0xF3, 0xE0, 0xFC, 0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0x78, 0x7D, 0xE1,
  0xF7, 0x87, 0xDE, 0x1E, 0x78, 0x79, 0xE1, 0xE0, 0x01, 0xE1, 0xE0, 0x0F,
  0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xE1, 0xE0,
  0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF0, 0x78, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00,
  0xF1, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xE0, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x38, 0x78, 0x03, 0xC3, 0xC0, 0x1E,
  0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x7E, 0x01, 0xFF, 0xF1, 0xFF, 0xFD, 0xFF,
  0xFD, 0xFF, 0xFE, 0xFD, 0xC6, 0x7C, 0xE0, 0x3E, 0x70, 0x1F, 0xB8, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x3B, 0xF0, 0x1C, 0xF8, 0x0E, 0x7E, 0x07, 0x3F, 0xE3,
  0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0x87, 0xFF, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x7F, 0x80,
  0x1E, 0x01, 0xFF, 0x80, 0x78, 0x03, 0xFF, 0x80, 0xF0, 0x07, 0x8F, 0x03,
  0xC0, 0x1F, 0x1E, 0x07, 0x80, 0x3E, 0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x3C,
  0x00, 0xF8, 0xF8, 0xF8, 0x01, 0xF1, 0xF1, 0xE0, 0x03, 0xE3, 0xE7, 0xC0,
  0x07, 0xC7, 0x8F, 0x1F, 0x87, 0x8F, 0x3E, 0x7F, 0x8F, 0xBE, 0x79, 0xFF,
  0x8F, 0xF9, 0xF7, 0xFF, 0x1F, 0xF3, 0xCF, 0x9F, 0x0F, 0x8F, 0x9E, 0x3E,
  0x00, 0x1E, 0x3C, 0x3C, 0x00, 0x7C, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0xF0,
  0x03, 0xE1, 0xE1, 0xE0, 0x07, 0x83, 0xC3, 0xC0, 0x1F, 0x07, 0x8F, 0x80,
  0x3C, 0x0F, 0x9F, 0x00, 0xF8, 0x1F, 0x7C, 0x01, 0xE0, 0x1F, 0xF8, 0x07,
  0xC0, 0x1F, 0xE0, 0x0F, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F,
  0xDF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0xFC, 0x7F, 0xE0, 0xFC, 0x7F, 0xF8, 0x7E, 0x7F, 0x7E, 0x3F,
  0x3F, 0x3F, 0xBF, 0x3F, 0x0F, 0xFF, 0x9F, 0x83, 0xFF, 0x8F, 0xC0, 0xFF,
  0xC7, 0xE0, 0x3F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFF, 0x3F, 0xF0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0xC0, 0xFF, 0x87, 0xF0, 0xFF,
  0xFF, 0xFF, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x07, 0xC3, 0xE0, 0xF0, 0x7C,
  0x1E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E,
  0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8,
  0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x18, 0x78, 0x67, 0xDE,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0xE0,
  0x0F, 0xFC, 0x07, 0xCF, 0x03, 0xF3, 0xE0, 0xF8, 0x7C, 0x0E, 0x1C, 0x00,
  0x84, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3E, 0x7C, 0xFB,
  0xF7, 0xCF, 0x9F, 0x3C, 0x79, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x79, 0xFB, 0xF7, 0xFF, 0xCF, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3F, 0xBF, 0x9F, 0x87, 0xE7, 0xE0, 0xF9, 0xF0, 0x3F, 0x7C, 0x0F, 0xDF,
  0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xF7, 0xC0, 0xFD, 0xF0, 0x3F,
  0x7E, 0x0F, 0xDF, 0x83, 0xF7, 0xE1, 0xF8, 0xFE, 0xFE, 0x3F, 0xFF, 0x07,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F,
  0xF0, 0xFF, 0x9F, 0xFD, 0xFF, 0xFF, 0xDF, 0x7C, 0xF9, 0xC7, 0xC4, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0x8F, 0x07, 0xE1, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0x8F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0x7F, 0x8C, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xE0,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x1E, 0xF8, 0x03, 0xDF, 0x00, 0xF3, 0xE0, 0x3E, 0x7C,
  0x07, 0x9F, 0x81, 0xF3, 0xF0, 0x3C, 0x7E, 0x0F, 0x0F, 0xC3, 0xE1, 0xF8,
  0x78, 0x3F, 0x1F, 0x07, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC7, 0xFF, 0xE3, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF,
  0xFC, 0x40, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFD, 0xF1, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0x3F, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x1F, 0xF1, 0x8F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xCF, 0xC1, 0xF7, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFB, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7D,
  0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x81, 0xF7, 0xE0, 0xFC, 0xFE, 0x7F, 0x3F,
  0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x07,
  0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x7F, 0x1F, 0x9F, 0x83,
  0xF7, 0xC0, 0xFD, 0xF0, 0x3F, 0x7E, 0x0F, 0x8F, 0xC7, 0xE3, 0xFB, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0x3F, 0x9F, 0x87, 0xF7, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7D, 0xF8, 0x3F, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0,
  0x3F, 0xF0, 0x07, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F,
  0xFF, 0x9F, 0x87, 0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0x87, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x1F, 0xF7, 0xC3, 0xF9, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF1, 0x03, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0x80, 0x30, 0xFB, 0xF7, 0xFF, 0xCF, 0x8E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x79, 0xFB, 0xF7, 0xFF, 0xCF,
  0x80, 0x1C, 0x3E, 0x7E, 0x7F, 0x7E, 0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C,
  0x7C, 0x78, 0x78, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00,
  0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x02, 0x00,
  0x00, 0x0F, 0xF0, 0x7F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x7E, 0xFF, 0x30,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0x00,
  0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0x87, 0x80,
  0xFC, 0x3E, 0x7C, 0x3F, 0xF8, 0xF3, 0xC3, 0xFF, 0xC7, 0x9E, 0x3F, 0xFE,
  0x3D, 0xE1, 0xF0, 0xF0, 0xFF, 0x1F, 0x07, 0x87, 0xF8, 0xF8, 0x3C, 0x3F,
  0xC7, 0x81, 0xE1, 0xFE, 0x3C, 0x0F, 0x0F, 0xF1, 0xE0, 0x78, 0x7F, 0x8F,
  0x07, 0xC7, 0xBC, 0x7C, 0x3E, 0x3D, 0xE3, 0xE3, 0xF1, 0xEF, 0x0F, 0xFF,
  0xFE, 0x7C, 0x7F, 0xDF, 0xF1, 0xE1, 0xFC, 0x7E, 0x0F, 0x81, 0x80, 0x40,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x01, 0x00, 0x1F,
  0xF3, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00,
  0x07, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xF0, 0x01, 0xF8, 0xF8,
  0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x07,
  0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xBF,
  0x80, 0x0F, 0xDF, 0x80, 0x07, 0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0,
  0x3E, 0xFC, 0x07, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFC, 0x0F, 0xDF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE3, 0xF8, 0x0C, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x63, 0xFF,
  0x7E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x7E, 0x0F, 0xF3, 0xF0, 0x1F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x03, 0xFB, 0xF0, 0x7F, 0x9F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xEF,
  0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFD, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x1F, 0xE0, 0x18, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x80, 0xFC, 0xFE, 0x07, 0xE7,
  0xFE, 0x7F, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF,
  0xC0, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xC1, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC,
  0xFF, 0x8F, 0xF0, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x01, 0xF9, 0xF8,
  0x1F, 0x8F, 0xC1, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x8F, 0xE0,
  0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x7F, 0x01, 0xFB, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xF3, 0xF0, 0x3F, 0x1F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F,
  0xC3, 0xF0, 0x7F, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F,
  0x00, 0xFD, 0xF8, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFB, 0xC0, 0x3D, 0xFF, 0xBE, 0x07, 0xDF,
  0xFB, 0xE0, 0x7D, 0xFF, 0x9E, 0x07, 0x9F, 0xF9, 0xF0, 0x79, 0xFF, 0x9F,
  0x0F, 0x9F, 0xF9, 0xF0, 0xF1, 0xFF, 0x8F, 0x0F, 0x1F, 0xF8, 0xF9, 0xF1,
  0xFF, 0x8F, 0x9F, 0x1F, 0xF8, 0x79, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0x3F, 0xC1, 0xFF, 0x83, 0xFC,
  0x1F, 0xF8, 0x3F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0x81, 0xFF,
  0x81, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFB, 0xF0, 0x3F, 0xF7, 0xE0, 0x7F, 0xE7, 0xE0, 0xFF, 0xCF,
  0xC1, 0xFF, 0x8F, 0xC3, 0xFF, 0x1F, 0x87, 0xFE, 0x1F, 0x8F, 0xFC, 0x3F,
  0x1F, 0xF8, 0x3F, 0x3F, 0xF0, 0x7E, 0x7F, 0xE0, 0x7E, 0xFF, 0xC0, 0xFD,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF,
  0x07, 0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x00, 0xFE,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0x81, 0xFC,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7E, 0x0F, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7,
  0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x7F, 0xFF,
  0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xE3, 0xE0, 0x3F,
  0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E,
  0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x01, 0xFD, 0xF8,
  0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE,
  0xFC, 0x0E, 0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x01, 0xFD, 0xF8, 0x0F, 0xCF, 0xFB, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0xFD, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F,
  0x8F, 0x80, 0x3E, 0x1F, 0x80, 0x7C, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xE0,
  0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03,
  0xF0, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x0F,
  0x9F, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xFF, 0x80, 0x7E, 0x00,
  0xFB, 0xF0, 0x0F, 0xC0, 0x1F, 0x3E, 0x01, 0xFC, 0x07, 0xE7, 0xC0, 0x3F,
  0x80, 0xFC, 0xFC, 0x0F, 0xF0, 0x1F, 0x1F, 0x81, 0xFE, 0x03, 0xE1, 0xF0,
  0x3F, 0xE0, 0xFC, 0x3E, 0x07, 0xFC, 0x1F, 0x87, 0xC1, 0xF7, 0x83, 0xF0,
  0xFC, 0x3E, 0xF0, 0x7C, 0x0F, 0x87, 0xDF, 0x0F, 0x81, 0xF0, 0xF3, 0xE3,
  0xF0, 0x3E, 0x1E, 0x7C, 0x7E, 0x07, 0xC7, 0xC7, 0x8F, 0x80, 0xFC, 0xF8,
  0xF1, 0xF0, 0x0F, 0x9F, 0x1F, 0x3E, 0x01, 0xF3, 0xC3, 0xEF, 0xC0, 0x3E,
  0xF8, 0x3D, 0xF0, 0x07, 0xDF, 0x07, 0xBE, 0x00, 0x7F, 0xE0, 0xF7, 0xC0,
  0x0F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x1F, 0xE0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFE, 0xFE, 0x01,
  0xF8, 0xFC, 0x07, 0xE1, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x01, 0xF8, 0x7E,
  0x03, 0xF1, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xC0, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xBF, 0x00, 0x3F, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xE0,
  0xFC, 0x0F, 0xC1, 0xFC, 0x3F, 0x01, 0xF8, 0xFE, 0x03, 0xF9, 0xF8, 0x03,
  0xF7, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x1F,
  0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF0, 0x7C, 0x0F, 0xC1, 0xF8, 0x7E, 0x07,
  0xE1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0xF8, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xBC, 0x00, 0x7B, 0xE0, 0x0F, 0x9E,
  0x00, 0xF1, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0xF8, 0x3E, 0x07, 0x83, 0xC0,
  0x7C, 0x7C, 0x03, 0xC7, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x00, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF,
  0x82, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC1, 0xFF, 0xF1,
  0xFF, 0xFC, 0xFF, 0xFF, 0x7F, 0x0F, 0xDF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xDF, 0x87, 0xF7, 0xFF, 0xFD, 0xFF, 0xDF, 0x3F, 0xF7,
  0xC7, 0xF0, 0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x70, 0x3E,
  0x7F, 0x0F, 0xBF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x87, 0xEF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xBF,
  0xCF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFB, 0xFE, 0x3C, 0x7F, 0x00, 0x00,
  0xE0, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF7, 0xFF, 0xCF, 0xE1, 0xBF, 0x80,
  0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x02, 0xFE, 0x3D, 0xFF, 0xF9, 0xFF,
  0xF1, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x07,
  0x07, 0xC7, 0xF9, 0xF3, 0xFF, 0x7D, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x87,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC,
  0x0F, 0xDF, 0xC7, 0xF7, 0xFF, 0xFC, 0xFF, 0xDF, 0x3F, 0xF7, 0xC3, 0xF0,
  0xF0, 0x01, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xBF,
  0x9F, 0x87, 0xEF, 0xC0, 0xFB, 0xF0, 0x3E, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF,
  0x81, 0xFF, 0x80, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0xC7, 0xFF, 0x1F, 0xF8,
  0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x01, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0xFF, 0xF8, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x07, 0xF9,
  0xF3, 0xFF, 0x7D, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0x87, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0xC7,
  0xF7, 0xFF, 0xFC, 0xFF, 0xDF, 0x3F, 0xF7, 0xC3, 0xF1, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xD0, 0x03, 0xF7, 0x83, 0xF9, 0xFF, 0xFE, 0x7F,
  0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x38, 0x3E, 0x7F, 0x8F, 0xBF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0x87, 0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xF0, 0x38, 0xFB, 0xF7, 0xF7, 0xCF, 0x00, 0x00, 0x00, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x80, 0x03, 0x81, 0xF0, 0xFC, 0x3F, 0x07, 0xC1,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF9,
  0xFF, 0xFF, 0xFF, 0xBF, 0xEF, 0xE0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x01, 0xFB, 0xE0, 0x7E, 0x7C, 0x1F, 0xCF, 0x83,
  0xF1, 0xF0, 0xFC, 0x3E, 0x3F, 0x07, 0xCF, 0xC0, 0xFB, 0xF0, 0x1F, 0x7E,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFD, 0xF8, 0x3F, 0x3F,
  0x07, 0xC3, 0xF0, 0xF8, 0x3F, 0x1F, 0x07, 0xE3, 0xE0, 0x7E, 0x7C, 0x0F,
  0xEF, 0x80, 0xFD, 0xF0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x78, 0x07, 0x07, 0x8F, 0xF1, 0xFF, 0x3C, 0xFF, 0xDF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF1, 0xFF, 0xF0,
  0x7F, 0x07, 0xFF, 0x83, 0xF8, 0x3F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C,
  0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x0F,
  0xFC, 0x07, 0xC0, 0x7F, 0xE0, 0x3E, 0x03, 0xFF, 0x01, 0xF0, 0x1F, 0xF8,
  0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F,
  0x01, 0xFF, 0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x7C, 0x00, 0x70, 0x3C,
  0x7F, 0x8F, 0x3F, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x87, 0xEF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xF0, 0x01,
  0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF8, 0xFC,
  0x3F, 0xBF, 0x03, 0xF7, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xF7, 0xE0,
  0x7E, 0x7C, 0x0F, 0xCF, 0xC3, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x70, 0x3C, 0x7F, 0x8F, 0xBF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFF, 0xBF, 0x87, 0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xBF, 0xCF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFC, 0xFB, 0xFE, 0x3E, 0x7F, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x07, 0xF9, 0xF3, 0xFF, 0x7D, 0xFF, 0xFF, 0x7F,
  0xFF, 0xDF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0xC7, 0xF7, 0xFF, 0xFC, 0xFF, 0xDF, 0x3F,
  0xF7, 0xC3, 0xF1, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x77, 0x8F, 0xFC, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xF8, 0x1F,
  0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00,
  0x03, 0x80, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0xFE, 0xFB, 0xE0, 0x2F, 0x80,
  0x3F, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xF3, 0xFF, 0x80, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0xC4, 0x7F, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF7, 0xFF, 0x7D, 0xFF, 0x9F, 0x1F, 0xC7, 0xC0, 0xFC, 0x03,
  0xF7, 0xC0, 0x3F, 0x7E, 0x03, 0xE7, 0xE0, 0x7E, 0x3E, 0x07, 0xE3, 0xF0,
  0x7C, 0x3F, 0x07, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF8, 0xF8, 0x0F,
  0x9F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x7D, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x7E, 0xF8, 0x1F, 0xC0, 0xF9, 0xF0,
  0x3F, 0x83, 0xF3, 0xF0, 0xFF, 0x07, 0xE3, 0xE1, 0xEF, 0x0F, 0x87, 0xC3,
  0xDE, 0x1F, 0x0F, 0x87, 0xBC, 0x7E, 0x1F, 0x8F, 0x78, 0xFC, 0x1F, 0x3C,
  0xF1, 0xF0, 0x3E, 0x78, 0xF3, 0xE0, 0x7C, 0xF1, 0xEF, 0xC0, 0xFD, 0xE3,
  0xDF, 0x00, 0xFB, 0xC7, 0xBE, 0x01, 0xFF, 0x0F, 0x7C, 0x03, 0xFE, 0x0E,
  0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F,
  0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0xFE, 0x07, 0xF3, 0xF0, 0x7E, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x1F,
  0x9F, 0x80, 0xFD, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x01, 0xF9, 0xF8, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x07,
  0xE7, 0xE0, 0x7E, 0xFE, 0x03, 0xF0, 0xFC, 0x03, 0xF7, 0xC0, 0x3F, 0x7E,
  0x03, 0xE7, 0xE0, 0x7E, 0x3E, 0x07, 0xE3, 0xF0, 0x7C, 0x3F, 0x07, 0xC1,
  0xF0, 0xFC, 0x1F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x9F, 0x80, 0xF9, 0xF0,
  0x07, 0xDF, 0x00, 0x7D, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x04, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x7F, 0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFC, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F,
  0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x80, 0xFF, 0x07, 0xF0, 0x3F, 0x0F, 0xF1, 0xFE, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F,
  0x03, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0x1F, 0x00, 0x5F, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xE8, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Bold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 28, 11, 2, -28 },
  { 26, 14, 10, 18, 2, -28 },
  { 44, 21, 28, 23, 1, -28 },
  { 118, 17, 32, 21, 2, -30 },
  { 186, 31, 28, 33, 1, -28 },
  { 295, 25, 28, 26, 1, -28 },
  { 383, 6, 10, 10, 2, -28 },
  { 391, 10, 34, 13, 2, -28 },
  { 434, 10, 34, 13, 1, -28 },
  { 477, 18, 18, 20, 1, -30 },
  { 518, 18, 19, 21, 1, -23 },
  { 561, 7, 10, 11, 1, -5 },
  { 570, 10, 5, 12, 1, -13 },
  { 577, 7, 6, 11, 2, -6 },
  { 583, 16, 28, 16, 0, -28 },
  { 639, 18, 28, 21, 1, -28 },
  { 702, 13, 28, 21, 2, -28 },
  { 748, 18, 28, 21, 1, -28 },
  { 811, 18, 28, 21, 1, -28 },
  { 874, 19, 28, 21, 1, -28 },
  { 941, 17, 28, 21, 2, -28 },
  { 1001, 18, 28, 21, 1, -28 },
  { 1064, 18, 28, 21, 1, -28 },
  { 1127, 18, 28, 21, 1, -28 },
  { 1190, 18, 28, 21, 1, -28 },
  { 1253, 7, 22, 11, 2, -22 },
  { 1273, 8, 27, 11, 1, -22 },
  { 1300, 18, 20, 21, 1, -24 },
  { 1345, 18, 12, 21, 1, -20 },
  { 1372, 18, 20, 21, 1, -24 },
  { 1417, 16, 28, 17, 0, -28 },
  { 1473, 29, 31, 32, 2, -28 },
  { 1586, 25, 28, 25, 0, -28 },
  { 1674, 19, 28, 24, 3, -28 },
  { 1741, 20, 28, 23, 2, -28 },
  { 1811, 21, 28, 26, 3, -28 },
  { 1885, 15, 28, 20, 3, -28 },
  { 1938, 15, 28, 20, 3, -28 },
  { 1991, 21, 28, 26, 2, -28 },
  { 2065, 21, 28, 27, 3, -28 },
  { 2139, 12, 28, 14, 1, -28 },
  { 2181, 12, 36, 12, -3, -28 },
  { 2235, 21, 28, 24, 3, -28 },
  { 2309, 16, 28, 20, 3, -28 },
  { 2365, 28, 28, 34, 3, -28 },
  { 2463, 23, 28, 29, 3, -28 },
  { 2544, 24, 28, 28, 2, -28 },
  { 2628, 18, 28, 22, 3, -28 },
  { 2691, 24, 35, 28, 2, -28 },
  { 2796, 21, 28, 24, 3, -28 },
  { 2870, 16, 28, 20, 2, -28 },
  { 2926, 19, 28, 20, 1, -28 },
  { 2993, 21, 28, 27, 3, -28 },
  { 3067, 23, 28, 23, 0, -28 },
  { 3148, 35, 28, 35, 0, -28 },
  { 3271, 23, 28, 23, 0, -28 },
  { 3352, 22, 28, 22, 0, -28 },
  { 3429, 18, 28, 20, 1, -28 },
  { 3492, 9, 34, 13, 3, -28 },
  { 3531, 16, 28, 16, 0, -28 },
  { 3587, 9, 34, 13, 1, -28 },
  { 3626, 20, 18, 22, 1, -28 },
  { 3671, 16, 3, 16, 0, 3 },
  { 3677, 10, 6, 13, 2, -30 },
  { 3685, 18, 22, 21, 1, -22 },
  { 3735, 18, 30, 23, 3, -30 },
  { 3803, 15, 22, 18, 2, -22 },
  { 3845, 18, 30, 23, 2, -30 },
  { 3913, 18, 22, 21, 2, -22 },
  { 3963, 14, 30, 14, 1, -30 },
  { 4016, 18, 31, 23, 2, -22 },
  { 4086, 18, 30, 23, 3, -30 },
  { 4154, 7, 30, 11, 2, -30 },
  { 4181, 10, 39, 11, -2, -30 },
  { 4230, 19, 30, 22, 3, -30 },
  { 4302, 5, 30, 11, 3, -30 },
  { 4321, 29, 22, 35, 3, -22 },
  { 4401, 18, 22, 23, 3, -22 },
  { 4451, 19, 22, 22, 2, -22 },
  { 4504, 18, 31, 23, 3, -22 },
  { 4574, 18, 31, 23, 2, -22 },
  { 4644, 13, 22, 16, 3, -22 },
  { 4680, 14, 22, 18, 2, -22 },
  { 4719, 13, 26, 15, 1, -26 },
  { 4762, 18, 21, 23, 3, -21 },
  { 4810, 20, 21, 20, 0, -21 },
  { 4863, 31, 21, 31, 0, -21 },
  { 4945, 20, 21, 20, 0, -21 },
  { 4998, 20, 30, 20, 0, -21 },
  { 5073, 15, 21, 17, 1, -21 },
  { 5113, 13, 34, 15, 0, -28 },
  { 5169, 4, 39, 20, 8, -30 },
  { 5189, 12, 34, 15, 2, -28 },
  { 5240, 18, 7, 21, 1, -17 },
};

const GFXfont NotoSans_SemiCondensed_Bold39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold39pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD39PT7B_H_
