#ifndef _NOTOSANS_SEMICONDENSED_BOLD50PT7B_H_
#define _NOTOSANS_SEMICONDENSED_BOLD50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Bold.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Bold50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x10, 0xFE, 0x3F, 0xFF, 0x8F, 0xEF, 0xE1, 0xFB, 0xF8, 0x7E, 0xFE,
  0x1F, 0xBF, 0x87, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07,
  0xE7, 0xC1, 0xF9, 0xF0, 0x7E, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8,
  0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFC, 0xE0, 0xC7, 0xF1, 0xC0,
  0x0F, 0xE3, 0x80, 0x1F, 0xC7, 0x00, 0x3F, 0xCE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x3B, 0xFC, 0x00, 0x73, 0xFC, 0x00, 0xE3, 0xFC, 0x01, 0xC7, 0xFC, 0x03,
  0x9F, 0xDF, 0x07, 0x3F, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x7C, 0x00, 0x3F, 0xFE, 0x00, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0xF8, 0x00, 0x7E, 0x3F, 0x01, 0xF8, 0x00, 0x7C,
  0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x1F, 0x03, 0xF0, 0x00, 0x7C, 0x1F, 0x03,
  0xE0, 0x00, 0xFC, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x07, 0xC0, 0x00,
  0x7C, 0x1F, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x1F,
  0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x1F, 0x0F, 0xF8, 0x7E, 0x3F, 0x3F, 0x1F,
  0xFC, 0x3F, 0xFE, 0x3E, 0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0x7F, 0xFE, 0x1F,
  0xFC, 0x7C, 0x7E, 0x7E, 0x0F, 0xF8, 0xFC, 0x7C, 0x3F, 0x07, 0xF0, 0xF8,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x3F,
  0x00, 0x03, 0xF0, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x00, 0x07,
  0xE0, 0xFC, 0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x3F, 0x00, 0x0F, 0xC0, 0xFC,
  0x3F, 0x00, 0x0F, 0x80, 0x7C, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x3F, 0x00,
  0x1F, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x00,
  0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x01, 0xFE,
  0x1F, 0xFF, 0x01, 0xFC, 0x3F, 0xFF, 0x81, 0xFC, 0x7F, 0xFF, 0xC3, 0xFC,
  0x7F, 0xBF, 0xE3, 0xF8, 0xFF, 0x1F, 0xF3, 0xF8, 0xFF, 0x0F, 0xFF, 0xF8,
  0xFE, 0x07, 0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0xE0,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xE3, 0xFE, 0x03, 0xFF, 0x81, 0xFF,
  0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFD,
  0xF9, 0xF3, 0xE7, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81,
  0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1C, 0x1F, 0x03,
  0x3F, 0x3E, 0x7E, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x01,
  0xF7, 0xE0, 0x07, 0xEF, 0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E,
  0x1F, 0xC0, 0x78, 0x3C, 0x00, 0x30, 0x20, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x9F, 0xDF, 0xCF, 0xE7, 0xF3, 0xF9,
  0xF8, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x10, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xFC,
  0xFE, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF,
  0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03,
  0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x8F, 0xF0, 0x7F,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE,
  0x7F, 0xFF, 0x7F, 0xBF, 0xFF, 0xBF, 0xFF, 0x9F, 0xEF, 0x8F, 0xF3, 0x87,
  0xF8, 0x83, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x1F, 0xC1, 0xFF, 0x1E, 0x01,
  0xFE, 0x18, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x0F, 0x01, 0xFF, 0x08, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE8, 0x00, 0x3F, 0xDC, 0x00, 0xFF,
  0xBF, 0x9F, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3E, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F,
  0x3F, 0x80, 0x1F, 0x9F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0x87, 0xF0, 0x0F,
  0xC3, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x03,
  0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFD, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x87, 0x07, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0x1F,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0,
  0x3F, 0xBF, 0xF8, 0x7E, 0x7F, 0xF8, 0xFD, 0xFF, 0xF9, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFC, 0x1F, 0xEF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xCF, 0xF0, 0x7F, 0x8F, 0xFB,
  0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF8, 0xFF,
  0x1F, 0xC0, 0xFF, 0x3F, 0x80, 0xFE, 0x7E, 0x01, 0xFC, 0xFC, 0x03, 0xF9,
  0xFC, 0x07, 0xF3, 0xF8, 0x1F, 0xC3, 0xF8, 0x7F, 0x87, 0xF9, 0xFE, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xF1, 0xFF, 0x1F, 0xC0,
  0xFF, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0xFF,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x7F, 0xC3, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xC3, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0x7F, 0x0F, 0xFE, 0x7E,
  0x07, 0xFC, 0x7E, 0x00, 0x70, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x10, 0x3F, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x3C, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x10, 0x1E, 0x1F, 0x9F, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0x7E, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x7F, 0x3F, 0xBF, 0x9F, 0xCF, 0xE7, 0xE3, 0xF3,
  0xF9, 0xF8, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xF0,
  0x1F, 0xE6, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x1F, 0x87, 0xC0, 0x7F, 0xFC, 0x7C,
  0x7E, 0x0F, 0xFF, 0xE3, 0xF3, 0xE0, 0xFF, 0xFF, 0x0F, 0xBF, 0x0F, 0xFF,
  0xF8, 0x7D, 0xF0, 0x7E, 0x0F, 0xC3, 0xEF, 0x87, 0xE0, 0x7E, 0x1F, 0x7C,
  0x3F, 0x03, 0xE0, 0xFF, 0xE1, 0xF0, 0x1F, 0x07, 0xFF, 0x0F, 0x80, 0xF8,
  0x3F, 0xF8, 0x7C, 0x07, 0xC1, 0xFF, 0x87, 0xE0, 0x3E, 0x0F, 0xFC, 0x1F,
  0x01, 0xF0, 0x7F, 0xE0, 0xF8, 0x1F, 0x83, 0xFF, 0x87, 0xC0, 0xFC, 0x1F,
  0xFC, 0x3F, 0x07, 0xE1, 0xF7, 0xE1, 0xFC, 0x7F, 0x9F, 0x9F, 0x07, 0xFF,
  0xFF, 0xF8, 0xF8, 0x3F, 0xFD, 0xFF, 0xC7, 0xE0, 0xFF, 0xC7, 0xFC, 0x3F,
  0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x20, 0x03, 0xFE,
  0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xBF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0,
  0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80,
  0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFE, 0x07, 0xFE, 0xFE,
  0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x0F, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFE, 0x07, 0xFE, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x78,
  0x7F, 0xC0, 0x0C, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x11, 0xFF, 0x80, 0x70,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x30, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0x87, 0xFF, 0xC7, 0xF0, 0x0F,
  0xFC, 0xFE, 0x00, 0xFF, 0x9F, 0xC0, 0x0F, 0xFB, 0xF8, 0x00, 0xFF, 0x7F,
  0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xDF, 0xC0,
  0x07, 0xFB, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0xCF, 0xE0, 0x1F, 0xF1,
  0xFC, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0x01, 0xE1, 0xFF, 0x80, 0x04, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF,
  0xC0, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0xE0, 0x3F, 0xC7, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x30, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x1F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFF, 0x3F, 0xFC, 0xFF, 0xE3, 0xFE, 0x01, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFB, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x7F, 0x8F,
  0xE0, 0x1F, 0xF1, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x3F,
  0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0x7F,
  0x0F, 0xF0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xE0,
  0x07, 0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xC7, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0,
  0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1,
  0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x07, 0xF8, 0xFE, 0x00,
  0xFF, 0x9F, 0xC0, 0x0F, 0xF3, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xF0,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xDF,
  0x80, 0x1F, 0xFF, 0xFD, 0xF8, 0x01, 0xFF, 0xFF, 0xDF, 0x80, 0x3F, 0x7F,
  0xFC, 0xFC, 0x03, 0xF7, 0xFF, 0xEF, 0xC0, 0x3F, 0x7F, 0xFE, 0xFC, 0x03,
  0xE7, 0xFF, 0xEF, 0xC0, 0x7E, 0x7F, 0xFE, 0x7E, 0x07, 0xE7, 0xFF, 0xE7,
  0xE0, 0x7C, 0x7F, 0xFE, 0x7E, 0x0F, 0xC7, 0xFF, 0xE3, 0xF0, 0xFC, 0x7F,
  0xFE, 0x3F, 0x0F, 0xC7, 0xFF, 0xE3, 0xF1, 0xF8, 0x7F, 0xFE, 0x1F, 0x1F,
  0x87, 0xFF, 0xE1, 0xF9, 0xF8, 0x7F, 0xFE, 0x1F, 0x9F, 0x07, 0xFF, 0xE1,
  0xFB, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xFE, 0x07, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0x80, 0x7F, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0x7F, 0x00, 0x7F, 0xFB, 0xFC, 0x03, 0xFF, 0xCF, 0xF0, 0x1F, 0xFE,
  0x7F, 0x80, 0xFF, 0xF9, 0xFE, 0x07, 0xFF, 0xCF, 0xF0, 0x3F, 0xFE, 0x3F,
  0xC1, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF, 0x87, 0xF8, 0x7F, 0xFC, 0x1F, 0xC3,
  0xFF, 0xE0, 0xFF, 0x1F, 0xFF, 0x03, 0xF8, 0xFF, 0xF8, 0x1F, 0xE7, 0xFF,
  0xC0, 0x7F, 0x3F, 0xFE, 0x03, 0xFD, 0xFF, 0xF0, 0x0F, 0xEF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0x03,
  0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF9, 0xFE, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0xC0, 0x0F, 0xF0,
  0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF,
  0x87, 0xFF, 0x7F, 0x01, 0xFE, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0x7F, 0x01, 0xFE, 0xFE, 0x07, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0x03, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF9,
  0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F,
  0xC0, 0x0F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xE0,
  0xFF, 0xC3, 0xF8, 0x0F, 0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x8F,
  0xE0, 0x1F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F,
  0x8F, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x0F, 0xF0,
  0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x1F, 0xE0, 0xFE, 0x03,
  0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xE3, 0xF8, 0x03, 0xFC, 0xFE,
  0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x00, 0xFF,
  0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x87, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0x0F, 0xCF, 0xE0, 0x0C, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x04,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x1F,
  0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00,
  0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01,
  0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F,
  0xC0, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8,
  0x7F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7F, 0x3F,
  0x80, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE7, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0x8F, 0xE0, 0x0F, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x03, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0xFC, 0x07, 0xF0,
  0x7F, 0x01, 0xFF, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xDF, 0x01, 0xFC, 0x0F,
  0xE0, 0x7C, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xE7, 0xE0, 0xFE, 0x03, 0xF8,
  0x3F, 0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xF9, 0xF8, 0x3F, 0x80, 0x7F, 0x0F,
  0xC7, 0xE1, 0xFC, 0x03, 0xF8, 0xFE, 0x3F, 0x1F, 0xC0, 0x1F, 0xC7, 0xE1,
  0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xF8, 0x7E,
  0x3F, 0x80, 0x1F, 0xCF, 0xC1, 0xF9, 0xF8, 0x00, 0xFE, 0xFC, 0x0F, 0xDF,
  0xC0, 0x07, 0xF7, 0xE0, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x03, 0xF7, 0xF0,
  0x00, 0xFD, 0xF8, 0x0F, 0xBF, 0x00, 0x07, 0xEF, 0x80, 0x7D, 0xF8, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x07,
  0xF9, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF8,
  0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x01,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x7F,
  0x8F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC0,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x0F,
  0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xF8, 0x7F,
  0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80,
  0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x83, 0xF8,
  0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x01,
  0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFD,
  0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE1, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0x7C,
  0x07, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0x1F, 0x80, 0x07, 0xEF, 0xC0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x00, 0x1F,
  0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0xE0, 0x3F, 0xC2, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0xDF, 0xFC, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFB, 0xF3, 0xFF, 0xC7, 0xC7, 0xFC,
  0x1F, 0x01, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x0F,
  0x80, 0xFE, 0x3F, 0xE0, 0xFE, 0x7F, 0xF0, 0xFE, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xC3, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x00,
  0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0xE7, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFE, 0xFF, 0xF8, 0xFE, 0x7F, 0xF0, 0xFC, 0x3F, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xE1, 0xE7, 0xF8, 0x02, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x17, 0xFC, 0x03, 0x3F, 0xF3, 0xF3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFC, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xF0, 0x7F, 0x07,
  0xFC, 0x7F, 0x0F, 0xFE, 0x7F, 0x1F, 0xFF, 0x7F, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x00, 0xFF, 0x7F,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x7F,
  0x81, 0xFF, 0x7F, 0xE7, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0x7F, 0x0F, 0xFE, 0x3F, 0x03, 0xFC, 0x3F, 0x00, 0x40, 0x00, 0x00,
  0x7E, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xE0, 0x7F, 0x3F, 0xC0, 0x7F, 0x7F, 0x00,
  0xFE, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x8F, 0xF8, 0x0F, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x3F,
  0x0F, 0xFF, 0x7F, 0x1F, 0xFF, 0x7F, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x7F, 0xC3, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x81, 0xFF,
  0x7F, 0xE7, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0x7F,
  0x0F, 0xFE, 0x7F, 0x03, 0xFC, 0x7F, 0x00, 0x40, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x20, 0x01, 0xFE, 0x38, 0x03, 0xFE,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x07, 0x80, 0xFE, 0x3F, 0xF0, 0xFE, 0x7F, 0xF8, 0xFE, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xE3, 0xFE, 0xFF, 0x81, 0xFE,
  0xFF, 0x80, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x1F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC,
  0x1F, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF, 0x87, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x1F, 0xEF, 0xE0, 0x1F, 0xE7, 0xF0, 0x1F, 0xE3, 0xF8, 0x1F, 0xE1, 0xFC,
  0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F,
  0xCF, 0xF0, 0x0F, 0xEF, 0xF0, 0x07, 0xEF, 0xF0, 0x03, 0xF7, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x1F, 0xF7, 0xF8, 0x0F, 0xF1, 0xFC, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x3F,
  0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x7F, 0x01, 0xFE, 0x3F, 0x80,
  0xFF, 0x1F, 0xC0, 0x3F, 0xCF, 0xE0, 0x0F, 0xF7, 0xF0, 0x07, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x80, 0x1F, 0x83, 0xF0, 0xFF, 0xC1, 0xFF, 0x8F, 0xCF,
  0xFF, 0x8F, 0xFF, 0x3F, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x7F, 0xFF, 0xE0,
  0x7F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0x00,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0x80, 0x7F,
  0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0x00, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0xF0, 0xFC, 0x7F, 0xF8, 0xFE,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFE, 0xFF,
  0x81, 0xFE, 0xFF, 0x80, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF8,
  0xFF, 0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F,
  0xDF, 0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xF7, 0xF0, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x3F, 0x9F, 0xC0,
  0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xF0, 0xFF,
  0x8F, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0xFC, 0x3F, 0xE0, 0xFE, 0x7F, 0xF0, 0xFE, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xC3, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x00, 0xFE,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFE,
  0xFF, 0x81, 0xFE, 0xFF, 0xF7, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFE, 0xFF, 0xF8, 0xFE, 0x7F, 0xF0, 0xFE, 0x3F, 0xC0, 0xFE, 0x02, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xFC, 0x3F, 0x0F, 0xFF, 0x7F, 0x1F, 0xFF, 0x7F, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x00, 0xFF,
  0x7F, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFF,
  0x7F, 0x81, 0xFF, 0x7F, 0xE3, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0x7F, 0x0F, 0xFE, 0x7F, 0x03, 0xFC, 0x7F, 0x00, 0x40, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE,
  0x1F, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x01,
  0xFF, 0xF0, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F,
  0x80, 0x67, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x80,
  0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF,
  0xFC, 0x3F, 0xFE, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x30, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x18, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x3F, 0xFF, 0x7E, 0x3F, 0xFC, 0xFC, 0x1F, 0xF0,
  0xF8, 0x04, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0,
  0x03, 0xF9, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00,
  0xFC, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFE, 0xFE, 0x03, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xFC, 0x07, 0xF3, 0xF8,
  0x0F, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0xF0,
  0x3F, 0x8F, 0xE0, 0xFB, 0xE0, 0x7E, 0x1F, 0xC1, 0xF7, 0xC1, 0xFC, 0x1F,
  0xC3, 0xE7, 0xC3, 0xF8, 0x3F, 0x87, 0xCF, 0x87, 0xF0, 0x7F, 0x1F, 0x9F,
  0x0F, 0xC0, 0xFE, 0x3E, 0x3E, 0x3F, 0x80, 0xFE, 0x7C, 0x7E, 0x7F, 0x01,
  0xFC, 0xF8, 0x7C, 0xFE, 0x03, 0xF9, 0xF0, 0xF9, 0xF8, 0x03, 0xF7, 0xC1,
  0xF7, 0xF0, 0x07, 0xEF, 0x83, 0xEF, 0xE0, 0x0F, 0xDF, 0x07, 0xDF, 0x80,
  0x1F, 0xBE, 0x07, 0xBF, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xCF,
  0xE0, 0x1F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xE1, 0xFE,
  0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xCF,
  0xE0, 0x0F, 0xF3, 0xFC, 0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF,
  0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x1F, 0xEF, 0xF0, 0x03, 0xFC,
  0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xF9, 0xFE, 0x00,
  0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F,
  0x03, 0xFC, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x3F,
  0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xF8,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x02, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x40, 0x07, 0xFC, 0x80,
  0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Bold50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 8, 37, 14, 3, -36 },
  { 38, 18, 13, 23, 3, -36 },
  { 68, 28, 36, 30, 1, -36 },
  { 194, 23, 41, 27, 2, -38 },
  { 312, 40, 36, 43, 1, -36 },
  { 492, 32, 37, 34, 2, -36 },
  { 640, 7, 13, 13, 3, -36 },
  { 652, 13, 44, 17, 2, -36 },
  { 724, 13, 44, 17, 1, -36 },
  { 796, 23, 22, 25, 1, -38 },
  { 860, 23, 24, 27, 2, -30 },
  { 929, 9, 12, 14, 2, -6 },
  { 943, 13, 7, 16, 1, -17 },
  { 955, 8, 9, 14, 3, -8 },
  { 964, 20, 36, 21, 0, -36 },
  { 1054, 23, 37, 27, 2, -36 },
  { 1161, 17, 36, 27, 3, -36 },
  { 1238, 23, 36, 27, 2, -36 },
  { 1342, 23, 37, 27, 2, -36 },
  { 1449, 25, 36, 27, 1, -36 },
  { 1562, 22, 37, 27, 2, -36 },
  { 1664, 23, 37, 27, 2, -36 },
  { 1771, 24, 36, 27, 1, -36 },
  { 1879, 23, 37, 27, 2, -36 },
  { 1986, 24, 37, 27, 1, -36 },
  { 2097, 8, 29, 14, 3, -28 },
  { 2126, 9, 34, 14, 2, -28 },
  { 2165, 23, 26, 27, 2, -31 },
  { 2240, 23, 15, 27, 2, -25 },
  { 2284, 23, 26, 27, 2, -31 },
  { 2359, 21, 37, 22, 0, -36 },
  { 2457, 37, 40, 42, 2, -36 },
  { 2642, 32, 36, 32, 0, -36 },
  { 2786, 24, 36, 31, 4, -36 },
  { 2894, 25, 37, 29, 3, -36 },
  { 3010, 27, 36, 33, 4, -36 },
  { 3132, 19, 36, 26, 4, -36 },
  { 3218, 19, 36, 25, 4, -36 },
  { 3304, 27, 37, 33, 3, -36 },
  { 3429, 27, 36, 35, 4, -36 },
  { 3551, 16, 36, 18, 1, -36 },
  { 3623, 14, 47, 16, -3, -36 },
  { 3706, 27, 36, 30, 4, -36 },
  { 3828, 20, 36, 25, 4, -36 },
  { 3918, 36, 36, 44, 4, -36 },
  { 4080, 29, 36, 37, 4, -36 },
  { 4211, 30, 37, 36, 3, -36 },
  { 4350, 23, 36, 29, 4, -36 },
  { 4454, 30, 45, 36, 3, -36 },
  { 4623, 26, 36, 30, 4, -36 },
  { 4740, 21, 37, 25, 2, -36 },
  { 4838, 24, 36, 26, 1, -36 },
  { 4946, 27, 37, 34, 4, -36 },
  { 5071, 30, 36, 30, 0, -36 },
  { 5206, 45, 36, 44, 0, -36 },
  { 5409, 30, 36, 30, 0, -36 },
  { 5544, 29, 36, 29, 0, -36 },
  { 5675, 24, 36, 26, 1, -36 },
  { 5783, 12, 44, 16, 3, -36 },
  { 5849, 20, 36, 21, 0, -36 },
  { 5939, 12, 44, 16, 1, -36 },
  { 6005, 26, 23, 28, 1, -36 },
  { 6080, 21, 4, 21, 0, 4 },
  { 6091, 13, 8, 17, 2, -38 },
  { 6104, 22, 29, 27, 2, -28 },
  { 6184, 24, 39, 29, 3, -38 },
  { 6301, 20, 29, 24, 2, -28 },
  { 6374, 24, 39, 29, 2, -38 },
  { 6491, 23, 29, 27, 2, -28 },
  { 6575, 19, 38, 18, 1, -38 },
  { 6666, 24, 40, 29, 2, -28 },
  { 6786, 24, 38, 30, 3, -38 },
  { 6900, 8, 38, 14, 3, -38 },
  { 6938, 13, 50, 14, -2, -38 },
  { 7020, 25, 38, 29, 4, -38 },
  { 7139, 8, 38, 14, 3, -38 },
  { 7177, 38, 28, 45, 3, -28 },
  { 7310, 24, 28, 30, 3, -28 },
  { 7394, 25, 29, 29, 2, -28 },
  { 7485, 24, 40, 29, 3, -28 },
  { 7605, 24, 40, 29, 2, -28 },
  { 7725, 17, 28, 21, 3, -28 },
  { 7785, 19, 29, 23, 2, -28 },
  { 7854, 17, 34, 20, 1, -33 },
  { 7927, 23, 28, 30, 3, -27 },
  { 8008, 26, 27, 26, 0, -27 },
  { 8096, 39, 27, 40, 0, -27 },
  { 8228, 26, 27, 26, 0, -27 },
  { 8316, 26, 39, 26, 0, -27 },
  { 8443, 20, 27, 22, 1, -27 },
  { 8511, 16, 44, 19, 1, -36 },
  { 8599, 6, 49, 26, 10, -38 },
  { 8636, 16, 44, 19, 2, -36 },
  { 8724, 23, 9, 27, 2, -22 },
};

const GFXfont NotoSans_SemiCondensed_Bold50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Bold50pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Bold50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_SEMICONDENSED_BOLD50PT7B_H_
