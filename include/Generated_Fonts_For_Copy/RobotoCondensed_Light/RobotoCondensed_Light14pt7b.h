#ifndef _ROBOTOCONDENSED_LIGHT14PT7B_H_
#define _ROBOTOCONDENSED_LIGHT14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x40, 0xFC, 0x28, 0xA2, 0xBF, 0x49, 0x25, 0x3F, 0x51, 0x40,
  0x23, 0xA3, 0x18, 0x30, 0x41, 0x8C, 0x5C, 0x40, 0xC1, 0x4A, 0xA5, 0x4F,
  0x02, 0xCA, 0x95, 0x4A, 0x0C, 0x72, 0x49, 0x14, 0x62, 0x99, 0x62, 0x89,
  0xD0, 0xE0, 0x29, 0x49, 0x24, 0x92, 0x24, 0x40, 0x89, 0x12, 0x49, 0x24,
  0xA5, 0x00, 0x10, 0x8E, 0xCC, 0x31, 0x20, 0x21, 0x09, 0xF2, 0x10, 0x80,
  0x58, 0xE0, 0x80, 0x11, 0x11, 0x22, 0x24, 0x44, 0x80, 0x74, 0x63, 0x18,
  0xC6, 0x31, 0x8B, 0x80, 0x3C, 0x92, 0x49, 0x24, 0x74, 0x62, 0x11, 0x08,
  0x88, 0x87, 0xC0, 0x74, 0x62, 0x17, 0x04, 0x31, 0x8B, 0x80, 0x08, 0x61,
  0x8A, 0x29, 0x27, 0xC2, 0x08, 0x20, 0x7A, 0x21, 0x0F, 0x04, 0x31, 0x8B,
  0x80, 0x32, 0x21, 0xE8, 0xC6, 0x31, 0x8B, 0x80, 0xF8, 0x44, 0x21, 0x10,
  0x84, 0x42, 0x00, 0x74, 0x63, 0x17, 0x46, 0x31, 0x8B, 0x80, 0x74, 0x63,
  0x18, 0xC5, 0xE1, 0x13, 0x00, 0x82, 0x40, 0x05, 0x80, 0x16, 0x86, 0x10,
  0xF8, 0x01, 0xF0, 0x83, 0x82, 0xE8, 0x00, 0xE9, 0x11, 0x24, 0x40, 0x04,
  0x1E, 0x30, 0x90, 0x31, 0x99, 0x2D, 0x26, 0x93, 0x49, 0xA4, 0xCD, 0xA0,
  0x08, 0x03, 0xC0, 0x10, 0x30, 0x61, 0x42, 0x44, 0x9F, 0x21, 0x43, 0x04,
  0xFA, 0x28, 0x62, 0xF2, 0x28, 0x61, 0x87, 0xE0, 0x7A, 0x18, 0x60, 0x82,
  0x08, 0x21, 0x85, 0xE0, 0xF2, 0x28, 0x61, 0x86, 0x18, 0x61, 0x8B, 0xC0,
  0xFC, 0x21, 0x0F, 0xC2, 0x10, 0x87, 0xC0, 0xFC, 0x21, 0x0F, 0xC2, 0x10,
  0x84, 0x00, 0x7A, 0x18, 0x60, 0x82, 0x78, 0x61, 0x45, 0xE0, 0x86, 0x18,
  0x61, 0xFE, 0x18, 0x61, 0x86, 0x10, 0xFF, 0xC0, 0x08, 0x42, 0x10, 0x84,
  0x31, 0x97, 0x80, 0x86, 0x29, 0x28, 0xA3, 0x89, 0x22, 0x8A, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x87, 0xC0, 0x81, 0xC1, 0xC3, 0xA3, 0xA3, 0xA5,
  0x95, 0x95, 0x99, 0x89, 0x87, 0x1C, 0x69, 0x96, 0x58, 0xE3, 0x86, 0x10,
  0x7A, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE0, 0xFA, 0x18, 0x61, 0x87,
  0xE8, 0x20, 0x82, 0x00, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE0,
  0x41, 0xFA, 0x18, 0x61, 0x8B, 0xE9, 0x22, 0x8A, 0x10, 0x72, 0x28, 0x60,
  0x60, 0x60, 0x61, 0x89, 0xE0, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE0, 0x82, 0x85,
  0x0A, 0x22, 0x44, 0x8A, 0x0C, 0x18, 0x20, 0x84, 0x51, 0x14, 0xA5, 0x29,
  0x4A, 0x4A, 0xA3, 0x28, 0xC6, 0x31, 0x88, 0x40, 0x42, 0x88, 0x91, 0x41,
  0x03, 0x0A, 0x12, 0x44, 0x84, 0x82, 0x89, 0x11, 0x42, 0x82, 0x04, 0x08,
  0x10, 0x20, 0xFC, 0x21, 0x04, 0x20, 0x84, 0x10, 0x83, 0xF0, 0xEA, 0xAA,
  0xAA, 0xC0, 0x82, 0x10, 0x82, 0x10, 0x82, 0x10, 0x82, 0xD5, 0x55, 0x55,
  0xC0, 0x44, 0xAA, 0x90, 0xF8, 0x90, 0x74, 0x42, 0xF8, 0xC6, 0x7D, 0x84,
  0x21, 0xE8, 0xC6, 0x31, 0x8C, 0x7C, 0x74, 0x63, 0x08, 0x42, 0x2E, 0x08,
  0x42, 0xF8, 0xC6, 0x31, 0x8C, 0x5E, 0x74, 0x63, 0xF8, 0x42, 0x0E, 0x32,
  0x4F, 0x44, 0x44, 0x44, 0x40, 0x7C, 0x63, 0x18, 0xC6, 0x2F, 0x0C, 0x5C,
  0x84, 0x21, 0xE8, 0xC6, 0x31, 0x8C, 0x62, 0x9F, 0xE0, 0x41, 0x55, 0x55,
  0x60, 0x84, 0x21, 0x29, 0x53, 0x14, 0xA4, 0xA2, 0xFF, 0xE0, 0xF7, 0x44,
  0x62, 0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0xF4, 0x63, 0x18, 0xC6, 0x31,
  0x74, 0x63, 0x18, 0xC6, 0x2E, 0xF4, 0x63, 0x18, 0xC6, 0x3E, 0x84, 0x20,
  0x7C, 0x63, 0x18, 0xC6, 0x2F, 0x08, 0x42, 0xF2, 0x49, 0x24, 0x79, 0x84,
  0x31, 0x97, 0x4E, 0x44, 0x44, 0x44, 0x20, 0x8C, 0x63, 0x18, 0xC6, 0x2F,
  0x85, 0x24, 0x92, 0x30, 0xC3, 0x08, 0x88, 0xA4, 0x95, 0x4A, 0xA5, 0x51,
  0xA8, 0x88, 0x44, 0x49, 0x23, 0x0C, 0x30, 0xC4, 0x92, 0x85, 0x24, 0x92,
  0x30, 0xC3, 0x04, 0x20, 0x84, 0x00, 0xF0, 0x88, 0x44, 0x22, 0x1F, 0x29,
  0x24, 0xA4, 0x49, 0x24, 0x40, 0xFF, 0xF0, 0x84, 0x44, 0x42, 0x32, 0x44,
  0x44, 0x48, 0x66, 0x58, 0xC0,
};

const GFXglyph RobotoCondensed_Light14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 10, 3, 1, -10 },
  { 3, 2, 3, 4, 1, -11 },
  { 4, 6, 10, 7, 1, -10 },
  { 12, 5, 12, 7, 1, -11 },
  { 20, 7, 10, 9, 1, -10 },
  { 29, 6, 10, 8, 1, -10 },
  { 37, 1, 3, 2, 1, -11 },
  { 38, 3, 14, 4, 1, -11 },
  { 44, 3, 14, 4, 0, -11 },
  { 50, 6, 6, 6, 0, -10 },
  { 55, 5, 7, 7, 1, -8 },
  { 60, 2, 3, 3, 0, -1 },
  { 61, 3, 1, 4, 0, -5 },
  { 62, 1, 1, 3, 1, -1 },
  { 63, 4, 11, 5, 0, -10 },
  { 69, 5, 10, 7, 1, -10 },
  { 76, 3, 10, 7, 1, -10 },
  { 80, 5, 10, 7, 1, -10 },
  { 87, 5, 10, 7, 1, -10 },
  { 94, 6, 10, 7, 0, -10 },
  { 102, 5, 10, 7, 1, -10 },
  { 109, 5, 10, 7, 1, -10 },
  { 116, 5, 10, 7, 1, -10 },
  { 123, 5, 10, 7, 1, -10 },
  { 130, 5, 10, 7, 1, -10 },
  { 137, 1, 7, 3, 1, -7 },
  { 138, 2, 9, 3, 0, -7 },
  { 141, 4, 5, 6, 1, -7 },
  { 144, 5, 4, 7, 1, -7 },
  { 147, 5, 5, 6, 1, -7 },
  { 151, 4, 10, 6, 1, -10 },
  { 156, 9, 13, 11, 1, -10 },
  { 171, 7, 10, 8, 0, -10 },
  { 180, 6, 10, 8, 1, -10 },
  { 188, 6, 10, 8, 1, -10 },
  { 196, 6, 10, 8, 1, -10 },
  { 204, 5, 10, 7, 1, -10 },
  { 211, 5, 10, 7, 1, -10 },
  { 218, 6, 10, 8, 1, -10 },
  { 226, 6, 10, 9, 1, -10 },
  { 234, 1, 10, 3, 1, -10 },
  { 236, 5, 10, 7, 1, -10 },
  { 243, 6, 10, 8, 1, -10 },
  { 251, 5, 10, 7, 1, -10 },
  { 258, 8, 10, 10, 1, -10 },
  { 268, 6, 10, 9, 1, -10 },
  { 276, 6, 10, 8, 1, -10 },
  { 284, 6, 10, 8, 1, -10 },
  { 292, 6, 12, 8, 1, -10 },
  { 301, 6, 10, 8, 1, -10 },
  { 309, 6, 10, 7, 1, -10 },
  { 317, 7, 10, 7, 0, -10 },
  { 326, 6, 10, 8, 1, -10 },
  { 334, 7, 10, 8, 0, -10 },
  { 343, 10, 10, 11, 0, -10 },
  { 356, 7, 10, 8, 0, -10 },
  { 365, 7, 10, 7, 0, -10 },
  { 374, 6, 10, 7, 1, -10 },
  { 382, 2, 13, 3, 1, -11 },
  { 386, 5, 11, 5, 0, -10 },
  { 393, 2, 13, 3, 0, -11 },
  { 397, 4, 5, 5, 1, -10 },
  { 400, 5, 1, 5, 0, 0 },
  { 401, 2, 2, 4, 1, -11 },
  { 402, 5, 8, 7, 1, -8 },
  { 407, 5, 11, 7, 1, -11 },
  { 414, 5, 8, 6, 1, -8 },
  { 419, 5, 11, 7, 1, -11 },
  { 426, 5, 8, 6, 1, -8 },
  { 431, 4, 11, 4, 0, -11 },
  { 437, 5, 11, 7, 1, -8 },
  { 444, 5, 11, 7, 1, -11 },
  { 451, 1, 11, 3, 1, -11 },
  { 453, 2, 14, 3, 0, -11 },
  { 457, 5, 11, 6, 1, -11 },
  { 464, 1, 11, 3, 1, -11 },
  { 466, 9, 8, 11, 1, -8 },
  { 475, 5, 8, 7, 1, -8 },
  { 480, 5, 8, 7, 1, -8 },
  { 485, 5, 11, 7, 1, -8 },
  { 492, 5, 11, 7, 1, -8 },
  { 499, 3, 8, 4, 1, -8 },
  { 502, 4, 8, 6, 1, -8 },
  { 506, 4, 9, 4, 0, -9 },
  { 511, 5, 8, 7, 1, -8 },
  { 516, 6, 8, 6, 0, -8 },
  { 522, 9, 8, 9, 0, -8 },
  { 531, 6, 8, 6, 0, -8 },
  { 537, 6, 11, 6, 0, -8 },
  { 546, 5, 8, 6, 1, -8 },
  { 551, 3, 14, 4, 1, -11 },
  { 557, 1, 12, 3, 1, -10 },
  { 559, 4, 14, 4, 0, -11 },
  { 566, 6, 3, 8, 1, -6 },
};

const GFXfont RobotoCondensed_Light14pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light14pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light14pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOCONDENSED_LIGHT14PT7B_H_
