#ifndef _ROBOTOCONDENSED_LIGHT16PT7B_H_
#define _ROBOTOCONDENSED_LIGHT16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x90, 0xB6, 0xD0, 0x24, 0x48, 0x97, 0xF2, 0x45, 0x0A, 0x24,
  0xFE, 0x91, 0x22, 0x40, 0x10, 0x47, 0x92, 0x86, 0x14, 0x18, 0x18, 0x10,
  0x61, 0x8D, 0xE1, 0x00, 0x60, 0x90, 0x94, 0x94, 0x68, 0x08, 0x10, 0x17,
  0x25, 0x29, 0x05, 0x07, 0x30, 0x91, 0x22, 0x45, 0x04, 0x14, 0x49, 0x8B,
  0x0A, 0x13, 0xD0, 0xF0, 0x25, 0x29, 0x24, 0x92, 0x48, 0x91, 0x20, 0x84,
  0x42, 0x22, 0x11, 0x11, 0x12, 0x22, 0x44, 0x80, 0x10, 0x23, 0xF8, 0x82,
  0x88, 0x80, 0x20, 0x82, 0x08, 0xFC, 0x82, 0x08, 0x20, 0x56, 0xF0, 0x80,
  0x08, 0x44, 0x21, 0x08, 0x84, 0x22, 0x10, 0x88, 0x00, 0x71, 0x28, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x14, 0x9C, 0x3D, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x72, 0x28, 0x41, 0x08, 0x21, 0x04, 0x21, 0x04, 0x3F, 0x7A, 0x28, 0x41,
  0x08, 0xC0, 0x81, 0x06, 0x18, 0x9C, 0x08, 0x61, 0x8A, 0x29, 0x24, 0xA2,
  0xFC, 0x20, 0x82, 0x7D, 0x04, 0x10, 0x78, 0x30, 0x41, 0x06, 0x14, 0x5E,
  0x39, 0x84, 0x20, 0xBB, 0x28, 0x61, 0x86, 0x14, 0x8E, 0xFC, 0x10, 0x82,
  0x08, 0x41, 0x04, 0x20, 0x82, 0x10, 0x7A, 0x28, 0x61, 0x89, 0xC4, 0xA1,
  0x86, 0x18, 0xDE, 0x72, 0x28, 0x61, 0x86, 0x18, 0xDD, 0x04, 0x21, 0x9C,
  0x81, 0x83, 0xC0, 0x09, 0xB1, 0x83, 0x04, 0xFC, 0x00, 0x3F, 0x81, 0x81,
  0x81, 0x19, 0x88, 0x00, 0x74, 0xA2, 0x10, 0x88, 0x84, 0x20, 0x00, 0x40,
  0x1F, 0x04, 0x11, 0x01, 0x27, 0x28, 0x93, 0x24, 0x64, 0x8C, 0x91, 0x92,
  0x32, 0x4A, 0x76, 0x40, 0x04, 0x00, 0x40, 0x07, 0x80, 0x08, 0x08, 0x14,
  0x14, 0x14, 0x22, 0x22, 0x22, 0x7E, 0x41, 0x41, 0x81, 0xF9, 0x0A, 0x14,
  0x28, 0x5F, 0x21, 0x41, 0x83, 0x06, 0x17, 0xC0, 0x3C, 0x8E, 0x0C, 0x18,
  0x10, 0x20, 0x40, 0x83, 0x05, 0x19, 0xE0, 0xF9, 0x0A, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x17, 0xC0, 0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20,
  0x82, 0x08, 0x3F, 0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20, 0x82, 0x08, 0x20,
  0x3C, 0x86, 0x0C, 0x08, 0x10, 0x23, 0xC1, 0x83, 0x05, 0x09, 0xE0, 0x83,
  0x06, 0x0C, 0x18, 0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0xFF, 0xF0,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x0C, 0x62, 0xE0, 0x83, 0x0A, 0x24, 0xC9,
  0x14, 0x34, 0x4C, 0x89, 0x0A, 0x14, 0x10, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x3F, 0xC0, 0xF0, 0x3C, 0x0E, 0x85, 0xA1, 0x68, 0x59,
  0x26, 0x49, 0x92, 0x63, 0x18, 0xC6, 0x21, 0xC1, 0xC1, 0xA1, 0xA1, 0x91,
  0x91, 0x89, 0x89, 0x85, 0x85, 0x83, 0x83, 0x3C, 0x86, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x05, 0x09, 0xE0, 0xFD, 0x0A, 0x0C, 0x18, 0x30, 0xBF,
  0x40, 0x81, 0x02, 0x04, 0x00, 0x3C, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x05, 0x19, 0xE0, 0x60, 0x40, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0xBE,
  0x44, 0x85, 0x0A, 0x14, 0x10, 0x79, 0x0A, 0x0C, 0x0C, 0x0E, 0x03, 0x02,
  0x03, 0x06, 0x13, 0xC0, 0xFF, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x05, 0x11, 0xE0, 0x81, 0x41, 0x41, 0x42, 0x22, 0x22, 0x24, 0x14, 0x14,
  0x14, 0x18, 0x08, 0x84, 0x31, 0x86, 0x31, 0x45, 0x28, 0xA4, 0xA4, 0x94,
  0x92, 0x94, 0x51, 0x8A, 0x30, 0x86, 0x10, 0xC0, 0x83, 0x09, 0x12, 0x42,
  0x82, 0x0C, 0x14, 0x48, 0x8A, 0x14, 0x10, 0x41, 0x42, 0x42, 0x24, 0x24,
  0x14, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFC, 0x08, 0x20, 0x41, 0x02,
  0x08, 0x10, 0x40, 0x82, 0x07, 0xF0, 0xEA, 0xAA, 0xAA, 0xAC, 0x42, 0x10,
  0x82, 0x10, 0x82, 0x10, 0x82, 0x10, 0x80, 0xD5, 0x55, 0x55, 0x5C, 0x46,
  0x6A, 0x99, 0xFC, 0x90, 0x7A, 0x20, 0x82, 0x7A, 0x28, 0xA2, 0x78, 0x82,
  0x08, 0x2E, 0xC6, 0x18, 0x61, 0x86, 0x1C, 0xEE, 0x7A, 0x28, 0x60, 0x82,
  0x08, 0x62, 0x70, 0x04, 0x10, 0x5D, 0x8E, 0x18, 0x61, 0x86, 0x18, 0xDD,
  0x72, 0x28, 0x61, 0xFE, 0x08, 0x20, 0x78, 0x74, 0x4E, 0x44, 0x44, 0x44,
  0x44, 0x76, 0x38, 0x61, 0x86, 0x18, 0x63, 0x74, 0x10, 0x9E, 0x82, 0x08,
  0x2E, 0xCA, 0x18, 0x61, 0x86, 0x18, 0x61, 0x9F, 0xF0, 0x41, 0x55, 0x55,
  0x5C, 0x82, 0x08, 0x22, 0x92, 0xCA, 0x38, 0x92, 0x48, 0xA2, 0xFF, 0xF0,
  0xBB, 0xB3, 0x18, 0x46, 0x11, 0x84, 0x61, 0x18, 0x46, 0x11, 0x84, 0x40,
  0xBB, 0x28, 0x61, 0x86, 0x18, 0x61, 0x84, 0x7A, 0x28, 0x61, 0x86, 0x18,
  0x62, 0x78, 0xBB, 0x38, 0x61, 0x86, 0x18, 0x73, 0xBA, 0x08, 0x20, 0x76,
  0x38, 0x61, 0x86, 0x18, 0x63, 0x74, 0x10, 0x41, 0xAC, 0x88, 0x88, 0x88,
  0x80, 0x74, 0x61, 0x83, 0x04, 0x31, 0x70, 0x22, 0xF2, 0x22, 0x22, 0x22,
  0x30, 0x86, 0x18, 0x61, 0x86, 0x18, 0x63, 0x74, 0x85, 0x14, 0x52, 0x28,
  0xA2, 0x84, 0x10, 0x88, 0xCC, 0x66, 0x52, 0xA9, 0x53, 0x29, 0x98, 0xC4,
  0x42, 0x00, 0x45, 0x22, 0x8C, 0x10, 0xA2, 0x91, 0x44, 0x85, 0x14, 0x52,
  0x28, 0xA3, 0x04, 0x10, 0x42, 0x18, 0xF8, 0x44, 0x42, 0x21, 0x10, 0xF8,
  0x24, 0x44, 0x44, 0x48, 0x44, 0x44, 0x44, 0x30, 0xFF, 0xFC, 0x84, 0x22,
  0x22, 0x21, 0x22, 0x22, 0x24, 0x80, 0x63, 0x26, 0x38,
};

const GFXglyph RobotoCondensed_Light16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 12, 3, 1, -12 },
  { 3, 3, 4, 5, 1, -12 },
  { 5, 7, 12, 8, 1, -12 },
  { 16, 6, 15, 8, 1, -14 },
  { 28, 8, 12, 10, 1, -12 },
  { 40, 7, 12, 9, 1, -12 },
  { 51, 1, 4, 3, 1, -12 },
  { 52, 3, 17, 5, 1, -13 },
  { 59, 4, 17, 5, 0, -13 },
  { 68, 7, 6, 7, 0, -12 },
  { 74, 6, 9, 8, 1, -10 },
  { 81, 2, 4, 3, 0, -2 },
  { 82, 4, 1, 4, 0, -6 },
  { 83, 1, 1, 4, 1, -1 },
  { 84, 5, 13, 6, 0, -12 },
  { 93, 6, 12, 8, 1, -12 },
  { 102, 4, 12, 8, 1, -12 },
  { 108, 6, 12, 8, 1, -12 },
  { 117, 6, 12, 8, 1, -12 },
  { 126, 6, 12, 8, 1, -12 },
  { 135, 6, 12, 8, 1, -12 },
  { 144, 6, 12, 8, 1, -12 },
  { 153, 6, 12, 8, 1, -12 },
  { 162, 6, 12, 8, 1, -12 },
  { 171, 6, 12, 8, 1, -12 },
  { 180, 1, 8, 3, 1, -8 },
  { 181, 1, 10, 3, 1, -8 },
  { 183, 5, 6, 7, 1, -8 },
  { 187, 6, 4, 8, 1, -7 },
  { 190, 6, 7, 7, 1, -9 },
  { 196, 5, 12, 6, 1, -12 },
  { 204, 11, 15, 13, 1, -11 },
  { 225, 8, 12, 9, 0, -12 },
  { 237, 7, 12, 9, 1, -12 },
  { 248, 7, 12, 9, 1, -12 },
  { 259, 7, 12, 9, 1, -12 },
  { 270, 6, 12, 8, 1, -12 },
  { 279, 6, 12, 8, 1, -12 },
  { 288, 7, 12, 10, 1, -12 },
  { 299, 7, 12, 10, 1, -12 },
  { 310, 1, 12, 4, 1, -12 },
  { 312, 5, 12, 8, 1, -12 },
  { 320, 7, 12, 9, 1, -12 },
  { 331, 6, 12, 7, 1, -12 },
  { 340, 10, 12, 12, 1, -12 },
  { 355, 8, 12, 10, 1, -12 },
  { 367, 7, 12, 9, 1, -12 },
  { 378, 7, 12, 9, 1, -12 },
  { 389, 7, 14, 9, 1, -12 },
  { 402, 7, 12, 9, 1, -12 },
  { 413, 7, 12, 8, 1, -12 },
  { 424, 8, 12, 8, 0, -12 },
  { 436, 7, 12, 9, 1, -12 },
  { 447, 8, 12, 9, 0, -12 },
  { 459, 11, 12, 12, 1, -12 },
  { 476, 7, 12, 9, 1, -12 },
  { 487, 8, 12, 8, 0, -12 },
  { 499, 7, 12, 8, 1, -12 },
  { 510, 2, 15, 4, 1, -13 },
  { 514, 5, 13, 6, 0, -12 },
  { 523, 2, 15, 4, 0, -13 },
  { 527, 4, 6, 6, 1, -12 },
  { 530, 6, 1, 6, 0, 0 },
  { 531, 2, 2, 5, 1, -12 },
  { 532, 6, 9, 8, 1, -9 },
  { 539, 6, 12, 8, 1, -12 },
  { 548, 6, 9, 7, 1, -9 },
  { 555, 6, 12, 8, 1, -12 },
  { 564, 6, 9, 7, 1, -9 },
  { 571, 4, 12, 5, 1, -12 },
  { 577, 6, 12, 8, 1, -9 },
  { 586, 6, 12, 8, 1, -12 },
  { 595, 1, 12, 3, 1, -12 },
  { 597, 2, 15, 3, 0, -12 },
  { 601, 6, 12, 7, 1, -12 },
  { 610, 1, 12, 3, 1, -12 },
  { 612, 10, 9, 12, 1, -9 },
  { 624, 6, 9, 8, 1, -9 },
  { 631, 6, 9, 8, 1, -9 },
  { 638, 6, 12, 8, 1, -9 },
  { 647, 6, 12, 8, 1, -9 },
  { 656, 4, 9, 5, 1, -9 },
  { 661, 5, 9, 7, 1, -9 },
  { 667, 4, 11, 5, 0, -11 },
  { 673, 6, 9, 8, 1, -9 },
  { 680, 6, 9, 7, 0, -9 },
  { 687, 9, 9, 10, 1, -9 },
  { 698, 6, 9, 7, 0, -9 },
  { 705, 6, 12, 7, 0, -9 },
  { 714, 5, 9, 7, 1, -9 },
  { 720, 4, 15, 5, 1, -12 },
  { 728, 1, 14, 4, 1, -12 },
  { 730, 4, 15, 5, 0, -12 },
  { 738, 7, 3, 10, 1, -6 },
};

const GFXfont RobotoCondensed_Light16pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light16pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _ROBOTOCONDENSED_LIGHT16PT7B_H_
