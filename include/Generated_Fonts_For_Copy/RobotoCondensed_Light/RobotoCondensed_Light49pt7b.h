#ifndef _ROBOTOCONDENSED_LIGHT49PT7B_H_
#define _ROBOTOCONDENSED_LIGHT49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xB6, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0xC3, 0xC3, 0x00, 0x60, 0x30, 0x00, 0xC0, 0xE0, 0x01, 0x81, 0x80, 0x03,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x60,
  0x70, 0x00, 0xC0, 0xE0, 0x01, 0x81, 0x80, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF0, 0x1C, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x70, 0x00, 0xC0, 0xC0,
  0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x0E, 0x06, 0x00, 0x18, 0x0C, 0x00,
  0x30, 0x38, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0x0E, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x38, 0x00, 0x60,
  0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x07, 0x03, 0x00, 0x0C, 0x0E,
  0x00, 0x18, 0x1C, 0x00, 0x30, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3C, 0x0F, 0x0E, 0x01, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x01,
  0xDC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x77,
  0x00, 0x1D, 0xE0, 0x0E, 0x3C, 0x07, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F,
  0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC0,
  0x60, 0x10, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80,
  0xC0, 0x60, 0x60, 0x30, 0x18, 0x30, 0x0C, 0x06, 0x1C, 0x03, 0x01, 0x86,
  0x00, 0xE0, 0xE3, 0x80, 0x1C, 0x70, 0xC0, 0x03, 0xF8, 0x70, 0x00, 0x7C,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0xF0, 0x00, 0x30, 0xFF, 0x00, 0x1C, 0x38, 0xE0, 0x06, 0x18,
  0x18, 0x03, 0x86, 0x06, 0x00, 0xC3, 0x80, 0xC0, 0x70, 0xC0, 0x30, 0x18,
  0x30, 0x0C, 0x0C, 0x0C, 0x03, 0x03, 0x03, 0x00, 0xC1, 0x80, 0xE0, 0x30,
  0x60, 0x18, 0x18, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0,
  0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x18, 0x03, 0x80, 0x60, 0x0E,
  0x01, 0x80, 0x38, 0x06, 0x00, 0xE0, 0x38, 0x01, 0x80, 0xC0, 0x07, 0x07,
  0x00, 0x1C, 0x38, 0x00, 0x39, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0E, 0x38, 0x0E, 0x78,
  0x70, 0x39, 0xC1, 0xE0, 0xEE, 0x03, 0x83, 0xB8, 0x07, 0x0C, 0xE0, 0x0E,
  0x33, 0x00, 0x3D, 0xCC, 0x00, 0x77, 0x30, 0x00, 0xF8, 0xE0, 0x03, 0xE3,
  0x80, 0x07, 0x0F, 0x00, 0x3E, 0x1C, 0x01, 0xFC, 0x3C, 0x1F, 0x78, 0x7F,
  0xF8, 0xE0, 0xFF, 0x81, 0xC0, 0x20, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x40,
  0x30, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0x80,
  0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x06,
  0x01, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60,
  0x1C, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x10, 0x40, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E,
  0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80,
  0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01,
  0x80, 0xC0, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x30, 0x38, 0x1F, 0xC7, 0x0F, 0xFE,
  0xEF, 0xE3, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x07,
  0x70, 0x01, 0xC7, 0x00, 0x30, 0xE0, 0x0E, 0x0E, 0x03, 0x80, 0xE0, 0x60,
  0x1C, 0x04, 0x01, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x1C, 0x71, 0xC7,
  0x18, 0xE3, 0x8E, 0x71, 0xC6, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x73, 0x9E,
  0xE0, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x3C, 0x38, 0x07,
  0x1C, 0x00, 0xE7, 0x00, 0x39, 0x80, 0x0E, 0xE0, 0x01, 0xB8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x19, 0x80, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE3, 0x80, 0x70, 0xF0,
  0x3C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x60, 0x3C, 0x3F,
  0x9F, 0xFF, 0xCF, 0xE1, 0xF0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x03, 0xF0, 0x01,
  0xFF, 0x80, 0x7F, 0xF8, 0x1C, 0x07, 0x87, 0x00, 0x70, 0xE0, 0x07, 0x38,
  0x00, 0xE7, 0x00, 0x1C, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0E, 0x03, 0xC3, 0x80, 0x38, 0x70, 0x03, 0x9C,
  0x00, 0x73, 0x80, 0x06, 0x70, 0x00, 0xCE, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xB0, 0x00, 0x77, 0x00, 0x0C, 0xE0, 0x03, 0x8E, 0x00, 0x71, 0xE0,
  0x3C, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x67, 0x00, 0x07, 0x38, 0x00,
  0x71, 0xC0, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x01, 0x83, 0x80, 0x1C, 0x1C,
  0x00, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x60, 0x38, 0x07, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0x80, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x73, 0xF0, 0x1F, 0xFF,
  0x07, 0xFF, 0xE1, 0xE0, 0x7C, 0x70, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xF0, 0x00, 0x6E, 0x00, 0x1B, 0x80, 0x0E, 0xE0, 0x03, 0x9C, 0x00,
  0xE7, 0x00, 0x70, 0xE0, 0x3C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x61, 0xF8, 0x19, 0xFF, 0x8E, 0xFF, 0xF3, 0xF0, 0x1C,
  0xF8, 0x03, 0xBC, 0x00, 0xEE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x36, 0x00,
  0x1D, 0xC0, 0x07, 0x70, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0x38, 0x70, 0x1C,
  0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xF0, 0x3C, 0x78, 0x07, 0x9C, 0x00, 0xE6, 0x00, 0x3B, 0x80,
  0x06, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x19, 0x80, 0x0E, 0x70, 0x03,
  0x9C, 0x01, 0xC3, 0xC0, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0x03,
  0xC1, 0xE1, 0xE0, 0x1C, 0x70, 0x03, 0xB8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x77, 0x00, 0x39, 0xE0, 0x1C, 0x3F, 0xFF, 0x03, 0xFF, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xE0, 0x78, 0x70,
  0x07, 0x1C, 0x01, 0xCE, 0x00, 0x3B, 0x80, 0x0E, 0xC0, 0x01, 0xB0, 0x00,
  0x6C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xDC, 0x00, 0xF7, 0x00, 0x7C, 0xE0, 0x37, 0x3F,
  0xFD, 0xC7, 0xFC, 0x60, 0x7E, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0x7F, 0xF7, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF7, 0x33, 0xDE,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0xE7, 0x39, 0xCC, 0xE7, 0x73, 0x88, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x70, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0x00, 0x00,
  0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x38, 0x1C, 0x70, 0x0E, 0x70, 0x0E,
  0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0x03, 0x0E, 0x00, 0x7C, 0x01, 0x86, 0x00, 0x7F, 0x80, 0x63,
  0x00, 0x71, 0xE0, 0x33, 0x80, 0x70, 0x30, 0x19, 0x80, 0x70, 0x18, 0x0C,
  0xC0, 0x30, 0x0C, 0x06, 0x60, 0x38, 0x0E, 0x03, 0x70, 0x18, 0x07, 0x00,
  0xF8, 0x0C, 0x03, 0x80, 0x78, 0x0E, 0x01, 0x80, 0x3C, 0x07, 0x00, 0xC0,
  0x1E, 0x03, 0x00, 0x60, 0x0F, 0x01, 0x80, 0x30, 0x07, 0x80, 0xC0, 0x18,
  0x06, 0xC0, 0x60, 0x0C, 0x03, 0x60, 0x30, 0x06, 0x01, 0xB0, 0x18, 0x03,
  0x00, 0xD8, 0x0C, 0x03, 0x80, 0x6C, 0x06, 0x01, 0xC0, 0x66, 0x03, 0x81,
  0xE0, 0x33, 0x81, 0xC0, 0xF0, 0x38, 0xC0, 0x70, 0xDC, 0x38, 0x60, 0x3F,
  0xC7, 0xF8, 0x30, 0x0F, 0xC1, 0xF8, 0x1C, 0x00, 0x00, 0x20, 0x06, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x02, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x30, 0xE0, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00,
  0x06, 0x03, 0x00, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0x80, 0x30,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x70, 0x01,
  0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0E, 0x00,
  0x0E, 0x07, 0x00, 0x07, 0x07, 0x00, 0x01, 0x83, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x30,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0E, 0x00, 0x78, 0xE0, 0x03, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE,
  0x00, 0x0C, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xCE, 0x00, 0x1C,
  0xE0, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x07, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0xE0, 0x07, 0x8E, 0x00, 0x1C, 0xE0, 0x00, 0xCE, 0x00,
  0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xCE,
  0x00, 0x3C, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xC0, 0x3C, 0x1C, 0x00, 0x70,
  0xE0, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x06, 0x70, 0x00, 0x1D, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x77, 0x00, 0x01,
  0xDC, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE1, 0xC0, 0x07, 0x07,
  0x80, 0x3C, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xC0, 0x0F, 0x0E, 0x00, 0x3C,
  0x70, 0x00, 0xF3, 0x80, 0x03, 0x9C, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00,
  0x03, 0xB8, 0x00, 0x0D, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x37, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00,
  0xEE, 0x00, 0x0E, 0x70, 0x00, 0xF3, 0x80, 0x0F, 0x1C, 0x00, 0xF0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCE,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7C, 0x03, 0xC3, 0x80, 0x0F, 0x38, 0x00,
  0x39, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x37, 0x00,
  0x01, 0xBC, 0x00, 0x0C, 0xF0, 0x00, 0xE3, 0xC0, 0x1F, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x7F, 0x80, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x06, 0xE0, 0x03, 0xBC, 0x00, 0xE7, 0x00,
  0x71, 0xE0, 0x3C, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0xE0, 0x00,
  0x7B, 0x80, 0x03, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0x70, 0xE0, 0x03, 0x83,
  0x80, 0x1E, 0x0E, 0x00, 0xF0, 0x38, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0xE0, 0x0E, 0x07, 0x80, 0x38, 0x3C, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00,
  0x0E, 0x3C, 0x00, 0x39, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0xBF, 0x00, 0x0F,
  0xDE, 0x00, 0x3E, 0x38, 0x00, 0xF8, 0x70, 0x03, 0xC1, 0xE0, 0x0E, 0x03,
  0x80, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x70,
  0x38, 0x01, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x38,
  0x00, 0x38, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xEE, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xBE, 0xC0, 0x00, 0x3B, 0xEE, 0x00, 0x03, 0xBE, 0xE0, 0x00,
  0x33, 0xE6, 0x00, 0x07, 0x3E, 0x70, 0x00, 0x73, 0xE7, 0x00, 0x06, 0x3E,
  0x30, 0x00, 0xE3, 0xE3, 0x80, 0x0E, 0x3E, 0x38, 0x00, 0xC3, 0xE1, 0x80,
  0x1C, 0x3E, 0x1C, 0x01, 0xC3, 0xE1, 0xC0, 0x18, 0x3E, 0x0C, 0x03, 0x83,
  0xE0, 0xE0, 0x30, 0x3E, 0x06, 0x07, 0x03, 0xE0, 0x60, 0x70, 0x3E, 0x07,
  0x06, 0x03, 0xE0, 0x30, 0xE0, 0x3E, 0x03, 0x0E, 0x03, 0xE0, 0x38, 0xC0,
  0x3E, 0x01, 0x9C, 0x03, 0xE0, 0x1D, 0xC0, 0x3E, 0x01, 0xD8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3E, 0x00, 0x70,
  0x03, 0xE0, 0x07, 0x00, 0x30, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7E, 0xE0, 0x01,
  0xFB, 0x80, 0x07, 0xE7, 0x00, 0x1F, 0x9C, 0x00, 0x7E, 0x38, 0x01, 0xF8,
  0xE0, 0x07, 0xE1, 0xC0, 0x1F, 0x87, 0x00, 0x7E, 0x0E, 0x01, 0xF8, 0x18,
  0x07, 0xE0, 0x70, 0x1F, 0x80, 0xE0, 0x7E, 0x03, 0x81, 0xF8, 0x07, 0x07,
  0xE0, 0x1C, 0x1F, 0x80, 0x38, 0x7E, 0x00, 0xE1, 0xF8, 0x01, 0xC7, 0xE0,
  0x03, 0x1F, 0x80, 0x0E, 0x7E, 0x00, 0x1D, 0xF8, 0x00, 0x77, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0xF0, 0x0F, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x07, 0x1C,
  0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x1B, 0x80,
  0x00, 0x37, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0x73,
  0x80, 0x00, 0xE7, 0x00, 0x03, 0x87, 0x00, 0x07, 0x07, 0x00, 0x1C, 0x0F,
  0x80, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8E, 0x00, 0x3C, 0xE0, 0x01, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x3C, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFC, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0xF0, 0x0F, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x37, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7,
  0x00, 0x03, 0x87, 0x00, 0x07, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0xF8, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x08, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xC0, 0x07, 0x8E,
  0x00, 0x1C, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x0C, 0xE0, 0x00,
  0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x06, 0x70,
  0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x38, 0xE0, 0x03, 0xC7, 0xFF, 0xFC,
  0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0E, 0x01, 0xC0, 0x70, 0x07, 0x03, 0x80,
  0x38, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x38, 0x00, 0xE1,
  0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00,
  0x1C, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0x01, 0xFC, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3C, 0x03, 0xC3, 0xC0, 0x0F, 0x1C, 0x00,
  0x39, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x77, 0x00,
  0x03, 0xB8, 0x00, 0x1C, 0xE0, 0x01, 0xC7, 0xC0, 0x3E, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0E, 0x70, 0x00, 0xE3,
  0xC0, 0x3C, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xE0, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x30, 0x00,
  0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x0E, 0x00,
  0x38, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x03, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xC0, 0x03, 0x81,
  0xC0, 0x01, 0x81, 0xC0, 0x01, 0xC1, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xC3,
  0x80, 0x00, 0xE3, 0x80, 0x00, 0xE3, 0x00, 0x00, 0x67, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xF8,
  0x00, 0x78, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x07,
  0x60, 0x01, 0xE0, 0x01, 0x9C, 0x00, 0xFC, 0x00, 0xE7, 0x00, 0x3B, 0x00,
  0x39, 0xC0, 0x0C, 0xC0, 0x0E, 0x30, 0x03, 0x30, 0x03, 0x0C, 0x00, 0xCE,
  0x00, 0xC3, 0x80, 0x73, 0x80, 0x70, 0xE0, 0x18, 0x60, 0x1C, 0x38, 0x06,
  0x18, 0x07, 0x06, 0x01, 0x87, 0x01, 0x81, 0x80, 0xE1, 0xC0, 0x60, 0x70,
  0x38, 0x30, 0x38, 0x1C, 0x0C, 0x0C, 0x0E, 0x07, 0x03, 0x03, 0x03, 0x80,
  0xC1, 0xC0, 0xE0, 0xC0, 0x38, 0x70, 0x18, 0x30, 0x0E, 0x18, 0x06, 0x1C,
  0x03, 0x86, 0x01, 0x87, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x18, 0xE0, 0x0C,
  0x60, 0x07, 0x30, 0x03, 0x18, 0x01, 0xCC, 0x00, 0xCE, 0x00, 0x77, 0x00,
  0x3B, 0x80, 0x0D, 0xC0, 0x0E, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8,
  0x00, 0x6C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0xE1, 0xC0, 0x03, 0x83,
  0xC0, 0x07, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x07,
  0x01, 0xC0, 0x0E, 0x07, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0xE0, 0x00, 0x39, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x39, 0xC0, 0x00, 0x71, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x83, 0x80,
  0x0E, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x70, 0x0F, 0x01, 0xC0, 0x0E, 0x03,
  0x80, 0x1E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xE0,
  0x00, 0x3B, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C,
  0x00, 0x78, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x07, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x01,
  0xC3, 0x80, 0x01, 0xC7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0F, 0xFF, 0xFF, 0x80, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xE0, 0x01, 0xC0, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0xC0, 0x33, 0x00, 0xCC, 0x07, 0x38, 0x18, 0x60, 0x61, 0x83, 0x87, 0x0C,
  0x0C, 0x30, 0x31, 0xC0, 0xE6, 0x01, 0xB8, 0x06, 0xE0, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x01, 0xE7, 0x00, 0x77, 0x00, 0x3B,
  0x80, 0x0D, 0xC0, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0xFF,
  0xE1, 0xFF, 0xF1, 0xF8, 0x19, 0xE0, 0x0D, 0xC0, 0x06, 0xE0, 0x03, 0x60,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x77, 0x00, 0x7B, 0xC0, 0x6C,
  0xFF, 0xF7, 0x3F, 0xE3, 0x87, 0xC1, 0xC0, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x7E, 0x0C, 0xFF, 0xC6, 0xFF,
  0xF3, 0xE0, 0x3D, 0xE0, 0x0E, 0xE0, 0x07, 0x60, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x0E, 0xF0, 0x07, 0x7C, 0x07, 0x37, 0xFF, 0x99, 0xFF, 0x8C,
  0x3F, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF0, 0x1E, 0x38,
  0x03, 0x9C, 0x00, 0x77, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x00, 0xF8, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x36, 0x00, 0x1D, 0xC0, 0x07, 0x70,
  0x01, 0xCE, 0x00, 0xE3, 0xC0, 0x78, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0xFC, 0x31, 0xFF, 0x99, 0xFF, 0xED, 0xE0, 0x36, 0xE0, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x06, 0xC0, 0x07, 0x70, 0x07, 0xBC,
  0x07, 0xCF, 0xFF, 0x63, 0xFF, 0x30, 0x7E, 0x00, 0x01, 0xF8, 0x01, 0xFF,
  0x81, 0xFB, 0xF0, 0xF0, 0x1E, 0x38, 0x03, 0x9C, 0x00, 0x77, 0x00, 0x1D,
  0x80, 0x07, 0x60, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x23, 0xC0, 0x3C,
  0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xF0,
  0xF0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0xFF, 0xEF, 0xFE, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x07, 0xE1, 0x8F, 0xFC, 0xCF, 0xFF, 0x6F, 0x01,
  0xB7, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x36, 0x00,
  0x3B, 0x80, 0x3D, 0xE0, 0x3E, 0x7F, 0xFB, 0x1F, 0xF9, 0x83, 0xF0, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x40, 0x0E,
  0x78, 0x0F, 0x1F, 0xBF, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC3, 0xF0, 0xC7, 0xFC, 0xCF,
  0xFE, 0xD8, 0x0E, 0xF0, 0x0E, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x67,
  0xF6, 0x00, 0x00, 0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x06, 0x0F, 0x0F, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E,
  0xFC, 0xFC, 0xF0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x01, 0xCC, 0x01, 0xE6, 0x01, 0xE3, 0x00, 0xE1, 0x80,
  0xE0, 0xC0, 0xE0, 0x60, 0xE0, 0x30, 0xF0, 0x18, 0xF0, 0x0C, 0x70, 0x06,
  0x70, 0x03, 0x78, 0x01, 0xFE, 0x00, 0xF7, 0x00, 0x79, 0xC0, 0x38, 0x70,
  0x18, 0x38, 0x0C, 0x0E, 0x06, 0x03, 0x83, 0x01, 0xC1, 0x80, 0x70, 0xC0,
  0x1C, 0x60, 0x0E, 0x30, 0x03, 0x98, 0x01, 0xEC, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xE1, 0xF8, 0x07, 0xE1, 0xCF, 0xF8, 0x3F, 0xE3, 0xBF, 0xF8, 0xFF, 0xE7,
  0x60, 0x7B, 0x81, 0xEF, 0x80, 0x76, 0x01, 0xDE, 0x00, 0x78, 0x01, 0xFC,
  0x00, 0xF0, 0x03, 0xF0, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x0F, 0xC0,
  0x07, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x7E, 0x00,
  0x38, 0x00, 0xFC, 0x00, 0x70, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x01,
  0xC0, 0x07, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x0E,
  0x00, 0x3F, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x70,
  0x01, 0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0x80,
  0x0F, 0xC0, 0x07, 0x00, 0x1C, 0xC3, 0xF0, 0xC7, 0xFC, 0xCF, 0xFE, 0xD8,
  0x0E, 0xF0, 0x0E, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x03, 0xF0, 0x01,
  0xFF, 0x80, 0x7F, 0xF8, 0x1E, 0x07, 0x87, 0x00, 0x38, 0xE0, 0x07, 0x38,
  0x00, 0x77, 0x00, 0x0E, 0xE0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x06, 0xC0,
  0x00, 0xDC, 0x00, 0x1B, 0x80, 0x07, 0x70, 0x00, 0xE7, 0x00, 0x38, 0xE0,
  0x07, 0x0F, 0x01, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0xC3,
  0xF0, 0x67, 0xFE, 0x37, 0xFF, 0x9F, 0x01, 0xEF, 0x00, 0x77, 0x00, 0x3B,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x77, 0x00, 0x3B, 0xE0, 0x39,
  0xBF, 0xFC, 0xCF, 0xFC, 0x61, 0xF8, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x00, 0x07, 0xE1, 0x8F, 0xFC, 0xCF, 0xDF, 0x6F, 0x01,
  0xF7, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x36, 0x00,
  0x3B, 0x80, 0x3D, 0xE0, 0x3E, 0x7F, 0xFB, 0x1F, 0xF9, 0x83, 0xF0, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0xC3, 0xF3, 0xFD,
  0xFF, 0x60, 0xF0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF,
  0x87, 0x01, 0xE3, 0x00, 0x73, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0xEC, 0x00,
  0x77, 0x00, 0x3B, 0x80, 0x1C, 0xE0, 0x1C, 0x7F, 0xFE, 0x0F, 0xFC, 0x01,
  0xF8, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x87,
  0xFF, 0xFF, 0xE1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xF8, 0x3F, 0x01, 0xE0,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xD8, 0x00, 0xEC, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x3C, 0xE0,
  0x3E, 0x7F, 0xFF, 0x1F, 0xFB, 0x83, 0xF1, 0xC0, 0xE0, 0x00, 0xCC, 0x00,
  0x39, 0xC0, 0x07, 0x38, 0x00, 0xC3, 0x00, 0x38, 0x70, 0x07, 0x0E, 0x00,
  0xE0, 0xC0, 0x18, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x30, 0x18, 0x06, 0x07,
  0x00, 0xE0, 0xE0, 0x1C, 0x18, 0x01, 0x83, 0x00, 0x38, 0xE0, 0x07, 0x18,
  0x00, 0x63, 0x00, 0x0C, 0xE0, 0x01, 0xDC, 0x00, 0x1B, 0x00, 0x03, 0x60,
  0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x7E, 0x00, 0xE0, 0x07, 0xE0, 0x0F, 0x00, 0x76, 0x00, 0xF0, 0x06,
  0x60, 0x0F, 0x00, 0xE7, 0x01, 0xF0, 0x0E, 0x70, 0x1B, 0x80, 0xE7, 0x01,
  0x98, 0x0C, 0x30, 0x19, 0x80, 0xC3, 0x83, 0x9C, 0x1C, 0x38, 0x31, 0xC1,
  0xC3, 0x83, 0x0C, 0x18, 0x18, 0x70, 0xC1, 0x81, 0xC7, 0x0E, 0x38, 0x1C,
  0x60, 0xE3, 0x81, 0xC6, 0x06, 0x30, 0x0C, 0xE0, 0x63, 0x00, 0xCE, 0x07,
  0x70, 0x0E, 0xC0, 0x37, 0x00, 0xEC, 0x03, 0x60, 0x07, 0xC0, 0x36, 0x00,
  0x78, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x03, 0x80,
  0x1C, 0x00, 0x30, 0x01, 0xC0, 0x70, 0x01, 0xC7, 0x00, 0x70, 0xE0, 0x0E,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x38, 0xE0,
  0x03, 0x18, 0x00, 0x77, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x7C, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0xE3, 0x80,
  0x1C, 0x70, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x38, 0x0E, 0x0E, 0x00, 0xE1,
  0xC0, 0x1C, 0x70, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x01, 0xD8, 0x00, 0x77,
  0x00, 0x1D, 0xC0, 0x06, 0x30, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x30, 0xE0,
  0x1C, 0x1C, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0x60, 0x38, 0x38, 0x0E, 0x0E,
  0x03, 0x83, 0x00, 0x61, 0xC0, 0x1C, 0x70, 0x07, 0x18, 0x00, 0xC6, 0x00,
  0x3B, 0x80, 0x0E, 0xC0, 0x01, 0xB0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x20, 0x0F, 0x01, 0xE0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0xF8, 0x0F, 0x00,
  0xF8, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x01, 0xF0, 0x0F, 0x01, 0xF0, 0x3C, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x0C, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x1C, 0xFF, 0x80,
  0x3B, 0x83, 0x80, 0x66, 0x03, 0x80, 0xCC, 0x03, 0x83, 0xB8, 0x03, 0xFE,
  0x70, 0x03, 0xF8, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_Light49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 35, 11, 4, -35 },
  { 15, 8, 11, 14, 3, -37 },
  { 26, 23, 35, 25, 2, -35 },
  { 127, 18, 44, 24, 3, -40 },
  { 226, 26, 35, 31, 3, -35 },
  { 340, 22, 36, 26, 3, -35 },
  { 439, 2, 11, 8, 3, -37 },
  { 442, 10, 50, 14, 3, -39 },
  { 505, 10, 50, 15, 1, -39 },
  { 568, 19, 20, 21, 1, -35 },
  { 616, 20, 26, 24, 2, -29 },
  { 681, 6, 11, 9, 1, -5 },
  { 690, 10, 3, 13, 1, -17 },
  { 694, 5, 4, 12, 3, -4 },
  { 697, 15, 38, 17, 1, -35 },
  { 769, 18, 35, 24, 3, -35 },
  { 848, 11, 35, 24, 4, -35 },
  { 897, 19, 35, 24, 3, -35 },
  { 981, 19, 35, 24, 2, -35 },
  { 1065, 21, 35, 24, 2, -35 },
  { 1157, 18, 35, 24, 4, -35 },
  { 1236, 18, 35, 24, 3, -35 },
  { 1315, 19, 35, 24, 2, -35 },
  { 1399, 18, 35, 24, 3, -35 },
  { 1478, 18, 35, 24, 3, -35 },
  { 1557, 4, 26, 10, 3, -26 },
  { 1570, 5, 32, 9, 2, -26 },
  { 1590, 17, 21, 22, 2, -26 },
  { 1635, 16, 13, 24, 4, -23 },
  { 1661, 17, 20, 22, 3, -26 },
  { 1704, 16, 35, 20, 2, -35 },
  { 1774, 33, 45, 38, 3, -34 },
  { 1960, 25, 35, 27, 1, -35 },
  { 2070, 20, 35, 26, 4, -35 },
  { 2158, 22, 35, 28, 3, -35 },
  { 2255, 21, 35, 28, 4, -35 },
  { 2347, 18, 35, 24, 4, -35 },
  { 2426, 18, 35, 24, 4, -35 },
  { 2505, 21, 35, 29, 4, -35 },
  { 2597, 22, 35, 30, 4, -35 },
  { 2694, 2, 35, 12, 5, -35 },
  { 2703, 18, 35, 24, 2, -35 },
  { 2782, 22, 35, 27, 4, -35 },
  { 2879, 17, 35, 23, 4, -35 },
  { 2954, 28, 35, 37, 4, -35 },
  { 3077, 22, 35, 30, 4, -35 },
  { 3174, 23, 35, 29, 3, -35 },
  { 3275, 20, 35, 26, 4, -35 },
  { 3363, 23, 41, 29, 3, -35 },
  { 3481, 21, 35, 27, 4, -35 },
  { 3573, 21, 35, 25, 2, -35 },
  { 3665, 22, 35, 26, 2, -35 },
  { 3762, 20, 35, 28, 4, -35 },
  { 3850, 24, 35, 27, 1, -35 },
  { 3955, 34, 35, 38, 2, -35 },
  { 4104, 23, 35, 26, 2, -35 },
  { 4205, 24, 35, 26, 1, -35 },
  { 4310, 21, 35, 26, 2, -35 },
  { 4402, 7, 47, 11, 4, -40 },
  { 4444, 15, 38, 17, 1, -35 },
  { 4516, 6, 47, 11, 1, -40 },
  { 4552, 14, 17, 18, 2, -35 },
  { 4582, 17, 2, 19, 1, 0 },
  { 4587, 9, 7, 14, 2, -37 },
  { 4595, 17, 26, 23, 3, -26 },
  { 4651, 17, 37, 24, 4, -37 },
  { 4730, 18, 26, 22, 2, -26 },
  { 4789, 17, 37, 24, 3, -37 },
  { 4868, 18, 26, 22, 2, -26 },
  { 4927, 12, 38, 15, 2, -38 },
  { 4984, 17, 36, 24, 3, -26 },
  { 5061, 16, 37, 24, 4, -37 },
  { 5135, 4, 36, 10, 3, -36 },
  { 5153, 8, 46, 10, -1, -36 },
  { 5199, 17, 37, 21, 4, -37 },
  { 5278, 3, 37, 10, 4, -37 },
  { 5292, 31, 26, 37, 3, -26 },
  { 5393, 16, 26, 24, 4, -26 },
  { 5445, 19, 26, 24, 3, -26 },
  { 5507, 17, 36, 24, 4, -26 },
  { 5584, 17, 36, 24, 3, -26 },
  { 5661, 10, 26, 15, 4, -26 },
  { 5694, 17, 26, 22, 2, -26 },
  { 5750, 11, 33, 14, 1, -33 },
  { 5796, 17, 26, 24, 3, -26 },
  { 5852, 19, 26, 21, 1, -26 },
  { 5914, 28, 26, 32, 2, -26 },
  { 6005, 19, 26, 21, 1, -26 },
  { 6067, 18, 36, 21, 1, -26 },
  { 6148, 17, 26, 21, 2, -26 },
  { 6204, 12, 48, 15, 2, -38 },
  { 6276, 3, 41, 11, 4, -35 },
  { 6292, 12, 48, 15, 1, -38 },
  { 6364, 23, 9, 29, 3, -19 },
};

const GFXfont RobotoCondensed_Light49pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light49pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light49pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOCONDENSED_LIGHT49PT7B_H_
