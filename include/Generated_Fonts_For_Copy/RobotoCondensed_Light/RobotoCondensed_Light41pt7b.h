#ifndef _ROBOTOCONDENSED_LIGHT41PT7B_H_
#define _ROBOTOCONDENSED_LIGHT41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x6D, 0xB6, 0xDB, 0x6C, 0x00, 0x03, 0xFE,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xB1, 0x62, 0xC4, 0x01, 0x83, 0x00, 0x30,
  0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x02, 0x04, 0x00, 0xC1,
  0x80, 0x18, 0x30, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x0C, 0x18, 0x01, 0x82,
  0x00, 0x20, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x0C,
  0x00, 0xC1, 0x00, 0x10, 0x60, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x18, 0x30,
  0x03, 0x06, 0x00, 0x60, 0xC0, 0x08, 0x10, 0x03, 0x06, 0x00, 0x60, 0xC0,
  0x0C, 0x18, 0x01, 0x83, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x07, 0xE0, 0x0F, 0xF8, 0x1C, 0x3C, 0x38, 0x1C, 0x30, 0x0E, 0x70,
  0x06, 0x70, 0x06, 0x60, 0x06, 0x70, 0x06, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x60,
  0x06, 0x70, 0x06, 0x38, 0x0E, 0x3C, 0x3C, 0x1F, 0xF8, 0x07, 0xE0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x1E, 0x00, 0x00, 0xFC, 0x00,
  0x06, 0x18, 0x00, 0x18, 0x20, 0x20, 0xC0, 0xC0, 0xC3, 0x03, 0x06, 0x0C,
  0x0C, 0x18, 0x30, 0x30, 0xC0, 0xC0, 0xC2, 0x03, 0x03, 0x18, 0x06, 0x08,
  0xC0, 0x18, 0x63, 0x00, 0x3F, 0x18, 0x00, 0x78, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x78, 0x00, 0x63, 0xF8, 0x01, 0x18, 0x60, 0x0C, 0x60, 0xC0,
  0x21, 0x03, 0x01, 0x8C, 0x0C, 0x0C, 0x30, 0x30, 0x30, 0xC0, 0xC1, 0x83,
  0x03, 0x06, 0x04, 0x0C, 0x10, 0x18, 0x30, 0x00, 0x61, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0x70, 0xE0, 0x0C, 0x0C,
  0x01, 0x81, 0x80, 0x70, 0x30, 0x0E, 0x06, 0x01, 0xC0, 0xC0, 0x18, 0x38,
  0x03, 0x0E, 0x00, 0x73, 0x80, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0xE0, 0x00, 0xEC, 0x00, 0x38, 0xC0, 0xCE, 0x1C, 0x19, 0x81, 0xC3,
  0x70, 0x18, 0x6E, 0x03, 0x99, 0x80, 0x3B, 0x38, 0x03, 0xE7, 0x00, 0x38,
  0x60, 0x07, 0x0E, 0x01, 0xF0, 0xF0, 0xF6, 0x0F, 0xFC, 0xE0, 0x7E, 0x0E,
  0xFF, 0xFD, 0xB6, 0xC0, 0x01, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30,
  0x30, 0x30, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x60,
  0x70, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x06,
  0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x07, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x30,
  0x30, 0x60, 0xC0, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0xC1, 0x86, 0xF9, 0x9F, 0x3F, 0xFC, 0x07, 0xE0, 0x03, 0xC0,
  0x06, 0xC0, 0x0E, 0x60, 0x0C, 0x70, 0x18, 0x38, 0x38, 0x18, 0x10, 0x08,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x33, 0x33, 0x33, 0x76, 0x40, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0x07, 0xE0, 0x0F, 0xF0, 0x1C, 0x38, 0x38, 0x1C, 0x30,
  0x0C, 0x70, 0x0E, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x06, 0xE0,
  0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x70, 0x0E, 0x30, 0x0C, 0x38, 0x1C, 0x1C, 0x38, 0x0F, 0xF0, 0x07,
  0xE0, 0x00, 0x83, 0xC7, 0xEF, 0xBF, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x07, 0xE0,
  0x1F, 0xF0, 0x3C, 0x38, 0x30, 0x1C, 0x60, 0x0C, 0x60, 0x0E, 0xE0, 0x06,
  0xC0, 0x06, 0xC0, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x07, 0xE0, 0x3F, 0xE0,
  0xF0, 0xE1, 0x80, 0xE6, 0x00, 0xEC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0xFE, 0x01, 0xFC,
  0x00, 0x1E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xF0, 0x03, 0x60, 0x0E, 0xE0, 0x18, 0xF0, 0xF0, 0xFF,
  0xC0, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x01, 0x8C, 0x00,
  0x63, 0x00, 0x30, 0xC0, 0x1C, 0x30, 0x06, 0x0C, 0x03, 0x83, 0x00, 0xC0,
  0xC0, 0x70, 0x30, 0x18, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x30,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x3F, 0xFE, 0x7F,
  0xFC, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x9F, 0x03, 0xFF, 0x87, 0xC7, 0x8E, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x78, 0x00, 0xF8, 0x01, 0xB0, 0x07, 0x60, 0x0C, 0xE0, 0x38, 0xF1, 0xE0,
  0xFF, 0x80, 0x7C, 0x00, 0x00, 0xF0, 0x0F, 0xE0, 0x3E, 0x00, 0xE0, 0x03,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x1F,
  0x06, 0x7F, 0x8F, 0xC7, 0x9E, 0x03, 0xB8, 0x07, 0x60, 0x06, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xF0,
  0x06, 0x60, 0x1C, 0xE0, 0x30, 0xF1, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x1F,
  0xF8, 0x3C, 0x3C, 0x38, 0x1C, 0x70, 0x0E, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x06, 0x70, 0x0E, 0x30, 0x1C, 0x1C, 0x38, 0x0F,
  0xF0, 0x0F, 0xF0, 0x3C, 0x3C, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x06, 0xE0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x06, 0x70,
  0x0E, 0x3C, 0x3C, 0x1F, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x3F, 0xE0, 0xF1,
  0xE1, 0x80, 0xE7, 0x00, 0xCC, 0x01, 0xB8, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x6C, 0x01, 0xDC, 0x03, 0xB8,
  0x0F, 0x3C, 0x76, 0x3F, 0xCC, 0x1F, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0xFE, 0x01,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x3B, 0xCC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x73, 0x18,
  0xCE, 0x62, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x03, 0xC0, 0x3C, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1C, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0x80, 0x00, 0x0F, 0x81, 0xFF,
  0x1E, 0x38, 0xC0, 0xEE, 0x03, 0x60, 0x1F, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x07,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x63, 0x00, 0x7C, 0x06, 0x30, 0x0F, 0xE0, 0x22,
  0x01, 0x87, 0x02, 0x60, 0x30, 0x30, 0x36, 0x06, 0x03, 0x03, 0x60, 0x60,
  0x20, 0x36, 0x06, 0x02, 0x03, 0x40, 0xC0, 0x60, 0x3C, 0x0C, 0x06, 0x03,
  0xC0, 0xC0, 0x60, 0x3C, 0x0C, 0x06, 0x03, 0xC0, 0xC0, 0x60, 0x3C, 0x0C,
  0x06, 0x02, 0x40, 0xC0, 0x60, 0x64, 0x0C, 0x0E, 0x06, 0x60, 0xC1, 0xE0,
  0xC6, 0x06, 0x37, 0x1C, 0x60, 0x7F, 0x3F, 0x86, 0x03, 0xC1, 0xE0, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x60, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0xEC, 0x00, 0x06,
  0x60, 0x00, 0x31, 0x80, 0x03, 0x8C, 0x00, 0x18, 0x60, 0x00, 0xC1, 0x80,
  0x0E, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x03, 0x80, 0x18, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x07, 0x00, 0x60, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x1C, 0x00, 0x60, 0xC0, 0x03, 0x86, 0x00, 0x0C, 0x70, 0x00,
  0x63, 0x00, 0x03, 0x18, 0x00, 0x1D, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0x00,
  0xFF, 0xE0, 0x7F, 0xFC, 0x38, 0x0F, 0x1C, 0x01, 0xCE, 0x00, 0x67, 0x00,
  0x3B, 0x80, 0x1D, 0xC0, 0x06, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0x9C,
  0x01, 0xCE, 0x03, 0xC7, 0xFF, 0xC3, 0xFF, 0xF1, 0xC0, 0x3C, 0xE0, 0x07,
  0x70, 0x01, 0xB8, 0x00, 0xDC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x06, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x07, 0x9F, 0xFF, 0x8F,
  0xFF, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xE1, 0xE0, 0xE0, 0x1C, 0x70,
  0x03, 0x98, 0x00, 0x6E, 0x00, 0x1B, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x03, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x19, 0x80, 0x06, 0x70, 0x03, 0x8E, 0x01,
  0xC1, 0xE1, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0E, 0x03, 0xC3, 0x80, 0x38, 0xE0, 0x07, 0x38, 0x00, 0xCE, 0x00, 0x3B,
  0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xB8, 0x00, 0x6E, 0x00, 0x3B,
  0x80, 0x0C, 0xE0, 0x07, 0x38, 0x03, 0x8E, 0x03, 0xC3, 0xFF, 0xE0, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xF8,
  0x03, 0xFF, 0x81, 0xE0, 0xF0, 0xE0, 0x0E, 0x70, 0x03, 0x98, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x36,
  0x00, 0x0D, 0xC0, 0x03, 0x70, 0x00, 0xCE, 0x00, 0x71, 0xE0, 0xF8, 0x3F,
  0xFC, 0x03, 0xF8, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0xE7, 0x87, 0x0F, 0xFC, 0x0F, 0xC0,
  0xE0, 0x01, 0x9C, 0x00, 0x73, 0x80, 0x1C, 0x70, 0x07, 0x0E, 0x01, 0xC1,
  0xC0, 0x38, 0x38, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0xE0, 0x1C, 0x38, 0x03,
  0x87, 0x00, 0x71, 0xC0, 0x0E, 0x70, 0x01, 0xDE, 0x00, 0x3F, 0xE0, 0x07,
  0xCC, 0x00, 0xF9, 0xC0, 0x1E, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E,
  0x03, 0x81, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x1C,
  0x00, 0xE3, 0x80, 0x0E, 0x70, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x1B, 0xEC, 0x00, 0x1B, 0xEC, 0x00, 0x33, 0xE6, 0x00, 0x33, 0xE6, 0x00,
  0x73, 0xE6, 0x00, 0x63, 0xE3, 0x00, 0x63, 0xE3, 0x00, 0xE3, 0xE3, 0x80,
  0xC3, 0xE1, 0x80, 0xC3, 0xE1, 0x81, 0xC3, 0xE1, 0xC1, 0x83, 0xE0, 0xC1,
  0x83, 0xE0, 0xC3, 0x83, 0xE0, 0xE3, 0x03, 0xE0, 0x63, 0x03, 0xE0, 0x67,
  0x03, 0xE0, 0x76, 0x03, 0xE0, 0x36, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x1C,
  0x03, 0xE0, 0x1C, 0x03, 0xE0, 0x18, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFB, 0x00, 0x1F,
  0x30, 0x03, 0xE7, 0x00, 0x7C, 0x60, 0x0F, 0x8E, 0x01, 0xF0, 0xC0, 0x3E,
  0x1C, 0x07, 0xC1, 0x80, 0xF8, 0x38, 0x1F, 0x03, 0x03, 0xE0, 0x30, 0x7C,
  0x07, 0x0F, 0x80, 0x61, 0xF0, 0x0E, 0x3E, 0x00, 0xC7, 0xC0, 0x1C, 0xF8,
  0x01, 0x9F, 0x00, 0x3B, 0xE0, 0x03, 0x7C, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0E, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x78, 0x7C, 0x1C,
  0x03, 0x87, 0x00, 0x38, 0xC0, 0x03, 0x38, 0x00, 0x76, 0x00, 0x06, 0xC0,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB8, 0x00, 0x73, 0x00,
  0x0C, 0x70, 0x03, 0x87, 0x00, 0xE0, 0x78, 0x7C, 0x07, 0xFE, 0x00, 0x3F,
  0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x38, 0x07, 0x9C, 0x00, 0xEE, 0x00, 0x37,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3B, 0x80, 0x79, 0xFF, 0xF8, 0xFF,
  0xF0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xE1, 0xF0, 0xE0, 0x1C,
  0x70, 0x03, 0x98, 0x00, 0x6E, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x1D, 0x80, 0x06, 0x70, 0x03, 0x8E,
  0x01, 0xC1, 0xE1, 0xF0, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x20, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0E, 0x01, 0xE3, 0x80, 0x3C, 0xE0, 0x07, 0x38, 0x00, 0xCE, 0x00, 0x3B,
  0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0C, 0xE0,
  0x07, 0x38, 0x03, 0x8E, 0x01, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x38, 0x0C,
  0x0E, 0x03, 0x83, 0x80, 0x60, 0xE0, 0x1C, 0x38, 0x03, 0x0E, 0x00, 0xE3,
  0x80, 0x18, 0xE0, 0x07, 0x38, 0x00, 0xCE, 0x00, 0x3B, 0x80, 0x06, 0xE0,
  0x01, 0xC0, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0x07, 0x87, 0x00, 0xE7, 0x00,
  0x33, 0x00, 0x1D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0x70, 0x03, 0xBC, 0x03, 0x8F, 0x83, 0xC1,
  0xFF, 0x80, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0x60, 0x03, 0xB8, 0x03, 0x8F, 0x07, 0x83, 0xFF,
  0x80, 0x7F, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00,
  0x06, 0x70, 0x00, 0xE3, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x80, 0x0C, 0x18,
  0x01, 0xC1, 0x80, 0x18, 0x1C, 0x01, 0x80, 0xC0, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0E, 0x07, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x70, 0x60,
  0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x8C, 0x00, 0x19, 0xC0, 0x01, 0x98,
  0x00, 0x19, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x1B, 0x00, 0x18, 0x00, 0xD8,
  0x01, 0xE0, 0x06, 0xC0, 0x0F, 0x00, 0x77, 0x00, 0x78, 0x03, 0x18, 0x03,
  0xC0, 0x18, 0xC0, 0x33, 0x00, 0xC6, 0x01, 0x98, 0x0E, 0x38, 0x0C, 0xC0,
  0x71, 0xC0, 0x66, 0x03, 0x06, 0x06, 0x10, 0x18, 0x30, 0x30, 0xC0, 0xC1,
  0x81, 0x86, 0x0E, 0x0E, 0x0C, 0x30, 0x60, 0x30, 0xC1, 0x83, 0x01, 0x86,
  0x06, 0x18, 0x0C, 0x30, 0x30, 0xC0, 0x61, 0x81, 0x8E, 0x03, 0x98, 0x0C,
  0x60, 0x0C, 0xC0, 0x33, 0x00, 0x66, 0x01, 0x98, 0x03, 0x30, 0x0C, 0xC0,
  0x1B, 0x00, 0x6E, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x38, 0x01, 0xC1, 0x80, 0x18,
  0x1C, 0x03, 0x80, 0xC0, 0x30, 0x0E, 0x07, 0x00, 0x60, 0x60, 0x07, 0x0E,
  0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x19, 0x80, 0x03,
  0x9C, 0x00, 0x30, 0xC0, 0x07, 0x0E, 0x00, 0x60, 0x60, 0x0E, 0x07, 0x01,
  0xC0, 0x38, 0x1C, 0x03, 0x83, 0x80, 0x1C, 0x30, 0x00, 0xC7, 0x00, 0x0E,
  0x60, 0x00, 0x60, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0x70, 0x00, 0xC7, 0x00,
  0x1C, 0x38, 0x01, 0x83, 0x80, 0x38, 0x18, 0x03, 0x01, 0xC0, 0x70, 0x0C,
  0x06, 0x00, 0xE0, 0x60, 0x06, 0x0E, 0x00, 0x70, 0xC0, 0x03, 0x1C, 0x00,
  0x39, 0x80, 0x01, 0xB8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0xFF, 0xC0, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0xFF, 0xF0, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F,
  0xFF, 0xC0, 0x06, 0x01, 0xC0, 0x38, 0x05, 0x81, 0xB0, 0x36, 0x06, 0x61,
  0x8C, 0x31, 0x8E, 0x39, 0x83, 0x30, 0x6E, 0x0F, 0x80, 0xF0, 0x18, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE0, 0xE0, 0xE0, 0xC1, 0xC1, 0xC0, 0x07, 0xE0, 0x3F,
  0xE0, 0xE0, 0xE3, 0x80, 0xE6, 0x00, 0xCC, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x0F, 0xF8, 0x7F, 0xF1, 0xC0, 0x67, 0x00, 0xDC, 0x01, 0xB8,
  0x03, 0x60, 0x06, 0xC0, 0x0D, 0xC0, 0x39, 0x80, 0xF3, 0xC7, 0x63, 0xFC,
  0xC3, 0xF1, 0xC0, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x8F, 0x83, 0x3F, 0xC6,
  0xC3, 0xCF, 0x01, 0xDC, 0x01, 0xB0, 0x03, 0x60, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1B, 0x80, 0x37, 0x80, 0xED, 0x87, 0x99, 0xFE, 0x31,
  0xF0, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xE6, 0x00, 0xDC,
  0x01, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x03, 0xE0, 0x06, 0xC0, 0x19,
  0xC0, 0x71, 0xE1, 0xC1, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x0F, 0x8C, 0x7F, 0x99, 0xE1, 0xB7, 0x01, 0xEC, 0x01, 0xD8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x06, 0xC0, 0x0D, 0x80, 0x3B, 0x80,
  0xF3, 0xC3, 0x63, 0xFC, 0xC1, 0xF1, 0x80, 0x07, 0xE0, 0x3F, 0xE0, 0xF0,
  0xE3, 0x80, 0xE6, 0x00, 0xCC, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x31, 0xE0, 0xE1, 0xFF, 0x80, 0xFC,
  0x00, 0x01, 0xE0, 0xFC, 0x3C, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x1F, 0xFB, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x07, 0xC6, 0x3F, 0xCC,
  0xF0, 0xDB, 0x80, 0xF6, 0x00, 0xEC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0x60, 0x06, 0xC0, 0x1D, 0xC0, 0x79, 0xE1, 0xB1, 0xFE, 0x61,
  0xF8, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0xC0, 0x71, 0xC1,
  0xC1, 0xFF, 0x80, 0xFC, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x0F, 0x8C, 0xFF,
  0x37, 0x1E, 0xF0, 0x1B, 0x80, 0x6E, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xC0,
  0xFF, 0x00, 0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x80,
  0x0E, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xEF, 0x9E, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0xEC, 0x03, 0x30, 0x1C, 0xC0, 0xE3, 0x07, 0x0C, 0x38,
  0x31, 0xC0, 0xC6, 0x03, 0x38, 0x0D, 0xC0, 0x3F, 0x80, 0xF6, 0x03, 0x9C,
  0x0C, 0x38, 0x30, 0x60, 0xC1, 0xC3, 0x03, 0x8C, 0x06, 0x30, 0x1C, 0xC0,
  0x3B, 0x00, 0x6C, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xC7, 0xC0, 0x7C, 0x67, 0xF8, 0xFF, 0xB6, 0x1E, 0xE1, 0xDE, 0x07,
  0x60, 0x7E, 0x01, 0xE0, 0x1F, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x18, 0x03, 0xC0, 0x0C, 0x01, 0xE0, 0x06, 0x00, 0xF0, 0x03, 0x00, 0x78,
  0x01, 0x80, 0x3C, 0x00, 0xC0, 0x1E, 0x00, 0x60, 0x0F, 0x00, 0x30, 0x07,
  0x80, 0x18, 0x03, 0xC0, 0x0C, 0x01, 0xE0, 0x06, 0x00, 0xF0, 0x03, 0x00,
  0x78, 0x01, 0x80, 0x3C, 0x00, 0xC0, 0x1E, 0x00, 0x60, 0x0C, 0xC3, 0xE3,
  0x3F, 0xCD, 0xC7, 0xBC, 0x06, 0xE0, 0x1B, 0x80, 0x7C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x30, 0x07, 0xE0, 0x1F, 0xF8, 0x3C, 0x3C, 0x30, 0x0C, 0x70, 0x0E, 0x60,
  0x06, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0x60, 0x06, 0x70,
  0x06, 0x30, 0x0C, 0x3C, 0x3C, 0x1F, 0xF8, 0x07, 0xE0, 0xC7, 0xC1, 0x9F,
  0xE3, 0x61, 0xE7, 0x80, 0xEE, 0x01, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xE0, 0x06, 0xC0, 0x0D, 0xC0, 0x3B, 0x80, 0x77, 0xC3, 0xCD, 0xFF,
  0x18, 0xFC, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xC6, 0x3F, 0xCC, 0xF0, 0xDB,
  0x80, 0xF6, 0x00, 0xEC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0x60, 0x06, 0xC0, 0x1D, 0xC0, 0x79, 0xE1, 0xB1, 0xFF, 0x61, 0xF8, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0xC7, 0xE7, 0xF7, 0x1E, 0x0E, 0x07, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0x87, 0x9C, 0x06, 0x60,
  0x1D, 0x80, 0x36, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x36,
  0x01, 0xDE, 0x1E, 0x3F, 0xF0, 0x3F, 0x00, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x87, 0xFF, 0xFE, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x07,
  0xC1, 0xE0, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x80, 0x76, 0x03, 0xDE,
  0x3B, 0x3F, 0xCC, 0x7E, 0x30, 0xC0, 0x06, 0xC0, 0x0D, 0x80, 0x3B, 0x00,
  0x67, 0x00, 0xC6, 0x03, 0x8C, 0x06, 0x1C, 0x0C, 0x18, 0x18, 0x30, 0x60,
  0x60, 0xC0, 0x61, 0x80, 0xC7, 0x01, 0x8C, 0x01, 0x98, 0x03, 0x30, 0x06,
  0xC0, 0x0D, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60,
  0x18, 0x03, 0x60, 0x1C, 0x03, 0x60, 0x1C, 0x07, 0x60, 0x3C, 0x06, 0x70,
  0x3C, 0x06, 0x30, 0x36, 0x06, 0x30, 0x36, 0x06, 0x30, 0x66, 0x0C, 0x38,
  0x66, 0x0C, 0x18, 0x63, 0x0C, 0x18, 0x63, 0x0C, 0x18, 0xC3, 0x18, 0x1C,
  0xC1, 0x98, 0x0C, 0xC1, 0x98, 0x0C, 0xC1, 0x98, 0x0D, 0x81, 0x98, 0x0D,
  0x80, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x00, 0xF0, 0x07, 0x00, 0xF0, 0x07,
  0x00, 0x60, 0x03, 0x00, 0x60, 0x60, 0x0E, 0xE0, 0x18, 0xC0, 0x71, 0xC0,
  0xC1, 0x83, 0x81, 0x86, 0x03, 0x98, 0x03, 0x70, 0x07, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0xDC, 0x03, 0x98, 0x06, 0x38, 0x1C,
  0x30, 0x30, 0x70, 0xE0, 0x61, 0x80, 0xE7, 0x00, 0xFC, 0x00, 0xC0, 0xE0,
  0x07, 0xC0, 0x1D, 0x80, 0x3B, 0x00, 0x67, 0x00, 0xC6, 0x03, 0x8C, 0x06,
  0x1C, 0x0C, 0x18, 0x38, 0x30, 0x60, 0x70, 0xC0, 0x61, 0x80, 0xC6, 0x01,
  0x8C, 0x01, 0x98, 0x03, 0x70, 0x06, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x80, 0xF0, 0x70, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x07, 0x03, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x3C,
  0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x38,
  0x07, 0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x70, 0x0F, 0x03,
  0xC1, 0xC0, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x1C, 0x0E, 0x02, 0x00,
  0x1E, 0x00, 0x6F, 0xF0, 0x19, 0xCF, 0x03, 0x60, 0x70, 0x6C, 0x07, 0x19,
  0x80, 0x7F, 0x00, 0x07, 0x80,
};

const GFXglyph RobotoCondensed_Light41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 29, 9, 3, -29 },
  { 12, 7, 9, 12, 3, -31 },
  { 20, 19, 29, 21, 2, -29 },
  { 89, 16, 37, 20, 2, -33 },
  { 163, 22, 29, 26, 2, -29 },
  { 243, 19, 29, 22, 2, -29 },
  { 312, 3, 9, 7, 2, -31 },
  { 316, 8, 42, 12, 3, -33 },
  { 358, 8, 42, 12, 1, -33 },
  { 400, 16, 16, 17, 1, -29 },
  { 432, 16, 21, 20, 2, -24 },
  { 474, 4, 9, 8, 1, -4 },
  { 479, 8, 2, 11, 1, -14 },
  { 481, 3, 3, 10, 3, -3 },
  { 483, 12, 32, 15, 1, -29 },
  { 531, 16, 29, 20, 2, -29 },
  { 589, 9, 29, 20, 3, -29 },
  { 622, 16, 29, 20, 2, -29 },
  { 680, 15, 29, 20, 2, -29 },
  { 735, 18, 29, 20, 1, -29 },
  { 801, 15, 29, 20, 3, -29 },
  { 856, 15, 29, 20, 3, -29 },
  { 911, 16, 29, 20, 2, -29 },
  { 969, 16, 29, 20, 2, -29 },
  { 1027, 15, 29, 20, 2, -29 },
  { 1082, 3, 21, 8, 3, -21 },
  { 1090, 5, 26, 8, 1, -21 },
  { 1107, 14, 17, 18, 2, -22 },
  { 1137, 14, 10, 20, 3, -19 },
  { 1155, 14, 17, 19, 3, -22 },
  { 1185, 13, 29, 17, 2, -29 },
  { 1233, 28, 37, 32, 2, -28 },
  { 1363, 21, 29, 23, 1, -29 },
  { 1440, 17, 29, 22, 3, -29 },
  { 1502, 18, 29, 23, 3, -29 },
  { 1568, 18, 29, 23, 3, -29 },
  { 1634, 16, 29, 20, 3, -29 },
  { 1692, 16, 29, 20, 3, -29 },
  { 1750, 18, 29, 24, 3, -29 },
  { 1816, 19, 29, 25, 3, -29 },
  { 1885, 2, 29, 10, 4, -29 },
  { 1893, 14, 29, 20, 2, -29 },
  { 1944, 19, 29, 23, 3, -29 },
  { 2013, 15, 29, 19, 3, -29 },
  { 2068, 24, 29, 31, 3, -29 },
  { 2155, 19, 29, 25, 3, -29 },
  { 2224, 19, 29, 24, 3, -29 },
  { 2293, 17, 29, 22, 3, -29 },
  { 2355, 18, 34, 24, 3, -29 },
  { 2432, 18, 29, 23, 3, -29 },
  { 2498, 17, 29, 21, 2, -29 },
  { 2560, 19, 29, 21, 1, -29 },
  { 2629, 17, 29, 23, 3, -29 },
  { 2691, 20, 29, 22, 1, -29 },
  { 2764, 29, 29, 32, 1, -29 },
  { 2870, 20, 29, 22, 1, -29 },
  { 2943, 20, 29, 21, 1, -29 },
  { 3016, 18, 29, 21, 2, -29 },
  { 3082, 6, 39, 9, 3, -33 },
  { 3112, 13, 32, 14, 1, -29 },
  { 3164, 6, 39, 9, 0, -33 },
  { 3194, 11, 15, 15, 2, -29 },
  { 3215, 15, 2, 16, 0, 0 },
  { 3219, 7, 6, 12, 2, -31 },
  { 3225, 15, 22, 19, 2, -22 },
  { 3267, 15, 31, 20, 3, -31 },
  { 3326, 15, 22, 19, 2, -22 },
  { 3368, 15, 31, 20, 2, -31 },
  { 3427, 15, 22, 19, 2, -22 },
  { 3469, 11, 31, 12, 1, -31 },
  { 3512, 15, 30, 20, 2, -22 },
  { 3569, 14, 31, 20, 3, -31 },
  { 3624, 3, 30, 9, 3, -30 },
  { 3636, 7, 38, 9, -1, -30 },
  { 3670, 14, 31, 18, 3, -31 },
  { 3725, 2, 31, 9, 3, -31 },
  { 3733, 25, 22, 31, 3, -22 },
  { 3802, 14, 22, 20, 3, -22 },
  { 3841, 16, 22, 20, 2, -22 },
  { 3885, 15, 30, 20, 3, -22 },
  { 3942, 15, 30, 20, 2, -22 },
  { 3999, 9, 22, 12, 3, -22 },
  { 4024, 14, 22, 18, 2, -22 },
  { 4063, 9, 27, 12, 1, -27 },
  { 4094, 14, 22, 20, 3, -22 },
  { 4133, 15, 22, 17, 1, -22 },
  { 4175, 24, 22, 27, 1, -22 },
  { 4241, 15, 22, 18, 1, -22 },
  { 4283, 15, 30, 17, 1, -22 },
  { 4340, 14, 22, 18, 2, -22 },
  { 4379, 10, 40, 12, 2, -32 },
  { 4429, 2, 34, 9, 4, -29 },
  { 4438, 10, 40, 12, 1, -32 },
  { 4488, 19, 7, 24, 3, -15 },
};

const GFXfont RobotoCondensed_Light41pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light41pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light41pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _ROBOTOCONDENSED_LIGHT41PT7B_H_
