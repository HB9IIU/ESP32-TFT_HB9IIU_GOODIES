#ifndef _ROBOTOCONDENSED_LIGHT20PT7B_H_
#define _ROBOTOCONDENSED_LIGHT20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light20pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x50, 0x50, 0x99, 0x99, 0x09, 0x08, 0x84, 0x42, 0x47,
  0xF8, 0x90, 0x48, 0x44, 0x22, 0x7F, 0x89, 0x04, 0x82, 0x42, 0x20, 0x08,
  0x08, 0x3C, 0x66, 0x42, 0x42, 0x40, 0x40, 0x30, 0x0C, 0x02, 0x03, 0x81,
  0xC2, 0x42, 0x3C, 0x10, 0x10, 0x70, 0x11, 0x02, 0x24, 0x44, 0x88, 0xA1,
  0x14, 0x1D, 0x00, 0x2E, 0x0A, 0x41, 0x44, 0x48, 0x91, 0x10, 0x24, 0x03,
  0x80, 0x3C, 0x32, 0x11, 0x88, 0x86, 0x41, 0x40, 0xC0, 0xF1, 0x48, 0xC2,
  0xA0, 0xD0, 0x64, 0x71, 0xE4, 0xF0, 0x11, 0x22, 0x44, 0x44, 0xC8, 0x88,
  0xC4, 0x44, 0x42, 0x21, 0x10, 0x82, 0x08, 0x41, 0x08, 0x42, 0x10, 0x86,
  0x21, 0x08, 0x42, 0x11, 0x08, 0x88, 0x00, 0x08, 0x08, 0x08, 0x7F, 0x18,
  0x14, 0x26, 0x22, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0x10, 0xFE, 0x80, 0xF0, 0x70, 0x04, 0x10, 0x42, 0x08, 0x21, 0x04,
  0x10, 0x82, 0x08, 0x41, 0x04, 0x00, 0x3C, 0x46, 0x42, 0x82, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x82, 0x42, 0x66, 0x3C, 0x1F, 0x91, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x3C, 0x46, 0x82, 0x82, 0x02, 0x02, 0x04, 0x04, 0x08,
  0x10, 0x30, 0x20, 0x40, 0xFF, 0x3C, 0x46, 0xC2, 0x82, 0x02, 0x06, 0x38,
  0x06, 0x02, 0x02, 0x82, 0x82, 0x46, 0x3C, 0x04, 0x0C, 0x0C, 0x14, 0x14,
  0x24, 0x44, 0x44, 0x84, 0xFF, 0x04, 0x04, 0x04, 0x04, 0x7F, 0x02, 0x04,
  0x08, 0x1F, 0x33, 0x03, 0x02, 0x06, 0x0C, 0x3C, 0x4F, 0x00, 0x0C, 0x30,
  0x60, 0x40, 0x40, 0x9C, 0xE6, 0xC2, 0x81, 0x81, 0xC1, 0x42, 0x66, 0x3C,
  0xFF, 0x02, 0x02, 0x02, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x10, 0x10, 0x30,
  0x20, 0x20, 0x3C, 0x46, 0xC2, 0x82, 0x42, 0x46, 0x38, 0x46, 0x82, 0x81,
  0x81, 0x82, 0x46, 0x3C, 0x38, 0x8F, 0x0C, 0x18, 0x30, 0x70, 0xA3, 0x3A,
  0x04, 0x08, 0x30, 0xC6, 0x00, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x17, 0xA0,
  0x02, 0x18, 0xE3, 0x08, 0x0C, 0x0E, 0x06, 0x02, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x80, 0xC0, 0xE0, 0x60, 0x21, 0x8E, 0x30, 0x80, 0x79, 0x38, 0x61,
  0x04, 0x10, 0x84, 0x30, 0x80, 0x00, 0x20, 0xC0, 0x07, 0xC0, 0x60, 0x82,
  0x01, 0x08, 0x02, 0x43, 0x89, 0x11, 0x28, 0x84, 0x62, 0x21, 0x88, 0x86,
  0x22, 0x18, 0x88, 0xA2, 0x22, 0x89, 0x89, 0x19, 0xC4, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x3E, 0x00, 0x04, 0x01, 0x80, 0x28, 0x05, 0x00, 0xA0, 0x22,
  0x04, 0x40, 0x88, 0x20, 0x87, 0xF0, 0x82, 0x20, 0x24, 0x04, 0x80, 0x80,
  0xFC, 0x86, 0x82, 0x82, 0x82, 0x86, 0xFC, 0x86, 0x82, 0x83, 0x83, 0x82,
  0x86, 0xFC, 0x1E, 0x10, 0x90, 0x28, 0x1C, 0x0C, 0x02, 0x01, 0x00, 0x80,
  0x60, 0x50, 0x28, 0x12, 0x10, 0xF0, 0xF8, 0x86, 0x82, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x86, 0xF8, 0xFF, 0x02, 0x04, 0x08,
  0x10, 0x3F, 0x40, 0x81, 0x02, 0x04, 0x08, 0x1F, 0xC0, 0xFF, 0x02, 0x04,
  0x08, 0x10, 0x3F, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x00, 0x1E, 0x10,
  0xD0, 0x28, 0x1C, 0x06, 0x03, 0x01, 0x8F, 0xC0, 0xE0, 0x50, 0x28, 0x12,
  0x18, 0xF8, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0xFF, 0xFC, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x06, 0x0C, 0x1C, 0x4F, 0x00, 0x83, 0x41, 0x21,
  0x11, 0x09, 0x85, 0x82, 0x81, 0xA0, 0x98, 0x44, 0x21, 0x10, 0xC8, 0x34,
  0x08, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x1F, 0xC0, 0x80, 0x38, 0x0F, 0x01, 0xE0, 0x3A, 0x0B, 0x41, 0x68, 0x2C,
  0x89, 0x91, 0x32, 0x66, 0x28, 0xC5, 0x18, 0x43, 0x08, 0x40, 0x80, 0xE0,
  0x70, 0x34, 0x1A, 0x0C, 0x86, 0x43, 0x11, 0x8C, 0xC2, 0x60, 0xB0, 0x58,
  0x1C, 0x0C, 0x1E, 0x18, 0x44, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x0E, 0x03,
  0x80, 0xE0, 0x24, 0x09, 0x02, 0x61, 0x07, 0x80, 0xFC, 0x82, 0x83, 0x81,
  0x81, 0x83, 0x82, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1E, 0x30,
  0x90, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x28, 0x16,
  0x10, 0xF8, 0x06, 0x01, 0xFC, 0x86, 0x82, 0x83, 0x81, 0x82, 0x86, 0xFC,
  0x8C, 0x84, 0x86, 0x82, 0x82, 0x81, 0x3C, 0x31, 0xB0, 0x50, 0x2C, 0x02,
  0x00, 0xE0, 0x1C, 0x01, 0x00, 0xA0, 0x50, 0x24, 0x31, 0xF0, 0xFF, 0x84,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x50, 0x28, 0x36, 0x11, 0xF0, 0x40, 0x50, 0x14, 0x0C, 0x82, 0x20,
  0x88, 0x61, 0x10, 0x44, 0x11, 0x06, 0x80, 0xA0, 0x28, 0x0C, 0x01, 0x00,
  0x82, 0x06, 0x0C, 0x28, 0x30, 0xB1, 0x42, 0x45, 0x09, 0x12, 0x24, 0x49,
  0x12, 0x24, 0x28, 0x90, 0xA1, 0x42, 0x85, 0x0C, 0x18, 0x30, 0x60, 0x40,
  0x80, 0x81, 0xA0, 0x90, 0xC4, 0x43, 0x40, 0xA0, 0x60, 0x30, 0x14, 0x13,
  0x08, 0x88, 0x64, 0x14, 0x0C, 0x40, 0x50, 0x22, 0x08, 0x84, 0x11, 0x04,
  0x80, 0xA0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xFF,
  0x00, 0x80, 0x80, 0x40, 0x40, 0x60, 0x20, 0x20, 0x10, 0x10, 0x18, 0x08,
  0x0C, 0x07, 0xFC, 0xEA, 0xAA, 0xAA, 0xAA, 0xAC, 0x82, 0x08, 0x10, 0x41,
  0x02, 0x08, 0x20, 0x41, 0x04, 0x08, 0x20, 0x80, 0xE4, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x27, 0x80, 0x20, 0xC5, 0x14, 0x4A, 0x28, 0x80, 0xFF, 0xC8,
  0x80, 0x3C, 0x8E, 0x08, 0x10, 0x27, 0xD0, 0xC1, 0x83, 0x8D, 0xE8, 0xC0,
  0xC0, 0xC0, 0xC0, 0xDC, 0xE2, 0xC2, 0xC3, 0xC1, 0xC1, 0xC1, 0xC3, 0xC2,
  0xE2, 0x9C, 0x3C, 0x8E, 0x0C, 0x18, 0x10, 0x20, 0x40, 0x82, 0x8C, 0xF0,
  0x02, 0x04, 0x08, 0x13, 0xA8, 0xF0, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x28,
  0xCE, 0x80, 0x3C, 0x8E, 0x0C, 0x18, 0x3F, 0xE0, 0x40, 0x80, 0x84, 0xF0,
  0x3B, 0x10, 0x8F, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x00, 0x3A, 0x8F,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC2, 0x8C, 0xE8, 0x10, 0x28, 0xCF, 0x00,
  0xC1, 0x83, 0x06, 0x0D, 0xDC, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0x80, 0x30, 0x55, 0x55, 0x54, 0x03, 0x00, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x32, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x78, 0xB2, 0x68, 0xE1,
  0xE3, 0x66, 0x4C, 0x58, 0xB0, 0x80, 0xFF, 0xFE, 0x9C, 0xF5, 0x38, 0xB0,
  0xC3, 0x84, 0x1C, 0x20, 0xE1, 0x07, 0x08, 0x38, 0x41, 0xC2, 0x0E, 0x10,
  0x70, 0x82, 0xDD, 0xCF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x08,
  0x3C, 0x46, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC2, 0x46, 0x3C, 0x9C,
  0xE6, 0xC2, 0xC3, 0xC1, 0xC1, 0xC1, 0xC3, 0xC2, 0xC6, 0xFC, 0xC0, 0xC0,
  0xC0, 0xC0, 0x3A, 0x8F, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC2, 0x8C, 0xE8,
  0x10, 0x20, 0x40, 0x80, 0xFF, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x30, 0x38,
  0x8A, 0x0E, 0x06, 0x07, 0x03, 0x01, 0x83, 0x8D, 0xF0, 0x21, 0x3E, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x41, 0x80, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0x42, 0x8C, 0xE8, 0x83, 0x0E, 0x12, 0x24, 0x49, 0x12, 0x14, 0x30,
  0x60, 0x40, 0x84, 0x30, 0x86, 0x28, 0xA5, 0x24, 0xA4, 0x94, 0x94, 0x52,
  0x8A, 0x31, 0x86, 0x30, 0x82, 0x00, 0x86, 0x89, 0x21, 0x43, 0x02, 0x0E,
  0x14, 0x4D, 0x8A, 0x18, 0x41, 0x42, 0x42, 0x22, 0x22, 0x24, 0x34, 0x14,
  0x18, 0x18, 0x08, 0x10, 0x10, 0x10, 0x60, 0xFE, 0x08, 0x30, 0x41, 0x02,
  0x08, 0x30, 0x41, 0x03, 0xF8, 0x19, 0x88, 0x42, 0x10, 0x84, 0x62, 0x20,
  0x82, 0x10, 0x84, 0x21, 0x0C, 0x30, 0xFF, 0xFF, 0x80, 0xC3, 0x08, 0x42,
  0x10, 0x84, 0x20, 0x82, 0x22, 0x10, 0x84, 0x21, 0x19, 0x80, 0x30, 0x52,
  0x24, 0x4A, 0x0C,
};

const GFXglyph RobotoCondensed_Light20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 14, 4, 1, -14 },
  { 5, 4, 4, 6, 1, -15 },
  { 7, 9, 14, 10, 1, -14 },
  { 23, 8, 18, 10, 1, -16 },
  { 41, 11, 14, 13, 1, -14 },
  { 61, 9, 14, 11, 1, -14 },
  { 77, 1, 4, 3, 1, -15 },
  { 78, 4, 21, 6, 1, -16 },
  { 89, 5, 21, 6, 0, -16 },
  { 103, 8, 8, 8, 0, -14 },
  { 111, 8, 11, 10, 1, -12 },
  { 122, 2, 5, 4, 1, -2 },
  { 124, 4, 1, 5, 1, -7 },
  { 125, 2, 2, 5, 1, -2 },
  { 126, 6, 15, 7, 0, -14 },
  { 138, 8, 14, 10, 1, -14 },
  { 152, 4, 14, 10, 2, -14 },
  { 159, 8, 14, 10, 1, -14 },
  { 173, 8, 14, 10, 1, -14 },
  { 187, 8, 14, 10, 1, -14 },
  { 201, 7, 14, 10, 2, -14 },
  { 214, 8, 14, 10, 1, -14 },
  { 228, 8, 14, 10, 1, -14 },
  { 242, 8, 14, 10, 1, -14 },
  { 256, 7, 14, 10, 1, -14 },
  { 269, 2, 11, 4, 1, -11 },
  { 272, 2, 14, 4, 1, -11 },
  { 276, 7, 9, 9, 1, -11 },
  { 284, 7, 5, 10, 1, -9 },
  { 289, 7, 9, 9, 1, -11 },
  { 297, 6, 14, 8, 1, -14 },
  { 308, 14, 18, 16, 1, -14 },
  { 340, 11, 14, 11, 0, -14 },
  { 360, 8, 14, 11, 2, -14 },
  { 374, 9, 14, 11, 1, -14 },
  { 390, 8, 14, 11, 2, -14 },
  { 404, 7, 14, 10, 2, -14 },
  { 417, 7, 14, 10, 2, -14 },
  { 430, 9, 14, 12, 1, -14 },
  { 446, 9, 14, 12, 2, -14 },
  { 462, 1, 14, 5, 2, -14 },
  { 464, 7, 14, 10, 1, -14 },
  { 477, 9, 14, 11, 2, -14 },
  { 493, 7, 14, 9, 2, -14 },
  { 506, 11, 14, 15, 2, -14 },
  { 526, 9, 14, 12, 2, -14 },
  { 542, 10, 14, 12, 1, -14 },
  { 560, 8, 14, 11, 2, -14 },
  { 574, 9, 16, 12, 1, -14 },
  { 592, 8, 14, 11, 2, -14 },
  { 606, 9, 14, 10, 1, -14 },
  { 622, 9, 14, 10, 1, -14 },
  { 638, 9, 14, 11, 1, -14 },
  { 654, 10, 14, 11, 0, -14 },
  { 672, 14, 14, 15, 1, -14 },
  { 697, 9, 14, 11, 1, -14 },
  { 713, 10, 14, 10, 0, -14 },
  { 731, 9, 14, 10, 1, -14 },
  { 747, 2, 19, 5, 2, -16 },
  { 752, 6, 15, 7, 1, -14 },
  { 764, 3, 19, 5, 0, -16 },
  { 772, 6, 7, 7, 1, -14 },
  { 778, 8, 1, 8, 0, 0 },
  { 779, 3, 3, 6, 1, -15 },
  { 781, 7, 11, 9, 1, -11 },
  { 791, 8, 15, 10, 1, -15 },
  { 806, 7, 11, 9, 1, -11 },
  { 816, 7, 15, 10, 1, -15 },
  { 830, 7, 11, 9, 1, -11 },
  { 840, 5, 15, 6, 1, -15 },
  { 850, 7, 15, 10, 1, -11 },
  { 864, 7, 15, 10, 1, -15 },
  { 878, 2, 15, 4, 1, -15 },
  { 882, 4, 19, 4, -1, -15 },
  { 892, 7, 15, 9, 1, -15 },
  { 906, 1, 15, 4, 2, -15 },
  { 908, 13, 11, 15, 1, -11 },
  { 926, 7, 11, 10, 1, -11 },
  { 936, 8, 11, 10, 1, -11 },
  { 947, 8, 15, 10, 1, -11 },
  { 962, 7, 15, 10, 1, -11 },
  { 976, 5, 11, 6, 1, -11 },
  { 983, 7, 11, 9, 1, -11 },
  { 993, 5, 13, 6, 0, -13 },
  { 1002, 7, 11, 10, 1, -11 },
  { 1012, 7, 11, 8, 1, -11 },
  { 1022, 11, 11, 13, 1, -11 },
  { 1038, 7, 11, 9, 1, -11 },
  { 1048, 8, 15, 8, 0, -11 },
  { 1063, 7, 11, 9, 1, -11 },
  { 1073, 5, 20, 6, 1, -16 },
  { 1086, 1, 17, 4, 2, -14 },
  { 1089, 5, 20, 6, 0, -16 },
  { 1102, 10, 4, 12, 1, -8 },
};

const GFXfont RobotoCondensed_Light20pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light20pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light20pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _ROBOTOCONDENSED_LIGHT20PT7B_H_
