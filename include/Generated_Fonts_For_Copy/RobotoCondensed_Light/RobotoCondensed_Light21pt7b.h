#ifndef _ROBOTOCONDENSED_LIGHT21PT7B_H_
#define _ROBOTOCONDENSED_LIGHT21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xC6, 0xDD, 0x99, 0x90, 0x09, 0x02, 0x41, 0x10, 0x44, 0x7F,
  0xC4, 0x41, 0x20, 0x48, 0x22, 0x08, 0x8F, 0xF8, 0x88, 0x24, 0x09, 0x02,
  0x40, 0x08, 0x08, 0x3C, 0x62, 0x43, 0x41, 0x41, 0x40, 0x30, 0x1C, 0x06,
  0x03, 0x81, 0x81, 0x41, 0x62, 0x3C, 0x08, 0x08, 0x70, 0x11, 0x02, 0x22,
  0x44, 0x88, 0x91, 0x94, 0x1C, 0x80, 0x20, 0x05, 0xC1, 0x24, 0x28, 0x89,
  0x11, 0x22, 0x02, 0x40, 0x70, 0x3C, 0x09, 0x84, 0x21, 0x08, 0x64, 0x0B,
  0x03, 0x80, 0xE0, 0x48, 0xB1, 0x28, 0x6A, 0x0E, 0xC1, 0x10, 0xE3, 0xCC,
  0xF8, 0x08, 0x88, 0x46, 0x21, 0x08, 0x46, 0x31, 0x8C, 0x21, 0x08, 0x43,
  0x08, 0x41, 0x04, 0x82, 0x08, 0x41, 0x08, 0x42, 0x18, 0x42, 0x10, 0x8C,
  0x42, 0x10, 0x88, 0x44, 0x40, 0x08, 0x04, 0x02, 0x0F, 0xE0, 0x80, 0xA0,
  0x88, 0x44, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x5E, 0x80, 0xF0, 0x50, 0x02, 0x08, 0x10, 0x20, 0x81, 0x02, 0x08,
  0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x20, 0x3C, 0x66, 0x42, 0xC1, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42, 0x66, 0x3C, 0x17, 0x91,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x10, 0x3C, 0x66, 0x42, 0x83, 0x81, 0x02,
  0x02, 0x04, 0x0C, 0x08, 0x10, 0x30, 0x20, 0x40, 0xFF, 0x3C, 0x62, 0xC2,
  0x81, 0x01, 0x02, 0x06, 0x1C, 0x02, 0x01, 0x01, 0x81, 0xC3, 0x42, 0x3C,
  0x06, 0x03, 0x02, 0x81, 0x41, 0x21, 0x90, 0x88, 0x84, 0x42, 0x41, 0x3F,
  0xE0, 0x40, 0x20, 0x10, 0x08, 0x7E, 0x83, 0x04, 0x08, 0x17, 0x31, 0x01,
  0x02, 0x04, 0x0C, 0x18, 0x38, 0x8E, 0x00, 0x0C, 0x30, 0x20, 0x40, 0x40,
  0x5C, 0xE2, 0xC1, 0x81, 0x81, 0xC1, 0x41, 0x43, 0x62, 0x1C, 0xFF, 0x01,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x18, 0x10, 0x10, 0x20,
  0x20, 0x3C, 0x66, 0x43, 0xC1, 0xC1, 0x43, 0x62, 0x3C, 0x42, 0xC1, 0x81,
  0x81, 0xC1, 0x62, 0x3C, 0x3C, 0x66, 0x42, 0x83, 0x81, 0x81, 0x81, 0xC3,
  0x65, 0x39, 0x03, 0x02, 0x06, 0x0C, 0x38, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x15, 0xA0, 0x02, 0x1C, 0xE3, 0x08, 0x0C, 0x06, 0x07, 0x02, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x0E, 0x18, 0x60, 0x80,
  0x38, 0x8A, 0x14, 0x30, 0x60, 0x83, 0x04, 0x10, 0x20, 0xC0, 0x00, 0x02,
  0x0C, 0x00, 0x07, 0xC0, 0x20, 0xC1, 0x00, 0x88, 0x02, 0x43, 0x85, 0x19,
  0x14, 0x44, 0x61, 0x11, 0x88, 0x46, 0x21, 0x18, 0x84, 0x62, 0x11, 0x88,
  0xC6, 0x33, 0x24, 0x73, 0x10, 0x00, 0x40, 0x00, 0x80, 0x01, 0x84, 0x03,
  0xE0, 0x04, 0x00, 0xC0, 0x38, 0x05, 0x00, 0x90, 0x32, 0x04, 0x40, 0x84,
  0x10, 0x84, 0x10, 0xFF, 0x10, 0x24, 0x04, 0x80, 0xD0, 0x08, 0xFC, 0x86,
  0x82, 0x83, 0x83, 0x82, 0x86, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x82,
  0xFC, 0x1E, 0x08, 0x64, 0x09, 0x03, 0xC0, 0xF0, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x04, 0x0D, 0x03, 0x40, 0x88, 0x61, 0xE0, 0xFC, 0x43, 0x20, 0xD0,
  0x28, 0x14, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x50, 0x28, 0x34, 0x33,
  0xF0, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1F, 0x0C, 0x64, 0x0D, 0x01,
  0x40, 0x10, 0x0C, 0x03, 0x00, 0xC7, 0xD0, 0x14, 0x05, 0x01, 0x60, 0x4C,
  0x21, 0xF0, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0xFF, 0xFE, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0C, 0x18, 0x38, 0xDF, 0x00, 0x81,
  0x41, 0x21, 0x91, 0x88, 0x84, 0x82, 0xC1, 0xE0, 0xD8, 0x44, 0x21, 0x10,
  0xC8, 0x24, 0x0A, 0x06, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x3F, 0x80, 0x80, 0x3C, 0x03, 0xC0, 0x3E, 0x05,
  0xA0, 0x5A, 0x0D, 0xB0, 0x99, 0x09, 0x91, 0x99, 0x91, 0x89, 0x18, 0xB1,
  0x86, 0x18, 0x61, 0x84, 0x10, 0x80, 0xE0, 0x70, 0x34, 0x1A, 0x0C, 0x86,
  0x63, 0x11, 0x8C, 0xC2, 0x60, 0xB0, 0x58, 0x1C, 0x0E, 0x02, 0x1E, 0x0C,
  0x64, 0x09, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x05,
  0x01, 0x40, 0x8C, 0x61, 0xE0, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x83, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1E, 0x08, 0x64, 0x09,
  0x03, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x05, 0x03, 0x40,
  0x88, 0x61, 0xF0, 0x06, 0x00, 0x80, 0x10, 0xFC, 0x41, 0x20, 0xD0, 0x28,
  0x14, 0x0A, 0x0D, 0x04, 0xFC, 0x42, 0x21, 0x10, 0x48, 0x24, 0x0A, 0x04,
  0x3E, 0x31, 0x90, 0x78, 0x1C, 0x02, 0x00, 0xC0, 0x38, 0x03, 0x00, 0xC0,
  0x30, 0x1C, 0x1B, 0x18, 0xF8, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3,
  0x3C, 0x40, 0x68, 0x09, 0x81, 0x10, 0x22, 0x0C, 0x41, 0x04, 0x20, 0x8C,
  0x11, 0x03, 0x20, 0x2C, 0x05, 0x00, 0xA0, 0x0C, 0x01, 0x00, 0x81, 0x05,
  0x06, 0x0A, 0x0C, 0x16, 0x14, 0x24, 0x28, 0xC8, 0x91, 0x11, 0x22, 0x22,
  0x44, 0x24, 0x48, 0x50, 0xB0, 0xA1, 0x41, 0x42, 0x82, 0x83, 0x02, 0x06,
  0x04, 0x08, 0x00, 0x80, 0x90, 0x66, 0x10, 0x8C, 0x32, 0x05, 0x01, 0xC0,
  0x20, 0x1C, 0x05, 0x83, 0x20, 0x8C, 0x41, 0x10, 0x68, 0x08, 0x40, 0x48,
  0x08, 0x82, 0x10, 0x41, 0x10, 0x22, 0x02, 0x80, 0x50, 0x0C, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0xFF, 0x80, 0x80, 0x40, 0x40,
  0x60, 0x20, 0x30, 0x10, 0x10, 0x08, 0x08, 0x0C, 0x04, 0x06, 0x03, 0xFE,
  0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x70, 0x82, 0x0C, 0x10, 0x41,
  0x82, 0x08, 0x20, 0x41, 0x04, 0x08, 0x20, 0x81, 0xE4, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x24, 0xF0, 0x20, 0xC3, 0x12, 0x4A, 0x28, 0x40, 0xFF, 0xC6,
  0x20, 0x3C, 0x46, 0xC2, 0x02, 0x02, 0x3E, 0x42, 0x82, 0x82, 0xC6, 0x7A,
  0x81, 0x02, 0x04, 0x08, 0x17, 0x31, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x71, 0x5C, 0x3C, 0x42, 0xC2, 0x81, 0x80, 0x80, 0x80, 0x81, 0xC2, 0x46,
  0x3C, 0x01, 0x01, 0x01, 0x01, 0x01, 0x3D, 0x45, 0xC3, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xC3, 0x47, 0x3D, 0x3C, 0x46, 0xC2, 0x83, 0x81, 0xFF, 0x80,
  0x80, 0xC0, 0x62, 0x3C, 0x39, 0x18, 0x84, 0x7D, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x3D, 0x45, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0x43,
  0x3D, 0x01, 0x03, 0x42, 0x3C, 0x81, 0x02, 0x04, 0x08, 0x17, 0x31, 0x42,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x50, 0x55, 0x55, 0x54, 0x13,
  0x00, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x13, 0xE0, 0x81, 0x02, 0x04,
  0x08, 0x10, 0xA2, 0x48, 0xB1, 0xC3, 0x84, 0x89, 0x91, 0x23, 0x43, 0xFF,
  0xFF, 0xDC, 0x73, 0x8A, 0x2C, 0x30, 0xB0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C,
  0x30, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xC0, 0xB9, 0x8A, 0x14,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x3C, 0x62, 0x41, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x41, 0x62, 0x3C, 0xB9, 0x8A, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x8A, 0xE4, 0x08, 0x10, 0x20, 0x00, 0x3D, 0x43, 0xC3, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xC3, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01, 0xBC,
  0x88, 0x88, 0x88, 0x88, 0x80, 0x3C, 0x8F, 0x0E, 0x06, 0x03, 0x01, 0x81,
  0x82, 0x8C, 0xF0, 0x21, 0x09, 0xF2, 0x10, 0x84, 0x21, 0x08, 0x43, 0x0C,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x43, 0x43, 0x47, 0x3B, 0x83,
  0x06, 0x1A, 0x24, 0x48, 0x8A, 0x14, 0x28, 0x20, 0x40, 0x84, 0x18, 0x63,
  0x86, 0x24, 0xA2, 0x4A, 0x24, 0x92, 0x49, 0x43, 0x14, 0x30, 0xC3, 0x0C,
  0x30, 0x80, 0x82, 0x89, 0x11, 0x43, 0x82, 0x0A, 0x14, 0x45, 0x8E, 0x08,
  0x41, 0x41, 0x63, 0x22, 0x22, 0x26, 0x14, 0x14, 0x14, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x60, 0xFE, 0x0C, 0x10, 0x41, 0x82, 0x08, 0x10, 0x41, 0x83,
  0xF8, 0x08, 0x88, 0x42, 0x10, 0x84, 0x22, 0x20, 0x82, 0x10, 0x84, 0x21,
  0x04, 0x10, 0xFF, 0xFF, 0xC0, 0xC3, 0x08, 0x43, 0x18, 0xC6, 0x10, 0x82,
  0x23, 0x18, 0xC6, 0x21, 0x19, 0x80, 0x30, 0x53, 0x14, 0x4A, 0x0E,
};

const GFXglyph RobotoCondensed_Light21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 15, 5, 2, -15 },
  { 3, 4, 5, 6, 1, -16 },
  { 6, 10, 15, 11, 1, -15 },
  { 25, 8, 19, 10, 1, -17 },
  { 44, 11, 15, 13, 1, -15 },
  { 65, 10, 15, 11, 1, -15 },
  { 84, 1, 5, 4, 1, -16 },
  { 85, 5, 22, 6, 1, -17 },
  { 99, 5, 22, 6, 0, -17 },
  { 113, 9, 8, 9, 0, -15 },
  { 122, 8, 11, 10, 1, -12 },
  { 133, 2, 5, 4, 1, -2 },
  { 135, 4, 1, 5, 1, -7 },
  { 136, 2, 2, 5, 1, -2 },
  { 137, 7, 16, 7, 0, -15 },
  { 151, 8, 15, 10, 1, -15 },
  { 166, 4, 15, 10, 2, -15 },
  { 174, 8, 15, 10, 1, -15 },
  { 189, 8, 15, 10, 1, -15 },
  { 204, 9, 15, 10, 1, -15 },
  { 221, 7, 15, 10, 2, -15 },
  { 235, 8, 15, 10, 1, -15 },
  { 250, 8, 15, 10, 1, -15 },
  { 265, 8, 15, 10, 1, -15 },
  { 280, 8, 15, 10, 1, -15 },
  { 295, 2, 11, 4, 1, -11 },
  { 298, 2, 14, 4, 1, -11 },
  { 302, 7, 9, 9, 1, -11 },
  { 310, 8, 5, 10, 1, -9 },
  { 315, 8, 9, 10, 1, -11 },
  { 324, 7, 15, 8, 1, -15 },
  { 338, 14, 20, 16, 1, -15 },
  { 373, 11, 15, 12, 0, -15 },
  { 394, 8, 15, 11, 2, -15 },
  { 409, 10, 15, 12, 1, -15 },
  { 428, 9, 15, 12, 2, -15 },
  { 445, 8, 15, 10, 2, -15 },
  { 460, 8, 15, 10, 2, -15 },
  { 475, 10, 15, 12, 1, -15 },
  { 494, 9, 15, 13, 2, -15 },
  { 511, 1, 15, 5, 2, -15 },
  { 513, 7, 15, 10, 1, -15 },
  { 527, 9, 15, 12, 2, -15 },
  { 544, 7, 15, 10, 2, -15 },
  { 558, 12, 15, 16, 2, -15 },
  { 581, 9, 15, 13, 2, -15 },
  { 598, 10, 15, 12, 1, -15 },
  { 617, 8, 15, 11, 2, -15 },
  { 632, 10, 18, 12, 1, -15 },
  { 655, 9, 15, 12, 2, -15 },
  { 672, 9, 15, 11, 1, -15 },
  { 689, 9, 15, 11, 1, -15 },
  { 706, 8, 15, 12, 2, -15 },
  { 721, 11, 15, 11, 0, -15 },
  { 742, 15, 15, 16, 1, -15 },
  { 771, 10, 15, 11, 1, -15 },
  { 790, 11, 15, 11, 0, -15 },
  { 811, 9, 15, 11, 1, -15 },
  { 828, 3, 20, 5, 2, -17 },
  { 836, 6, 16, 7, 1, -15 },
  { 848, 3, 20, 5, 0, -17 },
  { 856, 6, 7, 8, 1, -15 },
  { 862, 8, 1, 8, 0, 0 },
  { 863, 4, 3, 6, 1, -16 },
  { 865, 8, 11, 10, 1, -11 },
  { 876, 7, 16, 10, 2, -16 },
  { 890, 8, 11, 10, 1, -11 },
  { 901, 8, 16, 10, 1, -16 },
  { 917, 8, 11, 10, 1, -11 },
  { 928, 5, 16, 6, 1, -16 },
  { 938, 8, 15, 10, 1, -11 },
  { 953, 7, 16, 10, 2, -16 },
  { 967, 2, 15, 4, 1, -15 },
  { 971, 4, 19, 4, -1, -15 },
  { 981, 7, 16, 9, 2, -16 },
  { 995, 1, 16, 4, 2, -16 },
  { 997, 14, 11, 16, 1, -11 },
  { 1017, 7, 11, 10, 2, -11 },
  { 1027, 8, 11, 10, 1, -11 },
  { 1038, 7, 15, 10, 2, -11 },
  { 1052, 8, 15, 10, 1, -11 },
  { 1067, 4, 11, 6, 2, -11 },
  { 1073, 7, 11, 9, 1, -11 },
  { 1083, 5, 14, 6, 0, -14 },
  { 1092, 8, 11, 10, 1, -11 },
  { 1103, 7, 11, 9, 1, -11 },
  { 1113, 12, 11, 14, 1, -11 },
  { 1130, 7, 11, 9, 1, -11 },
  { 1140, 8, 15, 9, 0, -11 },
  { 1155, 7, 11, 9, 1, -11 },
  { 1165, 5, 20, 6, 1, -16 },
  { 1178, 1, 18, 5, 2, -15 },
  { 1181, 5, 20, 6, 0, -16 },
  { 1194, 10, 4, 12, 1, -8 },
};

const GFXfont RobotoCondensed_Light21pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light21pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOCONDENSED_LIGHT21PT7B_H_
