#ifndef _ROBOTOCONDENSED_LIGHT38PT7B_H_
#define _ROBOTOCONDENSED_LIGHT38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light38pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00, 0x00, 0xDF, 0x00,
  0xCF, 0x3C, 0xE3, 0x8E, 0x38, 0xE3, 0x01, 0x06, 0x00, 0x83, 0x00, 0xC1,
  0x80, 0x60, 0x80, 0x30, 0x40, 0x18, 0x60, 0x08, 0x30, 0x04, 0x18, 0x7F,
  0xFF, 0xBF, 0xFF, 0xC1, 0x82, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x20, 0xC0,
  0x10, 0x60, 0x18, 0x20, 0x0C, 0x10, 0x06, 0x18, 0x3F, 0xFF, 0xDF, 0xFF,
  0xE0, 0x83, 0x00, 0xC1, 0x80, 0x60, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x08,
  0x30, 0x04, 0x18, 0x00, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x07,
  0xC0, 0x7F, 0xC3, 0x83, 0x8C, 0x06, 0x70, 0x1D, 0x80, 0x36, 0x00, 0xD8,
  0x03, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x36, 0x00, 0xDC, 0x07, 0x38, 0x38, 0x7F, 0xC0, 0x7C, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x63, 0x00, 0x0C,
  0x18, 0x10, 0xC1, 0x83, 0x0C, 0x18, 0x20, 0xC1, 0x86, 0x0C, 0x18, 0x40,
  0xC1, 0x8C, 0x0C, 0x18, 0x80, 0x63, 0x18, 0x07, 0xF3, 0x00, 0x1C, 0x30,
  0x00, 0x06, 0x00, 0x00, 0x63, 0xC0, 0x0C, 0x7E, 0x00, 0x8C, 0x30, 0x18,
  0x83, 0x01, 0x18, 0x10, 0x31, 0x81, 0x02, 0x18, 0x10, 0x61, 0x81, 0x0C,
  0x08, 0x10, 0xC0, 0x83, 0x00, 0x0C, 0x30, 0x00, 0x7E, 0x00, 0x03, 0xC0,
  0x07, 0xC0, 0x03, 0xF8, 0x01, 0xC7, 0x00, 0xE0, 0xC0, 0x30, 0x30, 0x0C,
  0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x38, 0x60, 0x06, 0x30, 0x01, 0xDC,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xB8, 0x00, 0xC6, 0x06,
  0x60, 0xC1, 0x38, 0x38, 0xCC, 0x07, 0x33, 0x00, 0xCC, 0xC0, 0x1F, 0x30,
  0x07, 0x8E, 0x00, 0xC1, 0x80, 0x78, 0x78, 0x3F, 0x0F, 0xFC, 0xE0, 0xFC,
  0x18, 0xFF, 0xFF, 0x02, 0x0C, 0x30, 0x61, 0x82, 0x0C, 0x18, 0x60, 0xC1,
  0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x20, 0x60, 0x60, 0xC0,
  0xC0, 0x80, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x0C,
  0x0C, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x07, 0x07, 0x07, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18,
  0x30, 0x20, 0x60, 0xC0, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x1C, 0x63, 0xBF, 0xDF, 0x0F, 0xF0, 0x03, 0x00, 0x0F, 0x00,
  0x33, 0x00, 0xE7, 0x01, 0x87, 0x06, 0x06, 0x04, 0x04, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x33, 0x33, 0x37, 0x6E, 0x40, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C,
  0x00, 0x07, 0xC0, 0x7F, 0x83, 0x87, 0x0C, 0x0E, 0x60, 0x19, 0x80, 0x76,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03,
  0x60, 0x0D, 0x80, 0x76, 0x01, 0x8C, 0x0E, 0x38, 0x70, 0x7F, 0x80, 0x7C,
  0x00, 0x01, 0x07, 0x3F, 0xFB, 0xE3, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x0F, 0xC0, 0x3F, 0xC0, 0xE1, 0xC3, 0x01, 0xC6,
  0x01, 0x98, 0x03, 0xB0, 0x03, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x7F, 0xC3, 0x87,
  0x18, 0x06, 0x60, 0x1B, 0x00, 0x3C, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x1C, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x36, 0x00, 0xDC,
  0x06, 0x38, 0x38, 0x7F, 0xC0, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x06, 0x60, 0x03, 0x30,
  0x03, 0x18, 0x03, 0x8C, 0x01, 0x86, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xC0,
  0xC0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x18, 0x30, 0x0C, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x3F, 0xF8, 0xFF, 0xE3, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0xFC,
  0x1F, 0xF8, 0x70, 0x71, 0x80, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x6E, 0x01, 0x98, 0x0E, 0x78,
  0x70, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x3C, 0x00, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC7, 0x81,
  0xBF, 0xC3, 0xE1, 0xCF, 0x01, 0x9C, 0x01, 0xB8, 0x03, 0x60, 0x06, 0xC0,
  0x0D, 0x80, 0x1F, 0x80, 0x3B, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x9C, 0x07,
  0x18, 0x0C, 0x1C, 0x38, 0x1F, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0x07,
  0xC0, 0x3F, 0xE0, 0xE1, 0xE3, 0x80, 0xC6, 0x01, 0xCC, 0x01, 0x98, 0x03,
  0x30, 0x06, 0x60, 0x0C, 0xC0, 0x31, 0xC0, 0x61, 0xC3, 0x81, 0xFE, 0x03,
  0xFC, 0x0E, 0x1C, 0x38, 0x0C, 0x60, 0x0D, 0x80, 0x1B, 0x00, 0x36, 0x00,
  0x6C, 0x00, 0xD8, 0x01, 0xB8, 0x03, 0x30, 0x0E, 0x38, 0x38, 0x3F, 0xE0,
  0x3F, 0x00, 0x0F, 0x80, 0x7F, 0x83, 0x87, 0x1C, 0x0E, 0x60, 0x1B, 0x80,
  0x6C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0,
  0x0D, 0x80, 0x77, 0x03, 0xCE, 0x1B, 0x1F, 0xCC, 0x3E, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x01, 0xE0, 0x7E, 0x01,
  0xE0, 0x00, 0x6F, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0xF6,
  0x37, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0x33, 0x37, 0x6E,
  0x40, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0x78, 0x0E,
  0x00, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x30,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x3E, 0x03,
  0xE0, 0x3E, 0x01, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x1F, 0x03, 0xFC, 0x70,
  0xEE, 0x06, 0xC0, 0x6C, 0x07, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xE0, 0x0C,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x3C, 0x03, 0x80, 0x1C,
  0x00, 0x30, 0x0E, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x30,
  0xC0, 0x00, 0x04, 0x30, 0x0F, 0x01, 0x88, 0x0F, 0xF0, 0x66, 0x03, 0x0C,
  0x09, 0x81, 0x83, 0x02, 0x60, 0xC0, 0xC0, 0xD0, 0x30, 0x30, 0x3C, 0x0C,
  0x0C, 0x0F, 0x06, 0x03, 0x03, 0xC1, 0x80, 0xC0, 0xF0, 0x60, 0x30, 0x3C,
  0x18, 0x08, 0x0B, 0x06, 0x02, 0x02, 0xC1, 0x81, 0x81, 0xB0, 0x60, 0x60,
  0x64, 0x18, 0x3C, 0x11, 0x03, 0x1B, 0x0C, 0x60, 0xFC, 0xFE, 0x18, 0x1E,
  0x0F, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0xC4, 0x00, 0x18, 0xC0, 0x03,
  0x18, 0x00, 0xC3, 0x00, 0x18, 0x30, 0x03, 0x06, 0x00, 0xE0, 0xC0, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x03, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x18, 0x00, 0x73, 0x00,
  0x06, 0x60, 0x00, 0xDC, 0x00, 0x1F, 0x00, 0x01, 0x80, 0xFF, 0xC1, 0xFF,
  0xE3, 0x00, 0xE6, 0x00, 0xEC, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06,
  0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x76, 0x01, 0xCF, 0xFF, 0x1F, 0xFE, 0x30,
  0x0E, 0x60, 0x06, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x06, 0xC0, 0x3D, 0xFF, 0xF3, 0xFF, 0x80,
  0x07, 0xE0, 0x1F, 0xF8, 0x3C, 0x1C, 0x70, 0x0E, 0x60, 0x06, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0x60, 0x06, 0x70, 0x0E,
  0x3C, 0x1C, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xC0, 0xFF, 0xF0, 0xC0, 0x38,
  0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x1C, 0xC0, 0x78, 0xFF, 0xF0, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFB, 0xFF,
  0xEC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFB, 0xFF,
  0xEC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0x07, 0x8E, 0x00, 0xC6, 0x00, 0x77, 0x00,
  0x1B, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x0D, 0x80,
  0x06, 0x60, 0x07, 0x3C, 0x0F, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xF8, 0x03, 0xE0, 0x0D, 0x80, 0x36, 0x01, 0xDC, 0x06, 0x38, 0x78, 0x7F,
  0xC0, 0xFC, 0x00, 0xC0, 0x07, 0x60, 0x07, 0x30, 0x03, 0x18, 0x03, 0x8C,
  0x03, 0x86, 0x03, 0x83, 0x01, 0x81, 0x81, 0x80, 0xC1, 0xC0, 0x61, 0xC0,
  0x31, 0xC0, 0x18, 0xC0, 0x0C, 0xE0, 0x06, 0xF8, 0x03, 0xEE, 0x01, 0xE3,
  0x00, 0xE1, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x18, 0x0E, 0x0C, 0x03, 0x86,
  0x00, 0xC3, 0x00, 0x71, 0x80, 0x1C, 0xC0, 0x06, 0x60, 0x03, 0xB0, 0x00,
  0xE0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x60,
  0x01, 0xFD, 0x80, 0x06, 0xF7, 0x00, 0x1B, 0xCC, 0x00, 0xEF, 0x30, 0x03,
  0x3C, 0x60, 0x0C, 0xF1, 0x80, 0x63, 0xC6, 0x01, 0x8F, 0x0C, 0x06, 0x3C,
  0x30, 0x30, 0xF0, 0xC0, 0xC3, 0xC1, 0x83, 0x0F, 0x06, 0x18, 0x3C, 0x18,
  0x60, 0xF0, 0x31, 0x83, 0xC0, 0xCC, 0x0F, 0x03, 0x30, 0x3C, 0x06, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x3C, 0x03, 0x00, 0xC0,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3D, 0x80, 0x1E, 0xC0,
  0x0F, 0x30, 0x07, 0x9C, 0x03, 0xC6, 0x01, 0xE3, 0x80, 0xF0, 0xC0, 0x78,
  0x30, 0x3C, 0x18, 0x1E, 0x06, 0x0F, 0x03, 0x07, 0x80, 0xC3, 0xC0, 0x61,
  0xE0, 0x18, 0xF0, 0x0E, 0x78, 0x03, 0x3C, 0x01, 0xDE, 0x00, 0x6F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x60, 0x03, 0xF0,
  0x03, 0xFF, 0x01, 0xE0, 0xE0, 0xE0, 0x1C, 0x30, 0x03, 0x9C, 0x00, 0x66,
  0x00, 0x19, 0x80, 0x03, 0x60, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x01, 0x9C, 0x00, 0x63,
  0x00, 0x38, 0xE0, 0x1C, 0x1E, 0x0E, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0xFF,
  0xE0, 0xFF, 0xF8, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xC0,
  0x0E, 0xC0, 0x1C, 0xFF, 0xF8, 0xFF, 0xE0, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xE0, 0xE0,
  0xE0, 0x1C, 0x30, 0x03, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0D,
  0x80, 0x07, 0x60, 0x01, 0x98, 0x00, 0x63, 0x00, 0x38, 0xE0, 0x1C, 0x1E,
  0x0E, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x02, 0xFF, 0xE0, 0xFF, 0xF8, 0xC0, 0x3C, 0xC0,
  0x0C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x38, 0xFF, 0xF0, 0xFF,
  0xE0, 0xC0, 0x60, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x18, 0xC0,
  0x1C, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0x07,
  0xE0, 0x1F, 0xF8, 0x38, 0x1C, 0x70, 0x0E, 0x60, 0x06, 0x60, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0x60, 0x00, 0x60, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x70, 0x06, 0x38,
  0x1E, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xE0, 0x06, 0x70, 0x0E, 0x38, 0x1C, 0x1F, 0xF8, 0x07, 0xE0,
  0xC0, 0x00, 0xFC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0xE7, 0x00, 0x18,
  0x60, 0x03, 0x0C, 0x00, 0xE1, 0x80, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60,
  0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x1C, 0x03, 0x83, 0x00,
  0x30, 0x60, 0x06, 0x1C, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00,
  0x33, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x6C, 0x01, 0xC0, 0x0D,
  0x80, 0x38, 0x03, 0xB0, 0x07, 0x80, 0x66, 0x00, 0xF0, 0x0C, 0x60, 0x36,
  0x01, 0x8C, 0x06, 0xC0, 0x31, 0x80, 0xCC, 0x0E, 0x30, 0x19, 0x81, 0x86,
  0x02, 0x30, 0x30, 0x60, 0xC6, 0x06, 0x0C, 0x18, 0x40, 0xC1, 0x83, 0x0C,
  0x30, 0x30, 0x41, 0x86, 0x06, 0x18, 0x30, 0xC0, 0x63, 0x02, 0x18, 0x0C,
  0x60, 0x63, 0x01, 0x88, 0x0C, 0xC0, 0x33, 0x01, 0x98, 0x07, 0x60, 0x13,
  0x00, 0x6C, 0x03, 0x60, 0x0D, 0x00, 0x6C, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x00, 0x60, 0x01, 0xDC, 0x00, 0x63, 0x00, 0x38, 0xE0, 0x1C, 0x18, 0x06,
  0x03, 0x03, 0x80, 0xE0, 0xC0, 0x18, 0x70, 0x07, 0x18, 0x00, 0xCE, 0x00,
  0x3B, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x03, 0xB0, 0x00, 0xCE, 0x00, 0x61, 0x80, 0x38, 0x30, 0x0C, 0x0E,
  0x07, 0x01, 0x81, 0x80, 0x70, 0xE0, 0x0C, 0x30, 0x03, 0x9C, 0x00, 0x66,
  0x00, 0x1C, 0xC0, 0x01, 0xF8, 0x00, 0x66, 0x00, 0x39, 0xC0, 0x0C, 0x30,
  0x03, 0x0E, 0x01, 0x81, 0x80, 0x60, 0x70, 0x30, 0x0C, 0x0C, 0x03, 0x87,
  0x00, 0x61, 0x80, 0x18, 0xE0, 0x03, 0x30, 0x00, 0xDC, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFF, 0x80, 0xC0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xFC, 0x0C, 0x03, 0x01,
  0xE0, 0x78, 0x16, 0x0C, 0xC3, 0x30, 0x84, 0x61, 0x98, 0x6C, 0x0B, 0x03,
  0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC3, 0x06, 0x0C, 0x0F, 0xC0,
  0xFF, 0xC3, 0x07, 0x18, 0x0E, 0x60, 0x1B, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x0F, 0xF8, 0xFF, 0xE7, 0x01, 0x98, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x01,
  0xB0, 0x0E, 0xE0, 0x39, 0xC3, 0xE7, 0xFD, 0x87, 0xC6, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x7E, 0x37, 0xF9, 0xE0, 0xEE, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1F, 0x01, 0xFC, 0x1D, 0xBF, 0xCC, 0xFC, 0x00, 0x0F, 0xC0, 0xFF,
  0x87, 0x07, 0x18, 0x06, 0xE0, 0x1B, 0x00, 0x6C, 0x00, 0xF0, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x3C, 0x01, 0xB8,
  0x06, 0x60, 0x19, 0xE1, 0xC3, 0xFE, 0x03, 0xF0, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x3E, 0x33, 0xFE, 0xDE, 0x1B, 0x60, 0x1D, 0x80, 0x7C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x60, 0x1D, 0x80, 0x73, 0x86, 0xCF, 0xFB, 0x0F, 0x8C, 0x0F,
  0xC0, 0x7F, 0xC3, 0x87, 0x18, 0x06, 0x60, 0x1B, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x08, 0xE0, 0xE1, 0xFF, 0x03, 0xF0, 0x03, 0xC1,
  0xF0, 0xE0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x3F, 0xEF, 0xF8,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x00, 0x0F,
  0x8C, 0xFF, 0xB7, 0x86, 0xD8, 0x07, 0x60, 0x1F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xD8, 0x07, 0x60, 0x1C, 0xE1, 0xB3, 0xFE, 0xC3, 0xE3, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x20, 0x19, 0xC0, 0xE3, 0xFF, 0x03, 0xF0,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x3E, 0x37, 0xF9, 0xF0, 0xEE, 0x03, 0x70, 0x1B, 0x00,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0x80,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C, 0x30, 0xC0, 0x00, 0x00,
  0x03, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x1B, 0xEF, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x03, 0xB0, 0x19, 0x81, 0x8C, 0x18, 0x61, 0xC3, 0x1C, 0x19, 0xC0,
  0xCC, 0x06, 0xC0, 0x3F, 0x01, 0xDC, 0x0E, 0x60, 0x61, 0x83, 0x0E, 0x18,
  0x30, 0xC0, 0xC6, 0x07, 0x30, 0x19, 0x80, 0x6C, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC7, 0xC1, 0xF1, 0xBF, 0xC7, 0xFB,
  0xC1, 0xD8, 0x77, 0x01, 0xE0, 0x7E, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x30, 0xC7, 0xC6, 0xFF, 0x3E, 0x1D, 0xC0, 0x6E, 0x03,
  0x60, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x30, 0x07, 0xC0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xC6, 0x00, 0xDC, 0x01,
  0xB0, 0x03, 0x60, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xB8, 0x03, 0x30, 0x06, 0x70, 0x18, 0x70, 0x70, 0x7F,
  0xC0, 0x3E, 0x00, 0xCF, 0xC6, 0xFF, 0x3C, 0x1D, 0xC0, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x3F, 0x83, 0xB7, 0xF9, 0x9F, 0x8C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x0F, 0x8C, 0xFF, 0xB7, 0x86, 0xD8, 0x07, 0x60, 0x1F, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0xD8, 0x07, 0x60, 0x1C, 0xE1, 0xF3, 0xFE, 0xC3, 0xE3,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0xCF, 0xDF, 0xF8, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x0F, 0x81,
  0xFF, 0x1C, 0x1C, 0xC0, 0x6E, 0x03, 0xF0, 0x0D, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x00, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x3B, 0x83, 0x8F, 0xF8, 0x1F, 0x00, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x87, 0xFB, 0xFC, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x1F, 0x07, 0x80,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xE0, 0x7B, 0x86, 0xDF, 0xE6, 0x3E, 0x30, 0xC0, 0x0F, 0x80,
  0x36, 0x01, 0x98, 0x06, 0x60, 0x18, 0xC0, 0xC3, 0x03, 0x0C, 0x0C, 0x18,
  0x30, 0x61, 0x81, 0x86, 0x03, 0x18, 0x0C, 0xC0, 0x33, 0x00, 0x4C, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x30, 0x00, 0xC0, 0xE0, 0x30, 0x0D, 0x80,
  0xE0, 0x36, 0x03, 0x80, 0xD8, 0x0E, 0x07, 0x60, 0x78, 0x18, 0xC1, 0xB0,
  0x63, 0x06, 0xC1, 0x8C, 0x33, 0x06, 0x30, 0xC4, 0x30, 0x63, 0x18, 0xC1,
  0x88, 0x63, 0x06, 0x61, 0x8C, 0x19, 0x83, 0x60, 0x36, 0x0D, 0x80, 0xD0,
  0x36, 0x03, 0xC0, 0x58, 0x0F, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x60, 0x1C,
  0x01, 0x80, 0x30, 0x60, 0x1D, 0xC0, 0x63, 0x03, 0x8E, 0x0C, 0x18, 0x60,
  0x31, 0x80, 0xCC, 0x01, 0xF0, 0x07, 0x80, 0x0C, 0x00, 0x38, 0x01, 0xE0,
  0x0E, 0xC0, 0x33, 0x01, 0xC6, 0x06, 0x1C, 0x30, 0x30, 0xC0, 0xE6, 0x01,
  0xB8, 0x07, 0xC0, 0x0F, 0x80, 0x76, 0x01, 0x98, 0x06, 0x60, 0x18, 0xC0,
  0xC3, 0x03, 0x0C, 0x0C, 0x18, 0x60, 0x61, 0x81, 0x86, 0x03, 0x18, 0x0C,
  0xC0, 0x33, 0x00, 0xEC, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x07,
  0x80, 0x1C, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x80, 0x70, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x0E, 0x0F, 0x03,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x07, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x1C, 0x06, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x18, 0x0C, 0x07, 0x01, 0xE0, 0xF0, 0xE0, 0x60, 0x70, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x1C, 0x1C, 0x08,
  0x00, 0x3C, 0x01, 0xBF, 0x80, 0xF8, 0xE0, 0x78, 0x38, 0x6C, 0x0E, 0x34,
  0x03, 0xF0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_Light38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 27, 8, 3, -27 },
  { 12, 6, 8, 11, 3, -29 },
  { 18, 17, 27, 20, 2, -27 },
  { 76, 14, 34, 18, 2, -31 },
  { 136, 20, 27, 24, 2, -27 },
  { 204, 18, 27, 20, 2, -27 },
  { 265, 2, 8, 7, 2, -29 },
  { 267, 7, 39, 11, 3, -30 },
  { 302, 8, 39, 11, 1, -30 },
  { 341, 15, 15, 16, 1, -27 },
  { 370, 15, 20, 19, 2, -23 },
  { 408, 4, 9, 7, 1, -4 },
  { 413, 8, 2, 10, 1, -13 },
  { 415, 3, 3, 9, 3, -3 },
  { 417, 11, 29, 14, 1, -27 },
  { 457, 14, 27, 18, 2, -27 },
  { 505, 8, 27, 18, 3, -27 },
  { 532, 15, 27, 18, 2, -27 },
  { 583, 14, 27, 18, 2, -27 },
  { 631, 17, 27, 18, 1, -27 },
  { 689, 14, 27, 18, 3, -27 },
  { 737, 15, 27, 18, 2, -27 },
  { 788, 15, 27, 18, 2, -27 },
  { 839, 15, 27, 18, 2, -27 },
  { 890, 14, 27, 18, 2, -27 },
  { 938, 4, 20, 8, 2, -20 },
  { 948, 4, 25, 7, 1, -20 },
  { 961, 12, 16, 17, 2, -20 },
  { 985, 13, 9, 18, 3, -17 },
  { 1000, 14, 16, 17, 2, -20 },
  { 1028, 12, 27, 15, 2, -27 },
  { 1069, 26, 34, 30, 2, -26 },
  { 1180, 19, 27, 21, 1, -27 },
  { 1245, 15, 27, 20, 3, -27 },
  { 1296, 16, 27, 21, 3, -27 },
  { 1350, 16, 27, 22, 3, -27 },
  { 1404, 14, 27, 19, 3, -27 },
  { 1452, 14, 27, 19, 3, -27 },
  { 1500, 17, 27, 23, 3, -27 },
  { 1558, 17, 27, 23, 3, -27 },
  { 1616, 2, 27, 9, 4, -27 },
  { 1623, 14, 27, 18, 1, -27 },
  { 1671, 17, 27, 21, 3, -27 },
  { 1729, 13, 27, 18, 3, -27 },
  { 1773, 22, 27, 28, 3, -27 },
  { 1848, 17, 27, 23, 3, -27 },
  { 1906, 18, 27, 22, 2, -27 },
  { 1967, 16, 27, 20, 3, -27 },
  { 2021, 18, 32, 22, 2, -27 },
  { 2093, 16, 27, 21, 3, -27 },
  { 2147, 16, 27, 20, 2, -27 },
  { 2201, 18, 27, 20, 1, -27 },
  { 2262, 16, 27, 22, 3, -27 },
  { 2316, 19, 27, 21, 1, -27 },
  { 2381, 27, 27, 29, 1, -27 },
  { 2473, 18, 27, 20, 1, -27 },
  { 2534, 18, 27, 20, 1, -27 },
  { 2595, 16, 27, 20, 2, -27 },
  { 2649, 5, 37, 9, 3, -31 },
  { 2673, 12, 29, 13, 1, -27 },
  { 2717, 6, 37, 9, 0, -31 },
  { 2745, 10, 13, 14, 2, -27 },
  { 2762, 14, 2, 15, 0, 0 },
  { 2766, 6, 5, 11, 2, -28 },
  { 2770, 14, 20, 18, 2, -20 },
  { 2805, 13, 29, 18, 3, -29 },
  { 2853, 14, 20, 17, 2, -20 },
  { 2888, 14, 29, 19, 2, -29 },
  { 2939, 14, 20, 17, 2, -20 },
  { 2974, 10, 29, 11, 1, -29 },
  { 3011, 14, 28, 19, 2, -20 },
  { 3060, 13, 29, 18, 3, -29 },
  { 3108, 2, 27, 8, 3, -27 },
  { 3115, 6, 35, 8, -1, -27 },
  { 3142, 13, 29, 17, 3, -29 },
  { 3190, 2, 29, 8, 3, -29 },
  { 3198, 23, 20, 29, 3, -20 },
  { 3256, 13, 20, 18, 3, -20 },
  { 3289, 15, 20, 19, 2, -20 },
  { 3327, 13, 28, 18, 3, -20 },
  { 3373, 14, 28, 19, 2, -20 },
  { 3422, 8, 20, 12, 3, -20 },
  { 3442, 13, 20, 17, 2, -20 },
  { 3475, 9, 25, 11, 1, -25 },
  { 3504, 13, 20, 18, 3, -20 },
  { 3537, 14, 20, 16, 1, -20 },
  { 3572, 22, 20, 25, 1, -20 },
  { 3627, 14, 20, 16, 1, -20 },
  { 3662, 14, 28, 16, 1, -20 },
  { 3711, 13, 20, 16, 2, -20 },
  { 3744, 10, 37, 11, 1, -30 },
  { 3791, 2, 32, 8, 3, -27 },
  { 3799, 9, 37, 11, 1, -30 },
  { 3841, 17, 7, 23, 3, -15 },
};

const GFXfont RobotoCondensed_Light38pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light38pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light38pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOCONDENSED_LIGHT38PT7B_H_
