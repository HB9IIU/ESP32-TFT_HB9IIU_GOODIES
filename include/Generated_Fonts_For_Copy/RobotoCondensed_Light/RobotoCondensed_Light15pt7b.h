#ifndef _ROBOTOCONDENSED_LIGHT15PT7B_H_
#define _ROBOTOCONDENSED_LIGHT15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0x80, 0x24, 0x48, 0xA7, 0xF2, 0x89, 0x12, 0x7E,
  0x48, 0xA1, 0x40, 0x23, 0xA3, 0x18, 0x20, 0xC1, 0x0C, 0x62, 0xE2, 0x00,
  0xE0, 0xA0, 0x94, 0xA8, 0xE8, 0x10, 0x16, 0x29, 0x29, 0x49, 0x06, 0x70,
  0x92, 0x22, 0x86, 0x0C, 0x25, 0x4A, 0x8D, 0x19, 0xD0, 0xE0, 0x29, 0x49,
  0x24, 0x92, 0x44, 0x88, 0x89, 0x12, 0x49, 0x24, 0x94, 0xA0, 0x10, 0x4F,
  0xC4, 0x29, 0x20, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x54, 0xE0, 0x80,
  0x08, 0x84, 0x21, 0x10, 0x84, 0x42, 0x11, 0x00, 0x74, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x5C, 0x3C, 0x92, 0x49, 0x24, 0x80, 0x72, 0x28, 0x82, 0x08,
  0x41, 0x08, 0x41, 0x0F, 0xC0, 0x74, 0x62, 0x10, 0x98, 0x21, 0x8C, 0x5C,
  0x18, 0x62, 0x8A, 0x49, 0x28, 0xBF, 0x08, 0x20, 0x80, 0x79, 0x04, 0x10,
  0x70, 0x20, 0x41, 0x86, 0x27, 0x00, 0x31, 0x08, 0x20, 0xF2, 0x28, 0x61,
  0x86, 0x27, 0x00, 0xFC, 0x20, 0x82, 0x10, 0x42, 0x08, 0x21, 0x04, 0x00,
  0x72, 0x28, 0xA2, 0x89, 0xC8, 0xA1, 0x86, 0x27, 0x00, 0x74, 0x63, 0x18,
  0xC5, 0xE1, 0x08, 0x98, 0x81, 0x40, 0x01, 0x50, 0x09, 0xB1, 0x83, 0x04,
  0xF8, 0x01, 0xF0, 0x83, 0x06, 0x36, 0x40, 0x79, 0x91, 0x12, 0x24, 0x00,
  0x40, 0x1F, 0x08, 0x24, 0x0A, 0x39, 0x92, 0x64, 0x9A, 0x26, 0x89, 0x96,
  0x66, 0xE8, 0x01, 0x00, 0x3E, 0x00, 0x08, 0x18, 0x18, 0x14, 0x24, 0x24,
  0x22, 0x7E, 0x42, 0x41, 0x81, 0xFA, 0x18, 0x61, 0x87, 0xE8, 0x61, 0x86,
  0x1F, 0x80, 0x38, 0x8A, 0x0C, 0x08, 0x10, 0x20, 0x40, 0x82, 0x88, 0xE0,
  0xF9, 0x0A, 0x14, 0x18, 0x30, 0x60, 0xC1, 0x85, 0x0B, 0xE0, 0xFE, 0x08,
  0x20, 0x83, 0xE8, 0x20, 0x82, 0x0F, 0xC0, 0xFE, 0x08, 0x20, 0x83, 0xE8,
  0x20, 0x82, 0x08, 0x00, 0x38, 0x8A, 0x0C, 0x08, 0x10, 0x23, 0xC1, 0x82,
  0x84, 0xF0, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x08,
  0xFF, 0xE0, 0x08, 0x42, 0x10, 0x84, 0x21, 0x8C, 0x5C, 0x85, 0x12, 0x24,
  0x8A, 0x1C, 0x34, 0x44, 0x89, 0x0A, 0x08, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x0F, 0xC0, 0xC0, 0xE0, 0xF0, 0x74, 0x3A, 0x2D, 0x16, 0x4B,
  0x29, 0x94, 0xC4, 0x62, 0x20, 0x83, 0x86, 0x8D, 0x19, 0x32, 0x62, 0xC5,
  0x87, 0x0E, 0x08, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x88,
  0xE0, 0xFA, 0x18, 0x61, 0x86, 0x1F, 0xA0, 0x82, 0x08, 0x00, 0x38, 0x8A,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x88, 0xE0, 0x20, 0x20, 0xF9, 0x0A,
  0x14, 0x28, 0x5F, 0x22, 0x44, 0x85, 0x0A, 0x10, 0x7A, 0x18, 0x60, 0x40,
  0xC0, 0xC1, 0x86, 0x17, 0x80, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x17, 0x80,
  0x81, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x14, 0x18, 0x18, 0x08, 0x88,
  0x63, 0x18, 0xC6, 0x52, 0x94, 0x94, 0xA5, 0x29, 0x4A, 0x63, 0x18, 0x42,
  0x10, 0x42, 0x42, 0x24, 0x24, 0x18, 0x18, 0x18, 0x24, 0x24, 0x42, 0x42,
  0x82, 0x42, 0x44, 0x24, 0x28, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFC,
  0x10, 0x84, 0x10, 0x82, 0x10, 0x42, 0x0F, 0xC0, 0xEA, 0xAA, 0xAA, 0xB0,
  0x82, 0x10, 0x82, 0x10, 0x82, 0x10, 0x82, 0x10, 0xD5, 0x55, 0x55, 0x70,
  0x46, 0xAA, 0x90, 0xFC, 0x90, 0x74, 0x42, 0xF8, 0xC6, 0x3F, 0x82, 0x08,
  0x20, 0xFA, 0x28, 0x61, 0x86, 0x18, 0xBC, 0x74, 0x63, 0x08, 0x46, 0x2E,
  0x08, 0x42, 0x17, 0xC6, 0x31, 0x8C, 0x62, 0xF0, 0x74, 0x63, 0xF8, 0x42,
  0x0F, 0x69, 0x2E, 0x92, 0x49, 0x20, 0x7C, 0x63, 0x18, 0xC6, 0x2F, 0x0C,
  0x5C, 0x84, 0x21, 0x0B, 0x66, 0x31, 0x8C, 0x63, 0x10, 0x9F, 0xE0, 0x41,
  0x55, 0x55, 0x60, 0x84, 0x21, 0x08, 0xCA, 0x98, 0xA4, 0xA5, 0x10, 0xFF,
  0xF0, 0xF3, 0xC6, 0x62, 0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0xB6, 0x63,
  0x18, 0xC6, 0x31, 0x72, 0x28, 0x61, 0x86, 0x18, 0x9C, 0xFA, 0x28, 0x61,
  0x86, 0x18, 0xBC, 0x82, 0x08, 0x00, 0x7C, 0x63, 0x18, 0xC6, 0x2F, 0x08,
  0x42, 0xF2, 0x49, 0x24, 0x74, 0x60, 0xC1, 0x06, 0x2E, 0x44, 0xF4, 0x44,
  0x44, 0x43, 0x8C, 0x63, 0x18, 0xC6, 0x2F, 0x85, 0x14, 0x92, 0x28, 0xC3,
  0x04, 0x91, 0x99, 0x99, 0xAA, 0xA6, 0x66, 0x66, 0x44, 0x45, 0x22, 0x84,
  0x30, 0xA4, 0x91, 0x85, 0x14, 0x92, 0x28, 0xC3, 0x04, 0x20, 0x84, 0x00,
  0xF8, 0x84, 0x44, 0x22, 0x1F, 0x29, 0x24, 0x94, 0x49, 0x24, 0x88, 0xFF,
  0xF8, 0x84, 0x22, 0x22, 0x21, 0x22, 0x22, 0x24, 0x80, 0x63, 0x26, 0x30,
};

const GFXglyph RobotoCondensed_Light15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 11, 3, 1, -11 },
  { 3, 3, 3, 4, 1, -11 },
  { 5, 7, 11, 8, 1, -11 },
  { 15, 5, 13, 7, 1, -12 },
  { 24, 8, 11, 10, 1, -11 },
  { 35, 7, 11, 8, 1, -11 },
  { 45, 1, 3, 3, 1, -11 },
  { 46, 3, 15, 4, 1, -12 },
  { 52, 3, 15, 4, 0, -12 },
  { 58, 6, 6, 6, 0, -11 },
  { 63, 6, 8, 7, 1, -9 },
  { 69, 2, 3, 3, 0, -1 },
  { 70, 3, 1, 4, 0, -5 },
  { 71, 1, 1, 4, 1, -1 },
  { 72, 5, 12, 5, 0, -11 },
  { 80, 5, 11, 7, 1, -11 },
  { 87, 3, 11, 7, 1, -11 },
  { 92, 6, 11, 7, 1, -11 },
  { 101, 5, 11, 7, 1, -11 },
  { 108, 6, 11, 7, 1, -11 },
  { 117, 6, 11, 7, 1, -11 },
  { 126, 6, 11, 7, 1, -11 },
  { 135, 6, 11, 7, 1, -11 },
  { 144, 6, 11, 7, 1, -11 },
  { 153, 5, 11, 7, 1, -11 },
  { 160, 1, 8, 3, 1, -8 },
  { 161, 2, 10, 3, 0, -8 },
  { 164, 5, 6, 7, 1, -8 },
  { 168, 5, 4, 7, 1, -7 },
  { 171, 5, 6, 7, 1, -8 },
  { 175, 4, 11, 6, 1, -11 },
  { 181, 10, 13, 12, 1, -10 },
  { 198, 8, 11, 8, 0, -11 },
  { 209, 6, 11, 8, 1, -11 },
  { 218, 7, 11, 8, 1, -11 },
  { 228, 7, 11, 9, 1, -11 },
  { 238, 6, 11, 7, 1, -11 },
  { 247, 6, 11, 7, 1, -11 },
  { 256, 7, 11, 9, 1, -11 },
  { 266, 7, 11, 9, 1, -11 },
  { 276, 1, 11, 4, 1, -11 },
  { 278, 5, 11, 7, 1, -11 },
  { 285, 7, 11, 8, 1, -11 },
  { 295, 6, 11, 7, 1, -11 },
  { 304, 9, 11, 11, 1, -11 },
  { 317, 7, 11, 9, 1, -11 },
  { 327, 7, 11, 9, 1, -11 },
  { 337, 6, 11, 8, 1, -11 },
  { 346, 7, 13, 9, 1, -11 },
  { 358, 7, 11, 8, 1, -11 },
  { 368, 6, 11, 8, 1, -11 },
  { 377, 7, 11, 8, 0, -11 },
  { 387, 6, 11, 9, 1, -11 },
  { 396, 8, 11, 8, 0, -11 },
  { 407, 10, 11, 12, 1, -11 },
  { 421, 8, 11, 8, 0, -11 },
  { 432, 8, 11, 8, 0, -11 },
  { 443, 6, 11, 8, 1, -11 },
  { 452, 2, 14, 3, 1, -12 },
  { 456, 5, 12, 5, 0, -11 },
  { 464, 2, 14, 3, 0, -12 },
  { 468, 4, 5, 6, 1, -11 },
  { 471, 6, 1, 6, 0, 0 },
  { 472, 2, 2, 4, 1, -11 },
  { 473, 5, 8, 7, 1, -8 },
  { 478, 6, 12, 7, 1, -12 },
  { 487, 5, 8, 7, 1, -8 },
  { 492, 5, 12, 7, 1, -12 },
  { 500, 5, 8, 7, 1, -8 },
  { 505, 3, 12, 5, 1, -12 },
  { 510, 5, 11, 7, 1, -8 },
  { 517, 5, 12, 7, 1, -12 },
  { 525, 1, 11, 3, 1, -11 },
  { 527, 2, 14, 3, 0, -11 },
  { 531, 5, 12, 7, 1, -12 },
  { 539, 1, 12, 3, 1, -12 },
  { 541, 9, 8, 11, 1, -8 },
  { 550, 5, 8, 7, 1, -8 },
  { 555, 6, 8, 7, 1, -8 },
  { 561, 6, 11, 7, 1, -8 },
  { 570, 5, 11, 7, 1, -8 },
  { 577, 3, 8, 5, 1, -8 },
  { 580, 5, 8, 7, 1, -8 },
  { 585, 4, 10, 4, 0, -10 },
  { 590, 5, 8, 7, 1, -8 },
  { 595, 6, 8, 6, 0, -8 },
  { 601, 8, 8, 10, 1, -8 },
  { 609, 6, 8, 6, 0, -8 },
  { 615, 6, 11, 6, 0, -8 },
  { 624, 5, 8, 6, 1, -8 },
  { 629, 3, 15, 4, 1, -12 },
  { 635, 1, 13, 3, 1, -11 },
  { 637, 4, 15, 4, 0, -12 },
  { 645, 7, 3, 9, 1, -6 },
};

const GFXfont RobotoCondensed_Light15pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light15pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOCONDENSED_LIGHT15PT7B_H_
