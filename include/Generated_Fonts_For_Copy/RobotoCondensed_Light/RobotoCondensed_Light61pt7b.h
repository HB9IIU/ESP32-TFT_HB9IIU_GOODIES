#ifndef _ROBOTOCONDENSED_LIGHT61PT7B_H_
#define _ROBOTOCONDENSED_LIGHT61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light61pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x7B, 0xDC, 0x40, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0x00,
  0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x18, 0x07, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x38, 0x0E, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x70,
  0x0E, 0x00, 0x07, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF0, 0x06, 0x01, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x18, 0x07,
  0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0,
  0x38, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x60,
  0x1C, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3E,
  0x07, 0xE0, 0xF0, 0x03, 0xC1, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00,
  0x07, 0x1C, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xB8, 0x00,
  0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xE0, 0x00, 0x7B, 0xC0, 0x00,
  0xF3, 0xC0, 0x03, 0xC7, 0xC0, 0x0F, 0x87, 0xE0, 0x3E, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x01, 0x80, 0x30, 0x03, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0xE0,
  0x0E, 0x01, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x38, 0x03, 0x80, 0xC0, 0x1C,
  0x01, 0xC0, 0xE0, 0x0E, 0x00, 0xE0, 0x60, 0x07, 0x00, 0x70, 0x70, 0x01,
  0x80, 0x30, 0x70, 0x00, 0xE0, 0x38, 0x38, 0x00, 0x78, 0x1C, 0x38, 0x00,
  0x1E, 0x3C, 0x1C, 0x00, 0x07, 0xFC, 0x1C, 0x00, 0x01, 0xFC, 0x0E, 0x00,
  0x00, 0x10, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x81,
  0xFC, 0x00, 0x01, 0xC1, 0xFF, 0x00, 0x00, 0xC1, 0xE3, 0xC0, 0x00, 0xE0,
  0xE0, 0x70, 0x00, 0xE0, 0xE0, 0x38, 0x00, 0x70, 0x70, 0x0E, 0x00, 0x70,
  0x30, 0x07, 0x00, 0x38, 0x18, 0x03, 0x80, 0x38, 0x0C, 0x01, 0xC0, 0x1C,
  0x06, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x70, 0x0E, 0x01, 0x80, 0x38, 0x0E,
  0x00, 0xC0, 0x1C, 0x06, 0x00, 0x70, 0x0E, 0x03, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xC0, 0x0E,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0xF0, 0x03, 0x80, 0x07, 0x80, 0x1C, 0x00,
  0x1C, 0x01, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0xE0, 0xF8, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x1C, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x07, 0x0F, 0x03, 0xC0, 0x38, 0x70, 0x0F,
  0x01, 0xC7, 0x80, 0x78, 0x1E, 0x38, 0x01, 0xE0, 0xE1, 0xC0, 0x07, 0x87,
  0x1E, 0x00, 0x1E, 0x38, 0xF0, 0x00, 0xF3, 0xC7, 0x80, 0x03, 0xDC, 0x3C,
  0x00, 0x0F, 0xE1, 0xE0, 0x00, 0x7F, 0x07, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x7E, 0x07, 0x80, 0x07, 0xF0, 0x3E, 0x00, 0xFB,
  0xC0, 0xFF, 0x3F, 0x8F, 0x03, 0xFF, 0xF8, 0x38, 0x07, 0xFF, 0x01, 0xE0,
  0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0x6C, 0x00, 0x10, 0x03,
  0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x10, 0x40, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x30,
  0x01, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x40, 0x1C, 0x02, 0xF8, 0x1C, 0x1F, 0xFE, 0x18, 0x7F, 0x7F, 0xDB, 0xFE,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xC3, 0x80, 0x03, 0xC3, 0xC0,
  0x07, 0x81, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x70,
  0x04, 0x00, 0x20, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xCF, 0x38, 0xE7,
  0xBC, 0xE1, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF7, 0x90,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1E, 0x03, 0xE0,
  0xF0, 0x07, 0x83, 0x80, 0x0F, 0x1E, 0x00, 0x1C, 0x70, 0x00, 0x79, 0xC0,
  0x00, 0xEF, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0x9C, 0x00,
  0x0E, 0x70, 0x00, 0x79, 0xE0, 0x01, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x78,
  0x1F, 0x03, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x20, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x0F, 0xF3, 0xFF, 0xFF, 0x9F,
  0xE0, 0xFC, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x10, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x3C, 0x70, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x1C,
  0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01,
  0xF0, 0x1F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x70,
  0x00, 0x3C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7E,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xCF, 0x00,
  0x03, 0x9E, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x1F, 0x00, 0xF0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x77, 0x80, 0x00, 0x1D, 0xE0,
  0x00, 0x0E, 0x78, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x71,
  0xE0, 0x00, 0x38, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x70, 0x1E, 0x00, 0x1C, 0x07, 0x80,
  0x0E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x00, 0x1E, 0x03, 0xC0,
  0x07, 0x80, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x8F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x3F, 0x00, 0x73, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xF0, 0xFE, 0x1F, 0x00,
  0x78, 0x78, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x79,
  0xE0, 0x01, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0xF8, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x3F, 0x00, 0xF1, 0xFF, 0x81, 0xCF, 0xFF, 0xC3, 0xBE,
  0x0F, 0x87, 0x70, 0x07, 0x8F, 0xC0, 0x07, 0x9F, 0x00, 0x0F, 0x3C, 0x00,
  0x0F, 0x78, 0x00, 0x1E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0x70, 0x00, 0x0E, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xF3,
  0xC0, 0x01, 0xE3, 0x80, 0x03, 0x87, 0x80, 0x0F, 0x07, 0x80, 0x3C, 0x0F,
  0x80, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xF0,
  0x1F, 0x03, 0xC0, 0x0F, 0x0F, 0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x38, 0x00,
  0x1C, 0xF0, 0x00, 0x39, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0xF7, 0x80, 0x01,
  0xEF, 0x00, 0x03, 0x9E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x3C, 0x00, 0x3C,
  0x38, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0x7C, 0x1F, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xC0, 0xF8, 0x1E, 0x00, 0x78, 0x78,
  0x00, 0x78, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0xF7, 0x00, 0x00, 0xEE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x01, 0xEF, 0x00, 0x03,
  0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x3E, 0x1F, 0x00, 0xF8, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xF0, 0x1E, 0x03,
  0xC0, 0x1E, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0x38, 0xE0,
  0x00, 0x79, 0xC0, 0x00, 0x77, 0x80, 0x00, 0xEF, 0x00, 0x01, 0xDC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xEE, 0x00, 0x03,
  0xDE, 0x00, 0x0F, 0x9C, 0x00, 0x3F, 0x3C, 0x00, 0xFE, 0x3C, 0x03, 0xFC,
  0x7E, 0x1F, 0x78, 0x7F, 0xFC, 0xE0, 0x3F, 0xF1, 0xC0, 0x1F, 0x83, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x90, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x4F, 0xFF, 0xFF,
  0x20, 0x00, 0x78, 0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x3C, 0x78, 0xE1, 0xC7, 0x8E, 0x38, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F,
  0xFF, 0x83, 0xC0, 0x78, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x0E, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x03,
  0x80, 0x03, 0xF0, 0x01, 0xC1, 0xC0, 0x03, 0xFE, 0x00, 0x30, 0x70, 0x01,
  0xFF, 0xE0, 0x0C, 0x18, 0x00, 0xF0, 0x38, 0x03, 0x8E, 0x00, 0x78, 0x0E,
  0x00, 0xE3, 0x80, 0x1C, 0x03, 0x80, 0x38, 0xE0, 0x0E, 0x00, 0xE0, 0x06,
  0x70, 0x03, 0x80, 0x38, 0x01, 0x9C, 0x01, 0xC0, 0x0E, 0x00, 0x67, 0x00,
  0x70, 0x03, 0x80, 0x19, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x70, 0x0E, 0x00,
  0x38, 0x01, 0x9C, 0x03, 0x80, 0x0E, 0x00, 0x66, 0x00, 0xE0, 0x03, 0x80,
  0x19, 0x80, 0x38, 0x00, 0xC0, 0x06, 0x60, 0x0E, 0x00, 0x30, 0x01, 0x98,
  0x03, 0x80, 0x0C, 0x00, 0x66, 0x00, 0xE0, 0x07, 0x00, 0x19, 0x80, 0x30,
  0x01, 0xC0, 0x0E, 0x60, 0x0C, 0x00, 0x70, 0x03, 0x98, 0x03, 0x80, 0x1C,
  0x00, 0xC7, 0x00, 0xE0, 0x07, 0x00, 0x31, 0xC0, 0x38, 0x03, 0xC0, 0x1C,
  0x70, 0x0E, 0x00, 0xF0, 0x06, 0x1C, 0x03, 0x80, 0x6C, 0x03, 0x87, 0x00,
  0x70, 0x3B, 0x81, 0xC0, 0xC0, 0x1F, 0x3C, 0xF0, 0xF0, 0x38, 0x03, 0xFE,
  0x1F, 0xF8, 0x0E, 0x00, 0x7F, 0x03, 0xFC, 0x03, 0x80, 0x0F, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x60, 0x00,
  0x00, 0x7E, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x07, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x70, 0x1E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x70,
  0x01, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x78, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xF0, 0x03, 0xF8, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x78, 0xF0, 0x03, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x7C, 0xF0, 0x01, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFC, 0x03, 0xF0, 0x3E, 0x00,
  0x1F, 0x07, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x39, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0x70, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x3F, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x40,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xC0,
  0x1F, 0xE0, 0xF0, 0x00, 0xFC, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x07,
  0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00,
  0x1E, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0xC3, 0xC0, 0x1F, 0xC0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x01, 0xF0,
  0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x3E, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x77,
  0x00, 0x03, 0xDC, 0x00, 0x0F, 0x78, 0x00, 0x39, 0xE0, 0x01, 0xE3, 0xC0,
  0x0F, 0x07, 0xC0, 0x7C, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x04, 0x00, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x3C, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x01, 0xE0,
  0x3C, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0x7F,
  0x00, 0x01, 0xEF, 0xF0, 0x00, 0x3F, 0xDE, 0x00, 0x07, 0xF1, 0xE0, 0x00,
  0xFC, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x78, 0x07,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x07,
  0x80, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01,
  0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFB, 0x80, 0x00, 0x01, 0xFF, 0x70, 0x00, 0x00, 0x7F, 0xEF, 0x00, 0x00,
  0x0E, 0xFC, 0xE0, 0x00, 0x01, 0xDF, 0x9C, 0x00, 0x00, 0x7B, 0xF3, 0xC0,
  0x00, 0x0E, 0x7E, 0x38, 0x00, 0x01, 0xCF, 0xC7, 0x00, 0x00, 0x79, 0xF8,
  0xF0, 0x00, 0x0E, 0x3F, 0x0E, 0x00, 0x01, 0xC7, 0xE1, 0xC0, 0x00, 0x78,
  0xFC, 0x3C, 0x00, 0x0E, 0x1F, 0x83, 0x80, 0x03, 0xC3, 0xF8, 0x70, 0x00,
  0x70, 0x7F, 0x0F, 0x00, 0x0E, 0x0F, 0xE0, 0xE0, 0x03, 0xC1, 0xFC, 0x1C,
  0x00, 0x70, 0x3F, 0x81, 0xC0, 0x0E, 0x07, 0xF0, 0x38, 0x03, 0xC0, 0xFE,
  0x07, 0x00, 0x70, 0x1F, 0xC0, 0x70, 0x0E, 0x03, 0xF8, 0x0E, 0x03, 0xC0,
  0x7F, 0x01, 0xE0, 0x70, 0x0F, 0xE0, 0x1C, 0x0E, 0x01, 0xFC, 0x03, 0x83,
  0xC0, 0x3F, 0x80, 0x78, 0x70, 0x07, 0xF0, 0x07, 0x0E, 0x00, 0xFE, 0x00,
  0xE3, 0x80, 0x1F, 0xC0, 0x1E, 0x70, 0x03, 0xF8, 0x01, 0xCE, 0x00, 0x7F,
  0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0x80, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x1E,
  0x00, 0x1F, 0xC0, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF7, 0x00,
  0x00, 0xFE, 0xF0, 0x00, 0x1F, 0xCE, 0x00, 0x03, 0xF9, 0xE0, 0x00, 0x7F,
  0x1E, 0x00, 0x0F, 0xE1, 0xC0, 0x01, 0xFC, 0x3C, 0x00, 0x3F, 0x83, 0x80,
  0x07, 0xF0, 0x78, 0x00, 0xFE, 0x07, 0x00, 0x1F, 0xC0, 0xF0, 0x03, 0xF8,
  0x0E, 0x00, 0x7F, 0x01, 0xE0, 0x0F, 0xE0, 0x1E, 0x01, 0xFC, 0x01, 0xC0,
  0x3F, 0x80, 0x3C, 0x07, 0xF0, 0x03, 0x80, 0xFE, 0x00, 0x78, 0x1F, 0xC0,
  0x07, 0x03, 0xF8, 0x00, 0xF0, 0x7F, 0x00, 0x0F, 0x0F, 0xE0, 0x01, 0xE1,
  0xFC, 0x00, 0x1E, 0x3F, 0x80, 0x01, 0xC7, 0xF0, 0x00, 0x3C, 0xFE, 0x00,
  0x03, 0x9F, 0xC0, 0x00, 0x7B, 0xF8, 0x00, 0x07, 0x7F, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xC0, 0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x3C, 0x38, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1E, 0x00, 0x3F, 0x8F,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xDE, 0x00,
  0x01, 0xEF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xF3, 0xC0, 0x07, 0xF1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x3E,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0x1E, 0x70, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x04, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x03, 0xC0, 0x07, 0xE0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x8F,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x3C, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x0F, 0x3C,
  0x00, 0x03, 0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x7C,
  0x3C, 0x00, 0x7E, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0xF0,
  0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0,
  0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x1C, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3C,
  0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x1F, 0x80, 0x7E, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xE0,
  0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03,
  0xDE, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x1F, 0x80,
  0x3E, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0x7E, 0x00, 0xF8, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x70, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x70, 0x07,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xE0,
  0x00, 0x3D, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x80, 0x00,
  0xE7, 0x80, 0x01, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0x8E,
  0x00, 0x07, 0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xDC, 0x00, 0x1E, 0x38, 0x00,
  0x3B, 0x80, 0x03, 0x87, 0x80, 0x07, 0x38, 0x00, 0x70, 0xF0, 0x00, 0xE7,
  0x00, 0x0E, 0x0E, 0x00, 0x38, 0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x1C, 0x00,
  0x70, 0x38, 0x00, 0xE1, 0xC0, 0x0E, 0x07, 0x80, 0x1C, 0x38, 0x01, 0xC0,
  0xF0, 0x07, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0xE0, 0x0F, 0x01, 0xC0,
  0x1C, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x81, 0xC0, 0x38, 0x07, 0x80, 0xE0,
  0x38, 0x07, 0x00, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x0E, 0x03, 0x80, 0x60,
  0x3C, 0x01, 0xC0, 0x70, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0xE0,
  0x07, 0x83, 0x80, 0x38, 0x1C, 0x00, 0x70, 0x70, 0x07, 0x07, 0x80, 0x0E,
  0x0E, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x3C, 0x70,
  0x01, 0xC3, 0x80, 0x07, 0x8E, 0x00, 0x38, 0x70, 0x00, 0x71, 0xC0, 0x03,
  0x9E, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x0E, 0x70,
  0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x03, 0xB8, 0x00, 0x19, 0xC0, 0x00,
  0x76, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x0F, 0x8F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x78, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x00, 0x78, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3B, 0x80, 0x1C, 0xE0, 0x07,
  0x38, 0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x39,
  0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0,
  0x38, 0x0F, 0x00, 0x10, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xF8, 0x1E, 0x01, 0xF0, 0xF0, 0x03, 0xC7, 0x80, 0x07, 0x9E, 0x00, 0x1E,
  0x70, 0x00, 0x39, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7C, 0x00, 0xE3, 0xC0, 0x03, 0x9E, 0x00, 0x0E, 0x70, 0x00, 0x39,
  0xC0, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0,
  0x01, 0xEF, 0x00, 0x07, 0x9C, 0x00, 0x3E, 0x78, 0x01, 0xF9, 0xF0, 0x1E,
  0xE3, 0xFF, 0xF3, 0x87, 0xFF, 0x8F, 0x0F, 0xF8, 0x3C, 0x03, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x0F, 0xF8, 0x3C, 0xFF, 0xF0, 0xF7, 0xFF, 0xE3, 0xFC,
  0x07, 0xCF, 0xC0, 0x0F, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x3B, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0E, 0xF8, 0x00, 0x7B, 0xF0, 0x03, 0xEF, 0xF0, 0x1F, 0x3D, 0xFF,
  0xF8, 0xF3, 0xFF, 0xC3, 0xC7, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0x01, 0xF0,
  0xF0, 0x01, 0xE3, 0x80, 0x07, 0x9E, 0x00, 0x0E, 0x70, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x80, 0x03,
  0x8E, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0x7C, 0x07, 0xC0, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x3F,
  0xE1, 0xC1, 0xFF, 0xE7, 0x1F, 0xFF, 0xDC, 0x7C, 0x07, 0x73, 0xC0, 0x07,
  0xCF, 0x00, 0x1F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xDC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x70,
  0x00, 0x1D, 0xC0, 0x00, 0x77, 0x80, 0x01, 0xDE, 0x00, 0x0F, 0x3C, 0x00,
  0x3C, 0xF0, 0x01, 0xF1, 0xF0, 0x1F, 0xC3, 0xFF, 0xF7, 0x07, 0xFF, 0x9C,
  0x0F, 0xF8, 0x70, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0x01, 0xF0, 0xF0, 0x01, 0xE3, 0x80,
  0x07, 0x9E, 0x00, 0x0E, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x04, 0x3E,
  0x00, 0x38, 0x7C, 0x01, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0x60, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFB,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x70, 0xFF, 0xF9, 0xC7, 0xFF,
  0xF7, 0x1F, 0x01, 0xDC, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0xDE, 0x00, 0x0F,
  0x78, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xE0,
  0x00, 0x77, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x7C, 0x7C, 0x07,
  0xF0, 0xFF, 0xFD, 0xC1, 0xFF, 0xE7, 0x03, 0xFE, 0x1C, 0x00, 0x80, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF1, 0x00,
  0x03, 0xC6, 0x00, 0x1E, 0x3C, 0x00, 0xF8, 0x7E, 0x0F, 0xC0, 0xFF, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x04, 0x03, 0xC3, 0xFE, 0x1E, 0x3F, 0xF8,
  0xF3, 0xFF, 0xE7, 0xB8, 0x0F, 0xBF, 0x80, 0x3D, 0xF8, 0x00, 0xEF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1C, 0x77, 0xBF, 0xF7, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0, 0x01,
  0xC0, 0x78, 0x0F, 0x81, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x03, 0xC8, 0xF9,
  0xFE, 0x3F, 0x87, 0xE0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x3C, 0x00, 0x78,
  0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0xF0,
  0x03, 0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0x3C, 0x00, 0xF8, 0x78, 0x03, 0xC1,
  0xE0, 0x0F, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x3C,
  0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x8F,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x04, 0x03, 0x83, 0xFE,
  0x01, 0xFF, 0x0F, 0x3F, 0xFC, 0x1F, 0xFE, 0x3D, 0xFF, 0xF8, 0xFF, 0xFC,
  0xFF, 0x01, 0xE7, 0x80, 0xFB, 0xF8, 0x03, 0xDC, 0x01, 0xEF, 0xC0, 0x07,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0xC0, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x0E,
  0x00, 0x07, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0xF0, 0x00, 0x38,
  0x00, 0x1F, 0xC0, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0x80, 0x01, 0xFC,
  0x00, 0x0E, 0x00, 0x07, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0xC0, 0x00, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0xF0,
  0x00, 0x38, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0x80,
  0x01, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0xC0,
  0x00, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x0E, 0x00,
  0x07, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x08, 0x07, 0x87, 0xFC, 0x3C,
  0x7F, 0xF1, 0xE7, 0xFF, 0xCF, 0x70, 0x1F, 0x7F, 0x00, 0x7B, 0xF0, 0x01,
  0xDF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x00, 0xF8,
  0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x78, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x78,
  0x1F, 0x00, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xC3, 0xFE, 0x0F, 0x3F, 0xFC, 0x3D,
  0xFF, 0xF8, 0xFF, 0x01, 0xF3, 0xF0, 0x03, 0xEF, 0x80, 0x07, 0xBC, 0x00,
  0x0E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xBE, 0x00, 0x1E, 0xFC, 0x00, 0xFB, 0xF8,
  0x07, 0xCF, 0x7F, 0xFE, 0x3C, 0xFF, 0xF0, 0xF1, 0xFF, 0x83, 0xC0, 0x60,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x70, 0xFF, 0xF9, 0xC7, 0xFF, 0xF7, 0x1F, 0x01, 0xFC, 0xF0, 0x01, 0xF3,
  0xC0, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xDC, 0x00,
  0x07, 0x70, 0x00, 0x1D, 0xE0, 0x00, 0x77, 0x80, 0x03, 0xCF, 0x00, 0x0F,
  0x3C, 0x00, 0x7C, 0x7C, 0x07, 0xF0, 0xFF, 0xFD, 0xC1, 0xFF, 0xE7, 0x03,
  0xFE, 0x1C, 0x00, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x07, 0x8F, 0xFC, 0xFF, 0xEF, 0xFF, 0xF0, 0x7F, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xE0, 0x3E, 0x1E, 0x00, 0x79, 0xE0, 0x03, 0xCE,
  0x00, 0x0E, 0x70, 0x00, 0x7B, 0x80, 0x03, 0xDE, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x80, 0x0F, 0x1F, 0x00, 0xF8,
  0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x30, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0x70, 0x00, 0x7B, 0x80, 0x03, 0xDE, 0x00, 0x3E, 0xF8, 0x03,
  0xF3, 0xE0, 0x3B, 0x8F, 0xFF, 0xDC, 0x7F, 0xFC, 0xE0, 0xFF, 0x87, 0x00,
  0x40, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xDC, 0x00,
  0x0E, 0x70, 0x00, 0x39, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x3C, 0x00, 0xF0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x78, 0x1E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0xE0, 0x07, 0x03,
  0x80, 0x1C, 0x0E, 0x00, 0x78, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xEF, 0x00,
  0x0F, 0x00, 0x0E, 0x70, 0x00, 0xF0, 0x00, 0xE7, 0x00, 0x1F, 0x00, 0x1E,
  0x78, 0x01, 0xF0, 0x01, 0xC7, 0x80, 0x1F, 0x80, 0x1C, 0x38, 0x01, 0xF8,
  0x01, 0xC3, 0x80, 0x3B, 0x80, 0x3C, 0x38, 0x03, 0xB8, 0x03, 0x83, 0xC0,
  0x39, 0xC0, 0x38, 0x1C, 0x03, 0x9C, 0x03, 0x81, 0xC0, 0x71, 0xC0, 0x38,
  0x1C, 0x07, 0x0E, 0x07, 0x01, 0xE0, 0x70, 0xE0, 0x70, 0x0E, 0x06, 0x0E,
  0x07, 0x00, 0xE0, 0xE0, 0xE0, 0x70, 0x0E, 0x0E, 0x07, 0x0F, 0x00, 0xF0,
  0xE0, 0x70, 0xE0, 0x07, 0x1C, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x70, 0xE0,
  0x07, 0x1C, 0x03, 0x9E, 0x00, 0x79, 0xC0, 0x39, 0xC0, 0x03, 0xB8, 0x03,
  0x9C, 0x00, 0x3B, 0x80, 0x19, 0xC0, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0x3B,
  0x80, 0x1F, 0x80, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x3D, 0xE0, 0x01, 0xE3,
  0x80, 0x07, 0x8F, 0x00, 0x3C, 0x1C, 0x00, 0xE0, 0x78, 0x07, 0x80, 0xF0,
  0x1C, 0x03, 0xC0, 0xF0, 0x07, 0x87, 0x80, 0x0E, 0x1E, 0x00, 0x3C, 0xF0,
  0x00, 0x73, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7B,
  0x80, 0x03, 0xCF, 0x00, 0x0E, 0x1C, 0x00, 0x78, 0x78, 0x01, 0xC0, 0xE0,
  0x0F, 0x03, 0xC0, 0x38, 0x07, 0x81, 0xE0, 0x1E, 0x0F, 0x00, 0x3C, 0x3C,
  0x00, 0x71, 0xE0, 0x01, 0xE7, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x03,
  0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x78,
  0x3C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0E, 0x00,
  0xE0, 0x1C, 0x01, 0xC0, 0x78, 0x03, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07,
  0x03, 0x80, 0x0F, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x3C,
  0xF0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x3C, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xE0, 0x1F,
  0x80, 0x3E, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x40, 0x01, 0xE0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x03, 0xC0, 0x02, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x07, 0x1F, 0xF8, 0x00, 0x73, 0xC7, 0xC0,
  0x07, 0x78, 0x1E, 0x00, 0x77, 0x00, 0xF0, 0x0E, 0x70, 0x07, 0x81, 0xEE,
  0x00, 0x3E, 0x3C, 0xE0, 0x01, 0xFF, 0xCE, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3E, 0x00,
};

const GFXglyph RobotoCondensed_Light61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 44, 13, 4, -43 },
  { 29, 10, 14, 18, 4, -46 },
  { 47, 28, 43, 31, 3, -43 },
  { 198, 23, 57, 30, 3, -50 },
  { 362, 33, 45, 39, 3, -44 },
  { 548, 29, 45, 33, 3, -44 },
  { 712, 3, 13, 10, 4, -46 },
  { 717, 12, 63, 18, 4, -49 },
  { 812, 13, 63, 18, 1, -49 },
  { 915, 24, 24, 26, 1, -43 },
  { 987, 25, 31, 30, 2, -36 },
  { 1084, 6, 14, 12, 2, -6 },
  { 1095, 12, 3, 16, 2, -21 },
  { 1100, 5, 6, 15, 4, -5 },
  { 1104, 18, 47, 22, 1, -43 },
  { 1210, 22, 45, 30, 4, -44 },
  { 1334, 13, 43, 30, 5, -43 },
  { 1404, 24, 44, 30, 3, -44 },
  { 1536, 23, 45, 30, 3, -44 },
  { 1666, 26, 43, 30, 2, -43 },
  { 1806, 22, 44, 30, 5, -43 },
  { 1927, 23, 44, 30, 4, -43 },
  { 2054, 24, 43, 30, 3, -43 },
  { 2183, 23, 45, 30, 3, -44 },
  { 2313, 23, 44, 30, 3, -44 },
  { 2440, 5, 33, 12, 4, -32 },
  { 2461, 7, 40, 11, 2, -32 },
  { 2496, 21, 25, 27, 2, -32 },
  { 2562, 21, 15, 29, 4, -28 },
  { 2602, 21, 25, 28, 4, -32 },
  { 2668, 19, 45, 25, 3, -44 },
  { 2775, 42, 56, 48, 3, -42 },
  { 3069, 31, 43, 33, 1, -43 },
  { 3236, 24, 43, 33, 5, -43 },
  { 3365, 27, 45, 34, 4, -44 },
  { 3517, 26, 43, 35, 5, -43 },
  { 3657, 23, 43, 30, 5, -43 },
  { 3781, 23, 43, 30, 5, -43 },
  { 3905, 28, 45, 36, 4, -44 },
  { 4063, 27, 43, 38, 5, -43 },
  { 4209, 3, 43, 15, 6, -43 },
  { 4226, 22, 44, 29, 2, -43 },
  { 4347, 27, 43, 33, 5, -43 },
  { 4493, 21, 43, 28, 5, -43 },
  { 4606, 35, 43, 46, 5, -43 },
  { 4795, 27, 43, 38, 5, -43 },
  { 4941, 28, 45, 36, 4, -44 },
  { 5099, 25, 43, 33, 5, -43 },
  { 5234, 28, 52, 36, 4, -44 },
  { 5416, 26, 43, 34, 5, -43 },
  { 5556, 26, 45, 32, 3, -44 },
  { 5703, 28, 43, 32, 2, -43 },
  { 5854, 25, 44, 35, 5, -43 },
  { 5992, 31, 43, 33, 1, -43 },
  { 6159, 43, 43, 47, 2, -43 },
  { 6391, 29, 43, 33, 2, -43 },
  { 6547, 30, 43, 32, 1, -43 },
  { 6709, 26, 43, 32, 3, -43 },
  { 6849, 8, 59, 14, 5, -50 },
  { 6908, 18, 47, 22, 2, -43 },
  { 7014, 8, 59, 14, 1, -50 },
  { 7073, 18, 22, 23, 2, -43 },
  { 7123, 22, 3, 24, 1, 0 },
  { 7132, 10, 8, 17, 3, -45 },
  { 7142, 22, 34, 29, 3, -33 },
  { 7236, 22, 47, 30, 4, -46 },
  { 7366, 22, 34, 28, 3, -33 },
  { 7460, 22, 47, 30, 3, -46 },
  { 7590, 22, 34, 28, 3, -33 },
  { 7684, 16, 47, 18, 2, -47 },
  { 7778, 22, 45, 30, 3, -33 },
  { 7902, 21, 46, 29, 4, -46 },
  { 8023, 5, 44, 13, 4, -44 },
  { 8051, 11, 56, 13, -2, -44 },
  { 8128, 22, 46, 26, 4, -46 },
  { 8255, 3, 46, 13, 5, -46 },
  { 8273, 38, 33, 47, 4, -33 },
  { 8430, 21, 33, 29, 4, -33 },
  { 8517, 24, 34, 30, 3, -33 },
  { 8619, 22, 45, 30, 4, -33 },
  { 8743, 22, 45, 30, 3, -33 },
  { 8867, 13, 33, 18, 4, -33 },
  { 8921, 21, 34, 27, 3, -33 },
  { 9011, 14, 41, 18, 1, -40 },
  { 9083, 21, 33, 29, 4, -32 },
  { 9170, 22, 32, 26, 2, -32 },
  { 9258, 36, 32, 40, 2, -32 },
  { 9402, 22, 32, 26, 2, -32 },
  { 9490, 23, 44, 26, 1, -32 },
  { 9617, 21, 32, 26, 3, -32 },
  { 9701, 15, 60, 18, 2, -48 },
  { 9814, 3, 51, 14, 5, -43 },
  { 9834, 15, 60, 18, 1, -48 },
  { 9947, 28, 11, 36, 4, -24 },
};

const GFXfont RobotoCondensed_Light61pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light61pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light61pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOCONDENSED_LIGHT61PT7B_H_
