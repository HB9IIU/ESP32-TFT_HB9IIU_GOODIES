#ifndef _ROBOTOCONDENSED_LIGHT12PT7B_H_
#define _ROBOTOCONDENSED_LIGHT12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xF4, 0x52, 0xBE, 0xA5, 0x2B, 0xF4, 0xA0, 0x26, 0x99,
  0x86, 0x19, 0x96, 0x20, 0xC2, 0xAB, 0x34, 0x20, 0xB5, 0x55, 0x0C, 0x64,
  0xA4, 0xC4, 0x56, 0x72, 0xE8, 0xE0, 0x5A, 0xAA, 0xA9, 0x40, 0x89, 0x12,
  0x49, 0x25, 0x28, 0x21, 0x1C, 0xA5, 0x00, 0x21, 0x09, 0xF2, 0x10, 0x80,
  0x58, 0xE0, 0x80, 0x11, 0x22, 0x24, 0x44, 0x88, 0x69, 0x99, 0x99, 0x99,
  0x60, 0x74, 0x92, 0x49, 0x20, 0x69, 0x91, 0x22, 0x48, 0xF0, 0xE9, 0x11,
  0x61, 0x19, 0xE0, 0x10, 0x42, 0x8A, 0x49, 0x2F, 0xC2, 0x08, 0xF8, 0x8E,
  0x11, 0x19, 0x60, 0x68, 0x8E, 0x99, 0x99, 0x60, 0xF8, 0x42, 0x21, 0x08,
  0x84, 0x20, 0x69, 0x99, 0x69, 0x99, 0xE0, 0x69, 0x99, 0x9F, 0x11, 0x60,
  0x84, 0x40, 0x16, 0x19, 0x30, 0xC1, 0x80, 0xF0, 0x0F, 0x86, 0x16, 0x80,
  0xF4, 0x92, 0x90, 0x40, 0x3C, 0x42, 0x81, 0x99, 0xA5, 0xA9, 0xA9, 0xB6,
  0x80, 0x80, 0x78, 0x10, 0x42, 0x8A, 0x49, 0xE4, 0x51, 0x84, 0xF4, 0x63,
  0x1F, 0x46, 0x31, 0xF0, 0x74, 0x63, 0x08, 0x42, 0x31, 0x70, 0xF4, 0x63,
  0x18, 0xC6, 0x31, 0xF0, 0xF8, 0x88, 0xF8, 0x88, 0xF0, 0xF8, 0x88, 0xF8,
  0x88, 0x80, 0x74, 0x63, 0x09, 0xC6, 0x31, 0x70, 0x8C, 0x63, 0x1F, 0xC6,
  0x31, 0x88, 0xFF, 0x80, 0x08, 0x42, 0x10, 0x84, 0x31, 0x70, 0x8C, 0xA9,
  0x4C, 0x52, 0x52, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x83, 0x07, 0x1E,
  0x3A, 0xB5, 0x6A, 0xC9, 0x92, 0x8C, 0x73, 0x5A, 0xCE, 0x71, 0x88, 0x74,
  0x63, 0x18, 0xC6, 0x31, 0x70, 0xF4, 0x63, 0x1F, 0x42, 0x10, 0x80, 0x74,
  0x63, 0x18, 0xC6, 0x31, 0x70, 0x40, 0xF4, 0x63, 0x1F, 0x4A, 0x51, 0x88,
  0x74, 0xA3, 0x06, 0x0A, 0x31, 0x70, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x70, 0x85, 0x14, 0x52, 0x48, 0xA3,
  0x0C, 0x10, 0x88, 0xA4, 0x53, 0x2A, 0xA5, 0x52, 0xA8, 0x8C, 0x44, 0x22,
  0x00, 0x45, 0x22, 0x8C, 0x10, 0xC2, 0x92, 0x44, 0x85, 0x24, 0x8A, 0x30,
  0x41, 0x04, 0x10, 0xF8, 0x84, 0x42, 0x22, 0x10, 0xF8, 0xEA, 0xAA, 0xAB,
  0x84, 0x44, 0x22, 0x22, 0x11, 0xD5, 0x55, 0x57, 0x26, 0x59, 0xF8, 0xA0,
  0xE1, 0x1F, 0x99, 0xF0, 0x88, 0xE9, 0x99, 0x99, 0xE0, 0xE9, 0x88, 0x89,
  0xE0, 0x11, 0xF9, 0x99, 0x99, 0xF0, 0xE9, 0x9F, 0x88, 0xF0, 0x34, 0xE4,
  0x44, 0x44, 0x40, 0xF9, 0x99, 0x99, 0xF1, 0xE0, 0x88, 0xE9, 0x99, 0x99,
  0x90, 0xBF, 0x80, 0x45, 0x55, 0x58, 0x88, 0x9A, 0xCC, 0xAA, 0x90, 0xFF,
  0x80, 0xEF, 0x26, 0x4C, 0x99, 0x32, 0x64, 0x80, 0xE9, 0x99, 0x99, 0x90,
  0x69, 0x99, 0x99, 0x60, 0xE9, 0x99, 0x99, 0xE8, 0x80, 0xF9, 0x99, 0x99,
  0xF1, 0x10, 0xEA, 0xA8, 0xE9, 0x86, 0x11, 0xE0, 0x5D, 0x24, 0x93, 0x99,
  0x99, 0x99, 0xF0, 0x8A, 0x54, 0xA5, 0x10, 0x80, 0x8A, 0xB5, 0x6A, 0xD6,
  0xA4, 0x89, 0x00, 0x4A, 0x88, 0x45, 0x2A, 0x20, 0x8A, 0x94, 0xA5, 0x10,
  0x84, 0x40, 0xF2, 0x24, 0x88, 0xF0, 0x25, 0x25, 0x92, 0x44, 0x80, 0xFF,
  0xE0, 0x89, 0x24, 0x52, 0x4A, 0x00, 0xEC, 0xC0,
};

const GFXglyph RobotoCondensed_Light12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 2, 3, 3, 1, -9 },
  { 4, 5, 9, 6, 1, -9 },
  { 10, 4, 11, 6, 1, -10 },
  { 16, 6, 9, 8, 1, -9 },
  { 23, 5, 9, 6, 1, -9 },
  { 29, 1, 3, 2, 1, -9 },
  { 30, 2, 13, 4, 1, -10 },
  { 34, 3, 13, 4, 0, -10 },
  { 39, 5, 5, 5, 0, -9 },
  { 43, 5, 7, 6, 0, -8 },
  { 48, 2, 3, 2, 0, -1 },
  { 49, 3, 1, 3, 0, -4 },
  { 50, 1, 1, 3, 1, -1 },
  { 51, 4, 10, 4, 0, -9 },
  { 56, 4, 9, 6, 1, -9 },
  { 61, 3, 9, 6, 1, -9 },
  { 65, 4, 9, 6, 1, -9 },
  { 70, 4, 9, 6, 1, -9 },
  { 75, 6, 9, 6, 0, -9 },
  { 82, 4, 9, 6, 1, -9 },
  { 87, 4, 9, 6, 1, -9 },
  { 92, 5, 9, 6, 0, -9 },
  { 98, 4, 9, 6, 1, -9 },
  { 103, 4, 9, 6, 1, -9 },
  { 108, 1, 6, 2, 1, -6 },
  { 109, 2, 8, 2, 0, -6 },
  { 111, 5, 5, 5, 0, -6 },
  { 115, 4, 4, 6, 1, -6 },
  { 117, 4, 5, 5, 1, -6 },
  { 120, 3, 9, 5, 1, -9 },
  { 124, 8, 11, 9, 1, -8 },
  { 135, 6, 9, 7, 0, -9 },
  { 142, 5, 9, 6, 1, -9 },
  { 148, 5, 9, 7, 1, -9 },
  { 154, 5, 9, 7, 1, -9 },
  { 160, 4, 9, 6, 1, -9 },
  { 165, 4, 9, 6, 1, -9 },
  { 170, 5, 9, 7, 1, -9 },
  { 176, 5, 9, 7, 1, -9 },
  { 182, 1, 9, 3, 1, -9 },
  { 184, 5, 9, 6, 0, -9 },
  { 190, 5, 9, 7, 1, -9 },
  { 196, 4, 9, 6, 1, -9 },
  { 201, 7, 9, 9, 1, -9 },
  { 209, 5, 9, 7, 1, -9 },
  { 215, 5, 9, 7, 1, -9 },
  { 221, 5, 9, 6, 1, -9 },
  { 227, 5, 10, 7, 1, -9 },
  { 234, 5, 9, 7, 1, -9 },
  { 240, 5, 9, 6, 1, -9 },
  { 246, 6, 9, 6, 0, -9 },
  { 253, 5, 9, 7, 1, -9 },
  { 259, 6, 9, 7, 0, -9 },
  { 266, 9, 9, 9, 0, -9 },
  { 277, 6, 9, 6, 0, -9 },
  { 284, 6, 9, 6, 0, -9 },
  { 291, 5, 9, 6, 1, -9 },
  { 297, 2, 12, 3, 1, -10 },
  { 300, 4, 10, 4, 0, -9 },
  { 305, 2, 12, 3, 0, -10 },
  { 308, 4, 4, 4, 0, -9 },
  { 310, 5, 1, 5, 0, 0 },
  { 311, 2, 2, 3, 1, -9 },
  { 312, 4, 7, 6, 1, -7 },
  { 316, 4, 9, 6, 1, -9 },
  { 321, 4, 7, 5, 1, -7 },
  { 325, 4, 9, 6, 1, -9 },
  { 330, 4, 7, 6, 1, -7 },
  { 334, 4, 9, 4, 0, -9 },
  { 339, 4, 9, 6, 1, -7 },
  { 344, 4, 9, 6, 1, -9 },
  { 349, 1, 9, 3, 1, -9 },
  { 351, 2, 11, 3, 0, -9 },
  { 354, 4, 9, 5, 1, -9 },
  { 359, 1, 9, 3, 1, -9 },
  { 361, 7, 7, 9, 1, -7 },
  { 368, 4, 7, 6, 1, -7 },
  { 372, 4, 7, 6, 1, -7 },
  { 376, 4, 9, 6, 1, -7 },
  { 381, 4, 9, 6, 1, -7 },
  { 386, 2, 7, 4, 1, -7 },
  { 388, 4, 7, 5, 1, -7 },
  { 392, 3, 8, 3, 0, -8 },
  { 395, 4, 7, 6, 1, -7 },
  { 399, 5, 7, 5, 0, -7 },
  { 404, 7, 7, 8, 0, -7 },
  { 411, 5, 7, 5, 0, -7 },
  { 416, 5, 9, 5, 0, -7 },
  { 422, 4, 7, 5, 1, -7 },
  { 426, 3, 11, 4, 0, -9 },
  { 431, 1, 11, 3, 1, -9 },
  { 433, 3, 11, 4, 0, -9 },
  { 438, 5, 2, 7, 1, -4 },
};

const GFXfont RobotoCondensed_Light12pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light12pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _ROBOTOCONDENSED_LIGHT12PT7B_H_
