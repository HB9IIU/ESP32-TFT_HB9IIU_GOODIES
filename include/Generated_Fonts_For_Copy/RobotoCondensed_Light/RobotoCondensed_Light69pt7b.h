#ifndef _ROBOTOCONDENSED_LIGHT69PT7B_H_
#define _ROBOTOCONDENSED_LIGHT69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light69pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3B, 0xFF, 0xFB, 0x80, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C,
  0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x38, 0x07, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xF0,
  0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x78, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x03,
  0xF8, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79,
  0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0E, 0x78, 0x00,
  0x07, 0x9E, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x3F,
  0x00, 0x3F, 0x07, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0x80, 0x38, 0x00, 0x40, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x1E, 0x00, 0x70, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x1C, 0x0F, 0x00, 0x1C,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0x0F, 0x07, 0x80, 0x07, 0x80, 0x70, 0x38,
  0x00, 0x1C, 0x07, 0x83, 0x80, 0x00, 0xF0, 0x78, 0x1C, 0x00, 0x03, 0xFF,
  0xC1, 0xC0, 0x00, 0x0F, 0xFC, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x07, 0xF0, 0x00, 0x00, 0xE0, 0x7F, 0xC0, 0x00, 0x0E, 0x07,
  0xFF, 0x00, 0x00, 0xF0, 0x78, 0x3C, 0x00, 0x07, 0x07, 0x80, 0xE0, 0x00,
  0x78, 0x38, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x1C, 0x00, 0x3C, 0x0E, 0x00,
  0xE0, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x38, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x38,
  0x07, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x1E, 0x03, 0x80, 0x0E,
  0x00, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x40, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x1F,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x3E, 0x07, 0x80, 0x3C, 0x3C, 0x07,
  0xC0, 0x3C, 0x78, 0x03, 0xC0, 0x38, 0x78, 0x01, 0xE0, 0x38, 0xF0, 0x01,
  0xF0, 0x38, 0xF0, 0x00, 0xF8, 0x78, 0xF0, 0x00, 0x78, 0x78, 0xF0, 0x00,
  0x3C, 0x70, 0xE0, 0x00, 0x3E, 0xF0, 0xF0, 0x00, 0x1E, 0xF0, 0xF0, 0x00,
  0x0F, 0xE0, 0xF0, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xF0, 0x3E, 0x00,
  0x3F, 0xF8, 0x1F, 0x80, 0xFE, 0x78, 0x0F, 0xFF, 0xF8, 0x7C, 0x07, 0xFF,
  0xF0, 0x3E, 0x03, 0xFF, 0xC0, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0xE0, 0x00, 0x08, 0x00, 0x60, 0x03, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x60, 0x00, 0x80, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x01,
  0xC0, 0x3F, 0xF8, 0x38, 0x1F, 0xFF, 0xC7, 0x1F, 0xF3, 0xFF, 0xEF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x3E, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x01, 0xE0, 0x03, 0xE0, 0x1C, 0x00, 0x38, 0x01,
  0x00, 0x04, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x78, 0xF1, 0xE7, 0x9F, 0x3C, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x73, 0xEF, 0xFF, 0xF9, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xC0, 0xFC, 0x07,
  0xC0, 0x0F, 0x01, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F,
  0x0E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x78, 0x00,
  0x07, 0x9C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x7C, 0x03, 0xF8, 0x1F,
  0xF0, 0xFF, 0xEF, 0xFB, 0xFF, 0xC7, 0xFE, 0x0F, 0xE0, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0x7C, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x3C, 0x78, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0F,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x39, 0xE0, 0x00, 0x0E, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0F,
  0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x38, 0xF0, 0x00,
  0x1E, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x70, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x0F, 0xE0, 0x07, 0xBF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0xFC, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07,
  0xBC, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0xC0, 0x03, 0xC1, 0xF0, 0x03,
  0xE0, 0x7C, 0x07, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x07, 0xF0, 0x07, 0x8F, 0xFF, 0x01, 0xE7, 0xFF, 0xE0, 0x73, 0xFF,
  0xFC, 0x1D, 0xF0, 0x1F, 0x87, 0xF0, 0x01, 0xE3, 0xF8, 0x00, 0x3C, 0xFC,
  0x00, 0x0F, 0x3E, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x0E,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x39,
  0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0x80, 0xFC, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x7C,
  0x7C, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x79, 0xE0, 0x00,
  0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0,
  0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xF0,
  0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F,
  0x0F, 0x80, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x1F, 0x80,
  0xF8, 0x03, 0xE0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E,
  0x3C, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x07, 0xE7, 0x80, 0x07, 0xF3,
  0xE0, 0x07, 0xF8, 0xF8, 0x07, 0xBC, 0x3F, 0xFF, 0x9E, 0x0F, 0xFF, 0x8F,
  0x03, 0xFF, 0x87, 0x80, 0x7F, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x39, 0xF7, 0xDF,
  0x7C, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x7F, 0xFF, 0xDF,
  0x38, 0x1E, 0x3E, 0x3F, 0x3F, 0x1E, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0x70, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x03, 0xF0, 0xF0, 0x07,
  0xC7, 0xC0, 0x0F, 0x9E, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xEF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0xFC, 0x00,
  0x0C, 0x1C, 0x00, 0x0F, 0xFC, 0x00, 0x38, 0x70, 0x00, 0x7F, 0xF8, 0x00,
  0xE3, 0xC0, 0x03, 0xE1, 0xF0, 0x03, 0x8E, 0x00, 0x1E, 0x01, 0xE0, 0x06,
  0x38, 0x00, 0xF0, 0x07, 0x00, 0x1D, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x77,
  0x00, 0x1E, 0x00, 0x70, 0x01, 0xDC, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x70,
  0x03, 0xC0, 0x07, 0x00, 0x1D, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x77, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x07,
  0x80, 0x07, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x70,
  0x00, 0x70, 0x01, 0xF8, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0x00,
  0x0F, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x38, 0x00, 0x7E, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xF8, 0x03, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x0F, 0x00, 0x0E,
  0x00, 0x1F, 0x80, 0x3C, 0x00, 0x38, 0x00, 0xEE, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xB8, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0xF0, 0x07, 0x00, 0x1E, 0x00,
  0x71, 0xC0, 0x1C, 0x00, 0xF8, 0x01, 0xC7, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x1C, 0x01, 0xE0, 0x1F, 0xC0, 0x38, 0x70, 0x03, 0xC0, 0xE7, 0x81, 0xC1,
  0xE0, 0x0F, 0xFF, 0x1F, 0x1F, 0x03, 0x80, 0x1F, 0xF8, 0x3F, 0xF8, 0x0E,
  0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x04, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xF0, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x78, 0x70, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x0F, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0xE1,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x1E, 0x00, 0x0F, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x7D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x1F, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xF1, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E,
  0x1E, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x3E, 0x0F, 0x00, 0x07, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x7C, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x78, 0xF8, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x01,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0x7C, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x07,
  0xC1, 0xFC, 0x0F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x3C, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x7C,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x03,
  0xC7, 0xC0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x3C, 0xFE, 0x00, 0x00, 0xF7,
  0xFC, 0x00, 0x03, 0xFE, 0xF8, 0x00, 0x0F, 0xF3, 0xE0, 0x00, 0x3F, 0x87,
  0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xEE,
  0x00, 0x00, 0x00, 0xFF, 0xEF, 0x00, 0x00, 0x00, 0xFF, 0xEF, 0x00, 0x00,
  0x01, 0xEF, 0xE7, 0x80, 0x00, 0x01, 0xEF, 0xE7, 0x80, 0x00, 0x01, 0xCF,
  0xE7, 0x80, 0x00, 0x03, 0xCF, 0xE3, 0xC0, 0x00, 0x03, 0xCF, 0xE3, 0xC0,
  0x00, 0x03, 0x8F, 0xF3, 0xC0, 0x00, 0x07, 0x8F, 0xF1, 0xE0, 0x00, 0x07,
  0x8F, 0xF1, 0xE0, 0x00, 0x07, 0x0F, 0xF0, 0xE0, 0x00, 0x0F, 0x0F, 0xF0,
  0xF0, 0x00, 0x0F, 0x0F, 0xF0, 0xF0, 0x00, 0x0E, 0x0F, 0xF0, 0x70, 0x00,
  0x1E, 0x0F, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0xF0, 0x78, 0x00, 0x1C, 0x0F,
  0xF0, 0x38, 0x00, 0x3C, 0x0F, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0xF0, 0x3C,
  0x00, 0x78, 0x0F, 0xF0, 0x1C, 0x00, 0x78, 0x0F, 0xF0, 0x1E, 0x00, 0x70,
  0x0F, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0xF0, 0x0E, 0x00, 0xF0, 0x0F, 0xF0,
  0x0F, 0x00, 0xE0, 0x0F, 0xF0, 0x0F, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x01,
  0xE0, 0x0F, 0xF0, 0x07, 0x81, 0xC0, 0x0F, 0xF0, 0x03, 0x83, 0xC0, 0x0F,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0xF0, 0x03, 0xC3, 0x80, 0x0F, 0xF0, 0x01,
  0xC7, 0x80, 0x0F, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0xF0, 0x01, 0xE7, 0x00,
  0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0xF0, 0x00, 0x38, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xEF, 0x00, 0x00, 0x3F, 0xCF, 0x00, 0x00, 0x7F,
  0x9E, 0x00, 0x00, 0xFF, 0x1E, 0x00, 0x01, 0xFE, 0x3C, 0x00, 0x03, 0xFC,
  0x3C, 0x00, 0x07, 0xF8, 0x78, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x1F, 0xE0,
  0xF0, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0xFF, 0x01,
  0xE0, 0x01, 0xFE, 0x01, 0xE0, 0x03, 0xFC, 0x03, 0xC0, 0x07, 0xF8, 0x03,
  0xC0, 0x0F, 0xF0, 0x07, 0x80, 0x1F, 0xE0, 0x07, 0x80, 0x3F, 0xC0, 0x0F,
  0x00, 0x7F, 0x80, 0x0F, 0x00, 0xFF, 0x00, 0x1F, 0x01, 0xFE, 0x00, 0x1E,
  0x03, 0xFC, 0x00, 0x1E, 0x07, 0xF8, 0x00, 0x3C, 0x0F, 0xF0, 0x00, 0x3C,
  0x1F, 0xE0, 0x00, 0x78, 0x3F, 0xC0, 0x00, 0x78, 0x7F, 0x80, 0x00, 0xF0,
  0xFF, 0x00, 0x00, 0xF1, 0xFE, 0x00, 0x01, 0xE3, 0xFC, 0x00, 0x01, 0xE7,
  0xF8, 0x00, 0x01, 0xEF, 0xF0, 0x00, 0x03, 0xDF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x07,
  0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3E,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x78, 0x0F,
  0x80, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0xFC,
  0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x07,
  0xF8, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x07,
  0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x1E, 0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x3F, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0x78, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x78, 0x07, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3C,
  0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3E, 0x3C,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x3E, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3E, 0x1F, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x1F, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0x38, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x78, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0xE0, 0x00,
  0x1C, 0x3C, 0x00, 0x07, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x9C, 0x00,
  0x0F, 0x07, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE7, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x71, 0xE0,
  0x01, 0xE0, 0x38, 0x00, 0x38, 0x70, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x38,
  0x00, 0x78, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0E, 0x0F,
  0x00, 0x1C, 0x03, 0xC0, 0x07, 0x03, 0x80, 0x1E, 0x00, 0xE0, 0x07, 0x81,
  0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x0F, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x01, 0xE0, 0x38,
  0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0x78, 0x1E,
  0x00, 0x70, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x07,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0x80, 0x07, 0x07, 0x80, 0x03, 0xC3,
  0xC0, 0x03, 0x83, 0x80, 0x01, 0xE1, 0xE0, 0x01, 0xC1, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x38, 0xF0, 0x00, 0x1E,
  0x78, 0x00, 0x1C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x9C, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x77, 0x80, 0x00, 0x77, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0xC0,
  0x01, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x0F, 0x1F, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x07, 0xC0,
  0x00, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x80,
  0x00, 0x7C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F,
  0x00, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xEE, 0x00, 0x1D, 0xE0, 0x07, 0x9C, 0x00, 0xE3, 0x80, 0x1C, 0x78, 0x07,
  0x87, 0x00, 0xE0, 0xE0, 0x1C, 0x1E, 0x07, 0x81, 0xC0, 0xE0, 0x38, 0x1C,
  0x07, 0x87, 0x80, 0xF0, 0xF0, 0x0E, 0x1C, 0x01, 0xE7, 0x80, 0x3C, 0xF0,
  0x03, 0x9C, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x03,
  0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x1F, 0x00, 0xFC, 0x3E, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E,
  0x70, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0, 0x0E,
  0x3E, 0x00, 0x0E, 0x7C, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7E,
  0xF8, 0x00, 0xEE, 0x7E, 0x03, 0xEF, 0x3F, 0xFF, 0xCF, 0x1F, 0xFF, 0x0F,
  0x0F, 0xFE, 0x0F, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0xF0, 0xFF, 0xE0, 0x79,
  0xFF, 0xF8, 0x3D, 0xFF, 0xFE, 0x1E, 0xF0, 0x1F, 0x8F, 0xE0, 0x03, 0xE7,
  0xE0, 0x00, 0xF3, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0x78, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0xF3, 0xF0, 0x00, 0x79, 0xFC, 0x00, 0x7C,
  0xFF, 0x80, 0xFC, 0x7B, 0xFF, 0xFC, 0x3C, 0xFF, 0xFC, 0x1E, 0x1F, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xF8, 0x07, 0xE0, 0xF8, 0x00, 0xF0, 0xF8,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x77, 0x80, 0x00, 0x79, 0xC0,
  0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x07,
  0xC0, 0x3F, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0xF8, 0x0F, 0x03, 0xFF, 0x87, 0x83, 0xFF, 0xE3, 0xC7,
  0xFF, 0xF9, 0xE3, 0xF0, 0x1E, 0xF3, 0xE0, 0x03, 0xF9, 0xE0, 0x00, 0xFD,
  0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xFB,
  0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x7F, 0x1F, 0x80, 0xF7,
  0x87, 0xFF, 0xF3, 0xC1, 0xFF, 0xF1, 0xE0, 0x7F, 0xF0, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x07, 0x81, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x0C, 0x1F, 0x00, 0x07,
  0x83, 0xF0, 0x07, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x07, 0xFC,
  0x03, 0xFF, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3,
  0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xC3, 0xC3,
  0xFF, 0xF1, 0xE3, 0xFF, 0xFC, 0xF1, 0xF8, 0x0F, 0x79, 0xF0, 0x01, 0xFD,
  0xF0, 0x00, 0x7E, 0xF0, 0x00, 0x3F, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x3F, 0x3E, 0x00, 0x3F,
  0x8F, 0xC0, 0x7B, 0xC3, 0xFF, 0xF9, 0xE0, 0xFF, 0xF8, 0xF0, 0x3F, 0xF8,
  0x78, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC2, 0x00, 0x01, 0xE1, 0x80,
  0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x80, 0xF0, 0x7F, 0xE1, 0xE3, 0xFF,
  0xE3, 0xCF, 0xFF, 0xE7, 0xBC, 0x07, 0xCF, 0xF0, 0x07, 0xDF, 0xC0, 0x07,
  0xBF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x70, 0xF7, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF0, 0x01, 0xE0,
  0x1F, 0x01, 0xF0, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3C, 0x07, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0xFC, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0,
  0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x80, 0xF0, 0x1F, 0x00,
  0xF0, 0x3E, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00,
  0xF1, 0xE0, 0x00, 0xF3, 0xE0, 0x00, 0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0xFE, 0xF0, 0x00, 0xFC, 0x78, 0x00, 0xF8, 0x7C, 0x00,
  0xF0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0,
  0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x7C,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x1C, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0x87, 0xFF,
  0xC0, 0xFF, 0xF8, 0x79, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0x78, 0x0F, 0x8F,
  0x81, 0xF9, 0xFC, 0x00, 0xFB, 0xC0, 0x0F, 0x3F, 0x00, 0x0F, 0x70, 0x00,
  0xF7, 0xE0, 0x00, 0xFC, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xDE,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x1F, 0x01, 0xE0, 0xFF, 0xC3,
  0xC7, 0xFF, 0xC7, 0x9F, 0xFF, 0xCF, 0x78, 0x0F, 0x9F, 0xE0, 0x0F, 0xBF,
  0x80, 0x0F, 0x7E, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xC0, 0x0F,
  0x83, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x9E, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0E,
  0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0xF0, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x78, 0x7F, 0xF0, 0x3C, 0xFF, 0xFC, 0x1E, 0xFF, 0xFF, 0x0F, 0xF8, 0x0F,
  0xC7, 0xF0, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xDE, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x79, 0xF8, 0x00,
  0x3C, 0xFE, 0x00, 0x3C, 0x7F, 0x80, 0x7E, 0x3D, 0xFF, 0xFE, 0x1E, 0x7F,
  0xFE, 0x0F, 0x0F, 0xFE, 0x07, 0x81, 0xF8, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xC3, 0xC3, 0xFF, 0xF1, 0xE3, 0xFF,
  0xFC, 0xF1, 0xF8, 0x0F, 0x79, 0xF0, 0x01, 0xFD, 0xF0, 0x00, 0x7E, 0xF0,
  0x00, 0x1F, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x7D, 0xE0,
  0x00, 0x3E, 0x78, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x8F, 0xC0, 0x7B, 0xC3,
  0xFF, 0xFD, 0xE0, 0xFF, 0xF8, 0xF0, 0x3F, 0xF8, 0x78, 0x03, 0xE0, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xC3, 0xFF, 0x3F, 0xFD, 0xFF,
  0xF7, 0xC3, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0x80,
  0xFC, 0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x38, 0x00,
  0x0F, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x7C, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xEF, 0x00, 0x07, 0xDE, 0x00, 0x1F, 0xBE, 0x00, 0x7F, 0x3F, 0x03,
  0xEE, 0x3F, 0xFF, 0x9C, 0x7F, 0xFE, 0x38, 0x3F, 0xF8, 0x70, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x1C, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xE0,
  0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x81, 0xE0, 0x01,
  0xC0, 0x78, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x03, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x1C, 0x01, 0xE0, 0x07, 0x80, 0x70, 0x01, 0xE0, 0x3C, 0x00,
  0x38, 0x0F, 0x00, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0x70, 0x78,
  0x00, 0x1C, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x38,
  0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x1D, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x78, 0x00, 0x3E, 0x00, 0x0E, 0x38,
  0x00, 0x7E, 0x00, 0x1E, 0x3C, 0x00, 0x7F, 0x00, 0x1E, 0x3C, 0x00, 0x77,
  0x00, 0x1E, 0x3C, 0x00, 0x77, 0x00, 0x1C, 0x1C, 0x00, 0xF7, 0x80, 0x3C,
  0x1E, 0x00, 0xE7, 0x80, 0x3C, 0x1E, 0x00, 0xE3, 0x80, 0x3C, 0x1E, 0x01,
  0xE3, 0x80, 0x38, 0x0E, 0x01, 0xE3, 0xC0, 0x38, 0x0F, 0x01, 0xC3, 0xC0,
  0x78, 0x0F, 0x01, 0xC1, 0xC0, 0x78, 0x0F, 0x03, 0xC1, 0xC0, 0x70, 0x07,
  0x03, 0x81, 0xE0, 0x70, 0x07, 0x83, 0x80, 0xE0, 0xF0, 0x07, 0x83, 0x80,
  0xE0, 0xF0, 0x07, 0x87, 0x80, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0xF0, 0xE0,
  0x03, 0x87, 0x00, 0x71, 0xE0, 0x03, 0xCF, 0x00, 0x71, 0xE0, 0x03, 0xCF,
  0x00, 0x79, 0xC0, 0x01, 0xCE, 0x00, 0x79, 0xC0, 0x01, 0xCE, 0x00, 0x39,
  0xC0, 0x01, 0xFE, 0x00, 0x3B, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x0F, 0x9F, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x1E,
  0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x01, 0xE0,
  0x07, 0x80, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x3C,
  0x00, 0x07, 0x8F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x0F, 0x00, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x0F, 0x01,
  0xE0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x1F, 0x1F, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0,
  0x00, 0x78, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x0E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x03, 0xC0,
  0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x70,
  0x03, 0xC0, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x1E,
  0x00, 0x0E, 0x0F, 0x00, 0x07, 0x87, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3,
  0xC0, 0x00, 0x79, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07,
  0x78, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xF0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x3C, 0x00, 0x08, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x1C, 0x7F, 0xF0, 0x00, 0x39, 0xFF, 0xF8, 0x00, 0x77,
  0xC1, 0xF8, 0x01, 0xEF, 0x01, 0xF8, 0x03, 0xFC, 0x01, 0xF8, 0x0F, 0x78,
  0x01, 0xF8, 0x3E, 0xE0, 0x01, 0xFF, 0xF9, 0xC0, 0x00, 0xFF, 0xE3, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_Light69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 50, 15, 5, -49 },
  { 33, 11, 15, 20, 5, -52 },
  { 54, 32, 49, 35, 3, -49 },
  { 250, 26, 64, 34, 4, -57 },
  { 458, 37, 51, 44, 4, -50 },
  { 694, 32, 51, 37, 4, -50 },
  { 898, 4, 15, 12, 4, -52 },
  { 906, 14, 71, 20, 5, -55 },
  { 1031, 14, 71, 20, 2, -55 },
  { 1156, 27, 28, 29, 1, -49 },
  { 1251, 28, 36, 34, 3, -41 },
  { 1377, 7, 16, 13, 2, -6 },
  { 1391, 14, 4, 18, 2, -24 },
  { 1398, 6, 6, 17, 5, -5 },
  { 1403, 21, 53, 25, 1, -49 },
  { 1543, 26, 51, 34, 4, -50 },
  { 1709, 15, 49, 34, 6, -49 },
  { 1801, 27, 50, 34, 4, -50 },
  { 1970, 26, 51, 34, 3, -50 },
  { 2136, 30, 49, 34, 2, -49 },
  { 2320, 25, 50, 34, 5, -49 },
  { 2477, 26, 50, 34, 4, -49 },
  { 2640, 27, 49, 34, 3, -49 },
  { 2806, 26, 51, 34, 4, -50 },
  { 2972, 25, 50, 34, 4, -50 },
  { 3129, 6, 37, 14, 4, -36 },
  { 3157, 8, 46, 13, 2, -36 },
  { 3203, 23, 29, 31, 3, -37 },
  { 3287, 24, 18, 33, 5, -32 },
  { 3341, 24, 29, 31, 4, -37 },
  { 3428, 22, 51, 28, 3, -50 },
  { 3569, 46, 63, 54, 4, -48 },
  { 3932, 34, 49, 38, 2, -49 },
  { 4141, 27, 49, 37, 6, -49 },
  { 4307, 30, 51, 39, 5, -50 },
  { 4499, 29, 49, 39, 6, -49 },
  { 4677, 26, 49, 34, 6, -49 },
  { 4837, 25, 49, 34, 6, -49 },
  { 4991, 31, 51, 41, 5, -50 },
  { 5189, 31, 49, 42, 6, -49 },
  { 5379, 4, 49, 17, 6, -49 },
  { 5404, 25, 50, 33, 3, -49 },
  { 5561, 30, 49, 38, 6, -49 },
  { 5745, 24, 49, 32, 6, -49 },
  { 5892, 40, 49, 52, 6, -49 },
  { 6137, 31, 49, 43, 6, -49 },
  { 6327, 32, 51, 41, 4, -50 },
  { 6531, 28, 49, 37, 6, -49 },
  { 6703, 32, 59, 41, 4, -50 },
  { 6939, 29, 49, 38, 6, -49 },
  { 7117, 30, 51, 36, 3, -50 },
  { 7309, 32, 49, 36, 2, -49 },
  { 7505, 29, 50, 39, 5, -49 },
  { 7687, 34, 49, 37, 2, -49 },
  { 7896, 49, 49, 53, 2, -49 },
  { 8197, 33, 49, 37, 2, -49 },
  { 8400, 34, 49, 36, 1, -49 },
  { 8609, 30, 49, 36, 3, -49 },
  { 8793, 10, 67, 16, 5, -56 },
  { 8877, 21, 53, 24, 2, -49 },
  { 9017, 9, 67, 16, 1, -56 },
  { 9093, 19, 25, 26, 3, -49 },
  { 9153, 25, 4, 27, 1, 0 },
  { 9166, 12, 9, 20, 3, -51 },
  { 9180, 24, 38, 33, 4, -37 },
  { 9294, 25, 53, 34, 5, -52 },
  { 9460, 25, 38, 31, 3, -37 },
  { 9579, 25, 53, 34, 4, -52 },
  { 9745, 26, 38, 32, 3, -37 },
  { 9869, 18, 53, 21, 2, -53 },
  { 9989, 25, 51, 34, 4, -37 },
  { 10149, 23, 52, 33, 5, -52 },
  { 10299, 5, 49, 15, 5, -49 },
  { 10330, 12, 63, 15, -2, -49 },
  { 10425, 24, 52, 30, 5, -52 },
  { 10581, 4, 52, 15, 5, -52 },
  { 10607, 43, 37, 53, 5, -37 },
  { 10806, 23, 37, 33, 5, -37 },
  { 10913, 26, 38, 34, 4, -37 },
  { 11037, 25, 51, 34, 5, -37 },
  { 11197, 25, 51, 34, 4, -37 },
  { 11357, 14, 37, 21, 5, -37 },
  { 11422, 24, 38, 31, 3, -37 },
  { 11536, 16, 47, 20, 1, -46 },
  { 11630, 23, 37, 33, 5, -36 },
  { 11737, 26, 36, 29, 2, -36 },
  { 11854, 40, 36, 45, 2, -36 },
  { 12034, 26, 36, 30, 2, -36 },
  { 12151, 25, 50, 29, 2, -36 },
  { 12308, 24, 36, 30, 3, -36 },
  { 12416, 17, 68, 21, 3, -54 },
  { 12561, 3, 58, 15, 6, -49 },
  { 12583, 17, 68, 21, 1, -54 },
  { 12728, 31, 12, 41, 5, -26 },
};

const GFXfont RobotoCondensed_Light69pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light69pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light69pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _ROBOTOCONDENSED_LIGHT69PT7B_H_
