#ifndef _ROBOTOCONDENSED_LIGHT23PT7B_H_
#define _ROBOTOCONDENSED_LIGHT23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF1, 0x80, 0xB6, 0xDA, 0x08, 0x81, 0x10, 0x22, 0x04, 0x40,
  0x88, 0xFF, 0xC4, 0x40, 0x88, 0x11, 0x02, 0x20, 0x44, 0x7F, 0xE2, 0x20,
  0x44, 0x08, 0x81, 0x10, 0x22, 0x00, 0x08, 0x04, 0x07, 0x84, 0x64, 0x12,
  0x0D, 0x02, 0x80, 0x60, 0x18, 0x07, 0x00, 0xE0, 0x10, 0x0F, 0x03, 0x81,
  0x41, 0xB1, 0x87, 0x81, 0x00, 0x80, 0x30, 0x02, 0x40, 0x21, 0x11, 0x09,
  0x88, 0x48, 0x42, 0x81, 0x24, 0x06, 0x40, 0x02, 0x00, 0x27, 0x01, 0x24,
  0x12, 0x20, 0x90, 0x88, 0x84, 0x44, 0x40, 0x12, 0x00, 0xE0, 0x1C, 0x06,
  0x40, 0x8C, 0x31, 0x86, 0x20, 0x4C, 0x0F, 0x00, 0xC0, 0x38, 0x0D, 0x89,
  0x11, 0x61, 0x2C, 0x3D, 0x83, 0x10, 0x63, 0x1E, 0x3E, 0x60, 0xFA, 0x80,
  0x13, 0x24, 0x4C, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8C, 0x44, 0x23, 0x10,
  0x88, 0x44, 0x22, 0x31, 0x11, 0x11, 0x11, 0x11, 0x32, 0x24, 0x48, 0x80,
  0x0C, 0x06, 0x02, 0x1D, 0x33, 0xE0, 0x60, 0x58, 0x66, 0x21, 0x00, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00,
  0x57, 0x80, 0xF0, 0xA0, 0x02, 0x04, 0x18, 0x20, 0x41, 0x82, 0x04, 0x08,
  0x20, 0x40, 0x82, 0x04, 0x08, 0x20, 0x40, 0x80, 0x1E, 0x11, 0x90, 0x48,
  0x24, 0x1E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x14, 0x1A, 0x09,
  0x04, 0x46, 0x1E, 0x00, 0x0B, 0xF2, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x3E, 0x31, 0x90, 0x58, 0x28, 0x18, 0x08, 0x04, 0x06,
  0x02, 0x03, 0x03, 0x01, 0x01, 0x01, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x1E,
  0x31, 0x90, 0x48, 0x2C, 0x18, 0x08, 0x04, 0x04, 0x1E, 0x01, 0x80, 0x40,
  0x38, 0x0E, 0x0D, 0x04, 0xC6, 0x1E, 0x00, 0x03, 0x01, 0xC0, 0x70, 0x3C,
  0x0B, 0x06, 0xC1, 0x30, 0xCC, 0x23, 0x18, 0xC4, 0x33, 0x0C, 0xFF, 0xC0,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x7F, 0x40, 0x40, 0x40, 0x40, 0xC0, 0xFC,
  0xC6, 0x03, 0x01, 0x01, 0x01, 0x81, 0x81, 0xC3, 0x66, 0x3C, 0x0E, 0x0C,
  0x0C, 0x04, 0x04, 0x02, 0x01, 0x78, 0xE6, 0xC1, 0x60, 0x70, 0x38, 0x14,
  0x0A, 0x0D, 0x84, 0x66, 0x1E, 0x00, 0xFF, 0x80, 0x40, 0x40, 0x20, 0x30,
  0x10, 0x08, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x80, 0x40, 0x60,
  0x20, 0x00, 0x1E, 0x31, 0x90, 0x48, 0x34, 0x1A, 0x0D, 0x04, 0x46, 0x1E,
  0x31, 0x90, 0x78, 0x1C, 0x0E, 0x05, 0x06, 0xC6, 0x3E, 0x00, 0x3C, 0x31,
  0x10, 0x58, 0x28, 0x1C, 0x0E, 0x07, 0x83, 0x41, 0xB1, 0xCF, 0x60, 0x20,
  0x10, 0x08, 0x08, 0x1C, 0x38, 0x00, 0x50, 0x00, 0x05, 0x70, 0x00, 0x05,
  0x78, 0x01, 0x06, 0x18, 0x60, 0x80, 0x60, 0x18, 0x06, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x60, 0x18, 0x06, 0x01, 0x06, 0x18, 0x60, 0x80,
  0x3C, 0xCF, 0x0C, 0x10, 0x20, 0x41, 0x82, 0x08, 0x30, 0x40, 0x80, 0x00,
  0x00, 0x08, 0x10, 0x03, 0xE0, 0x0C, 0x18, 0x18, 0x04, 0x30, 0x06, 0x20,
  0x02, 0x41, 0xC2, 0x42, 0x21, 0x46, 0x21, 0x44, 0x21, 0x84, 0x21, 0x84,
  0x21, 0x84, 0x21, 0x8C, 0x22, 0xC4, 0x62, 0x44, 0xA6, 0x43, 0x1C, 0x40,
  0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x20, 0x07, 0xC0, 0x04, 0x01, 0x80,
  0x28, 0x05, 0x01, 0xA0, 0x26, 0x04, 0x41, 0x88, 0x21, 0x84, 0x10, 0x82,
  0x3F, 0xC4, 0x0C, 0x80, 0xB0, 0x14, 0x03, 0x80, 0x20, 0xFE, 0x41, 0xA0,
  0x50, 0x28, 0x1C, 0x0A, 0x05, 0x06, 0xFE, 0x40, 0xA0, 0x70, 0x18, 0x0C,
  0x06, 0x07, 0x06, 0xFE, 0x00, 0x3E, 0x18, 0x6C, 0x0A, 0x03, 0x80, 0xE0,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0xE0, 0x3C, 0x09,
  0x86, 0x3E, 0x00, 0xFC, 0x20, 0xC8, 0x1A, 0x02, 0x80, 0xA0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xA0, 0x28, 0x1A, 0x1C, 0xFC,
  0x00, 0xFF, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x1E, 0x18, 0x6C, 0x0A, 0x03, 0x80, 0x60, 0x08, 0x02, 0x00,
  0x80, 0x21, 0xF8, 0x06, 0x01, 0x80, 0x70, 0x14, 0x0D, 0xC6, 0x1F, 0x00,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xFF, 0xE0,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0xFF, 0xFF,
  0x80, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x81, 0x81, 0xC3, 0x66, 0x3C, 0x80, 0xA0, 0x68, 0x32, 0x18, 0x84,
  0x23, 0x09, 0x82, 0xC0, 0xB8, 0x32, 0x0C, 0xC2, 0x18, 0x82, 0x20, 0xC8,
  0x1A, 0x02, 0x80, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x40, 0x7A, 0x02, 0xD0, 0x16, 0x41, 0xB2, 0x09, 0x90, 0x4C,
  0x46, 0x62, 0x23, 0x11, 0x18, 0x58, 0xC2, 0x86, 0x14, 0x30, 0x61, 0x82,
  0x08, 0xC0, 0x70, 0x1E, 0x06, 0x81, 0xB0, 0x64, 0x19, 0x86, 0x21, 0x8C,
  0x61, 0x18, 0x66, 0x09, 0x81, 0x60, 0x58, 0x0E, 0x03, 0x80, 0x40, 0x1F,
  0x06, 0x31, 0x81, 0x20, 0x34, 0x02, 0x80, 0x50, 0x0E, 0x01, 0xC0, 0x38,
  0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0xD8, 0x11, 0x8C, 0x1F, 0x00, 0xFE,
  0x41, 0xA0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x83, 0x7F, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x00, 0x1F, 0x06, 0x31, 0x81, 0x20,
  0x34, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x14,
  0x02, 0x80, 0xD8, 0x11, 0x8C, 0x1F, 0x80, 0x18, 0x01, 0x80, 0x10, 0xFE,
  0x20, 0xC8, 0x1A, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x06, 0x83, 0x3F, 0x88,
  0x62, 0x08, 0x83, 0x20, 0x48, 0x1A, 0x02, 0x80, 0xC0, 0x1E, 0x1C, 0x64,
  0x09, 0x03, 0xC0, 0x50, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x08, 0x03,
  0x80, 0x70, 0x14, 0x0D, 0xC6, 0x1F, 0x00, 0xFF, 0xC3, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x06, 0xC6, 0x3E,
  0x00, 0x80, 0x70, 0x0B, 0x01, 0x20, 0x24, 0x0C, 0xC1, 0x18, 0x21, 0x0C,
  0x21, 0x06, 0x20, 0x44, 0x09, 0x01, 0x20, 0x14, 0x03, 0x80, 0x60, 0x0C,
  0x00, 0x81, 0x81, 0x81, 0x83, 0xC1, 0x83, 0x41, 0x82, 0x42, 0xC2, 0x42,
  0x42, 0x42, 0x46, 0x62, 0x46, 0x26, 0x44, 0x24, 0x24, 0x24, 0x24, 0x24,
  0x2C, 0x3C, 0x28, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC0,
  0x48, 0x19, 0x82, 0x10, 0xC3, 0x10, 0x24, 0x06, 0x80, 0x60, 0x0C, 0x01,
  0xC0, 0x68, 0x09, 0x83, 0x10, 0x43, 0x18, 0x22, 0x06, 0xC0, 0x40, 0x40,
  0x26, 0x06, 0x20, 0x42, 0x04, 0x10, 0x81, 0x08, 0x19, 0x80, 0x90, 0x0F,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xFF, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C,
  0x02, 0x01, 0x00, 0x40, 0x20, 0x18, 0x04, 0x03, 0x00, 0xFF, 0xC0, 0xF2,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x38, 0x81, 0x03, 0x02, 0x04,
  0x0C, 0x08, 0x10, 0x30, 0x20, 0x40, 0xC0, 0x81, 0x02, 0x02, 0x04, 0x08,
  0xE4, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x78, 0x10, 0xC3, 0x8A,
  0x49, 0x3C, 0x61, 0xFF, 0x80, 0x46, 0x30, 0x3E, 0x63, 0x41, 0xC1, 0x01,
  0x3F, 0x61, 0xC1, 0x81, 0xC3, 0x47, 0x39, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xBC, 0xC6, 0x83, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0xC6,
  0xBC, 0x3E, 0x63, 0x41, 0xC1, 0x80, 0x80, 0x80, 0x80, 0xC1, 0x41, 0x63,
  0x3E, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0xF6, 0xC7, 0x41, 0xE0,
  0xF0, 0x70, 0x38, 0x1E, 0x0F, 0x06, 0x83, 0x63, 0x9E, 0xC0, 0x3E, 0x31,
  0x90, 0x58, 0x28, 0x1F, 0xFE, 0x01, 0x00, 0xC0, 0x20, 0x18, 0xC7, 0xC0,
  0x1C, 0xC2, 0x08, 0x61, 0x8F, 0x98, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x80, 0x3D, 0xB1, 0xD0, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x83, 0xC1,
  0xA0, 0xD8, 0xE7, 0xB0, 0x18, 0x09, 0x04, 0xC6, 0x3E, 0x00, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x2F, 0x73, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x04, 0xC7, 0xFF, 0x80, 0x11, 0x00, 0x01, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x3E, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x86, 0x8C,
  0x88, 0x90, 0xA0, 0xE0, 0xD0, 0x98, 0x88, 0x84, 0x86, 0x82, 0xFF, 0xFF,
  0xC0, 0xBC, 0x7B, 0x1A, 0x28, 0x30, 0xE0, 0xC1, 0x82, 0x06, 0x08, 0x18,
  0x20, 0x60, 0x81, 0x82, 0x06, 0x08, 0x18, 0x20, 0x60, 0x81, 0xBD, 0xCF,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x1E, 0x31, 0x90,
  0x78, 0x1C, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0xA0, 0xD8, 0xC3, 0xC0, 0xBC,
  0xC6, 0x83, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0xC6, 0xBC, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x3D, 0xB1, 0xD0, 0x78, 0x3C, 0x1C, 0x0E, 0x07,
  0x83, 0xC1, 0xA0, 0xD8, 0xE7, 0xB0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xBE, 0xC8, 0x88, 0x88, 0x88, 0x88, 0x3C, 0x62, 0x43, 0x41, 0x60, 0x38,
  0x0E, 0x03, 0x81, 0xC1, 0x63, 0x3C, 0x30, 0xC3, 0x3F, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC1, 0xC0, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x07, 0x1B, 0xD0, 0x81, 0x83, 0xC2, 0x42, 0x42, 0x64, 0x24,
  0x24, 0x28, 0x18, 0x18, 0x18, 0x82, 0x0C, 0x10, 0x71, 0xC6, 0x8A, 0x24,
  0x51, 0x26, 0x89, 0xA2, 0xC5, 0x14, 0x28, 0xA1, 0x87, 0x0C, 0x18, 0x20,
  0x80, 0xC3, 0x42, 0x66, 0x24, 0x38, 0x18, 0x18, 0x3C, 0x24, 0x66, 0x42,
  0x83, 0x81, 0x83, 0xC2, 0x42, 0x42, 0x64, 0x24, 0x24, 0x2C, 0x18, 0x18,
  0x18, 0x10, 0x10, 0x10, 0x20, 0xC0, 0xFF, 0x02, 0x06, 0x04, 0x0C, 0x18,
  0x10, 0x30, 0x20, 0x40, 0xC0, 0xFF, 0x08, 0x63, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x86, 0x30, 0x60, 0x82, 0x08, 0x20, 0x82, 0x08, 0x10, 0x60, 0x80,
  0xFF, 0xFF, 0xF0, 0xC1, 0x82, 0x0C, 0x10, 0x41, 0x04, 0x10, 0x41, 0x83,
  0x18, 0x41, 0x04, 0x10, 0x41, 0x0C, 0x21, 0x8C, 0x00, 0x70, 0x76, 0x18,
  0xCA, 0x0E,
};

const GFXglyph RobotoCondensed_Light23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 17, 5, 2, -17 },
  { 4, 3, 5, 7, 2, -17 },
  { 6, 11, 17, 12, 1, -17 },
  { 30, 9, 21, 11, 1, -19 },
  { 54, 13, 17, 15, 1, -17 },
  { 82, 11, 17, 12, 1, -17 },
  { 106, 2, 5, 4, 1, -17 },
  { 108, 4, 23, 7, 2, -18 },
  { 120, 4, 23, 7, 1, -18 },
  { 132, 9, 9, 10, 0, -17 },
  { 143, 9, 11, 11, 1, -13 },
  { 156, 2, 5, 4, 1, -2 },
  { 158, 4, 1, 6, 1, -8 },
  { 159, 2, 2, 6, 2, -2 },
  { 160, 7, 18, 8, 0, -17 },
  { 176, 9, 17, 11, 1, -17 },
  { 196, 5, 17, 11, 2, -17 },
  { 207, 9, 17, 11, 1, -17 },
  { 227, 9, 17, 11, 1, -17 },
  { 247, 10, 17, 11, 1, -17 },
  { 269, 8, 17, 11, 2, -17 },
  { 286, 9, 17, 11, 1, -17 },
  { 306, 9, 17, 11, 1, -17 },
  { 326, 9, 17, 11, 1, -17 },
  { 346, 9, 17, 11, 1, -17 },
  { 366, 2, 12, 5, 1, -12 },
  { 369, 2, 15, 4, 1, -12 },
  { 373, 8, 9, 10, 1, -12 },
  { 382, 8, 5, 11, 2, -10 },
  { 387, 8, 9, 10, 1, -12 },
  { 396, 7, 17, 9, 1, -17 },
  { 411, 16, 21, 18, 1, -16 },
  { 453, 11, 17, 13, 1, -17 },
  { 477, 9, 17, 12, 2, -17 },
  { 497, 10, 17, 13, 2, -17 },
  { 519, 10, 17, 13, 2, -17 },
  { 541, 9, 17, 11, 2, -17 },
  { 561, 8, 17, 11, 2, -17 },
  { 578, 10, 17, 14, 2, -17 },
  { 600, 10, 17, 14, 2, -17 },
  { 622, 1, 17, 6, 2, -17 },
  { 625, 8, 17, 11, 1, -17 },
  { 642, 10, 17, 13, 2, -17 },
  { 664, 8, 17, 11, 2, -17 },
  { 681, 13, 17, 17, 2, -17 },
  { 709, 10, 17, 14, 2, -17 },
  { 731, 11, 17, 14, 1, -17 },
  { 755, 9, 17, 12, 2, -17 },
  { 775, 11, 20, 14, 1, -17 },
  { 803, 10, 17, 13, 2, -17 },
  { 825, 10, 17, 12, 1, -17 },
  { 847, 10, 17, 12, 1, -17 },
  { 869, 9, 17, 13, 2, -17 },
  { 889, 11, 17, 12, 1, -17 },
  { 913, 16, 17, 18, 1, -17 },
  { 947, 11, 17, 12, 1, -17 },
  { 971, 12, 17, 12, 0, -17 },
  { 997, 10, 17, 12, 1, -17 },
  { 1019, 3, 23, 5, 2, -19 },
  { 1028, 7, 18, 8, 1, -17 },
  { 1044, 3, 23, 5, 0, -19 },
  { 1053, 6, 8, 9, 1, -17 },
  { 1059, 9, 1, 9, 0, 0 },
  { 1061, 4, 3, 7, 1, -17 },
  { 1063, 8, 12, 11, 1, -12 },
  { 1075, 8, 18, 11, 2, -18 },
  { 1093, 8, 12, 10, 1, -12 },
  { 1105, 9, 18, 11, 1, -18 },
  { 1126, 9, 12, 11, 1, -12 },
  { 1140, 6, 18, 7, 1, -18 },
  { 1154, 9, 17, 11, 1, -12 },
  { 1174, 7, 18, 11, 2, -18 },
  { 1190, 1, 17, 5, 2, -17 },
  { 1193, 4, 22, 5, -1, -17 },
  { 1204, 8, 18, 10, 2, -18 },
  { 1222, 1, 18, 5, 2, -18 },
  { 1225, 14, 12, 18, 2, -12 },
  { 1246, 7, 12, 11, 2, -12 },
  { 1257, 9, 12, 11, 1, -12 },
  { 1271, 8, 17, 11, 2, -12 },
  { 1288, 9, 17, 11, 1, -12 },
  { 1308, 4, 12, 7, 2, -12 },
  { 1314, 8, 12, 10, 1, -12 },
  { 1326, 6, 15, 7, 0, -15 },
  { 1338, 7, 12, 11, 2, -12 },
  { 1349, 8, 12, 10, 1, -12 },
  { 1361, 13, 12, 15, 1, -12 },
  { 1381, 8, 12, 10, 1, -12 },
  { 1393, 8, 17, 10, 1, -12 },
  { 1410, 8, 12, 10, 1, -12 },
  { 1422, 6, 23, 7, 1, -18 },
  { 1440, 1, 20, 5, 2, -17 },
  { 1443, 6, 23, 7, 0, -18 },
  { 1461, 10, 4, 14, 2, -9 },
};

const GFXfont RobotoCondensed_Light23pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light23pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light23pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _ROBOTOCONDENSED_LIGHT23PT7B_H_
