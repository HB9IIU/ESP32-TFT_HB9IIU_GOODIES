#ifndef _ROBOTOCONDENSED_LIGHT55PT7B_H_
#define _ROBOTOCONDENSED_LIGHT55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light55pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0x66, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xD8, 0x60, 0x00,
  0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x03, 0x00,
  0x07, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0xE0, 0x30, 0x00, 0x70, 0x18, 0x00, 0x38, 0x1C, 0x0F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x07, 0x01, 0x80, 0x03, 0x80,
  0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x60, 0x38, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x07, 0x00, 0x06,
  0x03, 0x80, 0x03, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xC0, 0x70, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x0E, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x07, 0x01, 0x80, 0x03, 0x80, 0xC0,
  0x01, 0xC0, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x60, 0x38, 0x00, 0x30, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xCF,
  0xC0, 0xF0, 0x1E, 0x0F, 0x00, 0x78, 0x70, 0x01, 0xC3, 0x80, 0x0F, 0x3C,
  0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03,
  0x8E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x78, 0x00,
  0xF1, 0xF0, 0x0F, 0x07, 0xF7, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x02,
  0x03, 0x80, 0xE0, 0x18, 0x18, 0x03, 0x01, 0xC0, 0xC0, 0x18, 0x0C, 0x06,
  0x00, 0xC0, 0xE0, 0x30, 0x06, 0x06, 0x01, 0x80, 0x30, 0x70, 0x0E, 0x03,
  0x83, 0x00, 0x70, 0x1C, 0x38, 0x01, 0x81, 0xC1, 0x80, 0x0E, 0x0E, 0x1C,
  0x00, 0x3F, 0xE0, 0xC0, 0x00, 0xFE, 0x0E, 0x00, 0x00, 0x80, 0xE0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0x81, 0xF8, 0x00, 0x1C, 0x3F, 0xE0, 0x00, 0xC1,
  0xC3, 0x80, 0x0E, 0x1C, 0x0E, 0x00, 0x60, 0xC0, 0x70, 0x07, 0x06, 0x01,
  0x80, 0x30, 0x70, 0x0C, 0x03, 0x83, 0x80, 0x60, 0x18, 0x1C, 0x03, 0x01,
  0xC0, 0xE0, 0x18, 0x0C, 0x07, 0x00, 0xC0, 0xE0, 0x18, 0x06, 0x06, 0x00,
  0xC0, 0x70, 0x10, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x78,
  0x00, 0x70, 0x78, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x79, 0xE0, 0x1C, 0x78, 0x78, 0x0E, 0x78,
  0x1C, 0x07, 0x38, 0x0F, 0x03, 0x9C, 0x03, 0xC1, 0x9C, 0x00, 0xF1, 0xCE,
  0x00, 0x38, 0xE7, 0x00, 0x1E, 0x73, 0x80, 0x07, 0xF1, 0xC0, 0x01, 0xF8,
  0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x1F, 0x0F, 0x00, 0x1F,
  0x83, 0xC0, 0x3F, 0xE0, 0xFC, 0x7E, 0x78, 0x3F, 0xFC, 0x1C, 0x0F, 0xFC,
  0x07, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x40,
  0x1C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80,
  0x30, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x40, 0x40, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07,
  0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x06,
  0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0x40, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x38, 0x0C, 0x0E, 0xFC, 0x30,
  0xFB, 0xFE, 0xDF, 0xE1, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x87, 0x00, 0x1C,
  0x1E, 0x00, 0xE0, 0x38, 0x07, 0x80, 0x70, 0x1C, 0x01, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x39, 0xCE,
  0x73, 0x9C, 0xEF, 0x77, 0xB8, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0x00, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xC0, 0x1F, 0x1F, 0x01, 0xE0, 0x3C, 0x1E, 0x00, 0xE0, 0xE0,
  0x03, 0x87, 0x00, 0x1C, 0x70, 0x00, 0xF3, 0x80, 0x03, 0x9C, 0x00, 0x1C,
  0xE0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x38,
  0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0xF1, 0xC0, 0x07,
  0x0E, 0x00, 0x38, 0x78, 0x03, 0x81, 0xE0, 0x3C, 0x07, 0xC7, 0xC0, 0x1F,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x20, 0x3C, 0x1F, 0x8F,
  0xF7, 0xFF, 0xF1, 0xF8, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0x1F, 0x03,
  0xC0, 0x3C, 0x3C, 0x00, 0xF1, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x00,
  0xF7, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xF8, 0xF8, 0x3C, 0x03, 0xC3, 0x80,
  0x1E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1F, 0xF0,
  0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0x70,
  0x00, 0xF7, 0x80, 0x0E, 0x3C, 0x01, 0xC1, 0xF8, 0xFC, 0x0F, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0x70, 0x00, 0x0E, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xC7,
  0x00, 0x03, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x70,
  0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x1C,
  0x00, 0xE0, 0x78, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x39, 0xFC, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xE0, 0x7C, 0x78, 0x03, 0xC1, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x38,
  0x01, 0xE3, 0xC0, 0x3C, 0x1F, 0x8F, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x02, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC3, 0xF0, 0x0E, 0x7F, 0xE0, 0x77, 0xFF, 0xC3, 0xF8,
  0x1E, 0x1F, 0x80, 0x78, 0xF0, 0x01, 0xEF, 0x80, 0x07, 0x78, 0x00, 0x3B,
  0xC0, 0x01, 0xDE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xDC, 0x00,
  0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x01, 0xEF,
  0x00, 0x0E, 0x38, 0x00, 0x71, 0xE0, 0x07, 0x87, 0x00, 0x38, 0x3E, 0x03,
  0xC0, 0xFC, 0x7C, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x02, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0x1F, 0x83, 0xE0, 0x3C,
  0x1C, 0x00, 0xF1, 0xE0, 0x03, 0x8E, 0x00, 0x1E, 0x70, 0x00, 0x73, 0x80,
  0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x39,
  0xE0, 0x03, 0x87, 0x00, 0x1C, 0x3C, 0x01, 0xC0, 0xF0, 0x3E, 0x03, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0x83, 0xE0, 0xF0, 0x07, 0x87,
  0x00, 0x1C, 0x70, 0x00, 0x73, 0x80, 0x03, 0xB8, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7B, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xF0, 0x01, 0xC3, 0xC0, 0x1E,
  0x0F, 0xC7, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0xF9, 0xF8, 0x3C, 0x07, 0x83,
  0x80, 0x3C, 0x78, 0x01, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xEE, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x77, 0x00,
  0x0F, 0x70, 0x00, 0xF7, 0x80, 0x1F, 0x3C, 0x03, 0xF3, 0xE0, 0x77, 0x1F,
  0xFE, 0x70, 0xFF, 0xC7, 0x03, 0xF0, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0xFC, 0x00, 0xEF, 0xFF, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0xFF, 0xF4, 0x39, 0xF7, 0xCE, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x73, 0xCE, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00,
  0x01, 0xC0, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x40, 0x01,
  0xFE, 0x00, 0xFF, 0xE0, 0x7C, 0xFC, 0x3C, 0x07, 0x1E, 0x01, 0xE7, 0x00,
  0x39, 0xC0, 0x0E, 0xF0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0xC0,
  0x70, 0x00, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x00, 0xC1, 0xC0, 0x03, 0xE0, 0x07, 0x1C, 0x00, 0x7F, 0xC0, 0x18, 0xE0,
  0x07, 0xFF, 0x00, 0xC6, 0x00, 0x70, 0x38, 0x06, 0x70, 0x07, 0x00, 0xC0,
  0x3B, 0x80, 0x30, 0x0E, 0x01, 0xDC, 0x03, 0x80, 0x70, 0x06, 0xC0, 0x18,
  0x03, 0x80, 0x36, 0x01, 0xC0, 0x1C, 0x01, 0xB0, 0x0E, 0x00, 0xE0, 0x0F,
  0x80, 0x60, 0x07, 0x00, 0x7C, 0x03, 0x00, 0x38, 0x03, 0xE0, 0x38, 0x01,
  0x80, 0x1F, 0x01, 0xC0, 0x0C, 0x00, 0xF8, 0x0E, 0x00, 0x60, 0x07, 0xC0,
  0x70, 0x03, 0x00, 0x7E, 0x03, 0x80, 0x18, 0x03, 0xF0, 0x1C, 0x01, 0xC0,
  0x1B, 0x80, 0xE0, 0x0E, 0x00, 0xDC, 0x07, 0x00, 0x70, 0x0E, 0x60, 0x38,
  0x07, 0x80, 0x63, 0x00, 0xE0, 0x3C, 0x07, 0x18, 0x07, 0x03, 0x70, 0x30,
  0xE0, 0x3C, 0x73, 0x83, 0x87, 0x00, 0xFF, 0x8F, 0xF8, 0x18, 0x03, 0xF0,
  0x3F, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x07, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03,
  0x80, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00,
  0x0E, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x3C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x70, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xC0,
  0x0F, 0x8E, 0x00, 0x1E, 0x70, 0x00, 0x7B, 0x80, 0x01, 0xDC, 0x00, 0x0E,
  0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00,
  0x07, 0x70, 0x00, 0x7B, 0x80, 0x03, 0x9C, 0x00, 0x3C, 0xE0, 0x07, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0E, 0x00, 0x3E, 0x70, 0x00,
  0x73, 0x80, 0x01, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xB8, 0x00, 0x3D, 0xC0,
  0x07, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xE7, 0xF0, 0x1F, 0x00,
  0x78, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00,
  0x0E, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1F, 0x00,
  0x78, 0x0F, 0xE7, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0x00, 0x3E,
  0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xEE, 0x00, 0x01,
  0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x79,
  0xC0, 0x01, 0xE3, 0x80, 0x07, 0x87, 0x00, 0x3E, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xE3, 0xF8, 0x1F, 0x00,
  0x7C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70, 0x00,
  0x0F, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x78, 0x00,
  0x07, 0x38, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x3E, 0x07, 0xF1, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x0C,
  0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0x70, 0x00, 0xE7,
  0x00, 0x0E, 0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x1F, 0x9F, 0x80, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x04, 0x00, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0x78, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0,
  0x03, 0xC0, 0xE0, 0x07, 0x80, 0xE0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1E, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0xF0, 0x00, 0xE0,
  0xF0, 0x00, 0xE1, 0xE0, 0x00, 0xE3, 0xC0, 0x00, 0xE7, 0x80, 0x00, 0xEF,
  0xC0, 0x00, 0xEF, 0xE0, 0x00, 0xFE, 0xE0, 0x00, 0xFC, 0xF0, 0x00, 0xF8,
  0x78, 0x00, 0xF0, 0x3C, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0xE0,
  0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0x78, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFB, 0x80, 0x00, 0x0F, 0xF7, 0x00,
  0x00, 0x1D, 0xEE, 0x00, 0x00, 0x3B, 0xEE, 0x00, 0x00, 0xE7, 0xDC, 0x00,
  0x01, 0xCF, 0xB8, 0x00, 0x03, 0x9F, 0x38, 0x00, 0x0E, 0x3E, 0x70, 0x00,
  0x1C, 0x7C, 0xE0, 0x00, 0x38, 0xF8, 0xE0, 0x00, 0xE1, 0xF1, 0xC0, 0x01,
  0xC7, 0xE3, 0x80, 0x03, 0x8F, 0xC3, 0x80, 0x0E, 0x1F, 0x87, 0x00, 0x1C,
  0x3F, 0x0E, 0x00, 0x38, 0x7E, 0x0E, 0x00, 0xE0, 0xFC, 0x1C, 0x01, 0xC1,
  0xF8, 0x18, 0x03, 0x83, 0xF0, 0x38, 0x0E, 0x07, 0xE0, 0x70, 0x1C, 0x0F,
  0xC0, 0x70, 0x30, 0x1F, 0x80, 0xE0, 0xE0, 0x3F, 0x01, 0xC1, 0xC0, 0x7E,
  0x01, 0xC3, 0x00, 0xFC, 0x03, 0x8E, 0x01, 0xF8, 0x07, 0x1C, 0x03, 0xF0,
  0x07, 0x70, 0x07, 0xE0, 0x0E, 0xE0, 0x0F, 0xC0, 0x1D, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x70, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xEE, 0x00, 0x07, 0xEE, 0x00, 0x07, 0xE7, 0x00,
  0x07, 0xE7, 0x80, 0x07, 0xE3, 0x80, 0x07, 0xE3, 0xC0, 0x07, 0xE1, 0xC0,
  0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0x70,
  0x07, 0xE0, 0x38, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1E,
  0x07, 0xE0, 0x0E, 0x07, 0xE0, 0x07, 0x07, 0xE0, 0x07, 0x07, 0xE0, 0x03,
  0x87, 0xE0, 0x03, 0x87, 0xE0, 0x01, 0xC7, 0xE0, 0x01, 0xE7, 0xE0, 0x00,
  0xE7, 0xE0, 0x00, 0xF7, 0xE0, 0x00, 0x77, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x01, 0xFE, 0xFE, 0x01, 0xF0, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0xE0,
  0x00, 0x78, 0xF0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0x3C,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x07, 0x81, 0xF0, 0x07, 0x80,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x38, 0x00, 0xFC,
  0xE0, 0x00, 0xF3, 0x80, 0x01, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3B,
  0x80, 0x01, 0xEE, 0x00, 0x0F, 0x38, 0x00, 0x7C, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xEF, 0xE0, 0x0F, 0x80, 0x3C, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x8F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x0F, 0x80,
  0x3C, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x08, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x10, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0x00, 0x1F, 0x0E, 0x00, 0x0F,
  0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C,
  0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x79, 0xC0,
  0x00, 0xE3, 0x80, 0x03, 0xC7, 0x00, 0x1F, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x0E,
  0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xF1, 0xC0, 0x00, 0xE3,
  0x80, 0x01, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x0F, 0xE3, 0xF8, 0x1F, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x78, 0x00, 0x0F, 0x38, 0x00, 0x0E,
  0x3C, 0x00, 0x1E, 0x1F, 0x00, 0x3C, 0x0F, 0xF3, 0xF8, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x38, 0xF0, 0x00,
  0xF1, 0xF0, 0x03, 0xC1, 0xFC, 0x7F, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0x08, 0x00, 0xF0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C,
  0x3C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x78, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x03,
  0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x78, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1F, 0xC0, 0x00, 0x70, 0x00, 0x3B, 0xC0, 0x01, 0xE0, 0x00, 0x73, 0x80,
  0x03, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0xC0, 0x01, 0xCE, 0x00, 0x0D, 0x80,
  0x07, 0x9C, 0x00, 0x3B, 0x00, 0x0E, 0x1C, 0x00, 0x77, 0x00, 0x1C, 0x38,
  0x00, 0xEE, 0x00, 0x38, 0x70, 0x01, 0x9C, 0x00, 0x70, 0xE0, 0x07, 0x18,
  0x01, 0xC1, 0xC0, 0x0E, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x70, 0x07, 0x03,
  0x80, 0x30, 0xE0, 0x0E, 0x07, 0x00, 0xE0, 0xC0, 0x1C, 0x0E, 0x01, 0xC1,
  0x80, 0x70, 0x1C, 0x03, 0x83, 0x80, 0xE0, 0x1C, 0x06, 0x07, 0x01, 0xC0,
  0x38, 0x1C, 0x06, 0x03, 0x80, 0x70, 0x38, 0x0C, 0x07, 0x00, 0xE0, 0x70,
  0x1C, 0x1C, 0x00, 0xC0, 0xC0, 0x38, 0x38, 0x01, 0xC1, 0x80, 0x30, 0x70,
  0x03, 0x87, 0x00, 0x60, 0xE0, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x0E, 0x18,
  0x01, 0xC7, 0x00, 0x0E, 0x30, 0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x03, 0x1C,
  0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0x73, 0x80, 0x0E, 0x60, 0x00, 0xE6,
  0x00, 0x1D, 0xC0, 0x00, 0xDC, 0x00, 0x1B, 0x80, 0x01, 0xF8, 0x00, 0x37,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x9E, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x07,
  0x80, 0x07, 0x00, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x01, 0xE0, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x01, 0xE1,
  0xC0, 0x00, 0x38, 0xF0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x0F,
  0x03, 0x80, 0x03, 0x80, 0xF0, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0E,
  0x1C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x80,
  0x03, 0xC0, 0x70, 0x00, 0x70, 0x0F, 0x00, 0x1E, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0xF0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x07, 0x80, 0x03, 0x80,
  0xE0, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xFF, 0xE0, 0x01,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x06,
  0x60, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x30, 0x1C, 0x38, 0x1C, 0x38, 0x1C,
  0x18, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x0C, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x06, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x01, 0xF0, 0xF8, 0x3C, 0x03, 0xC7, 0x80, 0x1C, 0x70,
  0x01, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x3C, 0x00, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xEF, 0x00,
  0x3E, 0x78, 0x0E, 0xE7, 0xF7, 0xEE, 0x3F, 0xFC, 0xE1, 0xFF, 0x0E, 0x01,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x02, 0x00, 0xE3, 0xFE, 0x0E, 0x7F,
  0xF0, 0xEF, 0x1F, 0x8F, 0xC0, 0x3C, 0xF8, 0x01, 0xCF, 0x00, 0x1E, 0xE0,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0E, 0xE0, 0x00, 0xEF, 0x00, 0x1E, 0xF8, 0x01, 0xCF, 0xC0,
  0x3C, 0xEF, 0x9F, 0x8E, 0x7F, 0xF0, 0xE3, 0xFE, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xF0, 0xF8, 0x3C, 0x03, 0xC7,
  0x80, 0x1C, 0x70, 0x00, 0xEF, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x06,
  0xE0, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x00, 0x6F, 0x00, 0x0E, 0x70,
  0x00, 0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xC1, 0xF0, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x04, 0x07, 0x07,
  0xFC, 0x70, 0xFF, 0xE7, 0x1F, 0x0F, 0x73, 0xC0, 0x3F, 0x78, 0x01, 0xF7,
  0x00, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x0F, 0x78,
  0x01, 0xF3, 0xC0, 0x3F, 0x1F, 0x9F, 0x70, 0xFF, 0xE7, 0x07, 0xFC, 0x70,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xF0, 0xF8,
  0x3C, 0x03, 0xC7, 0x80, 0x1C, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x04, 0x3C, 0x01, 0xE1, 0xF8, 0x7C,
  0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x10, 0x07, 0xF0,
  0x3F, 0xC1, 0xF9, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x40,
  0x00, 0x7F, 0xC7, 0x0F, 0xFE, 0x71, 0xF0, 0xF7, 0x3C, 0x03, 0xF7, 0x80,
  0x1F, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00,
  0xF7, 0x80, 0x1F, 0x3C, 0x03, 0xF1, 0xF9, 0xF7, 0x0F, 0xFE, 0x70, 0x7F,
  0xC7, 0x00, 0x40, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE3, 0x00, 0x0E, 0x38, 0x01, 0xE3, 0xC0, 0x3C, 0x1F, 0xFF, 0x80,
  0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x1F, 0xE1,
  0xCF, 0xFE, 0x3B, 0xE7, 0xE7, 0x60, 0x1C, 0xF8, 0x03, 0xDF, 0x00, 0x3B,
  0xC0, 0x07, 0x78, 0x00, 0xEE, 0x00, 0x0D, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0xEF, 0xF6, 0x00, 0x00, 0x00,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xE0, 0x03, 0x80, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81,
  0xE0, 0xF3, 0xFC, 0xFE, 0x3E, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x3D, 0xC0, 0x0F, 0x38, 0x03, 0xC7, 0x00, 0x70, 0xE0, 0x1C, 0x1C, 0x07,
  0x83, 0x81, 0xE0, 0x70, 0x78, 0x0E, 0x1E, 0x01, 0xC3, 0x80, 0x38, 0xE0,
  0x07, 0x3C, 0x00, 0xEF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7C, 0xE0,
  0x0F, 0x1E, 0x01, 0xC1, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x3C,
  0x1C, 0x03, 0x83, 0x80, 0x78, 0x70, 0x07, 0x8E, 0x00, 0x71, 0xC0, 0x0F,
  0x38, 0x00, 0xF7, 0x00, 0x0E, 0xE0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x20, 0x38, 0x7F, 0x80, 0xFF, 0x0E, 0x7F, 0xF0, 0xFF,
  0xF3, 0xBE, 0x7E, 0x7C, 0x7C, 0xFC, 0x07, 0x9C, 0x07, 0xBE, 0x00, 0xFE,
  0x00, 0xEF, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x07, 0xE0, 0x01,
  0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x1F, 0x80,
  0x07, 0x00, 0x07, 0xE0, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x7E,
  0x00, 0x1C, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x07, 0xE0, 0x01, 0xC0, 0x01,
  0xF8, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x07, 0x00,
  0x07, 0xE0, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x1C,
  0x00, 0x1F, 0x80, 0x07, 0x00, 0x07, 0xE0, 0x01, 0xC0, 0x01, 0xF8, 0x00,
  0x70, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x07, 0xE0,
  0x01, 0xC0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x3F,
  0xC3, 0x9F, 0xFC, 0x77, 0xCF, 0xCE, 0xC0, 0x39, 0xF0, 0x07, 0xBE, 0x00,
  0x77, 0x80, 0x0E, 0xF0, 0x01, 0xDC, 0x00, 0x1B, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0x1F, 0x83, 0xE0, 0x3E, 0x1C, 0x00, 0x71,
  0xE0, 0x03, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x77, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1D, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x78,
  0x00, 0xF1, 0xC0, 0x07, 0x0F, 0x80, 0x78, 0x3F, 0x1F, 0x80, 0xFF, 0xF8,
  0x01, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x0E, 0x3F, 0xE0, 0xE7,
  0xFF, 0x0E, 0xF1, 0xF8, 0xFC, 0x03, 0xCF, 0x80, 0x1C, 0xF0, 0x01, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xF0, 0x01, 0xEF, 0x00, 0x1C, 0xFC,
  0x03, 0xCE, 0xF0, 0xF8, 0xE7, 0xFF, 0x0E, 0x3F, 0xE0, 0xE0, 0x20, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x7F, 0xC7, 0x1F, 0xFE, 0x71, 0xF0, 0xF7, 0x3C,
  0x03, 0xF7, 0x80, 0x1F, 0x70, 0x00, 0xF7, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0xF7, 0x80, 0x1F, 0x3C, 0x03, 0xF1, 0xF0, 0xF7, 0x0F,
  0xFE, 0x70, 0x7F, 0xC7, 0x00, 0x40, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x7F, 0x9F,
  0xF7, 0xFF, 0xC1, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0x0F, 0xC3,
  0x80, 0x78, 0xE0, 0x07, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xCE,
  0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xB8, 0x00, 0x3F, 0x00, 0x0E, 0xE0,
  0x01, 0xCE, 0x00, 0x39, 0xE0, 0x0F, 0x1F, 0x8F, 0xC1, 0xFF, 0xF0, 0x0F,
  0xF8, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xF2, 0x07, 0xF0, 0x1F, 0x80, 0x20, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x1F, 0x70, 0x03, 0xEF, 0x00, 0xFC, 0xFD, 0xFB, 0x8F, 0xFE,
  0x70, 0xFF, 0x0E, 0x03, 0x00, 0x00, 0x70, 0x00, 0x3B, 0x80, 0x03, 0x9C,
  0x00, 0x1C, 0xF0, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x70, 0xE0, 0x03,
  0x83, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0x80, 0x70, 0x1C,
  0x07, 0x00, 0xE0, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0C, 0x00, 0xE0, 0xE0,
  0x03, 0x07, 0x00, 0x1C, 0x30, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x1C,
  0xE0, 0x00, 0xE6, 0x00, 0x07, 0x70, 0x00, 0x1B, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0xE0, 0x03, 0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0x0E, 0x70,
  0x03, 0xC0, 0x0E, 0x70, 0x07, 0xC0, 0x0E, 0x70, 0x07, 0xE0, 0x0E, 0x70,
  0x07, 0xE0, 0x1C, 0x38, 0x06, 0xE0, 0x1C, 0x38, 0x0E, 0x60, 0x1C, 0x38,
  0x0E, 0x70, 0x1C, 0x38, 0x0C, 0x70, 0x38, 0x1C, 0x0C, 0x70, 0x38, 0x1C,
  0x1C, 0x30, 0x38, 0x1C, 0x1C, 0x38, 0x38, 0x1C, 0x18, 0x38, 0x30, 0x0E,
  0x38, 0x18, 0x70, 0x0E, 0x38, 0x18, 0x70, 0x0E, 0x38, 0x1C, 0x70, 0x0E,
  0x30, 0x1C, 0x60, 0x06, 0x70, 0x0C, 0xE0, 0x07, 0x70, 0x0E, 0xE0, 0x07,
  0x70, 0x0E, 0xE0, 0x07, 0x60, 0x0E, 0xC0, 0x03, 0xE0, 0x06, 0xC0, 0x03,
  0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01,
  0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0xF0, 0x00, 0xE7, 0x00, 0x1E,
  0x78, 0x01, 0xC3, 0x80, 0x3C, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0x0E, 0x07,
  0x00, 0xE0, 0xE0, 0x07, 0x1E, 0x00, 0x79, 0xC0, 0x03, 0xBC, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x3B, 0x80, 0x03, 0x9C, 0x00, 0x71, 0xE0, 0x07, 0x0E, 0x00,
  0xE0, 0xF0, 0x1E, 0x07, 0x01, 0xC0, 0x78, 0x3C, 0x03, 0x83, 0x80, 0x1C,
  0x70, 0x01, 0xEF, 0x00, 0x0E, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x7B, 0x80,
  0x03, 0x9C, 0x00, 0x1C, 0xF0, 0x00, 0xE3, 0x80, 0x0E, 0x1C, 0x00, 0x70,
  0xF0, 0x03, 0x83, 0x80, 0x3C, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0x80,
  0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x00,
  0xE0, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x30, 0x00, 0xE3, 0x80, 0x03, 0x1C,
  0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x03, 0x70, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x08, 0x00, 0xE0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x03, 0xF0, 0x0F,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x60, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xF0, 0x01, 0xCF, 0xFC, 0x00, 0xEF, 0x0F, 0x00, 0x77,
  0x03, 0xC0, 0x37, 0x00, 0xF0, 0x3B, 0x80, 0x3C, 0x3D, 0xC0, 0x0F, 0xFC,
  0xC0, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_Light55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 40, 12, 4, -39 },
  { 21, 9, 12, 16, 4, -41 },
  { 35, 25, 39, 28, 3, -39 },
  { 157, 21, 51, 27, 3, -45 },
  { 291, 29, 41, 35, 3, -40 },
  { 440, 25, 41, 30, 3, -40 },
  { 569, 3, 12, 9, 3, -41 },
  { 574, 11, 57, 16, 4, -44 },
  { 653, 11, 57, 16, 1, -44 },
  { 732, 22, 22, 23, 1, -39 },
  { 793, 23, 28, 27, 2, -32 },
  { 874, 5, 12, 11, 2, -5 },
  { 882, 10, 3, 14, 2, -19 },
  { 886, 4, 5, 13, 4, -4 },
  { 889, 17, 42, 20, 1, -39 },
  { 979, 21, 41, 27, 3, -40 },
  { 1087, 11, 39, 27, 5, -39 },
  { 1141, 21, 40, 27, 3, -40 },
  { 1246, 20, 41, 27, 3, -40 },
  { 1349, 23, 39, 27, 2, -39 },
  { 1462, 20, 40, 27, 4, -39 },
  { 1562, 21, 40, 27, 3, -39 },
  { 1667, 22, 39, 27, 2, -39 },
  { 1775, 21, 41, 27, 3, -40 },
  { 1883, 20, 40, 27, 3, -40 },
  { 1983, 4, 30, 11, 4, -29 },
  { 1998, 6, 36, 10, 2, -29 },
  { 2025, 19, 23, 25, 2, -29 },
  { 2080, 19, 14, 27, 4, -25 },
  { 2114, 19, 23, 25, 3, -29 },
  { 2169, 18, 41, 22, 2, -40 },
  { 2262, 37, 50, 43, 3, -38 },
  { 2494, 28, 39, 30, 1, -39 },
  { 2631, 21, 39, 29, 5, -39 },
  { 2734, 24, 41, 31, 4, -40 },
  { 2857, 23, 39, 31, 5, -39 },
  { 2970, 20, 39, 27, 5, -39 },
  { 3068, 20, 39, 27, 5, -39 },
  { 3166, 24, 41, 33, 4, -40 },
  { 3289, 24, 39, 34, 5, -39 },
  { 3406, 3, 39, 13, 5, -39 },
  { 3421, 20, 40, 27, 2, -39 },
  { 3521, 24, 39, 30, 5, -39 },
  { 3638, 19, 39, 26, 5, -39 },
  { 3731, 31, 39, 41, 5, -39 },
  { 3883, 24, 39, 34, 5, -39 },
  { 4000, 25, 41, 32, 4, -40 },
  { 4129, 22, 39, 30, 5, -39 },
  { 4237, 26, 47, 32, 3, -40 },
  { 4390, 23, 39, 30, 5, -39 },
  { 4503, 24, 41, 28, 2, -40 },
  { 4626, 25, 39, 29, 2, -39 },
  { 4748, 23, 40, 31, 4, -39 },
  { 4863, 28, 39, 30, 1, -39 },
  { 5000, 39, 39, 42, 2, -39 },
  { 5191, 26, 39, 29, 2, -39 },
  { 5318, 27, 39, 29, 1, -39 },
  { 5450, 23, 39, 29, 3, -39 },
  { 5563, 8, 53, 12, 4, -45 },
  { 5616, 16, 42, 19, 2, -39 },
  { 5700, 7, 53, 12, 1, -45 },
  { 5747, 16, 20, 20, 2, -39 },
  { 5787, 20, 3, 21, 1, 0 },
  { 5795, 9, 8, 16, 3, -42 },
  { 5804, 20, 31, 26, 3, -30 },
  { 5882, 20, 42, 27, 4, -41 },
  { 5987, 20, 31, 25, 3, -30 },
  { 6065, 20, 42, 27, 3, -41 },
  { 6170, 20, 31, 25, 3, -30 },
  { 6248, 14, 42, 17, 2, -42 },
  { 6322, 20, 41, 27, 3, -30 },
  { 6425, 19, 41, 26, 4, -41 },
  { 6523, 4, 39, 12, 4, -39 },
  { 6543, 10, 50, 12, -2, -39 },
  { 6606, 19, 41, 24, 4, -41 },
  { 6704, 3, 41, 12, 4, -41 },
  { 6720, 34, 30, 42, 4, -30 },
  { 6848, 19, 30, 27, 4, -30 },
  { 6920, 21, 31, 27, 3, -30 },
  { 7002, 20, 41, 27, 4, -30 },
  { 7105, 20, 41, 27, 3, -30 },
  { 7208, 11, 30, 17, 4, -30 },
  { 7250, 19, 31, 25, 3, -30 },
  { 7324, 13, 38, 16, 1, -37 },
  { 7386, 19, 30, 26, 4, -29 },
  { 7458, 21, 29, 23, 1, -29 },
  { 7535, 32, 29, 36, 2, -29 },
  { 7651, 20, 29, 24, 2, -29 },
  { 7724, 21, 40, 23, 1, -29 },
  { 7829, 19, 29, 24, 3, -29 },
  { 7898, 14, 54, 16, 2, -43 },
  { 7993, 3, 46, 12, 5, -39 },
  { 8011, 13, 54, 16, 1, -43 },
  { 8099, 25, 10, 33, 4, -21 },
};

const GFXfont RobotoCondensed_Light55pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light55pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light55pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _ROBOTOCONDENSED_LIGHT55PT7B_H_
