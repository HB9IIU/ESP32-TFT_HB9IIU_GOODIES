#ifndef _ROBOTOCONDENSED_LIGHT27PT7B_H_
#define _ROBOTOCONDENSED_LIGHT27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x99, 0x99, 0x99, 0x04, 0x20, 0x21,
  0x01, 0x18, 0x08, 0x80, 0x44, 0x06, 0x21, 0xFF, 0xE1, 0x08, 0x08, 0xC0,
  0x46, 0x02, 0x20, 0x31, 0x0F, 0xFF, 0x08, 0x40, 0x46, 0x02, 0x30, 0x11,
  0x01, 0x88, 0x0C, 0x40, 0x08, 0x02, 0x00, 0x80, 0x78, 0x7F, 0x10, 0x6C,
  0x0B, 0x02, 0xC0, 0xB0, 0x06, 0x00, 0xC0, 0x1E, 0x01, 0xC0, 0x18, 0x02,
  0x80, 0xE0, 0x38, 0x0B, 0x06, 0x77, 0x0F, 0x80, 0x80, 0x20, 0x38, 0x00,
  0xC8, 0x01, 0x18, 0x06, 0x11, 0x8C, 0x22, 0x18, 0x4C, 0x11, 0x90, 0x32,
  0x40, 0x38, 0x80, 0x02, 0x00, 0x04, 0xE0, 0x13, 0x20, 0x64, 0x60, 0x88,
  0x43, 0x10, 0x84, 0x21, 0x10, 0x46, 0x00, 0xC8, 0x00, 0xE0, 0x0F, 0x00,
  0xDC, 0x0C, 0x60, 0x41, 0x02, 0x08, 0x18, 0xC0, 0xCC, 0x03, 0xC0, 0x0C,
  0x00, 0xE0, 0x0D, 0x84, 0xC6, 0x24, 0x11, 0x60, 0xDB, 0x03, 0x88, 0x0C,
  0x60, 0xE1, 0xDD, 0x87, 0xC6, 0xFC, 0x08, 0xC4, 0x42, 0x31, 0x08, 0xC6,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x31, 0x84, 0x21, 0x84, 0x20, 0x86, 0x10,
  0x84, 0x10, 0xC2, 0x18, 0x42, 0x10, 0xC6, 0x10, 0x84, 0x21, 0x18, 0xC6,
  0x31, 0x08, 0xC4, 0x62, 0x21, 0x00, 0x06, 0x00, 0x80, 0x10, 0x02, 0x1F,
  0x4E, 0x3F, 0x03, 0x80, 0x58, 0x19, 0x06, 0x30, 0x82, 0x00, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xFF, 0xFF, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x6D, 0xAD, 0x00, 0xF8, 0xF0, 0x02,
  0x02, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x18, 0x10, 0x10, 0x30,
  0x20, 0x20, 0x60, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x3E, 0x1D, 0xC4, 0x1B,
  0x06, 0x80, 0xA0, 0x28, 0x0A, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xA0, 0x28, 0x0B, 0x06, 0x41, 0x9D, 0xC3, 0xE0, 0x04, 0xFE, 0x61, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x40, 0x1F,
  0x06, 0x71, 0x83, 0x20, 0x64, 0x05, 0x80, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0xFF, 0x80, 0x1F, 0x0E, 0xE6, 0x0D, 0x03, 0x40, 0x40, 0x10, 0x0C, 0x03,
  0x07, 0x83, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x1C, 0x05, 0x01, 0x60, 0xCE,
  0xE1, 0xF0, 0x01, 0x80, 0x30, 0x0A, 0x03, 0x40, 0x48, 0x19, 0x02, 0x20,
  0xC4, 0x10, 0x86, 0x11, 0x82, 0x20, 0x4C, 0x09, 0xFF, 0xC0, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x7F, 0xDF, 0xF6, 0x01, 0x80, 0x40, 0x10,
  0x04, 0x01, 0x78, 0x7F, 0x90, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x3C, 0x0F,
  0x03, 0x41, 0x9E, 0xE1, 0xE0, 0x07, 0x07, 0x03, 0x01, 0x80, 0x40, 0x30,
  0x0C, 0x02, 0x78, 0xB7, 0x30, 0x6C, 0x0A, 0x03, 0x80, 0xE0, 0x38, 0x0F,
  0x02, 0x61, 0x8D, 0xC1, 0xE0, 0xFF, 0xE0, 0x0C, 0x01, 0x00, 0x60, 0x08,
  0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x00, 0x1F, 0x07, 0x71, 0x83,
  0x30, 0x24, 0x04, 0x80, 0x98, 0x13, 0x06, 0x3B, 0x83, 0xE0, 0xC6, 0x30,
  0x24, 0x07, 0x80, 0xF0, 0x1A, 0x03, 0x60, 0xC7, 0x70, 0x7C, 0x00, 0x1E,
  0x0E, 0xE6, 0x09, 0x03, 0x40, 0x70, 0x1C, 0x07, 0x01, 0x40, 0x50, 0x36,
  0x0C, 0xED, 0x1E, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x83, 0xC1, 0xC0, 0xF0,
  0x00, 0x00, 0xF0, 0x6C, 0x00, 0x00, 0x00, 0x36, 0xD6, 0x80, 0x00, 0x81,
  0xC1, 0xC3, 0x87, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x20, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70,
  0x0C, 0x1C, 0x38, 0x78, 0x70, 0x20, 0x00, 0x1E, 0x3B, 0x90, 0x58, 0x3C,
  0x18, 0x0C, 0x04, 0x02, 0x03, 0x03, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x00,
  0x00, 0x00, 0x0C, 0x06, 0x00, 0x03, 0xF0, 0x03, 0x8F, 0x01, 0x80, 0x60,
  0xC0, 0x0C, 0x20, 0x01, 0x18, 0x00, 0x24, 0x0E, 0x0B, 0x0C, 0x42, 0x82,
  0x10, 0xA1, 0x84, 0x38, 0x41, 0x06, 0x10, 0x41, 0x84, 0x10, 0xE3, 0x04,
  0x38, 0xC1, 0x0A, 0x30, 0xC2, 0x84, 0x31, 0xA1, 0xB4, 0xCC, 0x38, 0xE1,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x70, 0xC0, 0x07,
  0xE0, 0x00, 0x02, 0x00, 0x38, 0x01, 0x40, 0x0A, 0x00, 0xD8, 0x04, 0xC0,
  0x22, 0x03, 0x18, 0x10, 0xC0, 0x82, 0x0C, 0x10, 0x40, 0xC2, 0x02, 0x3F,
  0xF1, 0x80, 0xC8, 0x02, 0xC0, 0x16, 0x00, 0xE0, 0x06, 0xFF, 0x18, 0x73,
  0x03, 0x60, 0x2C, 0x05, 0x80, 0xB0, 0x16, 0x06, 0xC3, 0x9F, 0xF3, 0x03,
  0x60, 0x2C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xD8, 0x7B, 0xFC, 0x00,
  0x1F, 0x83, 0xBC, 0x60, 0x64, 0x02, 0xC0, 0x38, 0x03, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x03, 0xC0, 0x34, 0x02,
  0x60, 0x63, 0xBC, 0x1F, 0x00, 0xFF, 0x0C, 0x78, 0xC0, 0xCC, 0x06, 0xC0,
  0x2C, 0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x02, 0xC0, 0x2C, 0x06, 0xC0, 0xCC, 0x38, 0xFF, 0x00, 0xFF, 0xF0,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xEC, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFC, 0xFF, 0xF0,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xEC, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x1F, 0x83,
  0xDC, 0x60, 0x64, 0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x83, 0xF8, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x34, 0x03, 0x60, 0x33,
  0xDE, 0x0F, 0x80, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1F, 0xFF, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x10, 0xFF, 0xFF, 0xE0, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xF0, 0x3C, 0x0F, 0x03, 0x41, 0x9C, 0xC1, 0xE0, 0xC0,
  0x6C, 0x06, 0xC0, 0xCC, 0x18, 0xC3, 0x0C, 0x60, 0xC6, 0x0C, 0xC0, 0xD8,
  0x0F, 0xC0, 0xE4, 0x0C, 0x60, 0xC3, 0x0C, 0x18, 0xC1, 0x8C, 0x0C, 0xC0,
  0x6C, 0x06, 0xC0, 0x30, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0F, 0xFC, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x05,
  0xF0, 0x0F, 0xD0, 0x0B, 0xD8, 0x0B, 0xD8, 0x1B, 0xC8, 0x13, 0xCC, 0x13,
  0xCC, 0x33, 0xC4, 0x23, 0xC6, 0x23, 0xC2, 0x63, 0xC2, 0x43, 0xC3, 0xC3,
  0xC1, 0xC3, 0xC1, 0x83, 0xC1, 0x83, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x01,
  0xD0, 0x1D, 0x81, 0xC8, 0x1C, 0xC1, 0xC6, 0x1C, 0x21, 0xC3, 0x1C, 0x11,
  0xC1, 0x9C, 0x09, 0xC0, 0xDC, 0x05, 0xC0, 0x7C, 0x03, 0xC0, 0x10, 0x1F,
  0x83, 0xFC, 0x60, 0x6C, 0x02, 0xC0, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0xC0, 0x3C, 0x02, 0x60,
  0x63, 0xFC, 0x1F, 0x80, 0xFF, 0x18, 0x7B, 0x01, 0xE0, 0x3C, 0x03, 0x80,
  0x70, 0x0E, 0x03, 0xC0, 0x78, 0x3B, 0xFC, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x00, 0x1F, 0x83, 0xFC, 0x60, 0x6C,
  0x02, 0xC0, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x03, 0xC0, 0x3C, 0x02, 0x60, 0x63, 0xFC, 0x1F, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0xFF, 0x0C, 0x3C, 0xC0, 0xCC, 0x06, 0xC0, 0x6C,
  0x02, 0xC0, 0x6C, 0x06, 0xC0, 0xCC, 0x3C, 0xFF, 0x0C, 0x30, 0xC1, 0x8C,
  0x18, 0xC0, 0xCC, 0x0C, 0xC0, 0x6C, 0x06, 0xC0, 0x30, 0x0F, 0x83, 0xDC,
  0x60, 0x66, 0x02, 0x40, 0x34, 0x03, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xF8,
  0x01, 0xC0, 0x06, 0x00, 0x3C, 0x03, 0xC0, 0x34, 0x03, 0x60, 0x63, 0xDE,
  0x0F, 0x80, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0x60, 0x6F, 0x78, 0x7C, 0x00, 0x80, 0x1E,
  0x00, 0xF0, 0x04, 0x80, 0x66, 0x03, 0x30, 0x10, 0x81, 0x86, 0x0C, 0x30,
  0x40, 0x86, 0x04, 0x30, 0x31, 0x00, 0x88, 0x04, 0xC0, 0x34, 0x00, 0xA0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0xC0, 0x40, 0x78, 0x1C, 0x0F, 0x03, 0x81,
  0x20, 0x50, 0x24, 0x0A, 0x04, 0xC3, 0x61, 0x98, 0x6C, 0x31, 0x08, 0x84,
  0x21, 0x10, 0x84, 0x62, 0x30, 0xCC, 0x66, 0x19, 0x04, 0xC1, 0x20, 0x90,
  0x2C, 0x12, 0x05, 0x83, 0xC0, 0xE0, 0x38, 0x1C, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x00, 0xC0, 0x33, 0x01, 0x98, 0x18, 0x60, 0x81, 0x0C, 0x0C,
  0x40, 0x26, 0x01, 0xA0, 0x07, 0x00, 0x30, 0x01, 0xC0, 0x1A, 0x00, 0x98,
  0x0C, 0x60, 0xC3, 0x06, 0x0C, 0x60, 0x63, 0x01, 0xB0, 0x04, 0xC0, 0x16,
  0x01, 0x90, 0x08, 0xC0, 0xC2, 0x04, 0x18, 0x60, 0x42, 0x03, 0x30, 0x09,
  0x00, 0x78, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x7F, 0xF0, 0x02, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xFF, 0xF0, 0xFC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0x80,
  0xC0, 0x40, 0x40, 0x60, 0x20, 0x20, 0x30, 0x10, 0x10, 0x18, 0x18, 0x08,
  0x0C, 0x0C, 0x04, 0x06, 0x06, 0x02, 0x02, 0x03, 0xF1, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x18, 0x18, 0x18,
  0x3C, 0x24, 0x24, 0x66, 0x42, 0x42, 0xC3, 0xFF, 0xC0, 0x63, 0x0C, 0x20,
  0x1F, 0x0E, 0xE6, 0x09, 0x03, 0x00, 0xC0, 0x31, 0xFC, 0xC3, 0x60, 0xD0,
  0x3C, 0x0F, 0x03, 0x41, 0xDD, 0xF3, 0xCC, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x09, 0xE2, 0xDC, 0xC1, 0xB0, 0x28, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xF0, 0x2C, 0x1A, 0xFC, 0x9E, 0x00, 0x1F, 0x0E,
  0xE6, 0x0D, 0x03, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x05,
  0x03, 0x60, 0xCE, 0xE1, 0xF0, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x11, 0xE4, 0xED, 0x60, 0xD0, 0x14, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0x40, 0x50, 0x16, 0x0C, 0xED, 0x1E, 0x40, 0x1F, 0x0E, 0xE6, 0x09,
  0x03, 0xC0, 0x70, 0x1C, 0x07, 0xFF, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60,
  0x0E, 0xF1, 0xF0, 0x0E, 0x34, 0xC1, 0x82, 0x04, 0x3F, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0x1E, 0x4E,
  0xD6, 0x0D, 0x01, 0x40, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x14, 0x05,
  0x01, 0x60, 0xCE, 0xD1, 0xE4, 0x01, 0x00, 0xD0, 0x33, 0xB8, 0x7C, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x79, 0x7E, 0xE1, 0xE0, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x18, 0xC0, 0x00, 0x0C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x5E, 0xE0, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x07, 0x06, 0x86, 0x46, 0x22, 0x13, 0x0B, 0x07, 0xC3,
  0x21, 0x18, 0x86, 0x43, 0x20, 0xD0, 0x28, 0x18, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x9E, 0x1E, 0x5B, 0xBB, 0xB0, 0x70, 0x58, 0x30, 0x38, 0x08,
  0x1C, 0x04, 0x0E, 0x02, 0x07, 0x01, 0x03, 0x80, 0x81, 0xC0, 0x40, 0xE0,
  0x20, 0x70, 0x10, 0x38, 0x08, 0x1C, 0x04, 0x0E, 0x02, 0x06, 0x9E, 0x5F,
  0xB8, 0x78, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x02, 0x1F, 0x07, 0x71, 0x83, 0x30, 0x24, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0D, 0x01, 0xA0, 0x26, 0x0C, 0x77, 0x07, 0xC0,
  0x9E, 0x2D, 0xCC, 0x1B, 0x02, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x02, 0xC1, 0xAD, 0xC9, 0xE2, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x1E, 0x4E, 0xD6, 0x0D, 0x01, 0x40, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x14, 0x05, 0x01, 0x60, 0xCE, 0xD1, 0xE4, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x9E, 0xFC, 0x30, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x00, 0x1E, 0x0C, 0xE6, 0x19, 0x02, 0x40, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x60, 0x0F, 0x03, 0x40, 0x9C, 0xE1, 0xE0, 0x10, 0x20, 0x47,
  0xF1, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x1A,
  0x1C, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x38, 0x3C, 0x1B, 0xB4, 0xF2, 0x80, 0xF0, 0x2C, 0x09, 0x06, 0x41,
  0x18, 0x42, 0x30, 0x8C, 0x32, 0x0C, 0x81, 0x60, 0x50, 0x1C, 0x03, 0x00,
  0x80, 0xC1, 0x83, 0xC1, 0x82, 0x41, 0x82, 0x43, 0x86, 0x42, 0xC6, 0x62,
  0xC4, 0x66, 0x44, 0x26, 0x4C, 0x24, 0x6C, 0x34, 0x68, 0x3C, 0x28, 0x1C,
  0x28, 0x18, 0x38, 0x18, 0x10, 0x18, 0x10, 0xC0, 0x90, 0x66, 0x10, 0x8C,
  0x32, 0x07, 0x80, 0xC0, 0x30, 0x1C, 0x05, 0x83, 0x20, 0x8C, 0x61, 0x10,
  0x6C, 0x0C, 0x80, 0xF0, 0x2C, 0x19, 0x06, 0x61, 0x18, 0x42, 0x30, 0x88,
  0x32, 0x05, 0x81, 0x60, 0x70, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x04,
  0x07, 0x03, 0x80, 0xFF, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30, 0x0F, 0xFC, 0x04, 0x18,
  0x60, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x8E, 0x18, 0x08, 0x18,
  0x30, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0C, 0x0C, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x40, 0xC0, 0xC0, 0x81, 0x02, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC0, 0xE0, 0xC2, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x04, 0x18,
  0x60, 0x80, 0x38, 0x17, 0xC1, 0xC6, 0x38, 0x3E, 0x81, 0xC0,
};

const GFXglyph RobotoCondensed_Light27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 19, 6, 2, -19 },
  { 6, 4, 6, 8, 2, -20 },
  { 9, 13, 19, 14, 1, -19 },
  { 40, 10, 24, 13, 2, -22 },
  { 70, 15, 19, 17, 1, -19 },
  { 106, 13, 19, 15, 1, -19 },
  { 137, 1, 6, 5, 2, -20 },
  { 138, 5, 28, 8, 2, -22 },
  { 156, 5, 28, 8, 1, -22 },
  { 174, 11, 11, 11, 0, -19 },
  { 190, 11, 14, 13, 1, -16 },
  { 210, 3, 6, 5, 1, -3 },
  { 213, 5, 1, 7, 1, -9 },
  { 214, 2, 2, 6, 2, -2 },
  { 215, 8, 21, 10, 1, -19 },
  { 236, 10, 19, 13, 2, -19 },
  { 260, 6, 19, 13, 2, -19 },
  { 275, 11, 19, 13, 1, -19 },
  { 302, 10, 19, 13, 1, -19 },
  { 326, 11, 19, 13, 1, -19 },
  { 353, 10, 19, 13, 2, -19 },
  { 377, 10, 19, 13, 2, -19 },
  { 401, 11, 19, 13, 1, -19 },
  { 428, 11, 19, 13, 1, -19 },
  { 455, 10, 19, 13, 1, -19 },
  { 479, 2, 14, 5, 2, -14 },
  { 483, 3, 17, 5, 1, -14 },
  { 490, 9, 11, 12, 1, -14 },
  { 503, 9, 6, 13, 2, -12 },
  { 510, 9, 11, 12, 2, -14 },
  { 523, 9, 19, 11, 1, -19 },
  { 545, 18, 25, 21, 2, -19 },
  { 602, 13, 19, 15, 1, -19 },
  { 633, 11, 19, 14, 2, -19 },
  { 660, 12, 19, 15, 2, -19 },
  { 689, 12, 19, 15, 2, -19 },
  { 718, 10, 19, 13, 2, -19 },
  { 742, 10, 19, 13, 2, -19 },
  { 766, 12, 19, 16, 2, -19 },
  { 795, 12, 19, 17, 2, -19 },
  { 824, 1, 19, 7, 3, -19 },
  { 827, 10, 19, 13, 1, -19 },
  { 851, 12, 19, 15, 2, -19 },
  { 880, 10, 19, 13, 2, -19 },
  { 904, 16, 19, 20, 2, -19 },
  { 942, 12, 19, 17, 2, -19 },
  { 971, 12, 19, 16, 2, -19 },
  { 1000, 11, 19, 15, 2, -19 },
  { 1027, 12, 22, 16, 2, -19 },
  { 1060, 12, 19, 15, 2, -19 },
  { 1089, 12, 19, 14, 1, -19 },
  { 1118, 12, 19, 14, 1, -19 },
  { 1147, 11, 19, 15, 2, -19 },
  { 1174, 13, 19, 15, 1, -19 },
  { 1205, 19, 19, 21, 1, -19 },
  { 1251, 13, 19, 14, 1, -19 },
  { 1282, 13, 19, 14, 1, -19 },
  { 1313, 12, 19, 14, 1, -19 },
  { 1342, 4, 26, 6, 2, -22 },
  { 1355, 8, 21, 10, 1, -19 },
  { 1376, 4, 26, 6, 0, -22 },
  { 1389, 8, 10, 10, 1, -19 },
  { 1399, 10, 1, 10, 0, 0 },
  { 1401, 5, 4, 8, 1, -21 },
  { 1404, 10, 15, 13, 1, -15 },
  { 1423, 10, 21, 13, 2, -21 },
  { 1450, 10, 15, 12, 1, -15 },
  { 1469, 10, 21, 13, 1, -21 },
  { 1496, 10, 15, 12, 1, -15 },
  { 1515, 7, 21, 8, 1, -21 },
  { 1534, 10, 20, 13, 1, -15 },
  { 1559, 9, 21, 13, 2, -21 },
  { 1583, 2, 20, 6, 2, -20 },
  { 1588, 5, 25, 6, -1, -20 },
  { 1604, 9, 21, 12, 2, -21 },
  { 1628, 2, 21, 6, 2, -21 },
  { 1634, 17, 15, 21, 2, -15 },
  { 1666, 9, 15, 13, 2, -15 },
  { 1683, 11, 15, 13, 1, -15 },
  { 1704, 10, 20, 13, 2, -15 },
  { 1729, 10, 20, 13, 1, -15 },
  { 1754, 6, 15, 8, 2, -15 },
  { 1766, 10, 15, 12, 1, -15 },
  { 1785, 7, 18, 8, 0, -18 },
  { 1801, 9, 15, 13, 2, -15 },
  { 1818, 10, 15, 11, 1, -15 },
  { 1837, 16, 15, 18, 1, -15 },
  { 1867, 10, 15, 12, 1, -15 },
  { 1886, 10, 20, 11, 1, -15 },
  { 1911, 10, 15, 12, 1, -15 },
  { 1930, 7, 26, 8, 1, -21 },
  { 1953, 2, 23, 6, 2, -19 },
  { 1959, 7, 26, 8, 0, -21 },
  { 1982, 12, 5, 16, 2, -11 },
};

const GFXfont RobotoCondensed_Light27pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light27pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOCONDENSED_LIGHT27PT7B_H_
