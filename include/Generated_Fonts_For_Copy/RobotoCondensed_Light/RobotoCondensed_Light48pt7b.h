#ifndef _ROBOTOCONDENSED_LIGHT48PT7B_H_
#define _ROBOTOCONDENSED_LIGHT48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xED, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0x00, 0x00,
  0x37, 0xF8, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xC3, 0xC3, 0xC3,
  0xC3, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18,
  0x00, 0xE0, 0x60, 0x03, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00,
  0xC0, 0xC0, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x01, 0x81,
  0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80,
  0x0C, 0x0E, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C,
  0x0C, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x06, 0x07, 0x00, 0x18, 0x18,
  0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x38, 0x18, 0x00,
  0xC0, 0xE0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0x0F, 0x0E, 0x01, 0xC7, 0x00, 0x39,
  0xC0, 0x0E, 0x60, 0x03, 0x98, 0x00, 0x66, 0x00, 0x19, 0xC0, 0x06, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xB8, 0x00, 0xE7, 0x00, 0x39, 0xE0, 0x3C, 0x3F, 0xFE, 0x07, 0xFF,
  0x00, 0x3F, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x18, 0x00,
  0x0C, 0x0E, 0x02, 0x06, 0x03, 0x01, 0x83, 0x01, 0x81, 0x81, 0x80, 0xC0,
  0xC0, 0xC0, 0x60, 0xC0, 0x60, 0x30, 0xE0, 0x30, 0x18, 0x60, 0x18, 0x1C,
  0x70, 0x0E, 0x0C, 0x30, 0x03, 0x8E, 0x30, 0x00, 0xFE, 0x18, 0x00, 0x3E,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x1F, 0x00,
  0x06, 0x1F, 0xC0, 0x07, 0x1C, 0x70, 0x03, 0x0C, 0x1C, 0x03, 0x8C, 0x06,
  0x01, 0x86, 0x03, 0x01, 0x83, 0x01, 0x80, 0xC1, 0x80, 0xC0, 0xC0, 0xC0,
  0x60, 0x60, 0x60, 0x30, 0x60, 0x30, 0x18, 0x30, 0x18, 0x0C, 0x00, 0x06,
  0x0E, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xF7, 0xC0, 0x07, 0x07, 0x00, 0x18, 0x0E,
  0x00, 0xE0, 0x38, 0x03, 0x80, 0x60, 0x0E, 0x01, 0x80, 0x38, 0x0E, 0x00,
  0xE0, 0x30, 0x01, 0x81, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0x3B,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00,
  0x03, 0x8E, 0x03, 0x1E, 0x38, 0x0C, 0x70, 0x70, 0x33, 0x80, 0xE0, 0xCE,
  0x03, 0xC7, 0x30, 0x07, 0x1C, 0xC0, 0x0E, 0x63, 0x00, 0x1F, 0x8C, 0x00,
  0x7E, 0x38, 0x00, 0xF0, 0xE0, 0x01, 0xC1, 0xC0, 0x0F, 0x87, 0x80, 0xFE,
  0x0F, 0xDF, 0x9C, 0x1F, 0xFC, 0x38, 0x1F, 0x80, 0xE0, 0xFF, 0xFF, 0xF0,
  0x00, 0x40, 0x30, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06,
  0x01, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0E, 0x03,
  0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30,
  0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80,
  0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03,
  0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x06,
  0x03, 0x00, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x38, 0x30, 0x37, 0xC6, 0x3F, 0x7F,
  0xDF, 0xC1, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3B, 0x00, 0x0E,
  0x70, 0x01, 0x87, 0x00, 0x70, 0x70, 0x1C, 0x0E, 0x07, 0x00, 0xE0, 0x20,
  0x08, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x18, 0xC6, 0x31, 0x9C, 0xE7, 0x73, 0x18,
  0xFF, 0xFF, 0xF0, 0x7F, 0xF7, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0xF0,
  0x03, 0xFE, 0x01, 0xF7, 0xC0, 0xF0, 0x38, 0x38, 0x07, 0x1C, 0x01, 0xC6,
  0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0x6E, 0x00, 0x1B, 0x00,
  0x06, 0xC0, 0x01, 0xB0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x6E,
  0x00, 0x1B, 0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0xE6, 0x00, 0x39, 0xC0,
  0x0E, 0x70, 0x07, 0x0E, 0x01, 0xC3, 0xC0, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x40, 0xF0, 0xFC, 0xFF, 0xFC, 0xF8, 0x38, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x07, 0xF0,
  0x07, 0xFF, 0x03, 0xF7, 0xE1, 0xE0, 0x38, 0x70, 0x07, 0x38, 0x01, 0xCE,
  0x00, 0x3B, 0x00, 0x0E, 0xC0, 0x03, 0xB0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFB, 0xF0, 0xF0, 0x1C,
  0x38, 0x03, 0x9C, 0x00, 0x67, 0x00, 0x1D, 0xC0, 0x07, 0x60, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x36, 0x00, 0x0D, 0xC0, 0x07, 0x70, 0x01, 0xCE, 0x00, 0xE3, 0xC0,
  0x78, 0x7E, 0xFC, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0x70, 0x00,
  0x77, 0x00, 0x06, 0x70, 0x00, 0xE7, 0x00, 0x0C, 0x70, 0x01, 0xC7, 0x00,
  0x38, 0x70, 0x03, 0x07, 0x00, 0x70, 0x70, 0x06, 0x07, 0x00, 0xE0, 0x70,
  0x0C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x07, 0x03, 0x80, 0x70, 0x70, 0x07,
  0x07, 0x00, 0x70, 0xE0, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x3F, 0xFF, 0x9F,
  0xFF, 0xCF, 0xFF, 0xE6, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x3F,
  0x03, 0x7F, 0xC1, 0xFF, 0xF8, 0xF0, 0x3C, 0x60, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x73, 0x80,
  0x38, 0xE0, 0x38, 0x7E, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x61, 0xF8, 0x39, 0xFF, 0x0E, 0xFB, 0xE3, 0xF0, 0x3C, 0xF8, 0x07,
  0xBC, 0x00, 0xEE, 0x00, 0x1B, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x76, 0x00, 0x19, 0xC0,
  0x0E, 0x70, 0x03, 0x8E, 0x01, 0xC1, 0xC0, 0xF0, 0x7E, 0xF8, 0x07, 0xFC,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xF0, 0x03, 0xFF, 0x01, 0xF7, 0xE0, 0xE0, 0x3C, 0x70, 0x07, 0x1C,
  0x00, 0xE6, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00,
  0x39, 0x80, 0x0E, 0x70, 0x03, 0x9C, 0x01, 0xC3, 0x80, 0xE0, 0x7D, 0xF0,
  0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xC1, 0xE1, 0xC0, 0x1C, 0x70, 0x03, 0xB8,
  0x00, 0xEE, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0x9C, 0x00, 0xE7, 0x80, 0xF0, 0xFD, 0xF8,
  0x1F, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x01, 0xFB, 0xE0,
  0x70, 0x3C, 0x38, 0x07, 0x8E, 0x00, 0xE7, 0x00, 0x19, 0xC0, 0x07, 0x60,
  0x01, 0xD8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xD8, 0x00,
  0x36, 0x00, 0x0D, 0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0xF3, 0x80, 0x3C,
  0xF0, 0x3B, 0x1F, 0xBC, 0xC3, 0xFE, 0x70, 0x3E, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xE0, 0x00, 0x6F, 0xF6,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xF6, 0x33,
  0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC6, 0x31, 0x8C, 0xE7, 0x3B, 0x9C, 0xC0, 0x00, 0x01, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0x07,
  0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC0, 0xE7, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x0C, 0x38, 0x01, 0xF0, 0x06, 0x30,
  0x07, 0xF8, 0x06, 0x70, 0x0F, 0x1C, 0x06, 0x60, 0x1C, 0x0C, 0x06, 0x60,
  0x18, 0x0C, 0x03, 0x60, 0x38, 0x0C, 0x03, 0xE0, 0x30, 0x0C, 0x03, 0xC0,
  0x30, 0x0C, 0x03, 0xC0, 0x70, 0x0C, 0x03, 0xC0, 0x60, 0x0C, 0x03, 0xC0,
  0x60, 0x0C, 0x03, 0xC0, 0x60, 0x0C, 0x03, 0xC0, 0x60, 0x0C, 0x03, 0xC0,
  0xE0, 0x1C, 0x03, 0xC0, 0xE0, 0x1C, 0x06, 0xC0, 0xE0, 0x18, 0x06, 0xC0,
  0x60, 0x18, 0x06, 0xC0, 0x60, 0x38, 0x06, 0xC0, 0x60, 0x3C, 0x0C, 0xC0,
  0x70, 0x6C, 0x1C, 0xE0, 0x39, 0xCE, 0x38, 0x60, 0x3F, 0x87, 0xF0, 0x60,
  0x0F, 0x03, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x04, 0x00, 0x01,
  0xF0, 0x3C, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x76, 0x00, 0x00, 0x67, 0x00, 0x00, 0x67, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x80, 0x01, 0xC1, 0x80, 0x01,
  0x81, 0x80, 0x01, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x80, 0xC0, 0x03,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x60, 0x06, 0x00, 0x70, 0x0E,
  0x00, 0x70, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1C,
  0x00, 0x18, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x60,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x70, 0x03, 0xCE, 0x00, 0x39, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E,
  0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x19,
  0xC0, 0x07, 0x38, 0x01, 0xC7, 0x03, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3,
  0x80, 0x1E, 0x70, 0x01, 0xEE, 0x00, 0x1D, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0xE7, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0x80,
  0x78, 0x3C, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x00, 0x03, 0x9C, 0x00, 0x0E,
  0x70, 0x00, 0x39, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x06, 0x60, 0x00, 0x19, 0xC0,
  0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x38, 0x00, 0x70, 0xF0, 0x01,
  0xC1, 0xE0, 0x1E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0E, 0x00, 0x78, 0xE0, 0x03,
  0xCE, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01,
  0xCE, 0x00, 0x3C, 0xE0, 0x07, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCE, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0x80, 0x3C, 0x3C, 0x00,
  0x70, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x06, 0x70, 0x00, 0x1D,
  0x80, 0x00, 0x76, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x76,
  0x00, 0x01, 0xD8, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00,
  0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0x70, 0x00, 0xF0, 0xF0, 0x07,
  0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x73, 0x80, 0x39, 0xE0, 0x38, 0x7F, 0xFC, 0x1F, 0xF8, 0x03, 0xF0,
  0x00, 0xE0, 0x00, 0x77, 0x00, 0x07, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x8E,
  0x00, 0x78, 0x70, 0x03, 0x83, 0x80, 0x38, 0x1C, 0x03, 0x80, 0xE0, 0x3C,
  0x07, 0x01, 0xC0, 0x38, 0x1C, 0x01, 0xC1, 0xC0, 0x0E, 0x1E, 0x00, 0x71,
  0xE0, 0x03, 0x8E, 0x00, 0x1C, 0xF0, 0x00, 0xEF, 0x80, 0x07, 0xEE, 0x00,
  0x3F, 0x38, 0x01, 0xF1, 0xE0, 0x0F, 0x07, 0x00, 0x70, 0x1C, 0x03, 0x80,
  0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x00, 0x78, 0x38, 0x01, 0xC1,
  0xC0, 0x07, 0x0E, 0x00, 0x3C, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00,
  0x1E, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFE, 0xC0, 0x00, 0x37,
  0xEE, 0x00, 0x07, 0x7E, 0xE0, 0x00, 0x77, 0xE6, 0x00, 0x06, 0x7E, 0x70,
  0x00, 0xE7, 0xE7, 0x00, 0x0E, 0x7E, 0x30, 0x00, 0xC7, 0xE3, 0x80, 0x1C,
  0x7E, 0x38, 0x01, 0xC7, 0xE1, 0x80, 0x18, 0x7E, 0x1C, 0x03, 0x87, 0xE1,
  0xC0, 0x30, 0x7E, 0x0C, 0x03, 0x07, 0xE0, 0xE0, 0x70, 0x7E, 0x0E, 0x06,
  0x07, 0xE0, 0x60, 0xE0, 0x7E, 0x07, 0x0E, 0x07, 0xE0, 0x30, 0xC0, 0x7E,
  0x03, 0x1C, 0x07, 0xE0, 0x39, 0xC0, 0x7E, 0x01, 0x98, 0x07, 0xE0, 0x1B,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x00, 0x7E, 0x00, 0xF0, 0x07,
  0xE0, 0x0F, 0x00, 0x7E, 0x00, 0x60, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7E,
  0xC0, 0x01, 0xFB, 0x80, 0x07, 0xE7, 0x00, 0x1F, 0x9C, 0x00, 0x7E, 0x38,
  0x01, 0xF8, 0xE0, 0x07, 0xE1, 0xC0, 0x1F, 0x87, 0x00, 0x7E, 0x0E, 0x01,
  0xF8, 0x18, 0x07, 0xE0, 0x70, 0x1F, 0x80, 0xC0, 0x7E, 0x03, 0x81, 0xF8,
  0x07, 0x07, 0xE0, 0x1C, 0x1F, 0x80, 0x38, 0x7E, 0x00, 0xE1, 0xF8, 0x01,
  0xC7, 0xE0, 0x03, 0x1F, 0x80, 0x0E, 0x7E, 0x00, 0x19, 0xF8, 0x00, 0x77,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x70, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0x80, 0x78, 0x3C, 0x00, 0x70, 0xE0, 0x01, 0xE7, 0x00, 0x03,
  0x9C, 0x00, 0x06, 0x60, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1D, 0x80, 0x00, 0x77, 0x00, 0x01, 0x9C, 0x00, 0x0E, 0x38, 0x00,
  0x38, 0xF0, 0x01, 0xC1, 0xE0, 0x1E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8E, 0x00,
  0x3C, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x06, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x03, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0x80, 0x78, 0x3C, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x00, 0x03, 0x9C,
  0x00, 0x0E, 0x60, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1D, 0x80, 0x00, 0x77, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x38, 0x00, 0x78,
  0xF0, 0x01, 0xC1, 0xE0, 0x1E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x02, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0E, 0x00, 0x78, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E,
  0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x07,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xE0, 0x1C, 0x0E, 0x01,
  0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x03, 0x8E, 0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xF0, 0x3C, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x39, 0xC0,
  0x01, 0xCE, 0x00, 0x06, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x07, 0x1C,
  0x00, 0x78, 0xF8, 0x07, 0x83, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x06, 0xE0, 0x00, 0xE7, 0x00, 0x1E, 0x78, 0x03, 0xC3, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x3F, 0x80, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x38, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x03, 0x81,
  0xC0, 0x03, 0x81, 0xC0, 0x01, 0x81, 0xC0, 0x01, 0x81, 0x80, 0x01, 0xC3,
  0x80, 0x01, 0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xB8, 0x00, 0x70, 0x00, 0xEE, 0x00, 0x1C, 0x00, 0x3B, 0x80,
  0x07, 0x80, 0x0E, 0x60, 0x03, 0xE0, 0x03, 0x9C, 0x00, 0xD8, 0x00, 0xC7,
  0x00, 0x36, 0x00, 0x71, 0xC0, 0x0D, 0xC0, 0x1C, 0x70, 0x07, 0x30, 0x07,
  0x0C, 0x01, 0xCC, 0x01, 0xC3, 0x80, 0x63, 0x00, 0x60, 0xE0, 0x18, 0xE0,
  0x38, 0x38, 0x0E, 0x18, 0x0E, 0x06, 0x03, 0x86, 0x03, 0x81, 0x80, 0xC1,
  0x80, 0xC0, 0x70, 0x30, 0x70, 0x30, 0x1C, 0x1C, 0x0C, 0x1C, 0x07, 0x07,
  0x03, 0x07, 0x00, 0xC1, 0x80, 0xC1, 0xC0, 0x30, 0x60, 0x38, 0x60, 0x0E,
  0x38, 0x0E, 0x18, 0x03, 0x8E, 0x01, 0x8E, 0x00, 0xE3, 0x00, 0x63, 0x80,
  0x18, 0xC0, 0x1C, 0xE0, 0x06, 0x70, 0x07, 0x30, 0x01, 0xDC, 0x00, 0xCC,
  0x00, 0x76, 0x00, 0x37, 0x00, 0x0D, 0x80, 0x0D, 0xC0, 0x03, 0x60, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0xE0,
  0x00, 0x3D, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x8E, 0x00, 0x1C, 0x3C, 0x00,
  0xE0, 0x70, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x03, 0x80,
  0x1C, 0x0E, 0x00, 0x38, 0x70, 0x00, 0xE3, 0x80, 0x01, 0xCE, 0x00, 0x07,
  0x70, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00,
  0x38, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0x78, 0x1C, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x07,
  0x1C, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x39, 0xC0, 0x00, 0x71, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x83,
  0x80, 0x0E, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x70,
  0x70, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xDC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xFF, 0xF0, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xE0, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF,
  0xF0, 0x03, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x37, 0x00,
  0xCC, 0x07, 0x30, 0x18, 0xE0, 0x61, 0x83, 0x86, 0x0C, 0x1C, 0x70, 0x31,
  0xC0, 0xC6, 0x03, 0xB8, 0x06, 0xE0, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x70, 0x38, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xDF, 0x8F, 0x01, 0xC7, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0xFF, 0xE1, 0xFF, 0xF1, 0xF0,
  0x39, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x60, 0x03, 0xB0, 0x01, 0xD8,
  0x00, 0xEC, 0x00, 0x77, 0x00, 0x7B, 0xC0, 0xFC, 0xFF, 0xEE, 0x3F, 0xE3,
  0x0F, 0xC1, 0xC0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x1F, 0x83, 0x9F, 0xF0, 0xEF, 0xFE, 0x3F, 0x01, 0xCF, 0x80,
  0x3B, 0xC0, 0x0E, 0xE0, 0x01, 0xB8, 0x00, 0x6E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xB8, 0x00, 0xEF, 0x00,
  0x3B, 0xC0, 0x0E, 0xFC, 0x0F, 0x3B, 0xFF, 0x8E, 0x7F, 0xC3, 0x87, 0xE0,
  0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFB, 0xF0, 0xF0, 0x1C, 0x38, 0x03, 0x9C,
  0x00, 0x67, 0x00, 0x19, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0x8E,
  0x00, 0xE3, 0xC0, 0x70, 0x7E, 0xFC, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC1, 0xF8, 0xE3, 0xFE,
  0x73, 0xFF, 0xBB, 0xC0, 0x7D, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0E, 0xE0, 0x0F, 0x78, 0x0F, 0x9F, 0xFD, 0xC7,
  0xFC, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFB, 0xF0, 0xF0,
  0x1C, 0x38, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x19, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x63, 0xC0, 0x38, 0x7F, 0xFE, 0x0F, 0xFE,
  0x00, 0xFE, 0x00, 0x01, 0xF0, 0x7F, 0x07, 0xF0, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xFF, 0xEF, 0xFE, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x07, 0xE3, 0x8F,
  0xF9, 0xCF, 0xFE, 0xEF, 0x01, 0xF7, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x3D, 0xE0, 0x3E, 0x7F, 0xF7,
  0x1F, 0xF3, 0x83, 0xF1, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x40, 0x0E, 0x70, 0x0E, 0x1F, 0x3F, 0x07, 0xFF, 0x00,
  0xFE, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x7E, 0x1C, 0x7F, 0x8E, 0xFF, 0xE7, 0x60, 0x7B, 0xE0, 0x1D, 0xE0, 0x06,
  0xF0, 0x03, 0x70, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x70, 0x6F, 0xF6, 0x00, 0x00, 0x06,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x60, 0x06, 0x0F, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0xFC, 0xFC, 0xF0, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x01, 0xDC, 0x01, 0xCE,
  0x01, 0xC7, 0x01, 0xE3, 0x81, 0xE1, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0,
  0x38, 0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x07, 0x78, 0x03, 0xFE, 0x01, 0xF7,
  0x00, 0xF1, 0xC0, 0x78, 0xE0, 0x38, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x07,
  0x01, 0xC3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x0E, 0x70, 0x03, 0xB8, 0x01,
  0xDC, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE1, 0xF8, 0x0F, 0xC3, 0x9F, 0xF0, 0x7F, 0xCE, 0xFF, 0xE3, 0xDF, 0xBF,
  0x03, 0xD8, 0x0E, 0xF8, 0x07, 0xC0, 0x1F, 0xC0, 0x0F, 0x00, 0x7F, 0x00,
  0x38, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x0E,
  0x00, 0x3E, 0x00, 0x38, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0x80,
  0x0F, 0x80, 0x0E, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xF8, 0x00, 0xE0, 0x03,
  0xE0, 0x03, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xF8,
  0x00, 0xE0, 0x03, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x3E, 0x00,
  0x38, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x0E,
  0x00, 0x30, 0xE1, 0xF8, 0x71, 0xFE, 0x3B, 0xFF, 0x9D, 0x81, 0xEF, 0x80,
  0x77, 0x80, 0x1B, 0xC0, 0x0D, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xC0, 0x03, 0xF0,
  0x03, 0xFF, 0x01, 0xF7, 0xE0, 0xE0, 0x3C, 0x70, 0x07, 0x1C, 0x00, 0xEE,
  0x00, 0x1B, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x06, 0x70, 0x03, 0x9C, 0x01, 0xC3,
  0x80, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0xE1, 0xF8, 0x39,
  0xFF, 0x0E, 0xFF, 0xE3, 0xF0, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0xEE, 0x00,
  0x3B, 0x80, 0x06, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1B, 0x80, 0x0E, 0xF0, 0x03, 0xBC, 0x01, 0xEF, 0x80,
  0xF3, 0xBF, 0xF8, 0xE7, 0xFC, 0x38, 0x7E, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE3, 0x8F, 0xF9, 0xCF, 0xDE,
  0xEF, 0x01, 0xF7, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3B, 0x80, 0x3D, 0xE0, 0x3E, 0x7E, 0xFF, 0x1F, 0xFB, 0x83,
  0xF1, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0xE3,
  0xF9, 0xFE, 0xFF, 0xF0, 0xF8, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x03, 0xF0, 0x07, 0xFE,
  0x07, 0xDF, 0x87, 0x01, 0xE7, 0x00, 0x73, 0x80, 0x19, 0xC0, 0x0E, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xFC, 0x00, 0x76, 0x00, 0x3B, 0x80, 0x18, 0xE0, 0x1C, 0x7F, 0xFC, 0x1F,
  0xFC, 0x01, 0xF8, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x3F, 0xFF, 0xFF, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1F, 0xC1, 0xF8, 0x1F,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xEC, 0x00, 0x77, 0x00, 0x7B, 0x80, 0x3C, 0xE0,
  0x7E, 0x7F, 0xF7, 0x1F, 0xF3, 0x83, 0xF1, 0xC0, 0xE0, 0x01, 0xD8, 0x00,
  0x77, 0x00, 0x19, 0xC0, 0x0E, 0x30, 0x03, 0x8E, 0x00, 0xC3, 0x80, 0x30,
  0xE0, 0x1C, 0x18, 0x07, 0x07, 0x01, 0x81, 0xC0, 0xE0, 0x30, 0x38, 0x0E,
  0x0C, 0x03, 0x83, 0x00, 0x61, 0xC0, 0x18, 0x60, 0x07, 0x18, 0x00, 0xCE,
  0x00, 0x33, 0x80, 0x0E, 0xC0, 0x03, 0xB0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0xC0, 0x0E, 0x00, 0x6E, 0x00,
  0xE0, 0x06, 0xE0, 0x0E, 0x00, 0xEE, 0x00, 0xF0, 0x0E, 0x60, 0x1F, 0x00,
  0xC7, 0x01, 0xB0, 0x0C, 0x70, 0x1B, 0x01, 0xC7, 0x01, 0xB8, 0x1C, 0x30,
  0x3B, 0x81, 0xC3, 0x03, 0x18, 0x18, 0x38, 0x31, 0x81, 0x83, 0x83, 0x1C,
  0x38, 0x18, 0x70, 0xC3, 0x81, 0x86, 0x0C, 0x30, 0x1C, 0x60, 0xC3, 0x01,
  0xCE, 0x0E, 0x70, 0x0C, 0xE0, 0x67, 0x00, 0xCC, 0x06, 0x60, 0x0E, 0xC0,
  0x66, 0x00, 0xFC, 0x07, 0x60, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x03, 0xC0,
  0x07, 0x80, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30,
  0x01, 0x80, 0x70, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0x38, 0x70, 0x1C, 0x1C,
  0x0E, 0x03, 0x83, 0x80, 0xE1, 0xC0, 0x1C, 0x70, 0x07, 0x38, 0x00, 0xEE,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x0E, 0xC0, 0x03, 0xB8, 0x01, 0xC6, 0x00, 0x61, 0xC0, 0x38, 0x38, 0x1C,
  0x0E, 0x07, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x0E, 0x70, 0x03, 0x9C, 0x00,
  0x70, 0xE0, 0x01, 0xD8, 0x00, 0x77, 0x00, 0x19, 0xC0, 0x0E, 0x70, 0x03,
  0x8E, 0x00, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x18, 0x07, 0x07, 0x01, 0x81,
  0xC0, 0xE0, 0x30, 0x38, 0x0E, 0x0C, 0x03, 0x87, 0x00, 0x61, 0xC0, 0x1C,
  0x60, 0x07, 0x18, 0x00, 0xCE, 0x00, 0x33, 0x80, 0x0E, 0xC0, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0x7F, 0xFF,
  0x3F, 0xFF, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x0E, 0x01, 0xC0, 0x38,
  0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xF0, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x3E, 0x00, 0xF0, 0x1F, 0x03, 0x80, 0x70, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x0C, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x33, 0xFE, 0x00, 0xDC,
  0x1C, 0x03, 0x60, 0x38, 0x1D, 0x80, 0xF0, 0xEE, 0x01, 0xFF, 0xB8, 0x01,
  0xFC, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_Light48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 34, 10, 4, -34 },
  { 14, 8, 11, 14, 3, -36 },
  { 25, 22, 34, 25, 2, -34 },
  { 119, 18, 43, 23, 3, -39 },
  { 216, 25, 34, 31, 3, -34 },
  { 323, 22, 34, 26, 3, -34 },
  { 417, 2, 10, 8, 3, -36 },
  { 420, 10, 49, 14, 3, -38 },
  { 482, 10, 49, 14, 1, -38 },
  { 544, 19, 19, 20, 1, -34 },
  { 590, 20, 25, 24, 2, -29 },
  { 653, 5, 11, 9, 1, -4 },
  { 660, 10, 2, 12, 1, -16 },
  { 663, 4, 4, 11, 3, -4 },
  { 665, 14, 37, 17, 1, -34 },
  { 730, 18, 34, 23, 3, -34 },
  { 807, 10, 34, 23, 4, -34 },
  { 850, 18, 34, 23, 3, -34 },
  { 927, 18, 34, 23, 2, -34 },
  { 1004, 20, 34, 23, 2, -34 },
  { 1089, 17, 34, 23, 4, -34 },
  { 1162, 18, 34, 23, 3, -34 },
  { 1239, 19, 34, 23, 2, -34 },
  { 1320, 18, 34, 23, 3, -34 },
  { 1397, 18, 34, 23, 2, -34 },
  { 1474, 4, 26, 10, 3, -26 },
  { 1487, 5, 33, 9, 2, -26 },
  { 1508, 16, 20, 22, 2, -25 },
  { 1548, 17, 13, 23, 3, -22 },
  { 1576, 17, 20, 22, 3, -25 },
  { 1619, 15, 34, 19, 2, -34 },
  { 1683, 32, 44, 38, 3, -33 },
  { 1859, 24, 34, 26, 1, -34 },
  { 1961, 19, 34, 26, 4, -34 },
  { 2042, 22, 34, 27, 3, -34 },
  { 2136, 20, 34, 27, 4, -34 },
  { 2221, 18, 34, 24, 4, -34 },
  { 2298, 18, 34, 24, 4, -34 },
  { 2375, 22, 34, 29, 3, -34 },
  { 2469, 21, 34, 30, 4, -34 },
  { 2559, 2, 34, 12, 5, -34 },
  { 2568, 17, 34, 23, 2, -34 },
  { 2641, 21, 34, 26, 4, -34 },
  { 2731, 17, 34, 22, 4, -34 },
  { 2804, 28, 34, 36, 4, -34 },
  { 2923, 22, 34, 30, 4, -34 },
  { 3017, 22, 34, 28, 3, -34 },
  { 3111, 20, 34, 26, 4, -34 },
  { 3196, 22, 40, 28, 3, -34 },
  { 3306, 20, 34, 26, 4, -34 },
  { 3391, 21, 34, 25, 2, -34 },
  { 3481, 23, 34, 25, 1, -34 },
  { 3579, 20, 34, 27, 4, -34 },
  { 3664, 24, 34, 26, 1, -34 },
  { 3766, 34, 34, 37, 2, -34 },
  { 3911, 22, 34, 26, 2, -34 },
  { 4005, 23, 34, 25, 1, -34 },
  { 4103, 21, 34, 25, 2, -34 },
  { 4193, 6, 46, 11, 4, -39 },
  { 4228, 15, 37, 17, 1, -34 },
  { 4298, 6, 46, 11, 1, -39 },
  { 4333, 14, 17, 18, 2, -34 },
  { 4363, 17, 2, 19, 1, 0 },
  { 4368, 8, 7, 14, 2, -36 },
  { 4375, 17, 26, 23, 3, -26 },
  { 4431, 18, 36, 23, 3, -36 },
  { 4512, 18, 26, 22, 2, -26 },
  { 4571, 17, 36, 23, 3, -36 },
  { 4648, 18, 26, 22, 2, -26 },
  { 4707, 12, 36, 14, 2, -36 },
  { 4761, 17, 36, 23, 3, -26 },
  { 4838, 17, 36, 23, 3, -36 },
  { 4915, 4, 35, 10, 3, -35 },
  { 4933, 8, 45, 10, -1, -35 },
  { 4978, 17, 36, 21, 3, -36 },
  { 5055, 2, 36, 10, 4, -36 },
  { 5064, 30, 26, 37, 3, -26 },
  { 5162, 17, 26, 23, 3, -26 },
  { 5218, 18, 26, 24, 3, -26 },
  { 5277, 18, 36, 23, 3, -26 },
  { 5358, 17, 36, 24, 3, -26 },
  { 5435, 10, 26, 15, 3, -26 },
  { 5468, 17, 26, 21, 2, -26 },
  { 5524, 11, 32, 14, 1, -32 },
  { 5568, 17, 26, 23, 3, -26 },
  { 5624, 18, 26, 20, 1, -26 },
  { 5683, 28, 26, 31, 2, -26 },
  { 5774, 18, 26, 21, 1, -26 },
  { 5833, 18, 36, 20, 1, -26 },
  { 5914, 17, 26, 21, 2, -26 },
  { 5970, 12, 46, 14, 2, -37 },
  { 6039, 3, 40, 11, 4, -34 },
  { 6054, 12, 46, 14, 1, -37 },
  { 6123, 22, 9, 29, 3, -19 },
};

const GFXfont RobotoCondensed_Light48pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light48pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light48pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _ROBOTOCONDENSED_LIGHT48PT7B_H_
