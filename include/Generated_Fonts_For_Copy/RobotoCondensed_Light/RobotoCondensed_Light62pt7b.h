#ifndef _ROBOTOCONDENSED_LIGHT62PT7B_H_
#define _ROBOTOCONDENSED_LIGHT62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light62pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xB8, 0x37, 0x06, 0xE0,
  0xDC, 0x3B, 0x87, 0x70, 0xEE, 0x1D, 0xC3, 0x80, 0x00, 0x1C, 0x03, 0x80,
  0x01, 0xC0, 0x30, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x18,
  0x07, 0x00, 0x01, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x60,
  0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x03,
  0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x01, 0xC0, 0x00,
  0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x18, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0xE0, 0x38, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x38, 0x00,
  0x1C, 0x03, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0,
  0x70, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0x03, 0x80, 0x60, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x30,
  0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x70, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7C,
  0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x07, 0x1E, 0x00,
  0x0F, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00,
  0x73, 0x80, 0x00, 0xE7, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x77, 0x80, 0x00,
  0xE7, 0x00, 0x03, 0xCF, 0x00, 0x07, 0x8F, 0x00, 0x3E, 0x1F, 0x80, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80,
  0x38, 0x03, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xE0, 0x38, 0x03, 0x80, 0x38, 0x0C, 0x00, 0xE0, 0x0E, 0x07, 0x00,
  0x38, 0x03, 0x81, 0x80, 0x06, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0x38, 0x30,
  0x00, 0x70, 0x1C, 0x1C, 0x00, 0x0E, 0x07, 0x0E, 0x00, 0x03, 0xC7, 0x83,
  0x80, 0x00, 0x7F, 0xC1, 0xC0, 0x00, 0x0F, 0xE0, 0x70, 0x00, 0x00, 0x40,
  0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x7F, 0x00, 0x00, 0x38, 0x3F, 0xE0,
  0x00, 0x1C, 0x1E, 0x3C, 0x00, 0x06, 0x0E, 0x07, 0x00, 0x03, 0x83, 0x00,
  0xE0, 0x00, 0xC1, 0xC0, 0x38, 0x00, 0x70, 0x70, 0x06, 0x00, 0x38, 0x1C,
  0x01, 0x80, 0x0E, 0x07, 0x00, 0x70, 0x07, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x1C,
  0x01, 0xC0, 0x18, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x80, 0x0E, 0x03, 0x80,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xC0,
  0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x1C,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1C,
  0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x78, 0xF0, 0x07, 0x07, 0x83, 0xC0, 0x38, 0x78,
  0x1E, 0x01, 0xC3, 0x80, 0x78, 0x0E, 0x3C, 0x01, 0xE0, 0x71, 0xC0, 0x07,
  0x83, 0x8E, 0x00, 0x3C, 0x3C, 0xF0, 0x00, 0xF1, 0xC7, 0x80, 0x03, 0xCE,
  0x3C, 0x00, 0x1F, 0xF1, 0xE0, 0x00, 0x7F, 0x07, 0x00, 0x01, 0xF8, 0x38,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xF0, 0x3C, 0x00,
  0x3F, 0xC0, 0xF8, 0x07, 0xCF, 0x07, 0xFB, 0xFC, 0x78, 0x0F, 0xFF, 0xC1,
  0xE0, 0x3F, 0xF8, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xED, 0x80, 0x00, 0x10, 0x01, 0x80, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x40, 0x40, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x30, 0x01, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x02, 0x70, 0x1C, 0x07, 0x7E, 0x0E, 0x1F, 0xBF,
  0xE7, 0x3F, 0xE7, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x70, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x04, 0x00, 0x20, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xCF, 0x3C, 0xE7, 0xBC,
  0xE1, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xEF, 0xFF, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x1E, 0x0F,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x38, 0xE0, 0x00, 0x73, 0xC0,
  0x00, 0xF7, 0x80, 0x01, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00,
  0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70,
  0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0xF3, 0x80,
  0x01, 0xE7, 0x00, 0x03, 0x8F, 0x00, 0x07, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x78, 0x3E, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x08, 0x03, 0xC0, 0x7E,
  0x0F, 0xF1, 0xFF, 0xFF, 0x9F, 0xF0, 0xFE, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x00,
  0x78, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xF0, 0x0F,
  0x03, 0xC0, 0x0F, 0x0F, 0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x78, 0x00, 0x1C,
  0xE0, 0x00, 0x39, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xEE, 0x00, 0x03, 0xDE,
  0x00, 0x07, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1E,
  0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x07, 0x00,
  0x07, 0x00, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x0F, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x03,
  0xC0, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x1E, 0x00, 0x1C, 0x03, 0x80, 0x03,
  0x80, 0xF0, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC7, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0xFE, 0x01, 0xEF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xE3, 0xF8, 0x7C,
  0x01, 0xF1, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0x70, 0x00, 0x39, 0xE0, 0x00,
  0xE7, 0x80, 0x07, 0x8F, 0x00, 0x3C, 0x1F, 0x01, 0xF0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x3F, 0x80, 0x71, 0xFF, 0xC1, 0xE7, 0xFF, 0xC3,
  0xDF, 0x0F, 0xC7, 0x78, 0x07, 0x8F, 0xC0, 0x07, 0x9F, 0x00, 0x07, 0x3E,
  0x00, 0x0F, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xC0, 0x00,
  0x73, 0xC0, 0x00, 0xE7, 0x80, 0x03, 0xC7, 0x80, 0x07, 0x0F, 0x00, 0x1E,
  0x0F, 0x00, 0x78, 0x0F, 0x81, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0x81, 0xF8, 0x1E, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x0E,
  0x78, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x3C,
  0x1E, 0x00, 0x38, 0x0F, 0x00, 0xF8, 0x07, 0xC3, 0xF0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0x81, 0xF0, 0x1E, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x0E,
  0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01,
  0xF0, 0x1F, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x78,
  0x00, 0x3C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x01,
  0xEF, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0x9E, 0x00, 0x1F, 0x3C, 0x00, 0x7E,
  0x3C, 0x01, 0xDC, 0x3E, 0x0F, 0x38, 0x7F, 0xFC, 0x70, 0x3F, 0xF0, 0xE0,
  0x1F, 0x83, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x27, 0xFF,
  0xF7, 0x90, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x7F, 0xFF, 0xF9, 0x00, 0x08, 0x78, 0xF9, 0xF3,
  0xC1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0xF1, 0xE3, 0x8F, 0x1C, 0x70, 0x60, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0x78, 0xF0, 0x07, 0x9C, 0x00,
  0x77, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0xFC, 0x00, 0x30, 0xE0, 0x00,
  0xFF, 0x80, 0x1C, 0x70, 0x01, 0xFF, 0xE0, 0x0E, 0x38, 0x01, 0xF0, 0x78,
  0x03, 0x38, 0x00, 0xE0, 0x1C, 0x01, 0x9C, 0x00, 0xE0, 0x0E, 0x00, 0xEE,
  0x00, 0x70, 0x07, 0x00, 0x77, 0x00, 0x70, 0x03, 0x80, 0x3F, 0x00, 0x38,
  0x01, 0xC0, 0x1F, 0x80, 0x38, 0x00, 0xC0, 0x0F, 0xC0, 0x1C, 0x00, 0x60,
  0x03, 0xE0, 0x0E, 0x00, 0x70, 0x01, 0xF0, 0x06, 0x00, 0x38, 0x00, 0xF8,
  0x07, 0x00, 0x1C, 0x00, 0x7C, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x01, 0xC0,
  0x07, 0x00, 0x3E, 0x00, 0xE0, 0x03, 0x80, 0x1F, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x80, 0x38, 0x00, 0xE0, 0x07, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0xE0,
  0x0E, 0x00, 0x38, 0x01, 0xB8, 0x07, 0x00, 0x3C, 0x01, 0xDC, 0x03, 0x80,
  0x1E, 0x00, 0xEE, 0x01, 0xC0, 0x0F, 0x00, 0x67, 0x00, 0xE0, 0x0F, 0x80,
  0x73, 0x80, 0x38, 0x0F, 0xC0, 0x39, 0xC0, 0x1E, 0x0E, 0xF0, 0x38, 0x70,
  0x0F, 0x9E, 0x38, 0x38, 0x38, 0x03, 0xFF, 0x1F, 0xF8, 0x1C, 0x00, 0xFE,
  0x07, 0xF8, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x01, 0x00, 0x00, 0x07, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x01,
  0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1E, 0x00, 0x7F, 0x0F,
  0x00, 0x07, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C,
  0xF0, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x3C, 0x00, 0x03, 0x9E, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x39, 0xE0, 0x00,
  0x3C, 0xF0, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x1E, 0x00,
  0x7E, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xE0,
  0x01, 0xF8, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x77, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00,
  0x79, 0xE0, 0x00, 0x7C, 0xF0, 0x01, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0xF0,
  0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0E, 0x38,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x80, 0x7C, 0x01, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xC0, 0x1F, 0xE0, 0xF0,
  0x00, 0xFC, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C,
  0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x3C, 0x00,
  0x07, 0x8F, 0x00, 0x03, 0xE3, 0xC0, 0x03, 0xF0, 0xF0, 0x07, 0xF8, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0E, 0x78, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x80, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x71, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x7E,
  0x00, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7B,
  0x80, 0x00, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9F, 0x00, 0x1E, 0x1E,
  0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x01, 0xF0,
  0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0xF0,
  0x0F, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0xF3, 0xF0, 0x00, 0x0F, 0x7F, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xF3, 0xC0, 0x00, 0xFE, 0x3E, 0x00, 0x0F, 0xC1, 0xE0, 0x00,
  0xF8, 0x0F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0,
  0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xEE, 0x00, 0x00, 0x07, 0xFE,
  0xE0, 0x00, 0x00, 0x77, 0xEF, 0x00, 0x00, 0x07, 0x7E, 0x70, 0x00, 0x00,
  0xF7, 0xE7, 0x00, 0x00, 0x0E, 0x7E, 0x78, 0x00, 0x00, 0xE7, 0xF3, 0x80,
  0x00, 0x1E, 0x7F, 0x38, 0x00, 0x01, 0xC7, 0xF3, 0xC0, 0x00, 0x1C, 0x7F,
  0x1C, 0x00, 0x03, 0xC7, 0xF1, 0xC0, 0x00, 0x38, 0x7F, 0x1E, 0x00, 0x07,
  0x87, 0xF0, 0xE0, 0x00, 0x70, 0x7F, 0x0F, 0x00, 0x07, 0x07, 0xF0, 0x70,
  0x00, 0xF0, 0x7F, 0x07, 0x00, 0x0E, 0x07, 0xF0, 0x78, 0x00, 0xE0, 0x7F,
  0x03, 0x80, 0x1E, 0x07, 0xF0, 0x38, 0x01, 0xC0, 0x7F, 0x03, 0xC0, 0x1C,
  0x07, 0xF0, 0x1C, 0x03, 0xC0, 0x7F, 0x01, 0xC0, 0x38, 0x07, 0xF0, 0x1E,
  0x03, 0x80, 0x7F, 0x00, 0xE0, 0x78, 0x07, 0xF0, 0x0E, 0x07, 0x00, 0x7F,
  0x00, 0xF0, 0x70, 0x07, 0xF0, 0x07, 0x0F, 0x00, 0x7F, 0x00, 0x70, 0xE0,
  0x07, 0xF0, 0x07, 0x8E, 0x00, 0x7F, 0x00, 0x39, 0xC0, 0x07, 0xF0, 0x03,
  0x9C, 0x00, 0x7F, 0x00, 0x1D, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0x00,
  0x07, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xF7, 0x00, 0x00, 0x7F, 0x78, 0x00, 0x07, 0xF3, 0xC0, 0x00,
  0x7F, 0x1C, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0x7F, 0x0E, 0x00, 0x07, 0xF0,
  0xF0, 0x00, 0x7F, 0x07, 0x00, 0x07, 0xF0, 0x78, 0x00, 0x7F, 0x03, 0x80,
  0x07, 0xF0, 0x3C, 0x00, 0x7F, 0x01, 0xE0, 0x07, 0xF0, 0x1E, 0x00, 0x7F,
  0x00, 0xF0, 0x07, 0xF0, 0x07, 0x00, 0x7F, 0x00, 0x78, 0x07, 0xF0, 0x03,
  0x80, 0x7F, 0x00, 0x3C, 0x07, 0xF0, 0x01, 0xC0, 0x7F, 0x00, 0x1E, 0x07,
  0xF0, 0x00, 0xF0, 0x7F, 0x00, 0x0F, 0x07, 0xF0, 0x00, 0x78, 0x7F, 0x00,
  0x03, 0x87, 0xF0, 0x00, 0x3C, 0x7F, 0x00, 0x01, 0xC7, 0xF0, 0x00, 0x1E,
  0x7F, 0x00, 0x00, 0xE7, 0xF0, 0x00, 0x0F, 0x7F, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x00,
  0x78, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x9C,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x1E, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xC0, 0x07, 0xF0, 0xF0, 0x00, 0x3E, 0x3C,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0E, 0xF0,
  0x00, 0x03, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3C,
  0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x1F, 0xE3, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0x01,
  0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0E,
  0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x61, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xC0, 0x07,
  0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x3C, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x0F,
  0x00, 0x1F, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x00,
  0x38, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1E,
  0x3C, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1C, 0xF0, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x00,
  0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x1E, 0x78, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0,
  0x00, 0x07, 0x78, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x77, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x0F,
  0x87, 0xE0, 0x0F, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0E,
  0xF0, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF0, 0xF8, 0x00,
  0x7C, 0x3F, 0x00, 0x7E, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0xC0,
  0x07, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x70, 0x07, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x01,
  0xC0, 0x78, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x78, 0x00, 0x1F, 0x80, 0x01,
  0xE7, 0x80, 0x01, 0xF8, 0x00, 0x1E, 0x38, 0x00, 0x1F, 0x80, 0x01, 0xE3,
  0x80, 0x01, 0xD8, 0x00, 0x1C, 0x38, 0x00, 0x3D, 0xC0, 0x01, 0xC3, 0xC0,
  0x03, 0x9C, 0x00, 0x3C, 0x3C, 0x00, 0x39, 0xC0, 0x03, 0xC1, 0xC0, 0x03,
  0x9C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x0E,
  0x00, 0x38, 0x1E, 0x00, 0x70, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x0E, 0x00,
  0x78, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xE0, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x07, 0x00, 0xF0, 0x07,
  0x00, 0xE0, 0x38, 0x0F, 0x00, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x00, 0x78, 0x1C, 0x03, 0x80, 0xE0, 0x07, 0x81, 0xC0,
  0x1C, 0x1E, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x1C,
  0x1C, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x03, 0xC3, 0x80, 0x0E, 0x1C,
  0x00, 0x3C, 0x70, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x1E,
  0xE0, 0x00, 0x73, 0x80, 0x00, 0xEE, 0x00, 0x07, 0x78, 0x00, 0x0E, 0xE0,
  0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78,
  0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x3C, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x1E,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x78, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C,
  0x3C, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x38, 0x07, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0xFF, 0xFF,
  0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3B, 0x80, 0x1D, 0xC0,
  0x0E, 0xE0, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x8E, 0x03, 0x83, 0x81, 0xC1,
  0xC1, 0xE0, 0xE0, 0xE0, 0x38, 0x70, 0x1C, 0x78, 0x0E, 0x38, 0x07, 0x9C,
  0x01, 0xDE, 0x00, 0xEE, 0x00, 0x7F, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x38, 0x07, 0x00, 0x10, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xFC, 0x1F, 0x01, 0xF0, 0xF0, 0x01, 0xE3, 0x80, 0x07, 0x9E, 0x00,
  0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xF8, 0x03, 0xCF, 0x80, 0x0F, 0x78, 0x00,
  0x3D, 0xE0, 0x00, 0xF7, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0x70, 0x00, 0xFD, 0xE0,
  0x07, 0xF7, 0xC0, 0x7B, 0xCF, 0xFF, 0xEF, 0x1F, 0xFE, 0x3C, 0x3F, 0xF0,
  0x70, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0x00, 0x3C, 0x3F, 0xE0, 0x79,
  0xFF, 0xF0, 0xF7, 0xFF, 0xF1, 0xEE, 0x03, 0xE3, 0xF0, 0x01, 0xE7, 0xE0,
  0x01, 0xCF, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x78, 0x00,
  0x0E, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x78, 0x00, 0x1E, 0xF8,
  0x00, 0x3D, 0xF0, 0x00, 0xF3, 0xF0, 0x01, 0xE7, 0xF8, 0x0F, 0x8F, 0x7F,
  0xFE, 0x1E, 0x7F, 0xF8, 0x3C, 0x3F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0x01, 0xF0,
  0xF0, 0x01, 0xE3, 0x80, 0x03, 0x9E, 0x00, 0x0F, 0x70, 0x00, 0x1D, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01,
  0xDE, 0x00, 0x07, 0x38, 0x00, 0x3C, 0xF0, 0x01, 0xE1, 0xF0, 0x0F, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0xFF, 0x87, 0x83, 0xFF, 0xCF, 0x0F, 0xFF, 0xDE,
  0x3E, 0x03, 0xFC, 0xF8, 0x01, 0xF9, 0xE0, 0x01, 0xF7, 0x80, 0x03, 0xEF,
  0x00, 0x03, 0xDC, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x70, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xEE, 0x00, 0x03,
  0xDC, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x7C,
  0xF8, 0x01, 0xF8, 0xF8, 0x0F, 0xF0, 0xFF, 0xFD, 0xE0, 0xFF, 0xF3, 0xC0,
  0xFF, 0x83, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xF0, 0x1F, 0x07, 0x80, 0x0F, 0x0F, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0x3B, 0xC0, 0x00,
  0x77, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x87, 0xC0, 0x03, 0x87, 0xC0, 0x1F, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x1E,
  0x00, 0x7F, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x1C, 0x1F, 0xFE, 0x78, 0x7F, 0xFE, 0xF1, 0xF0, 0x1F,
  0xE7, 0xC0, 0x0F, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x1E,
  0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0xE0, 0x00,
  0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF3, 0xC0, 0x03, 0xE7, 0xC0, 0x0F,
  0xC7, 0xC0, 0x7F, 0x87, 0xFF, 0xEF, 0x07, 0xFF, 0x9E, 0x07, 0xFC, 0x3C,
  0x00, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x10, 0x00, 0x3C, 0x30, 0x00, 0x70, 0xF8,
  0x01, 0xE0, 0xFC, 0x1F, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE1, 0xFF, 0x0E, 0x3F, 0xF8, 0xE7, 0xFF, 0xCE, 0xF0, 0x3E, 0xFC,
  0x01, 0xEF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x70,
  0x73, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x07, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x01, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x0F, 0x23, 0xE7, 0xF8, 0xFE, 0x1F,
  0x80, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x07, 0xDC, 0x00, 0x3C, 0xE0, 0x03, 0xC7, 0x00, 0x3C,
  0x38, 0x03, 0xC1, 0xC0, 0x3E, 0x0E, 0x03, 0xE0, 0x70, 0x1E, 0x03, 0x81,
  0xE0, 0x1C, 0x1E, 0x00, 0xE1, 0xE0, 0x07, 0x1F, 0x00, 0x38, 0xF0, 0x01,
  0xCF, 0x00, 0x0E, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x3C,
  0x00, 0xF8, 0xF0, 0x07, 0x87, 0x80, 0x38, 0x1E, 0x01, 0xC0, 0x78, 0x0E,
  0x03, 0xC0, 0x70, 0x0F, 0x03, 0x80, 0x3C, 0x1C, 0x01, 0xE0, 0xE0, 0x07,
  0x87, 0x00, 0x3C, 0x38, 0x00, 0xF1, 0xC0, 0x03, 0xCE, 0x00, 0x1E, 0x70,
  0x00, 0x7B, 0x80, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xE1, 0xFF, 0x00, 0xFF, 0x83, 0xC7, 0xFF, 0x03,
  0xFF, 0xC7, 0xBF, 0xFF, 0x0F, 0xFF, 0xCF, 0x70, 0x1F, 0x3C, 0x07, 0x9F,
  0xC0, 0x1E, 0xE0, 0x07, 0xBF, 0x00, 0x1F, 0xC0, 0x0F, 0x7C, 0x00, 0x3F,
  0x00, 0x0E, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x00, 0x78, 0x00, 0x3F,
  0xC0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0x00, 0x01, 0xFC, 0x00, 0x0E, 0x00, 0x03,
  0xF8, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x38, 0x00, 0x0F, 0xE0, 0x00,
  0x70, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x07, 0x00, 0x01, 0xFC, 0x00,
  0x0E, 0x00, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x38, 0x00,
  0x0F, 0xE0, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x07, 0x00,
  0x01, 0xFC, 0x00, 0x0E, 0x00, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x07, 0xF0,
  0x00, 0x38, 0x00, 0x0F, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x1F, 0xF0, 0xE3, 0xFF, 0x8E, 0x7F, 0xFC, 0xEF, 0x03, 0xEF, 0xC0, 0x1E,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x08,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x80,
  0xF8, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00,
  0x0F, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x08, 0x01, 0xE1, 0xFF,
  0x03, 0xCF, 0xFF, 0x87, 0xBF, 0xFF, 0x8F, 0xF0, 0x1F, 0x1F, 0x80, 0x0F,
  0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x3B,
  0xC0, 0x00, 0x77, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3B, 0xC0, 0x00,
  0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x07, 0x9F, 0x80, 0x0F, 0x3F, 0xC0, 0x7C,
  0x7B, 0xFF, 0xF0, 0xF3, 0xFF, 0xC1, 0xE1, 0xFF, 0x03, 0xC0, 0x60, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x3C, 0x1F, 0xFE, 0x78, 0x7F, 0xFE, 0xF1, 0xF0,
  0x1F, 0xE7, 0xC0, 0x0F, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x78, 0x00,
  0x1E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0xE0,
  0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF3, 0xC0, 0x03, 0xE7, 0xC0,
  0x0F, 0xC7, 0xC0, 0x7F, 0x87, 0xFF, 0xEF, 0x07, 0xFF, 0x9E, 0x07, 0xFE,
  0x3C, 0x00, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x2E, 0x1F, 0xE7, 0xFE, 0xFF, 0xEF, 0x0F, 0xC0,
  0xF8, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xE0, 0x3E, 0x1E, 0x00, 0x79, 0xE0, 0x01,
  0xCF, 0x00, 0x0F, 0x78, 0x00, 0x3B, 0x80, 0x01, 0xDE, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x77, 0x80, 0x07, 0xBC, 0x00,
  0x78, 0xF8, 0x07, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x0C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x20, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0x70, 0x00, 0x3B, 0x80, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x01, 0xF3, 0xC0,
  0x1F, 0x9F, 0x01, 0xFC, 0x7F, 0xFE, 0xE1, 0xFF, 0xE7, 0x07, 0xFC, 0x38,
  0x02, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0x73,
  0x80, 0x01, 0xE7, 0x00, 0x03, 0x8F, 0x00, 0x07, 0x0E, 0x00, 0x1E, 0x1C,
  0x00, 0x38, 0x3C, 0x00, 0x70, 0x38, 0x01, 0xE0, 0x70, 0x03, 0x80, 0xE0,
  0x07, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x07, 0x80,
  0xE0, 0x07, 0x03, 0xC0, 0x0E, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE7, 0x00,
  0x01, 0xCE, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x0F, 0x70,
  0x00, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x00, 0x0E, 0x78, 0x00, 0xF8, 0x00,
  0xE7, 0x80, 0x1F, 0x80, 0x1E, 0x38, 0x01, 0xF8, 0x01, 0xE3, 0x80, 0x1F,
  0xC0, 0x1C, 0x3C, 0x03, 0x9C, 0x01, 0xC3, 0xC0, 0x39, 0xC0, 0x1C, 0x1C,
  0x03, 0x9C, 0x03, 0xC1, 0xC0, 0x39, 0xE0, 0x38, 0x1C, 0x07, 0x0E, 0x03,
  0x81, 0xE0, 0x70, 0xE0, 0x38, 0x0E, 0x07, 0x0E, 0x07, 0x80, 0xE0, 0x70,
  0x70, 0x70, 0x0E, 0x0E, 0x07, 0x07, 0x00, 0xF0, 0xE0, 0x70, 0x70, 0x07,
  0x0E, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x38, 0xE0, 0x07, 0x1C, 0x03, 0x8E,
  0x00, 0x79, 0xC0, 0x38, 0xE0, 0x03, 0x9C, 0x03, 0x8E, 0x00, 0x3B, 0x80,
  0x1D, 0xC0, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x01,
  0xF8, 0x00, 0xDC, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x78, 0xE0, 0x01, 0xE1, 0xE0, 0x03, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0x0F, 0x00,
  0x0F, 0x1C, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x78, 0xE0, 0x00, 0xE1,
  0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x03, 0xC0, 0x1E, 0x03, 0x80, 0x78, 0x07,
  0x80, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x1E, 0x00, 0x0E,
  0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x0E,
  0x78, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x78,
  0x0E, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xF0,
  0x07, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0x81, 0xC0,
  0x03, 0xC1, 0xC0, 0x01, 0xC3, 0xC0, 0x01, 0xC3, 0x80, 0x01, 0xE3, 0x80,
  0x00, 0xE3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x02, 0x00, 0x0E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x01, 0xE0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0xF8, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x03, 0xC0, 0x02,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xC7, 0xFF, 0x00,
  0x0C, 0x7C, 0xFC, 0x00, 0xE7, 0x81, 0xF0, 0x07, 0x38, 0x07, 0xC0, 0x39,
  0xC0, 0x1F, 0x03, 0x9C, 0x00, 0x7E, 0x7C, 0xE0, 0x01, 0xFF, 0xC7, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
};

const GFXglyph RobotoCondensed_Light62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 45, 13, 5, -44 },
  { 24, 11, 14, 18, 4, -47 },
  { 44, 28, 44, 32, 3, -44 },
  { 198, 23, 58, 30, 4, -51 },
  { 365, 34, 46, 40, 3, -45 },
  { 561, 29, 46, 33, 3, -45 },
  { 728, 3, 14, 11, 4, -47 },
  { 734, 13, 63, 18, 4, -49 },
  { 837, 13, 63, 18, 1, -49 },
  { 940, 25, 25, 26, 1, -44 },
  { 1019, 25, 32, 31, 3, -36 },
  { 1119, 6, 14, 12, 2, -6 },
  { 1130, 12, 3, 16, 2, -21 },
  { 1135, 6, 6, 15, 4, -5 },
  { 1140, 19, 48, 22, 1, -44 },
  { 1254, 23, 46, 30, 4, -45 },
  { 1387, 13, 44, 30, 5, -44 },
  { 1459, 24, 45, 30, 3, -45 },
  { 1594, 23, 46, 30, 3, -45 },
  { 1727, 27, 44, 30, 2, -44 },
  { 1876, 22, 45, 30, 5, -44 },
  { 2000, 23, 45, 30, 4, -44 },
  { 2130, 24, 44, 30, 3, -44 },
  { 2262, 24, 46, 30, 3, -45 },
  { 2400, 23, 45, 30, 3, -45 },
  { 2530, 5, 34, 13, 4, -33 },
  { 2552, 7, 41, 12, 2, -33 },
  { 2588, 21, 26, 28, 3, -33 },
  { 2657, 22, 15, 30, 4, -28 },
  { 2699, 21, 26, 28, 4, -33 },
  { 2768, 19, 46, 25, 3, -45 },
  { 2878, 41, 57, 49, 4, -43 },
  { 3171, 32, 44, 34, 1, -44 },
  { 3347, 25, 44, 33, 5, -44 },
  { 3485, 28, 46, 35, 4, -45 },
  { 3646, 26, 44, 35, 5, -44 },
  { 3789, 23, 44, 31, 5, -44 },
  { 3916, 23, 44, 30, 5, -44 },
  { 4043, 28, 46, 37, 4, -45 },
  { 4204, 28, 44, 38, 5, -44 },
  { 4358, 3, 44, 15, 6, -44 },
  { 4375, 23, 45, 30, 2, -44 },
  { 4505, 28, 44, 34, 5, -44 },
  { 4659, 22, 44, 29, 5, -44 },
  { 4780, 36, 44, 46, 5, -44 },
  { 4978, 28, 44, 38, 5, -44 },
  { 5132, 29, 46, 37, 4, -45 },
  { 5299, 26, 44, 33, 5, -44 },
  { 5442, 28, 53, 37, 4, -45 },
  { 5628, 26, 44, 34, 5, -44 },
  { 5771, 26, 46, 32, 3, -45 },
  { 5921, 28, 44, 32, 2, -44 },
  { 6075, 26, 45, 35, 5, -44 },
  { 6222, 31, 44, 34, 1, -44 },
  { 6393, 44, 44, 48, 2, -44 },
  { 6635, 29, 44, 33, 2, -44 },
  { 6795, 30, 44, 32, 1, -44 },
  { 6960, 27, 44, 32, 3, -44 },
  { 7109, 8, 59, 14, 5, -50 },
  { 7168, 19, 48, 22, 2, -44 },
  { 7282, 8, 59, 14, 1, -50 },
  { 7341, 17, 22, 23, 3, -44 },
  { 7388, 22, 3, 24, 1, 0 },
  { 7397, 10, 8, 18, 3, -46 },
  { 7407, 22, 35, 29, 3, -34 },
  { 7504, 23, 48, 30, 4, -47 },
  { 7642, 22, 35, 28, 3, -34 },
  { 7739, 23, 48, 30, 3, -47 },
  { 7877, 23, 35, 28, 3, -34 },
  { 7978, 16, 48, 19, 2, -48 },
  { 8074, 23, 47, 30, 3, -34 },
  { 8210, 20, 47, 30, 5, -47 },
  { 8328, 5, 45, 13, 4, -45 },
  { 8357, 11, 58, 13, -2, -45 },
  { 8437, 21, 47, 27, 5, -47 },
  { 8561, 3, 47, 13, 5, -47 },
  { 8579, 39, 34, 47, 4, -34 },
  { 8745, 20, 34, 30, 5, -34 },
  { 8830, 24, 35, 30, 3, -34 },
  { 8935, 23, 47, 30, 4, -34 },
  { 9071, 23, 47, 30, 3, -34 },
  { 9207, 12, 34, 19, 5, -34 },
  { 9258, 21, 35, 28, 3, -34 },
  { 9350, 15, 42, 18, 1, -41 },
  { 9429, 21, 34, 30, 4, -33 },
  { 9519, 23, 33, 26, 2, -33 },
  { 9614, 36, 33, 40, 2, -33 },
  { 9763, 23, 33, 27, 2, -33 },
  { 9858, 24, 46, 26, 1, -33 },
  { 9996, 22, 33, 27, 3, -33 },
  { 10087, 16, 60, 19, 2, -48 },
  { 10207, 4, 52, 14, 5, -44 },
  { 10233, 15, 60, 19, 1, -48 },
  { 10346, 29, 11, 37, 4, -24 },
};

const GFXfont RobotoCondensed_Light62pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light62pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light62pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOCONDENSED_LIGHT62PT7B_H_
