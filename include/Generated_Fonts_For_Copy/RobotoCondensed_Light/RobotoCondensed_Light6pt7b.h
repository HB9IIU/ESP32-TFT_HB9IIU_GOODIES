#ifndef _ROBOTOCONDENSED_LIGHT6PT7B_H_
#define _ROBOTOCONDENSED_LIGHT6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light6pt7bBitmaps[] PROGMEM = {
  0x00, 0xE0, 0xC0, 0x69, 0x00, 0x57, 0x1A, 0x80, 0xE2, 0x52, 0xEB, 0x70,
  0xC0, 0x6A, 0x80, 0xF8, 0x10, 0x49, 0x20, 0xC0, 0x00, 0x00, 0x5A, 0xF6,
  0xF0, 0xD5, 0xE5, 0x20, 0xE4, 0xF0, 0x4B, 0x80, 0x48, 0xB0, 0x1A, 0xF0,
  0x49, 0x00, 0xFE, 0xF0, 0xF5, 0x20, 0x00, 0x30, 0x70, 0xF0, 0x50, 0xD0,
  0x7B, 0xFF, 0x40, 0x49, 0xC0, 0xF6, 0x50, 0xD2, 0x70, 0xB6, 0xD0, 0x92,
  0x40, 0x92, 0x40, 0xD2, 0x70, 0x96, 0xC0, 0x60, 0x17, 0xBA, 0x50, 0x92,
  0x40, 0x9D, 0xFA, 0x9E, 0xD0, 0xF6, 0xF0, 0xF6, 0x40, 0xF6, 0xF0, 0xF6,
  0x50, 0xF8, 0xF0, 0x49, 0x20, 0x96, 0xF0, 0x95, 0x20, 0xAF, 0xF5, 0x29,
  0x50, 0xA9, 0x20, 0x69, 0x60, 0xFC, 0xA5, 0x78, 0xE0, 0x00, 0x80, 0xD8,
  0x9A, 0xDE, 0xA8, 0x1F, 0xC0, 0xF8, 0x6A, 0x00, 0xFC, 0xAF, 0x80, 0x70,
  0x78, 0x93, 0x68, 0xF8, 0xBB, 0x80, 0xF8, 0xF7, 0x80, 0xF7, 0xC0, 0xFC,
  0xA8, 0x9C, 0x28, 0xB8, 0xB4, 0x96, 0x00, 0x18, 0xB4, 0x58, 0x60, 0x80,
  0x70, 0xA0, 0x80, 0xE0,
};

const GFXglyph RobotoCondensed_Light6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 1, 2, 2, 0, -5 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 6, 3, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 3, 4, 3, 0, -4 },
  { 12, 1, 2, 1, 0, -5 },
  { 13, 2, 6, 2, 0, -5 },
  { 15, 1, 6, 2, 0, -5 },
  { 16, 2, 2, 3, 0, -4 },
  { 17, 3, 4, 3, 0, -4 },
  { 19, 1, 2, 1, 0, -1 },
  { 20, 1, 1, 2, 0, -2 },
  { 21, 1, 1, 1, 0, -1 },
  { 22, 2, 4, 2, 0, -4 },
  { 23, 3, 4, 3, 0, -4 },
  { 25, 2, 4, 3, 0, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 1, 3, 1, 0, -3 },
  { 43, 1, 4, 1, 0, -3 },
  { 44, 2, 2, 3, 0, -3 },
  { 45, 2, 2, 3, 0, -3 },
  { 46, 2, 2, 3, 0, -3 },
  { 47, 2, 4, 2, 0, -4 },
  { 48, 4, 5, 5, 0, -4 },
  { 51, 3, 4, 3, 0, -4 },
  { 53, 3, 4, 3, 0, -4 },
  { 55, 3, 4, 3, 0, -4 },
  { 57, 3, 4, 3, 0, -4 },
  { 59, 3, 4, 3, 0, -4 },
  { 61, 3, 4, 3, 0, -4 },
  { 63, 3, 4, 4, 0, -4 },
  { 65, 3, 4, 4, 0, -4 },
  { 67, 1, 4, 1, 0, -4 },
  { 68, 2, 4, 3, 0, -4 },
  { 69, 3, 4, 3, 0, -4 },
  { 71, 3, 4, 3, 0, -4 },
  { 73, 4, 4, 4, 0, -4 },
  { 75, 3, 4, 4, 0, -4 },
  { 77, 3, 4, 4, 0, -4 },
  { 79, 3, 4, 3, 0, -4 },
  { 81, 3, 5, 4, 0, -4 },
  { 83, 3, 4, 3, 0, -4 },
  { 85, 3, 4, 3, 0, -4 },
  { 87, 3, 4, 3, 0, -4 },
  { 89, 3, 4, 3, 0, -4 },
  { 91, 3, 4, 3, 0, -4 },
  { 93, 4, 4, 5, 0, -4 },
  { 95, 3, 4, 3, 0, -4 },
  { 97, 3, 4, 3, 0, -4 },
  { 99, 3, 4, 3, 0, -4 },
  { 101, 1, 6, 1, 0, -5 },
  { 102, 2, 4, 2, 0, -4 },
  { 103, 1, 6, 1, 0, -5 },
  { 104, 2, 2, 2, 0, -4 },
  { 105, 2, 1, 2, 0, 0 },
  { 106, 1, 1, 2, 0, -5 },
  { 107, 2, 3, 3, 0, -3 },
  { 108, 3, 5, 3, 0, -5 },
  { 110, 2, 3, 3, 0, -3 },
  { 111, 2, 5, 3, 0, -5 },
  { 113, 2, 3, 3, 0, -3 },
  { 114, 2, 5, 2, 0, -5 },
  { 116, 2, 4, 3, 0, -3 },
  { 117, 2, 5, 3, 0, -5 },
  { 119, 1, 4, 1, 0, -4 },
  { 120, 1, 5, 1, 0, -4 },
  { 121, 3, 5, 3, 0, -5 },
  { 123, 1, 5, 1, 0, -5 },
  { 124, 4, 3, 5, 0, -3 },
  { 126, 2, 3, 3, 0, -3 },
  { 127, 3, 3, 3, 0, -3 },
  { 129, 3, 4, 3, 0, -3 },
  { 131, 2, 4, 3, 0, -3 },
  { 132, 2, 3, 2, 0, -3 },
  { 133, 2, 3, 3, 0, -3 },
  { 134, 2, 4, 2, 0, -4 },
  { 135, 2, 3, 3, 0, -3 },
  { 136, 2, 3, 3, 0, -3 },
  { 137, 4, 3, 4, 0, -3 },
  { 139, 2, 3, 3, 0, -3 },
  { 140, 2, 4, 3, 0, -3 },
  { 141, 2, 3, 3, 0, -3 },
  { 142, 2, 6, 2, 0, -5 },
  { 144, 1, 5, 1, 0, -4 },
  { 145, 2, 6, 2, 0, -5 },
  { 147, 3, 1, 4, 0, -2 },
};

const GFXfont RobotoCondensed_Light6pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light6pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light6pt7bGlyphs,
  0x20, 0x7E, 7
};

#endif // _ROBOTOCONDENSED_LIGHT6PT7B_H_
