#ifndef _ROBOTOCONDENSED_LIGHT7PT7B_H_
#define _ROBOTOCONDENSED_LIGHT7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light7pt7bBitmaps[] PROGMEM = {
  0x00, 0x60, 0xC0, 0x07, 0x6E, 0x00, 0x1E, 0x23, 0xC0, 0xCE, 0x23, 0x30,
  0x6A, 0x4A, 0xE0, 0x80, 0x1A, 0xA4, 0x25, 0x58, 0x4A, 0x00, 0x1D, 0x00,
  0x40, 0x00, 0x00, 0x16, 0x80, 0xF6, 0xDE, 0xF0, 0x64, 0xA4, 0x65, 0x16,
  0x2E, 0xF2, 0xA5, 0x40, 0x52, 0xD6, 0x64, 0xA0, 0xF5, 0x5E, 0xF6, 0xB2,
  0x80, 0x88, 0x39, 0x00, 0x5C, 0x8D, 0x00, 0xE5, 0x20, 0x33, 0x67, 0xBD,
  0xA0, 0x80, 0x46, 0x66, 0x90, 0xFF, 0x40, 0x69, 0x89, 0x70, 0x56, 0xD4,
  0x2E, 0x00, 0x2E, 0x00, 0x78, 0x89, 0x70, 0x37, 0xD2, 0x70, 0x24, 0x9E,
  0x1A, 0x60, 0x2A, 0x00, 0x19, 0xBB, 0x50, 0x36, 0xF2, 0x69, 0x99, 0x70,
  0xFE, 0x00, 0x69, 0x99, 0x61, 0xD7, 0x60, 0xF1, 0x1E, 0x49, 0x20, 0x3F,
  0xC0, 0x8A, 0x66, 0x00, 0xA5, 0x6A, 0xA4, 0x00, 0x06, 0x46, 0x00, 0x86,
  0x44, 0x00, 0x65, 0x2C, 0xFC, 0xA5, 0x00, 0xFC, 0x78, 0x40, 0x00, 0x46,
  0xF0, 0x9E, 0xDE, 0x52, 0x70, 0x0E, 0xDE, 0x52, 0xF0, 0x3A, 0x00, 0x56,
  0xF2, 0x3F, 0x40, 0x30, 0x3C, 0x3A, 0x40, 0x70, 0xFD, 0x6B, 0x50, 0xFD,
  0x76, 0xF0, 0xF6, 0xF8, 0x56, 0xF0, 0xE0, 0x51, 0xF0, 0x3A, 0x00, 0xB6,
  0xF0, 0xB5, 0x20, 0x8B, 0xD5, 0xA9, 0x50, 0xB5, 0x24, 0x00, 0xE9, 0x60,
  0x10, 0x40, 0x78, 0x20, 0x80, 0x52,
};

const GFXglyph RobotoCondensed_Light7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 2, 1, 2, 0, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 3, 7, 3, 0, -6 },
  { 9, 4, 5, 4, 0, -5 },
  { 12, 4, 5, 4, 0, -5 },
  { 15, 1, 1, 1, 0, -5 },
  { 16, 2, 8, 2, 0, -6 },
  { 18, 2, 8, 2, 0, -6 },
  { 20, 3, 3, 3, 0, -5 },
  { 22, 3, 4, 3, 0, -4 },
  { 24, 1, 2, 1, 0, -1 },
  { 25, 2, 1, 2, 0, -3 },
  { 26, 1, 1, 2, 0, -1 },
  { 27, 2, 5, 2, 0, -5 },
  { 29, 3, 5, 3, 0, -5 },
  { 31, 1, 5, 3, 1, -5 },
  { 32, 3, 5, 3, 0, -5 },
  { 34, 3, 5, 3, 0, -5 },
  { 36, 3, 5, 3, 0, -5 },
  { 38, 2, 5, 3, 1, -5 },
  { 40, 3, 5, 3, 0, -5 },
  { 42, 3, 5, 3, 0, -5 },
  { 44, 3, 5, 3, 0, -5 },
  { 46, 3, 5, 3, 0, -5 },
  { 48, 1, 4, 1, 0, -4 },
  { 49, 1, 5, 1, 0, -4 },
  { 50, 3, 3, 3, 0, -4 },
  { 52, 3, 2, 3, 0, -3 },
  { 53, 3, 3, 3, 0, -4 },
  { 55, 3, 5, 3, 0, -5 },
  { 57, 5, 7, 5, 0, -5 },
  { 62, 4, 5, 4, 0, -5 },
  { 65, 2, 5, 4, 1, -5 },
  { 67, 4, 5, 4, 0, -5 },
  { 70, 3, 5, 4, 1, -5 },
  { 72, 2, 5, 3, 1, -5 },
  { 74, 2, 5, 3, 1, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 3, 5, 4, 1, -5 },
  { 81, 1, 5, 2, 0, -5 },
  { 82, 3, 5, 3, 0, -5 },
  { 84, 3, 5, 4, 1, -5 },
  { 86, 2, 5, 3, 1, -5 },
  { 88, 4, 5, 5, 1, -5 },
  { 91, 3, 5, 4, 1, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 2, 5, 4, 1, -5 },
  { 98, 4, 6, 4, 0, -5 },
  { 101, 3, 5, 4, 1, -5 },
  { 103, 3, 5, 4, 0, -5 },
  { 105, 3, 5, 4, 0, -5 },
  { 107, 2, 5, 4, 1, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 5, 5, 5, 0, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 4, 5, 4, 0, -5 },
  { 122, 3, 5, 4, 0, -5 },
  { 124, 1, 7, 2, 1, -6 },
  { 125, 2, 5, 2, 0, -5 },
  { 127, 1, 7, 2, 0, -6 },
  { 128, 2, 3, 3, 0, -5 },
  { 129, 3, 1, 3, 0, 0 },
  { 130, 2, 1, 2, 0, -5 },
  { 131, 3, 4, 3, 0, -4 },
  { 133, 3, 5, 3, 0, -5 },
  { 135, 3, 4, 3, 0, -4 },
  { 137, 3, 5, 3, 0, -5 },
  { 139, 3, 4, 3, 0, -4 },
  { 141, 2, 5, 2, 0, -5 },
  { 143, 3, 5, 3, 0, -4 },
  { 145, 2, 5, 3, 1, -5 },
  { 147, 1, 5, 1, 0, -5 },
  { 148, 1, 7, 2, 0, -5 },
  { 149, 2, 5, 3, 1, -5 },
  { 151, 1, 5, 1, 0, -5 },
  { 152, 5, 4, 5, 0, -4 },
  { 155, 2, 4, 3, 1, -4 },
  { 156, 3, 4, 3, 0, -4 },
  { 158, 3, 5, 3, 0, -4 },
  { 160, 3, 5, 3, 0, -4 },
  { 162, 1, 4, 2, 1, -4 },
  { 163, 3, 4, 3, 0, -4 },
  { 165, 2, 5, 2, 0, -5 },
  { 167, 3, 4, 3, 0, -4 },
  { 169, 3, 4, 3, 0, -4 },
  { 171, 4, 4, 5, 0, -4 },
  { 173, 3, 4, 3, 0, -4 },
  { 175, 3, 6, 3, 0, -4 },
  { 178, 3, 4, 3, 0, -4 },
  { 180, 2, 6, 2, 0, -5 },
  { 182, 1, 6, 2, 0, -5 },
  { 183, 2, 6, 2, 0, -5 },
  { 185, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoCondensed_Light7pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light7pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOCONDENSED_LIGHT7PT7B_H_
