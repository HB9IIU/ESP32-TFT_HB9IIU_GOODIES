#ifndef _ROBOTOCONDENSED_LIGHT11PT7B_H_
#define _ROBOTOCONDENSED_LIGHT11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xD0, 0x52, 0xBE, 0xA6, 0x7A, 0x94, 0x4E, 0x98, 0xC2, 0x19,
  0xE4, 0xC6, 0xB5, 0xC3, 0xAD, 0x63, 0x65, 0x28, 0x8C, 0xDA, 0x5E, 0xC0,
  0x6A, 0xAA, 0xA9, 0x95, 0x55, 0x56, 0x27, 0x88, 0xA0, 0x21, 0x09, 0xF2,
  0x10, 0x80, 0xE0, 0xC0, 0x80, 0x12, 0x22, 0x44, 0x48, 0x80, 0xE9, 0x99,
  0x99, 0x9E, 0x75, 0x55, 0xE9, 0x12, 0x24, 0x8F, 0xE9, 0x16, 0x11, 0x9E,
  0x10, 0x8C, 0xA5, 0x7C, 0x42, 0xF8, 0x8E, 0x11, 0x96, 0x68, 0x8E, 0x99,
  0x96, 0xF8, 0x44, 0x22, 0x10, 0x88, 0xE9, 0x9E, 0x99, 0x9E, 0xE9, 0x99,
  0xF1, 0x2C, 0x84, 0x40, 0x16, 0x16, 0x86, 0x10, 0xF0, 0xF0, 0x86, 0x16,
  0x80, 0x69, 0x11, 0x22, 0x02, 0x3C, 0x86, 0x6D, 0x5C, 0xB9, 0x72, 0xDE,
  0x80, 0xF0, 0x20, 0xC3, 0x12, 0x49, 0xE4, 0x61, 0xF9, 0x9E, 0x99, 0x9F,
  0x74, 0x63, 0x08, 0x46, 0x2E, 0xE4, 0xA3, 0x18, 0xC6, 0x5C, 0xF8, 0x8F,
  0x88, 0x8F, 0xF8, 0x8F, 0x88, 0x88, 0x74, 0x61, 0x0B, 0xC6, 0x2E, 0x8C,
  0x63, 0xF8, 0xC6, 0x31, 0xFF, 0x11, 0x11, 0x11, 0x97, 0x94, 0xA9, 0x8A,
  0x52, 0x51, 0x88, 0x88, 0x88, 0x8F, 0x86, 0x1C, 0xF3, 0xCE, 0xDB, 0x65,
  0x8C, 0x73, 0x5A, 0xCE, 0x71, 0x74, 0x63, 0x18, 0xC6, 0x2E, 0xF9, 0x99,
  0xF8, 0x88, 0x74, 0x63, 0x18, 0xC6, 0x2E, 0x08, 0xF4, 0xA5, 0x2F, 0x52,
  0x51, 0x72, 0x50, 0xC1, 0x86, 0x2F, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x99,
  0x99, 0x99, 0x97, 0x85, 0x24, 0x92, 0x48, 0xC3, 0x08, 0x89, 0x49, 0x59,
  0x55, 0x56, 0x66, 0x22, 0x22, 0x49, 0x23, 0x0C, 0x30, 0xC4, 0xA2, 0x89,
  0x24, 0x8C, 0x20, 0x82, 0x08, 0xF1, 0x22, 0x48, 0x8F, 0xFF, 0xE0, 0x84,
  0x44, 0x42, 0x22, 0x10, 0xD5, 0x55, 0x5C, 0x06, 0x69, 0xF0, 0xC0, 0xE1,
  0x1F, 0xAD, 0x88, 0x8E, 0x99, 0x99, 0xE0, 0xE9, 0x88, 0x9E, 0x11, 0x1F,
  0x99, 0x99, 0xF0, 0xE9, 0xF8, 0x8E, 0x29, 0x74, 0x92, 0x40, 0xF9, 0x99,
  0x9F, 0x1E, 0x88, 0x8E, 0x99, 0x99, 0x90, 0xBF, 0x45, 0x55, 0x60, 0x88,
  0x8A, 0xC8, 0xCA, 0xA0, 0xFF, 0x80, 0xED, 0x26, 0x4C, 0x99, 0x32, 0x40,
  0xE9, 0x99, 0x99, 0xE9, 0x99, 0x9E, 0xE9, 0x99, 0x9E, 0x88, 0xF9, 0x99,
  0x9F, 0x11, 0xEA, 0xA0, 0xF3, 0x13, 0xC0, 0x5D, 0x24, 0x98, 0x99, 0x99,
  0x9F, 0x95, 0x55, 0x22, 0x92, 0xA5, 0xB3, 0x66, 0xC0, 0x00, 0x95, 0x22,
  0x59, 0x95, 0x56, 0x22, 0x24, 0x71, 0x22, 0x47, 0x29, 0x25, 0x12, 0x48,
  0x80, 0xFF, 0x80, 0x89, 0x24, 0x52, 0x4A, 0x00, 0xCD, 0x80,
};

const GFXglyph RobotoCondensed_Light11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 8, 2, 1, -8 },
  { 2, 2, 2, 3, 1, -8 },
  { 3, 5, 8, 6, 1, -8 },
  { 8, 4, 10, 5, 1, -9 },
  { 13, 5, 8, 7, 1, -8 },
  { 18, 5, 8, 6, 1, -8 },
  { 23, 1, 2, 2, 0, -8 },
  { 24, 2, 12, 3, 1, -9 },
  { 27, 2, 12, 3, 0, -9 },
  { 30, 5, 4, 5, 0, -8 },
  { 33, 5, 7, 5, 0, -7 },
  { 38, 1, 3, 2, 0, -1 },
  { 39, 2, 1, 3, 0, -4 },
  { 40, 1, 1, 3, 1, -1 },
  { 41, 4, 9, 4, 0, -8 },
  { 46, 4, 8, 5, 1, -8 },
  { 50, 2, 8, 5, 1, -8 },
  { 52, 4, 8, 5, 1, -8 },
  { 56, 4, 8, 5, 1, -8 },
  { 60, 5, 8, 5, 0, -8 },
  { 65, 4, 8, 5, 1, -8 },
  { 69, 4, 8, 5, 1, -8 },
  { 73, 5, 8, 5, 0, -8 },
  { 78, 4, 8, 5, 1, -8 },
  { 82, 4, 8, 5, 1, -8 },
  { 86, 1, 6, 2, 1, -6 },
  { 87, 2, 8, 2, 0, -6 },
  { 89, 4, 5, 5, 0, -6 },
  { 92, 4, 3, 5, 1, -5 },
  { 94, 4, 5, 5, 1, -6 },
  { 97, 4, 8, 4, 0, -8 },
  { 101, 7, 10, 9, 1, -8 },
  { 110, 6, 8, 6, 0, -8 },
  { 116, 4, 8, 6, 1, -8 },
  { 120, 5, 8, 6, 1, -8 },
  { 125, 5, 8, 6, 1, -8 },
  { 130, 4, 8, 5, 1, -8 },
  { 134, 4, 8, 5, 1, -8 },
  { 138, 5, 8, 7, 1, -8 },
  { 143, 5, 8, 7, 1, -8 },
  { 148, 1, 8, 3, 1, -8 },
  { 149, 4, 8, 5, 0, -8 },
  { 153, 5, 8, 6, 1, -8 },
  { 158, 4, 8, 5, 1, -8 },
  { 162, 6, 8, 8, 1, -8 },
  { 168, 5, 8, 7, 1, -8 },
  { 173, 5, 8, 6, 1, -8 },
  { 178, 4, 8, 6, 1, -8 },
  { 182, 5, 9, 6, 1, -8 },
  { 188, 5, 8, 6, 1, -8 },
  { 193, 5, 8, 6, 0, -8 },
  { 198, 5, 8, 6, 0, -8 },
  { 203, 4, 8, 6, 1, -8 },
  { 207, 6, 8, 6, 0, -8 },
  { 213, 8, 8, 8, 0, -8 },
  { 221, 6, 8, 6, 0, -8 },
  { 227, 6, 8, 6, 0, -8 },
  { 233, 4, 8, 6, 1, -8 },
  { 237, 1, 11, 2, 1, -9 },
  { 239, 4, 9, 4, 0, -8 },
  { 244, 2, 11, 2, 0, -9 },
  { 247, 4, 4, 4, 0, -8 },
  { 249, 4, 1, 4, 0, 0 },
  { 250, 1, 2, 3, 1, -9 },
  { 251, 4, 6, 5, 1, -6 },
  { 254, 4, 9, 5, 1, -9 },
  { 259, 4, 6, 5, 1, -6 },
  { 262, 4, 9, 5, 1, -9 },
  { 267, 4, 6, 5, 1, -6 },
  { 270, 3, 9, 3, 0, -9 },
  { 274, 4, 8, 5, 1, -6 },
  { 278, 4, 9, 5, 1, -9 },
  { 283, 1, 8, 2, 1, -8 },
  { 284, 2, 10, 2, 0, -8 },
  { 287, 4, 9, 5, 1, -9 },
  { 292, 1, 9, 2, 1, -9 },
  { 294, 7, 6, 8, 1, -6 },
  { 300, 4, 6, 5, 1, -6 },
  { 303, 4, 6, 5, 1, -6 },
  { 306, 4, 8, 5, 1, -6 },
  { 310, 4, 8, 5, 1, -6 },
  { 314, 2, 6, 3, 1, -6 },
  { 316, 3, 6, 5, 1, -6 },
  { 319, 3, 7, 3, 0, -7 },
  { 322, 4, 6, 5, 1, -6 },
  { 325, 4, 6, 5, 0, -6 },
  { 328, 7, 6, 7, 0, -6 },
  { 334, 4, 6, 5, 0, -6 },
  { 337, 4, 8, 5, 0, -6 },
  { 341, 4, 6, 5, 0, -6 },
  { 344, 3, 11, 3, 0, -9 },
  { 349, 1, 9, 2, 1, -8 },
  { 351, 3, 11, 3, 0, -9 },
  { 356, 5, 2, 7, 1, -4 },
};

const GFXfont RobotoCondensed_Light11pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light11pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOCONDENSED_LIGHT11PT7B_H_
