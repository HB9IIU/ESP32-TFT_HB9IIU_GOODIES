#ifndef _ROBOTOCONDENSED_LIGHT32PT7B_H_
#define _ROBOTOCONDENSED_LIGHT32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light32pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x00, 0x05, 0xD0, 0xCF, 0x3C,
  0xB2, 0xCB, 0x2C, 0x80, 0x06, 0x10, 0x18, 0x40, 0x43, 0x01, 0x0C, 0x04,
  0x30, 0x10, 0x87, 0xFF, 0xDF, 0xFF, 0x0C, 0x60, 0x21, 0x80, 0x86, 0x02,
  0x10, 0x18, 0x40, 0x61, 0x01, 0x84, 0x3F, 0xFE, 0xFF, 0xF8, 0x43, 0x01,
  0x08, 0x0C, 0x20, 0x30, 0x80, 0x86, 0x02, 0x18, 0x00, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xF0, 0x3F, 0xC7, 0x0E, 0x60, 0x66, 0x02, 0xC0, 0x34, 0x03,
  0x40, 0x06, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x06,
  0x00, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x66, 0x06, 0x3F, 0xC1, 0xF8,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x38, 0x00, 0x36, 0x00, 0x31, 0x80, 0x10,
  0x41, 0x08, 0x21, 0x84, 0x10, 0x82, 0x08, 0xC1, 0x04, 0x40, 0xC6, 0x60,
  0x36, 0x20, 0x0E, 0x30, 0x00, 0x10, 0x00, 0x19, 0xE0, 0x19, 0xF8, 0x08,
  0x84, 0x0C, 0xC3, 0x04, 0x61, 0x86, 0x30, 0xC2, 0x18, 0x63, 0x0C, 0x30,
  0x02, 0x10, 0x01, 0xB8, 0x00, 0x78, 0x0F, 0x00, 0x3F, 0x00, 0xC3, 0x01,
  0x06, 0x06, 0x0C, 0x0C, 0x18, 0x08, 0x30, 0x18, 0xC0, 0x33, 0x00, 0x3C,
  0x00, 0x30, 0x00, 0xE0, 0x03, 0x60, 0xCC, 0x61, 0xB0, 0xE2, 0x60, 0xC4,
  0xC0, 0xD9, 0x00, 0xF3, 0x01, 0xC6, 0x03, 0x86, 0x0F, 0x8F, 0xFB, 0x87,
  0xC3, 0x00, 0xFE, 0xA8, 0x04, 0x08, 0x30, 0xC1, 0x06, 0x08, 0x10, 0x60,
  0xC1, 0x02, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x10,
  0x30, 0x60, 0xC0, 0x81, 0x81, 0x03, 0x02, 0x02, 0x04, 0x83, 0x04, 0x18,
  0x30, 0xC1, 0x06, 0x18, 0x20, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC2, 0x18, 0x61, 0x0C, 0x30, 0x84, 0x30, 0x80, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x06, 0x31, 0xFD, 0xBC, 0x7F, 0x00, 0xE0, 0x07,
  0x80, 0x66, 0x06, 0x30, 0x30, 0xC1, 0x02, 0x00, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x1F, 0xFF, 0xFF, 0xF8, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x6D, 0xB7, 0xB0, 0xFF, 0xF0, 0x5D, 0x80, 0x01, 0x80, 0xC0, 0x40, 0x20,
  0x30, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60,
  0x20, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0x80, 0x00,
  0x1F, 0x03, 0xF8, 0x60, 0xC6, 0x06, 0xC0, 0x6C, 0x02, 0xC0, 0x2C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x2C, 0x02, 0xC0, 0x66, 0x06, 0x70, 0xC3, 0xF8, 0x0F, 0x00, 0x06,
  0x3D, 0xFE, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x1F, 0x03, 0xFC, 0x60,
  0xCC, 0x06, 0xC0, 0x6C, 0x06, 0x80, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0x03, 0xFC, 0x60, 0xCC,
  0x06, 0xC0, 0x6C, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x0F, 0x80,
  0xF8, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x38, 0x03, 0xC0, 0x2C,
  0x06, 0x60, 0xE7, 0xFC, 0x1F, 0x00, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x03, 0x60, 0x0D, 0x80, 0x66, 0x01, 0x98, 0x0C, 0x60, 0x21, 0x81,
  0x86, 0x04, 0x18, 0x30, 0x61, 0x81, 0x86, 0x06, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x3F,
  0xF3, 0xFF, 0x30, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x6F,
  0x87, 0xFC, 0x70, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x34, 0x03, 0x40, 0x36, 0x02, 0x30, 0x63, 0xFC, 0x0F, 0x80, 0x03, 0x80,
  0xF8, 0x1C, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x04, 0x00, 0xCF, 0x8D,
  0xFC, 0xF0, 0xEE, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0x40, 0x26, 0x06, 0x30, 0xE3, 0xFC, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x00, 0x1F,
  0x03, 0xFC, 0x60, 0xC6, 0x06, 0xC0, 0x6C, 0x02, 0xC0, 0x2C, 0x06, 0x60,
  0x66, 0x0C, 0x3F, 0x81, 0xF8, 0x70, 0xC6, 0x06, 0xC0, 0x3C, 0x03, 0x80,
  0x3C, 0x03, 0xC0, 0x3C, 0x06, 0x60, 0x63, 0xFC, 0x1F, 0x00, 0x1F, 0x03,
  0xF8, 0x60, 0xCC, 0x06, 0xC0, 0x6C, 0x06, 0x80, 0x28, 0x02, 0x80, 0x3C,
  0x03, 0xC0, 0x7C, 0x07, 0x60, 0xE3, 0xFA, 0x1E, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x03, 0x83, 0xF0, 0x3C, 0x00, 0x5F, 0x00, 0x00,
  0x00, 0x00, 0x17, 0xC0, 0x27, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x66,
  0x66, 0x6C, 0xC0, 0x00, 0x20, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x02, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x18, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0x70, 0x08, 0x00, 0x1F, 0x07, 0xF1, 0x83, 0x30, 0x64, 0x05, 0x80,
  0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x03, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0x80, 0x30, 0x18, 0x00, 0xC1, 0x80,
  0x02, 0x18, 0x00, 0x18, 0x80, 0x00, 0x4C, 0x07, 0x83, 0x40, 0xEE, 0x0A,
  0x0C, 0x30, 0x70, 0x61, 0x83, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x03,
  0x06, 0x08, 0x18, 0x30, 0x40, 0x81, 0x82, 0x04, 0x0C, 0x10, 0x20, 0xE0,
  0x83, 0x05, 0x86, 0x3C, 0x6C, 0x1F, 0x76, 0x20, 0xF1, 0xE1, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x80, 0x0F,
  0x3C, 0x00, 0x1F, 0x80, 0x00, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x02, 0xC0, 0x06, 0x40, 0x06, 0x60, 0x04, 0x60, 0x0C, 0x20, 0x0C,
  0x30, 0x08, 0x30, 0x18, 0x30, 0x18, 0x18, 0x10, 0x18, 0x30, 0x18, 0x3F,
  0xF8, 0x3F, 0xFC, 0x60, 0x0C, 0x60, 0x04, 0x60, 0x06, 0xC0, 0x06, 0xC0,
  0x02, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0xC0, 0xEC, 0x06, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x6C, 0x0E, 0xFF, 0xCF, 0xFC, 0xC0, 0xEC, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x6F, 0xFC,
  0xFF, 0x80, 0x07, 0xC0, 0x7F, 0xC3, 0x01, 0x98, 0x03, 0x60, 0x0D, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0D, 0x00, 0x36, 0x00, 0xD8,
  0x03, 0x30, 0x18, 0x7F, 0xC0, 0x7C, 0x00, 0xFF, 0x07, 0xFE, 0x30, 0x39,
  0x80, 0x6C, 0x03, 0x60, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0D, 0x80, 0x6C, 0x0E, 0x7F, 0xE3, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xFF, 0xCF, 0xFC, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF,
  0xCF, 0xFC, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xE0,
  0x63, 0x00, 0x66, 0x00, 0xCC, 0x01, 0xB0, 0x01, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x06, 0xC0, 0x0D, 0x80, 0x19, 0x80, 0x33, 0x81, 0xC3, 0xFF,
  0x01, 0xF8, 0x00, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x06, 0x70, 0xE3, 0xFC, 0x1F,
  0x00, 0xC0, 0x1B, 0x00, 0xCC, 0x06, 0x30, 0x38, 0xC0, 0xC3, 0x06, 0x0C,
  0x30, 0x31, 0x80, 0xCE, 0x03, 0x30, 0x0D, 0xC0, 0x3F, 0x00, 0xE6, 0x03,
  0x9C, 0x0C, 0x30, 0x30, 0x60, 0xC1, 0xC3, 0x03, 0x0C, 0x06, 0x30, 0x1C,
  0xC0, 0x33, 0x00, 0x6C, 0x01, 0xC0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF,
  0xFF, 0xF8, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x05, 0xB0,
  0x03, 0x6C, 0x00, 0xD9, 0x00, 0x26, 0x60, 0x19, 0x98, 0x06, 0xE2, 0x01,
  0x38, 0xC0, 0xCE, 0x30, 0x33, 0x84, 0x08, 0xF1, 0x86, 0x3C, 0x61, 0x8F,
  0x08, 0x43, 0xC3, 0x30, 0xF0, 0xCC, 0x3C, 0x12, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x30, 0x3C, 0x0C, 0x0C, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0x60, 0x3D, 0x80, 0xF3, 0x03, 0xCC, 0x0F, 0x18, 0x3C,
  0x60, 0xF0, 0xC3, 0xC3, 0x0F, 0x06, 0x3C, 0x08, 0xF0, 0x33, 0xC0, 0x6F,
  0x01, 0xBC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xC0, 0x07,
  0xC0, 0x3F, 0xE0, 0xE0, 0xE3, 0x00, 0x66, 0x00, 0xD8, 0x00, 0xB0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x09, 0x80, 0x33, 0x00,
  0x63, 0x83, 0x83, 0xFE, 0x01, 0xF0, 0x00, 0xFF, 0x87, 0xFF, 0x30, 0x1D,
  0x80, 0x6C, 0x01, 0x60, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x0D, 0x80, 0xEF, 0xFE, 0x7F, 0xC3, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x3F,
  0xE0, 0xC0, 0xE3, 0x00, 0xE6, 0x00, 0xD8, 0x01, 0xB0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x19, 0x80, 0x33, 0x00, 0xE3, 0x03,
  0x83, 0xFE, 0x01, 0xFC, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x10,
  0xFF, 0x87, 0xFE, 0x20, 0x19, 0x00, 0x68, 0x03, 0x40, 0x0A, 0x00, 0x50,
  0x02, 0x80, 0x34, 0x01, 0xA0, 0x19, 0xFF, 0x8F, 0xF8, 0x40, 0xC2, 0x06,
  0x10, 0x18, 0x80, 0xC4, 0x03, 0x20, 0x19, 0x00, 0x68, 0x03, 0x40, 0x0E,
  0x00, 0x60, 0x07, 0xC0, 0x7F, 0xC3, 0x83, 0x9C, 0x06, 0x60, 0x0D, 0x80,
  0x36, 0x00, 0xD8, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0xC0, 0x0D, 0x00, 0x36, 0x00, 0xD8,
  0x03, 0x30, 0x18, 0x7F, 0xC0, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x36, 0x00,
  0xD8, 0x06, 0x30, 0x38, 0xFF, 0xC0, 0xFC, 0x00, 0xC0, 0x06, 0xC0, 0x06,
  0x40, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x30, 0x0C, 0x30, 0x18,
  0x30, 0x18, 0x10, 0x18, 0x18, 0x10, 0x18, 0x30, 0x08, 0x30, 0x0C, 0x20,
  0x0C, 0x60, 0x04, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x02, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x10, 0x07, 0x80, 0x70, 0x09,
  0x00, 0xE0, 0x33, 0x01, 0x40, 0x66, 0x02, 0x80, 0xCC, 0x0D, 0x81, 0x98,
  0x1B, 0x02, 0x10, 0x26, 0x0C, 0x30, 0x44, 0x18, 0x61, 0x88, 0x30, 0xC3,
  0x18, 0x40, 0x84, 0x30, 0x81, 0x08, 0x23, 0x03, 0x30, 0x46, 0x06, 0x60,
  0xCC, 0x0C, 0x81, 0x90, 0x09, 0x01, 0x20, 0x16, 0x02, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x00, 0x60, 0x06, 0xC0, 0x18, 0xC0, 0x71, 0x80, 0xC1, 0x83, 0x03, 0x06,
  0x03, 0x18, 0x06, 0x30, 0x06, 0xC0, 0x0D, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xD8, 0x01, 0xB0, 0x06, 0x30, 0x0C, 0x70, 0x30, 0x60, 0x60,
  0x61, 0x80, 0xC7, 0x00, 0xCC, 0x01, 0xB0, 0x01, 0x80, 0xC0, 0x07, 0x80,
  0x19, 0x80, 0x33, 0x00, 0xC3, 0x01, 0x86, 0x02, 0x06, 0x0C, 0x0C, 0x18,
  0x0C, 0x60, 0x18, 0xC0, 0x13, 0x00, 0x36, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF1,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x7F, 0xE0, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60,
  0x08, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00,
  0x40, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06,
  0x00, 0x80, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFF, 0xE0, 0x0C, 0x06,
  0x07, 0x03, 0xC1, 0x21, 0x90, 0xCC, 0x42, 0x61, 0xA0, 0xF0, 0x20, 0xFF,
  0xFF, 0xFF, 0xC3, 0x0C, 0x30, 0x1F, 0x0F, 0xF9, 0x83, 0x60, 0x3C, 0x06,
  0x00, 0xC0, 0x18, 0xFF, 0x7C, 0x7C, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x81,
  0xF0, 0x7B, 0xFB, 0x3E, 0x60, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0xF8, 0xDF, 0xCF, 0x06, 0xE0, 0x6C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0,
  0x6E, 0x06, 0xDF, 0xCC, 0xF8, 0x1F, 0x0F, 0xF9, 0x83, 0x60, 0x3C, 0x07,
  0x00, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x3C, 0x07, 0x80,
  0xD8, 0x33, 0xFC, 0x1F, 0x00, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0xF9, 0x7F, 0xAC, 0x1F, 0x01, 0xE0, 0x1C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x06, 0xC1, 0xCF,
  0xE8, 0xF9, 0x0F, 0x81, 0xFE, 0x30, 0x66, 0x03, 0x60, 0x34, 0x03, 0x40,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x31, 0xFE, 0x0F, 0xC0, 0x07, 0x1F, 0x18, 0x10, 0x30, 0x30, 0x30, 0xFF,
  0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x1F, 0x2F, 0xF5, 0x83, 0xE0, 0x3C, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xD8,
  0x3B, 0xFD, 0x1F, 0x20, 0x04, 0x01, 0x80, 0x34, 0x06, 0xC1, 0x9F, 0xF0,
  0xF8, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x7C,
  0xDF, 0xDE, 0x1F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x1F, 0x00,
  0x02, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x08, 0xC6, 0x00, 0x00, 0x03,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0xFB, 0x80, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x07, 0xC0, 0xD8, 0x33, 0x0C, 0x63, 0x0C, 0xC1, 0xB8, 0x36, 0x07,
  0xE0, 0xE6, 0x18, 0xC3, 0x0C, 0x61, 0xCC, 0x19, 0x81, 0xB0, 0x36, 0x03,
  0xFF, 0xFF, 0xFF, 0xCF, 0x87, 0xCD, 0xFC, 0xFE, 0xF0, 0xD8, 0x7E, 0x07,
  0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0,
  0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C,
  0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x30, 0xCF, 0x9B,
  0xFB, 0xC3, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x60, 0x1F, 0x03,
  0xFC, 0x60, 0xEC, 0x06, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x06, 0x60, 0xE3, 0xFC, 0x1F, 0x00,
  0xCF, 0x8D, 0xFC, 0xE0, 0x6E, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x06, 0xE0, 0x6D, 0xFC,
  0xCF, 0x8C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x1F, 0x2F, 0xF5, 0x83, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xD8, 0x3B, 0xFF, 0x1F, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xCF, 0xBF, 0xC7,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0,
  0x1F, 0x0F, 0xF1, 0x83, 0x60, 0x6C, 0x05, 0x80, 0x18, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x68, 0x07, 0x80, 0xB0, 0x33, 0xFC, 0x1F, 0x00,
  0x30, 0x60, 0xC1, 0x8F, 0xFF, 0xCC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC0, 0xF0, 0xE0, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x06, 0x80, 0xD8, 0x39, 0xFF, 0x1E, 0x60, 0xC0, 0x3C, 0x02, 0x40, 0x66,
  0x06, 0x60, 0x42, 0x0C, 0x30, 0xC3, 0x08, 0x31, 0x81, 0x18, 0x19, 0x81,
  0x90, 0x0B, 0x00, 0xF0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x40, 0x78,
  0x1C, 0x09, 0x03, 0x83, 0x30, 0x70, 0x66, 0x1A, 0x0C, 0xC3, 0x61, 0x08,
  0x4C, 0x61, 0x88, 0x8C, 0x33, 0x11, 0x86, 0x63, 0x20, 0x48, 0x64, 0x0D,
  0x05, 0x81, 0xE0, 0xB0, 0x3C, 0x1C, 0x03, 0x03, 0x80, 0x60, 0x30, 0x0C,
  0x06, 0x00, 0xC0, 0x66, 0x06, 0x30, 0xC3, 0x0C, 0x19, 0x81, 0x90, 0x0F,
  0x00, 0xE0, 0x06, 0x00, 0xE0, 0x0F, 0x01, 0x98, 0x31, 0x83, 0x0C, 0x60,
  0xC6, 0x06, 0xC0, 0x70, 0xC0, 0x3C, 0x06, 0x40, 0x66, 0x06, 0x60, 0x46,
  0x0C, 0x30, 0xC3, 0x08, 0x31, 0x81, 0x18, 0x19, 0x81, 0x90, 0x0B, 0x00,
  0xF0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0xF8, 0x0E, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x60, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0x07, 0x0C, 0x0C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0xF0, 0xE0, 0x30, 0x10,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x07,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x40, 0x60, 0x30, 0x18, 0x18, 0x18, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x0C, 0x07, 0x03, 0x06, 0x0C, 0x0C,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0x18, 0x18, 0x30, 0x60, 0x40,
  0x3C, 0x06, 0xFC, 0x0D, 0x8C, 0x16, 0x0C, 0x6C, 0x0F, 0xD8, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_Light32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 23, 7, 2, -23 },
  { 10, 6, 7, 9, 2, -24 },
  { 16, 14, 23, 16, 2, -23 },
  { 57, 12, 29, 16, 2, -26 },
  { 101, 17, 23, 20, 2, -23 },
  { 150, 15, 23, 17, 2, -23 },
  { 194, 2, 7, 5, 2, -24 },
  { 196, 7, 33, 9, 2, -26 },
  { 225, 6, 33, 10, 1, -26 },
  { 250, 13, 13, 14, 0, -23 },
  { 272, 13, 17, 16, 1, -19 },
  { 300, 3, 7, 6, 1, -3 },
  { 303, 6, 2, 8, 1, -11 },
  { 305, 3, 3, 8, 2, -3 },
  { 307, 9, 25, 11, 1, -23 },
  { 336, 12, 23, 16, 2, -23 },
  { 371, 7, 23, 16, 3, -23 },
  { 392, 12, 23, 16, 2, -23 },
  { 427, 12, 23, 16, 2, -23 },
  { 462, 14, 23, 16, 1, -23 },
  { 503, 12, 23, 16, 2, -23 },
  { 538, 12, 23, 16, 2, -23 },
  { 573, 13, 23, 16, 1, -23 },
  { 611, 12, 23, 16, 2, -23 },
  { 646, 12, 23, 16, 2, -23 },
  { 681, 3, 17, 6, 2, -17 },
  { 688, 4, 21, 6, 1, -17 },
  { 699, 11, 13, 14, 1, -17 },
  { 717, 11, 9, 15, 2, -15 },
  { 730, 11, 13, 15, 2, -17 },
  { 748, 11, 23, 13, 1, -23 },
  { 780, 21, 29, 25, 2, -22 },
  { 857, 16, 23, 18, 1, -23 },
  { 903, 12, 23, 17, 3, -23 },
  { 938, 14, 23, 18, 2, -23 },
  { 979, 13, 23, 18, 3, -23 },
  { 1017, 12, 23, 16, 3, -23 },
  { 1052, 12, 23, 16, 3, -23 },
  { 1087, 15, 23, 19, 2, -23 },
  { 1131, 14, 23, 20, 3, -23 },
  { 1172, 2, 23, 8, 3, -23 },
  { 1178, 12, 23, 15, 1, -23 },
  { 1213, 14, 23, 18, 3, -23 },
  { 1254, 11, 23, 15, 3, -23 },
  { 1286, 18, 23, 24, 3, -23 },
  { 1338, 14, 23, 20, 3, -23 },
  { 1379, 15, 23, 19, 2, -23 },
  { 1423, 13, 23, 17, 3, -23 },
  { 1461, 15, 27, 19, 2, -23 },
  { 1512, 13, 23, 18, 3, -23 },
  { 1550, 14, 23, 17, 1, -23 },
  { 1591, 15, 23, 17, 1, -23 },
  { 1635, 14, 23, 18, 2, -23 },
  { 1676, 16, 23, 17, 1, -23 },
  { 1722, 23, 23, 25, 1, -23 },
  { 1789, 15, 23, 17, 1, -23 },
  { 1833, 15, 23, 17, 1, -23 },
  { 1877, 14, 23, 17, 1, -23 },
  { 1918, 5, 31, 7, 2, -26 },
  { 1938, 10, 25, 11, 1, -23 },
  { 1970, 5, 31, 7, 0, -26 },
  { 1990, 9, 11, 12, 1, -23 },
  { 2003, 12, 2, 12, 0, 0 },
  { 2006, 5, 4, 9, 2, -24 },
  { 2009, 11, 17, 15, 2, -17 },
  { 2033, 12, 24, 16, 2, -24 },
  { 2069, 11, 17, 15, 2, -17 },
  { 2093, 11, 24, 16, 2, -24 },
  { 2126, 12, 17, 15, 1, -17 },
  { 2152, 8, 24, 10, 1, -24 },
  { 2176, 11, 24, 16, 2, -17 },
  { 2209, 11, 24, 15, 2, -24 },
  { 2242, 3, 24, 7, 2, -24 },
  { 2251, 5, 31, 7, -1, -24 },
  { 2271, 11, 24, 14, 2, -24 },
  { 2304, 1, 24, 7, 3, -24 },
  { 2307, 20, 17, 24, 2, -17 },
  { 2350, 11, 17, 15, 2, -17 },
  { 2374, 12, 17, 16, 2, -17 },
  { 2400, 12, 24, 16, 2, -17 },
  { 2436, 11, 24, 16, 2, -17 },
  { 2469, 7, 17, 10, 2, -17 },
  { 2484, 11, 17, 14, 2, -17 },
  { 2508, 7, 21, 9, 1, -21 },
  { 2527, 11, 17, 15, 2, -17 },
  { 2551, 12, 17, 14, 1, -17 },
  { 2577, 19, 17, 21, 1, -17 },
  { 2618, 12, 17, 14, 1, -17 },
  { 2644, 12, 24, 13, 1, -17 },
  { 2680, 12, 17, 14, 1, -17 },
  { 2706, 8, 31, 10, 1, -25 },
  { 2737, 1, 27, 7, 3, -23 },
  { 2741, 8, 31, 10, 0, -25 },
  { 2772, 15, 6, 19, 2, -13 },
};

const GFXfont RobotoCondensed_Light32pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light32pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOCONDENSED_LIGHT32PT7B_H_
