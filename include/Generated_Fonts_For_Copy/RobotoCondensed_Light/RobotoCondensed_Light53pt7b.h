#ifndef _ROBOTOCONDENSED_LIGHT53PT7B_H_
#define _ROBOTOCONDENSED_LIGHT53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light53pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0xFE, 0x00, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x00, 0x70, 0x38,
  0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60,
  0x00, 0xC0, 0x60, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x01, 0xC0, 0xE0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0,
  0x01, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x01, 0x80,
  0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x07, 0x03, 0x80,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x06, 0x03, 0x00,
  0x06, 0x03, 0x00, 0x06, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00,
  0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x0E, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F,
  0x8F, 0x81, 0xC0, 0x3C, 0x38, 0x01, 0xC3, 0x80, 0x1E, 0x70, 0x00, 0xE7,
  0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x77,
  0x00, 0x0E, 0x70, 0x00, 0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xC1, 0xF8, 0xF8,
  0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x0E, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x0C, 0x0C, 0x03, 0x01, 0xC0,
  0xC0, 0x30, 0x18, 0x0C, 0x03, 0x03, 0x80, 0xC0, 0x30, 0x30, 0x0C, 0x03,
  0x07, 0x00, 0xC0, 0x30, 0x60, 0x0E, 0x03, 0x0E, 0x00, 0x60, 0x70, 0xC0,
  0x07, 0x0E, 0x1C, 0x00, 0x3F, 0xC1, 0x80, 0x01, 0xF8, 0x38, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x0C, 0x1F, 0x80, 0x01, 0x83, 0xFC, 0x00, 0x38, 0x70, 0xE0,
  0x03, 0x0E, 0x06, 0x00, 0x70, 0xC0, 0x70, 0x06, 0x0C, 0x03, 0x00, 0xE0,
  0xC0, 0x30, 0x0C, 0x0C, 0x03, 0x01, 0xC0, 0xC0, 0x30, 0x18, 0x0C, 0x03,
  0x03, 0x80, 0xC0, 0x30, 0x30, 0x0C, 0x03, 0x07, 0x00, 0xE0, 0x70, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x1C, 0x03,
  0x80, 0x1C, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x1C, 0x03,
  0x80, 0x1C, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x3C,
  0x00, 0x07, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x3C, 0x78,
  0x0E, 0x38, 0x38, 0x0E, 0x70, 0x1C, 0x0E, 0xF0, 0x1E, 0x0E, 0xE0, 0x0F,
  0x0C, 0xE0, 0x07, 0x1C, 0xE0, 0x03, 0x9C, 0xE0, 0x03, 0xDC, 0xE0, 0x01,
  0xF8, 0xE0, 0x00, 0xF8, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0xF8, 0x70, 0x01,
  0xF8, 0x38, 0x03, 0xFC, 0x3F, 0x0F, 0x9E, 0x1F, 0xFF, 0x0E, 0x07, 0xFC,
  0x07, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x40, 0x30,
  0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x07, 0x03, 0x80, 0xE0,
  0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x70,
  0x0C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x10, 0x40, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07,
  0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C,
  0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C,
  0x07, 0x00, 0xC0, 0x38, 0x0E, 0x00, 0x80, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x5E, 0x0E, 0x0E, 0xFE, 0x73, 0xFB, 0xFF, 0xFF, 0x01, 0xFF,
  0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0E, 0x70, 0x00,
  0x71, 0xC0, 0x07, 0x07, 0x00, 0x70, 0x3C, 0x07, 0x80, 0xE0, 0x38, 0x03,
  0x80, 0x80, 0x10, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x39, 0xCE, 0x73, 0x9C, 0xEE,
  0x77, 0x38, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x6F, 0xFF, 0x00, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x0F, 0xFE, 0x01, 0xF0, 0xF0, 0x1C, 0x07, 0x83, 0x80, 0x3C, 0x38,
  0x01, 0xC7, 0x00, 0x1C, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x60, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0xE6, 0x00, 0x0E, 0x70,
  0x00, 0xE7, 0x00, 0x0E, 0x70, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x03, 0xC1,
  0xC0, 0x78, 0x1F, 0x0F, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x0F, 0x03, 0xF1, 0xFF, 0x7F, 0x7F, 0xC7, 0xE0, 0x78, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xF0, 0xF8, 0x3C, 0x07, 0x87, 0x80, 0x3C,
  0x70, 0x01, 0xCE, 0x00, 0x1E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xF0, 0xF8, 0x3C, 0x03, 0x87,
  0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E,
  0xE0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x00, 0xEF, 0x00, 0x0E,
  0x70, 0x01, 0xC3, 0xC0, 0x3C, 0x3F, 0x0F, 0x81, 0xFF, 0xF0, 0x07, 0xFC,
  0x00, 0x04, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x0E,
  0x70, 0x00, 0x39, 0xC0, 0x01, 0xC7, 0x00, 0x06, 0x1C, 0x00, 0x38, 0x70,
  0x00, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x07,
  0x01, 0xC0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x01,
  0xC0, 0x60, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x9C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x7E, 0x03,
  0xBF, 0xF0, 0x7F, 0xFF, 0x0F, 0x81, 0xF1, 0xE0, 0x0F, 0x08, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xC7, 0x00, 0x38, 0xF0, 0x0E, 0x0F,
  0x87, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x1F, 0x00,
  0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x0F, 0xC0, 0x73, 0xFF, 0x07, 0x7F,
  0xF8, 0x6E, 0x07, 0xCF, 0xC0, 0x1C, 0xF8, 0x01, 0xEF, 0x00, 0x0E, 0xF0,
  0x00, 0xEE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07,
  0x70, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0xC0, 0x1C, 0x1E, 0x03,
  0xC0, 0xF8, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0xF0,
  0xF8, 0x3C, 0x03, 0xC3, 0x80, 0x1C, 0x78, 0x01, 0xE7, 0x00, 0x0E, 0x70,
  0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7,
  0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80, 0x1C, 0x3C, 0x03, 0xC1, 0xE0, 0x78,
  0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0xE0, 0x78, 0x3C, 0x03,
  0xC7, 0x80, 0x1E, 0x70, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xF7, 0x00, 0x0E, 0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x3F, 0x0F, 0x80,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x80,
  0x3F, 0xF8, 0x0F, 0x8F, 0x83, 0xC0, 0x78, 0x70, 0x07, 0x1C, 0x00, 0x73,
  0x80, 0x0E, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xB8, 0x00, 0xF7, 0x00, 0x1E, 0x70, 0x07, 0xCF,
  0x03, 0xF8, 0xFF, 0xF7, 0x0F, 0xFC, 0xE0, 0x7E, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x03, 0xE0, 0x00, 0x73, 0xFE, 0xF2, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x73, 0xFE, 0xE2, 0x00, 0x39,
  0xE7, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x38, 0xE3, 0x8E, 0x38, 0xE7, 0x1C, 0xE3,
  0x84, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x01, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00,
  0x1C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x07, 0xC7, 0xC3,
  0x80, 0xF3, 0x80, 0x39, 0xC0, 0x1E, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0x18, 0x1C, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x07, 0xC0, 0x0C, 0x38, 0x01,
  0xFF, 0x00, 0xC3, 0x80, 0x3E, 0xF8, 0x0E, 0x30, 0x07, 0x03, 0x80, 0x67,
  0x00, 0x60, 0x18, 0x06, 0x70, 0x0E, 0x03, 0x80, 0x66, 0x00, 0xC0, 0x38,
  0x06, 0x60, 0x1C, 0x03, 0x80, 0x66, 0x01, 0x80, 0x38, 0x07, 0xE0, 0x18,
  0x03, 0x80, 0x7E, 0x03, 0x80, 0x38, 0x07, 0xE0, 0x38, 0x03, 0x00, 0x7E,
  0x03, 0x80, 0x30, 0x07, 0xE0, 0x30, 0x03, 0x00, 0x6C, 0x03, 0x00, 0x30,
  0x06, 0xC0, 0x30, 0x03, 0x00, 0x6C, 0x03, 0x00, 0x30, 0x06, 0xE0, 0x30,
  0x03, 0x00, 0x6E, 0x03, 0x00, 0x70, 0x0E, 0xE0, 0x30, 0x07, 0x00, 0xCE,
  0x03, 0x80, 0xF0, 0x0C, 0x60, 0x38, 0x0F, 0x01, 0xC6, 0x03, 0x81, 0xB8,
  0x18, 0x60, 0x1E, 0x3B, 0x83, 0x87, 0x00, 0xFF, 0x1F, 0xF0, 0x70, 0x0F,
  0xE0, 0xFC, 0x03, 0x00, 0x10, 0x02, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x18, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x30,
  0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x30, 0x18, 0x00,
  0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x30, 0x06, 0x00, 0x0E, 0x00,
  0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x01, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF1, 0xC0, 0x07, 0xCE, 0x00, 0x1E, 0x70, 0x00, 0x7B, 0x80, 0x01,
  0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0,
  0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x03, 0x9C, 0x00, 0x3C,
  0xE0, 0x03, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8E, 0x00,
  0x3E, 0x70, 0x00, 0x7B, 0x80, 0x01, 0xDC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x77, 0x00, 0x07, 0xB8,
  0x00, 0x79, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7E, 0x1F, 0x81, 0xE0, 0x07,
  0x87, 0x80, 0x07, 0x1E, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1D,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x78,
  0xF0, 0x00, 0xE0, 0xF0, 0x03, 0xC0, 0xF8, 0x3F, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x08, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0x00, 0x3F, 0x0E, 0x00, 0x1F, 0x1C, 0x00, 0x0E, 0x38, 0x00,
  0x1E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x77, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x77, 0x00,
  0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0x70, 0x00,
  0x3C, 0xE0, 0x00, 0x71, 0xC0, 0x03, 0xE3, 0x80, 0x1F, 0x87, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x7E, 0x1F, 0x81, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x8E, 0x00,
  0x07, 0x38, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00,
  0x07, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xF0, 0x00, 0x78, 0xF8, 0x01,
  0xF0, 0xFC, 0x1F, 0xC0, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0C, 0x00,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0x70, 0x01, 0xCF, 0x00, 0x78, 0xF0, 0x1E, 0x1F, 0x8F, 0xC1, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0x10, 0x00, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0,
  0xE0, 0x03, 0xC0, 0xE0, 0x07, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x0F, 0x00,
  0xE0, 0x1E, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x70, 0x00,
  0xE0, 0xF0, 0x00, 0xE1, 0xE0, 0x00, 0xE3, 0xC0, 0x00, 0xE3, 0xC0, 0x00,
  0xE7, 0xE0, 0x00, 0xEF, 0xF0, 0x00, 0xFE, 0x70, 0x00, 0xFC, 0x78, 0x00,
  0xF8, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xC0,
  0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0x80, 0x00, 0x1F, 0xF7, 0x00,
  0x00, 0x3F, 0xEE, 0x00, 0x00, 0xEF, 0xCE, 0x00, 0x01, 0xDF, 0x9C, 0x00,
  0x03, 0xBF, 0x38, 0x00, 0x0E, 0x7E, 0x38, 0x00, 0x1C, 0xFC, 0x70, 0x00,
  0x31, 0xF8, 0xE0, 0x00, 0xE3, 0xF0, 0xE0, 0x01, 0xC7, 0xE1, 0xC0, 0x03,
  0x0F, 0xC3, 0x80, 0x0E, 0x1F, 0x83, 0x80, 0x1C, 0x3F, 0x07, 0x00, 0x30,
  0x7E, 0x06, 0x00, 0xE0, 0xFC, 0x0E, 0x01, 0xC1, 0xF8, 0x1C, 0x03, 0x03,
  0xF0, 0x18, 0x0E, 0x07, 0xE0, 0x38, 0x1C, 0x0F, 0xC0, 0x70, 0x70, 0x1F,
  0x80, 0x60, 0xE0, 0x3F, 0x00, 0xE1, 0xC0, 0x7E, 0x01, 0xC7, 0x00, 0xFC,
  0x01, 0x8E, 0x01, 0xF8, 0x03, 0x9C, 0x03, 0xF0, 0x07, 0x70, 0x07, 0xE0,
  0x06, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x1E, 0x00, 0x7E, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xEE, 0x00, 0x07, 0xE7, 0x00, 0x07, 0xE7,
  0x00, 0x07, 0xE3, 0x80, 0x07, 0xE3, 0x80, 0x07, 0xE1, 0xC0, 0x07, 0xE1,
  0xC0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0x70, 0x07, 0xE0,
  0x78, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0,
  0x0E, 0x07, 0xE0, 0x0E, 0x07, 0xE0, 0x07, 0x07, 0xE0, 0x07, 0x07, 0xE0,
  0x03, 0x87, 0xE0, 0x03, 0x87, 0xE0, 0x01, 0xC7, 0xE0, 0x01, 0xE7, 0xE0,
  0x00, 0xE7, 0xE0, 0x00, 0x77, 0xE0, 0x00, 0x77, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0xF0, 0x07, 0xC0, 0xF0, 0x00, 0xE0,
  0xF0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x38, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xD8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x1E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x3F,
  0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x38, 0x00, 0x7C, 0xE0, 0x00, 0xF3,
  0x80, 0x01, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE,
  0x00, 0x07, 0xB8, 0x00, 0x7C, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0xF0, 0x07, 0xC0, 0xF0,
  0x01, 0xE0, 0xF0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x0F, 0x38,
  0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x1E, 0x38,
  0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x01, 0xE0, 0x0F, 0x80,
  0x7E, 0x3F, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x10, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x10, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0x00, 0x1F, 0x0E, 0x00, 0x0F, 0x1C, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73,
  0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x71, 0xC0, 0x01, 0xE3, 0x80,
  0x07, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x38, 0x03,
  0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0F,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7,
  0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7E, 0x1F, 0x81, 0xE0, 0x0F, 0x83,
  0x80, 0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0xE0,
  0x00, 0x1D, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xDC,
  0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x38, 0xF0,
  0x00, 0xF0, 0xF0, 0x03, 0xC0, 0xFE, 0x1F, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xDC,
  0x00, 0x07, 0x70, 0x00, 0x39, 0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x07, 0xE1,
  0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x07,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x70, 0x07, 0x00, 0x0E,
  0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x18, 0x07, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x70, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C,
  0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F,
  0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x0E, 0xE0, 0x01, 0xF0,
  0x00, 0x77, 0x00, 0x0F, 0x80, 0x07, 0x38, 0x00, 0x7C, 0x00, 0x39, 0xC0,
  0x03, 0x60, 0x01, 0xCE, 0x00, 0x3B, 0x80, 0x0E, 0x38, 0x01, 0xDC, 0x00,
  0xE1, 0xC0, 0x0E, 0x60, 0x07, 0x0E, 0x00, 0x63, 0x00, 0x38, 0x70, 0x03,
  0x1C, 0x01, 0xC3, 0x80, 0x38, 0xE0, 0x0E, 0x0E, 0x01, 0xC3, 0x00, 0xE0,
  0x70, 0x0C, 0x18, 0x07, 0x03, 0x80, 0x60, 0xE0, 0x38, 0x1C, 0x07, 0x07,
  0x01, 0xC0, 0x60, 0x38, 0x18, 0x0E, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x1C,
  0x0C, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x38, 0x38, 0x07, 0x07, 0x01, 0xC1,
  0xC0, 0x18, 0x30, 0x06, 0x0E, 0x00, 0xE1, 0x80, 0x38, 0xE0, 0x07, 0x1C,
  0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x31, 0xC0,
  0x06, 0x30, 0x01, 0x8C, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x01, 0xDC, 0x00,
  0x77, 0x00, 0x0E, 0xE0, 0x01, 0xB8, 0x00, 0x76, 0x00, 0x0D, 0xC0, 0x01,
  0xB0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0x07, 0x38, 0x00, 0x07, 0x9E, 0x00, 0x03,
  0x87, 0x00, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xC0, 0x38, 0x01,
  0xE0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0xF0, 0x03, 0xC0, 0x70, 0x00, 0xE0,
  0x78, 0x00, 0x78, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xDC, 0x00, 0x01, 0xCF, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xE1, 0xE0,
  0x00, 0xF0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x78, 0x03,
  0x80, 0x38, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x1C, 0x00, 0x3C, 0x1E, 0x00,
  0x0E, 0x0E, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x38, 0xF0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x01,
  0xE0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xF0, 0x38, 0x00,
  0x1C, 0x0E, 0x00, 0x07, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0xE0,
  0x00, 0x07, 0x38, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x06, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xFF, 0xFF, 0xF8,
  0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xDC, 0x03,
  0xB8, 0x07, 0x30, 0x0C, 0x70, 0x38, 0xE0, 0x70, 0xC0, 0xC1, 0xC3, 0x83,
  0x87, 0x03, 0x0C, 0x07, 0x38, 0x0E, 0x70, 0x0C, 0xC0, 0x1F, 0x80, 0x38,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x78, 0x38, 0x1C,
  0x1E, 0x0E, 0x07, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0x07,
  0xC3, 0x80, 0x38, 0xE0, 0x07, 0x9C, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0xFF,
  0x83, 0xFF, 0xF1, 0xFF, 0x0E, 0x7C, 0x01, 0xCE, 0x00, 0x3B, 0x80, 0x07,
  0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x1E,
  0xE0, 0x07, 0xDE, 0x01, 0xF9, 0xF1, 0xF7, 0x1F, 0xFC, 0xE1, 0xFF, 0x0E,
  0x02, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x3F, 0xC1, 0xCF, 0xFE,
  0x3B, 0x87, 0xE7, 0xC0, 0x3C, 0xF0, 0x03, 0xDE, 0x00, 0x3B, 0x80, 0x07,
  0x70, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3B,
  0x80, 0x07, 0x78, 0x01, 0xEF, 0x80, 0x79, 0xFC, 0x3E, 0x3B, 0xFF, 0xC7,
  0x1F, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC,
  0x1F, 0x07, 0xC3, 0x80, 0x38, 0xE0, 0x03, 0x9C, 0x00, 0x77, 0x00, 0x06,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x33,
  0x80, 0x0E, 0x70, 0x01, 0xC7, 0x00, 0x70, 0xF8, 0x3E, 0x0F, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x7F, 0x8E,
  0x3F, 0xF9, 0xCF, 0xC7, 0xB9, 0xE0, 0x1F, 0x78, 0x01, 0xEE, 0x00, 0x3F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xEE,
  0x00, 0x1D, 0xC0, 0x07, 0xBC, 0x00, 0xF3, 0xC0, 0x3E, 0x7E, 0x1D, 0xC7,
  0xFF, 0x38, 0x3F, 0xC7, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x07, 0xFF, 0x80, 0xF8, 0x7C, 0x1C, 0x01, 0xC3, 0x80, 0x1E, 0x38, 0x00,
  0xE7, 0x00, 0x0E, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x76, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x41, 0xE0, 0x0E,
  0x1F, 0x83, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x3F, 0xC1, 0xF0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x03, 0xFF, 0xCF, 0xFF,
  0x3F, 0xFC, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x1C, 0x7F, 0xF3, 0x9F, 0x8F, 0x73, 0xC0, 0x3E, 0xF0, 0x03,
  0xDC, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x0F, 0x78, 0x01, 0xE7, 0x80, 0x7C,
  0xFC, 0x3B, 0x8F, 0xFE, 0x70, 0x7F, 0x8E, 0x01, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x80, 0x07, 0x18, 0x01, 0xE3,
  0xC0, 0x78, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x80,
  0xE3, 0xFC, 0x39, 0xFF, 0x8E, 0xF1, 0xF3, 0xF0, 0x1E, 0xF8, 0x03, 0xBC,
  0x00, 0xEF, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xEE, 0xEE, 0x00, 0x00, 0x00, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x78, 0x3B, 0xFD, 0xFC, 0xF8, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x07, 0xB8,
  0x01, 0xCE, 0x00, 0xE3, 0x80, 0x70, 0xE0, 0x3C, 0x38, 0x1E, 0x0E, 0x0F,
  0x03, 0x83, 0x80, 0xE1, 0xC0, 0x38, 0xE0, 0x0E, 0x78, 0x03, 0xBC, 0x00,
  0xEF, 0x00, 0x3F, 0xE0, 0x0F, 0xB8, 0x03, 0xC7, 0x00, 0xE1, 0xE0, 0x38,
  0x38, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0xE0, 0x38, 0x38, 0x07, 0x0E, 0x01,
  0xE3, 0x80, 0x38, 0xE0, 0x07, 0x38, 0x01, 0xEE, 0x00, 0x3B, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x71, 0xFE, 0x03, 0xFC, 0x39,
  0xFF, 0x87, 0xFF, 0x1D, 0xC3, 0xE7, 0x87, 0xCF, 0x80, 0x7B, 0x80, 0xF7,
  0xC0, 0x1F, 0x80, 0x3B, 0xC0, 0x0F, 0x80, 0x1D, 0xC0, 0x07, 0x80, 0x07,
  0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0x00,
  0xFC, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x0E, 0x00,
  0x1F, 0x80, 0x07, 0x00, 0x0F, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x01, 0xC0,
  0x03, 0xF0, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x38,
  0x00, 0x7E, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x07,
  0x00, 0x0F, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x00,
  0xE0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x7E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x20, 0x38, 0xFF, 0x0E, 0x7F, 0xE3, 0xBC, 0x7C,
  0xFC, 0x07, 0xBE, 0x00, 0xEF, 0x00, 0x3B, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xF0, 0xF8, 0x3C, 0x03, 0xC7, 0x80, 0x1E,
  0x70, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x38, 0x01, 0xC3,
  0xC0, 0x3C, 0x1F, 0x0F, 0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1C, 0x7F, 0x83, 0xBF, 0xFC, 0x7F, 0x0F, 0xCF, 0x80, 0x79,
  0xE0, 0x07, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x77, 0x00, 0x0E, 0xF0, 0x03, 0xDF,
  0x00, 0xF3, 0xF8, 0x7C, 0x77, 0xFF, 0x8E, 0x3F, 0xC1, 0xC0, 0xC0, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x1C, 0x7F, 0xF3, 0x9F, 0x07, 0x73, 0xC0, 0x3E, 0xF0,
  0x03, 0xDC, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x78, 0x01, 0xE7, 0x80,
  0x7C, 0xFC, 0x3B, 0x8F, 0xFF, 0x70, 0x7F, 0x8E, 0x01, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1C,
  0x7F, 0xBF, 0xF7, 0xFF, 0xC1, 0xF0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0xF8, 0x7C, 0x78,
  0x07, 0x9C, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x07, 0xE0, 0x01, 0xDC, 0x00,
  0x07, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0x9C, 0x01,
  0xE3, 0xE1, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x7F, 0x03, 0xF0, 0x04, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3D, 0xC0, 0x1F, 0x78, 0x0F,
  0xDF, 0x8F, 0x73, 0xFF, 0x9C, 0x3F, 0xC7, 0x01, 0x00, 0x00, 0xE0, 0x00,
  0x77, 0x00, 0x07, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x38, 0x00, 0xE3, 0x80,
  0x0C, 0x38, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0x81, 0xC0, 0x38, 0x0C,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x00, 0x60, 0x70, 0x07, 0x07, 0x00,
  0x70, 0x60, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x03, 0x8C, 0x00, 0x39, 0xC0,
  0x01, 0x9C, 0x00, 0x1D, 0x80, 0x01, 0xD8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0xC0, 0x07, 0x00, 0x3B, 0x80, 0x1E, 0x00, 0x73, 0x80, 0x3C, 0x00, 0xE7,
  0x00, 0x7C, 0x01, 0xCE, 0x00, 0xF8, 0x07, 0x1C, 0x03, 0xF0, 0x0E, 0x18,
  0x07, 0x60, 0x1C, 0x38, 0x0C, 0xE0, 0x38, 0x70, 0x39, 0xC0, 0x60, 0xE0,
  0x71, 0x81, 0xC0, 0xC0, 0xE3, 0x03, 0x81, 0xC1, 0x87, 0x07, 0x03, 0x87,
  0x0E, 0x0C, 0x07, 0x0E, 0x0C, 0x38, 0x06, 0x18, 0x1C, 0x70, 0x0E, 0x30,
  0x38, 0xE0, 0x1C, 0xE0, 0x71, 0x80, 0x39, 0xC0, 0x67, 0x00, 0x33, 0x00,
  0xEE, 0x00, 0x76, 0x01, 0xDC, 0x00, 0xFC, 0x01, 0xB0, 0x01, 0xF8, 0x03,
  0x60, 0x01, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xEE,
  0x00, 0x39, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0xC0, 0x70, 0x38, 0x1E, 0x03,
  0x83, 0x80, 0x70, 0xF0, 0x07, 0x1C, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x03,
  0xB8, 0x00, 0x77, 0x00, 0x1C, 0x70, 0x07, 0x8E, 0x00, 0xE0, 0xE0, 0x38,
  0x1C, 0x07, 0x01, 0xC1, 0xC0, 0x3C, 0x38, 0x03, 0x8E, 0x00, 0x7B, 0xC0,
  0x07, 0x70, 0x00, 0x70, 0xF0, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0xE7,
  0x00, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x1C, 0x38, 0x01, 0xC1, 0xC0, 0x1C,
  0x1C, 0x03, 0x81, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07,
  0x00, 0xE0, 0x70, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x38,
  0xE0, 0x03, 0x8C, 0x00, 0x39, 0xC0, 0x01, 0xDC, 0x00, 0x1D, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x18, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x03, 0x80, 0xF8, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xE0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x06,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xF8, 0x03, 0xC0, 0x3E, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x30, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0xC0, 0x07, 0x7F, 0xE0, 0x07, 0x70, 0xF0, 0x07, 0xE0,
  0x78, 0x06, 0xE0, 0x3C, 0x0E, 0xC0, 0x1E, 0x1E, 0xC0, 0x0F, 0xFC, 0xC0,
  0x07, 0xF8, 0x00, 0x01, 0xF0,
};

const GFXglyph RobotoCondensed_Light53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 39, 11, 4, -38 },
  { 21, 8, 12, 15, 4, -40 },
  { 33, 24, 38, 27, 3, -38 },
  { 147, 20, 50, 26, 3, -44 },
  { 272, 28, 40, 34, 3, -39 },
  { 412, 24, 40, 29, 3, -39 },
  { 532, 3, 12, 9, 3, -40 },
  { 537, 10, 54, 15, 4, -42 },
  { 605, 11, 54, 16, 1, -42 },
  { 680, 21, 21, 22, 1, -38 },
  { 736, 22, 27, 26, 2, -31 },
  { 811, 5, 12, 10, 2, -5 },
  { 819, 10, 3, 14, 2, -18 },
  { 823, 4, 5, 13, 4, -4 },
  { 826, 16, 41, 19, 1, -38 },
  { 908, 20, 40, 26, 3, -39 },
  { 1008, 12, 38, 26, 4, -38 },
  { 1065, 20, 39, 26, 3, -39 },
  { 1163, 20, 40, 26, 3, -39 },
  { 1263, 22, 38, 26, 2, -38 },
  { 1368, 19, 39, 26, 4, -38 },
  { 1461, 20, 39, 26, 3, -38 },
  { 1559, 21, 38, 26, 2, -38 },
  { 1659, 20, 40, 26, 3, -39 },
  { 1759, 19, 39, 26, 3, -39 },
  { 1852, 5, 29, 11, 3, -28 },
  { 1871, 6, 35, 10, 2, -28 },
  { 1898, 18, 22, 24, 2, -28 },
  { 1948, 18, 13, 26, 4, -24 },
  { 1978, 19, 22, 24, 3, -28 },
  { 2031, 17, 40, 21, 2, -39 },
  { 2116, 36, 49, 42, 3, -37 },
  { 2337, 27, 38, 29, 1, -38 },
  { 2466, 21, 38, 28, 4, -38 },
  { 2566, 23, 40, 30, 4, -39 },
  { 2681, 23, 38, 30, 4, -38 },
  { 2791, 20, 38, 26, 4, -38 },
  { 2886, 20, 38, 26, 4, -38 },
  { 2981, 23, 40, 31, 4, -39 },
  { 3096, 24, 38, 33, 4, -38 },
  { 3210, 3, 38, 13, 5, -38 },
  { 3225, 19, 39, 26, 2, -38 },
  { 3318, 24, 38, 29, 4, -38 },
  { 3432, 19, 38, 25, 4, -38 },
  { 3523, 31, 38, 40, 4, -38 },
  { 3671, 24, 38, 33, 4, -38 },
  { 3785, 25, 40, 31, 3, -39 },
  { 3910, 22, 38, 29, 4, -38 },
  { 4015, 25, 46, 31, 3, -39 },
  { 4159, 23, 38, 29, 4, -38 },
  { 4269, 23, 40, 27, 2, -39 },
  { 4384, 24, 38, 28, 2, -38 },
  { 4498, 22, 39, 30, 4, -38 },
  { 4606, 27, 38, 29, 1, -38 },
  { 4735, 37, 38, 41, 2, -38 },
  { 4911, 25, 38, 28, 2, -38 },
  { 5030, 26, 38, 28, 1, -38 },
  { 5154, 23, 38, 28, 2, -38 },
  { 5264, 7, 51, 12, 4, -43 },
  { 5309, 16, 41, 19, 2, -38 },
  { 5391, 7, 51, 12, 1, -43 },
  { 5436, 15, 19, 20, 2, -38 },
  { 5472, 19, 3, 20, 1, 0 },
  { 5480, 8, 7, 15, 3, -40 },
  { 5487, 19, 30, 25, 3, -29 },
  { 5559, 19, 41, 26, 4, -40 },
  { 5657, 19, 30, 24, 3, -29 },
  { 5729, 19, 41, 26, 3, -40 },
  { 5827, 20, 30, 24, 2, -29 },
  { 5902, 14, 41, 16, 2, -41 },
  { 5974, 19, 40, 26, 3, -29 },
  { 6069, 18, 40, 25, 4, -40 },
  { 6159, 4, 38, 11, 4, -38 },
  { 6178, 9, 49, 11, -2, -38 },
  { 6234, 18, 40, 23, 4, -40 },
  { 6324, 3, 40, 11, 4, -40 },
  { 6339, 33, 29, 40, 4, -29 },
  { 6459, 18, 29, 26, 4, -29 },
  { 6525, 20, 30, 26, 3, -29 },
  { 6600, 19, 40, 26, 4, -29 },
  { 6695, 19, 40, 26, 3, -29 },
  { 6790, 11, 29, 16, 4, -29 },
  { 6830, 18, 30, 24, 3, -29 },
  { 6898, 12, 36, 15, 1, -35 },
  { 6952, 18, 29, 26, 4, -28 },
  { 7018, 20, 28, 22, 1, -28 },
  { 7088, 31, 28, 35, 2, -28 },
  { 7197, 19, 28, 23, 2, -28 },
  { 7264, 20, 39, 22, 1, -28 },
  { 7362, 19, 28, 23, 2, -28 },
  { 7429, 13, 51, 16, 2, -41 },
  { 7512, 2, 45, 12, 5, -38 },
  { 7524, 13, 51, 16, 1, -41 },
  { 7607, 24, 10, 32, 4, -21 },
};

const GFXfont RobotoCondensed_Light53pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light53pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light53pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOCONDENSED_LIGHT53PT7B_H_
