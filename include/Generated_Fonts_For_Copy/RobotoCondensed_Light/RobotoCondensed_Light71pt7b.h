#ifndef _ROBOTOCONDENSED_LIGHT71PT7B_H_
#define _ROBOTOCONDENSED_LIGHT71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light71pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDC, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFB, 0xCC, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x0E,
  0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x70, 0x07, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0x00, 0x70, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x38,
  0x03, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x07, 0xF0, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x07,
  0x80, 0x03, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x78, 0xF0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C, 0x70,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x79, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0xF8, 0x3E,
  0x00, 0x3E, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x03, 0x80,
  0x1E, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x07, 0x80, 0x38, 0x00, 0xE0, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0xF0, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x1E, 0x00, 0x38, 0x01, 0xC0, 0x70, 0x00, 0xF0, 0x07, 0x03, 0xC0,
  0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x70, 0x00, 0x0F, 0x07,
  0x81, 0xC0, 0x00, 0x3F, 0xFC, 0x0E, 0x00, 0x00, 0x7F, 0xE0, 0x38, 0x00,
  0x00, 0x7F, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x3F, 0x80, 0x00, 0x07,
  0x81, 0xFF, 0x00, 0x00, 0x1C, 0x0F, 0xFE, 0x00, 0x00, 0xF0, 0x78, 0x3C,
  0x00, 0x03, 0x83, 0xC0, 0x78, 0x00, 0x1C, 0x0E, 0x00, 0xE0, 0x00, 0x70,
  0x38, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x0F, 0x00, 0x0E, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x0E, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x70,
  0x0F, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x0F, 0x01, 0xE0, 0x07,
  0x80, 0x38, 0x03, 0x00, 0x0E, 0x00, 0xE0, 0x04, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x03, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x03, 0xC0,
  0x00, 0xE0, 0x01, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0xF0, 0xF8, 0x01, 0xE0, 0xF0,
  0x3C, 0x00, 0xF0, 0xF8, 0x1F, 0x00, 0x78, 0x78, 0x07, 0xC0, 0x38, 0x78,
  0x01, 0xE0, 0x1C, 0x3C, 0x00, 0xF8, 0x0E, 0x3C, 0x00, 0x3E, 0x0F, 0x1E,
  0x00, 0x0F, 0x87, 0x8F, 0x00, 0x03, 0xC3, 0xC7, 0x80, 0x01, 0xF3, 0xC3,
  0xC0, 0x00, 0x7D, 0xE1, 0xE0, 0x00, 0x1E, 0xF0, 0xF0, 0x00, 0x07, 0xF0,
  0x78, 0x00, 0x03, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x7F, 0x01, 0xE0, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x7D,
  0xF0, 0x3F, 0x01, 0xFC, 0x78, 0x0F, 0xFF, 0xFC, 0x3E, 0x03, 0xFF, 0xFC,
  0x0F, 0x80, 0x7F, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0x00, 0x08, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x08, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x00, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x40, 0x07, 0x00, 0x27, 0x00, 0x70, 0x0E, 0xFE, 0x07, 0x07,
  0xFF, 0xFC, 0x71, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0xF1, 0xE7, 0x8F, 0x1C, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7B, 0xFF, 0xFF, 0x78, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x0F, 0x81, 0xF0,
  0x01, 0xE0, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00,
  0x0F, 0x78, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0x80, 0xF8, 0x03, 0xE0,
  0x3F, 0x03, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x1F, 0xF0,
  0xFF, 0xE7, 0xFF, 0xFF, 0xC7, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x0F, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0x7E, 0x07,
  0xC0, 0x0F, 0x83, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x07,
  0x9E, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0x8F, 0x80, 0x03,
  0xC3, 0xF0, 0x01, 0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x01,
  0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0,
  0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78,
  0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x1F, 0xC0, 0x0F, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC1, 0xFC, 0x07, 0xF0, 0xF8, 0x00, 0xFC, 0x78, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xE3, 0xC0, 0x01,
  0xE1, 0xF0, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x03, 0xF8, 0x01, 0xE1, 0xFF, 0xC0,
  0x3C, 0xFF, 0xFE, 0x07, 0xBF, 0xFF, 0xE0, 0xFF, 0x80, 0x7E, 0x1F, 0xE0,
  0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF9,
  0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1E, 0x3C,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x3E, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFC, 0x0F,
  0xE0, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x3C,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x1E, 0x78, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E,
  0x1E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x03, 0xE0,
  0x1F, 0x80, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xE0, 0x7F, 0x01, 0xF0, 0x03, 0xF0, 0x7C, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC0, 0xFE,
  0x03, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x1F, 0x03,
  0xE0, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x1E, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x78, 0x00,
  0x07, 0xDE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFC, 0xF0, 0x00, 0x7F, 0x3E,
  0x00, 0x3F, 0xC7, 0xE0, 0x3E, 0xF0, 0xFF, 0xFF, 0x3C, 0x1F, 0xFF, 0x8F,
  0x03, 0xFF, 0x83, 0x80, 0x3F, 0x80, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x73, 0xEF, 0xFE, 0xF9, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x73, 0xEF, 0xBE, 0xF9, 0xC0, 0x1E, 0x1F, 0x3F, 0x3F, 0x1F,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C,
  0x3C, 0x78, 0x78, 0x70, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xF8, 0x3F, 0x07, 0xC0, 0x1F, 0x1F,
  0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0,
  0x00, 0xF7, 0x80, 0x00, 0xEF, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0x1C,
  0x1E, 0x00, 0x07, 0xFE, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0xFF, 0x00, 0x1C,
  0x1C, 0x00, 0x1F, 0x0F, 0x80, 0x0E, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x0E,
  0x38, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x38, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x38, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x06, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x70, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x70, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0xF0, 0x03, 0x80, 0x03, 0x80, 0x07, 0xF0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0xF0, 0x03, 0x80, 0x03, 0x80, 0x07, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0xE0, 0x07, 0x80, 0x07, 0x80, 0x07, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x06,
  0xE0, 0x07, 0x00, 0x07, 0x00, 0x0E, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0xE0, 0x07, 0x00, 0x07, 0x00, 0x0E, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0xE0, 0x07, 0x00, 0x07, 0x00, 0x0E, 0xF0, 0x07, 0x00, 0x0F, 0x00, 0x1C,
  0xF0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x70, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x70, 0x07, 0x80, 0x1F, 0x00, 0x38, 0x70, 0x03, 0x80, 0x3F, 0x80, 0x38,
  0x70, 0x03, 0xC0, 0x77, 0x80, 0x70, 0x78, 0x03, 0xE0, 0xF3, 0xC0, 0xF0,
  0x78, 0x01, 0xFF, 0xE3, 0xE3, 0xE0, 0x38, 0x00, 0xFF, 0xC1, 0xFF, 0xC0,
  0x38, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xF0,
  0x00, 0x3F, 0x0F, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x1F, 0x0F, 0x00,
  0x03, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0xCF, 0x00,
  0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x01,
  0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0xF1, 0xF0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x1E, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x7F, 0x03, 0xC0, 0x00, 0x7E,
  0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3E, 0xF0,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x1F, 0x83, 0xC0, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0, 0x01, 0xF0,
  0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F,
  0x3E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0,
  0x00, 0x07, 0xBE, 0x00, 0x03, 0xE7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x7C, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x78, 0x03, 0xE0,
  0x00, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x3C, 0x7E, 0x00, 0x00, 0x79, 0xFC, 0x00, 0x00, 0xF3, 0xFC, 0x00, 0x01,
  0xEF, 0xFC, 0x00, 0x03, 0xFE, 0x78, 0x00, 0x07, 0xF8, 0xF8, 0x00, 0x0F,
  0xE0, 0xF8, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x78,
  0x01, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xE0, 0x07, 0x80, 0x03, 0xE0, 0x0F, 0x00, 0x07, 0xC0, 0x1E, 0x00,
  0x07, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x1F, 0x0F, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFB, 0xC0, 0x00, 0x00, 0x3B, 0xFD, 0xE0, 0x00, 0x00, 0x3D, 0xFE, 0xF0,
  0x00, 0x00, 0x1E, 0xFF, 0x3C, 0x00, 0x00, 0x1E, 0x7F, 0x9E, 0x00, 0x00,
  0x0F, 0x3F, 0xCF, 0x00, 0x00, 0x07, 0x9F, 0xE3, 0xC0, 0x00, 0x07, 0x8F,
  0xF1, 0xE0, 0x00, 0x03, 0xC7, 0xF8, 0xF0, 0x00, 0x01, 0xE3, 0xFC, 0x3C,
  0x00, 0x01, 0xE1, 0xFE, 0x1E, 0x00, 0x00, 0xF0, 0xFF, 0x07, 0x00, 0x00,
  0x78, 0x7F, 0x83, 0xC0, 0x00, 0x78, 0x3F, 0xC1, 0xE0, 0x00, 0x3C, 0x1F,
  0xE0, 0x70, 0x00, 0x1C, 0x0F, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0xF8, 0x1E,
  0x00, 0x0F, 0x03, 0xFC, 0x07, 0x00, 0x07, 0x01, 0xFE, 0x03, 0xC0, 0x07,
  0x80, 0xFF, 0x01, 0xE0, 0x03, 0xC0, 0x7F, 0x80, 0x70, 0x01, 0xC0, 0x3F,
  0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0xF0, 0x07,
  0x80, 0xF0, 0x07, 0xF8, 0x03, 0xC0, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x3C,
  0x01, 0xFE, 0x00, 0x78, 0x3C, 0x00, 0xFF, 0x00, 0x3C, 0x1E, 0x00, 0x7F,
  0x80, 0x0E, 0x0F, 0x00, 0x3F, 0xC0, 0x07, 0x8F, 0x00, 0x1F, 0xE0, 0x03,
  0xC7, 0x80, 0x0F, 0xF0, 0x00, 0xE3, 0x80, 0x07, 0xF8, 0x00, 0x7B, 0xC0,
  0x03, 0xFC, 0x00, 0x3D, 0xE0, 0x01, 0xFE, 0x00, 0x0E, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xF7, 0x80, 0x00, 0x0F, 0xF7, 0x80, 0x00, 0x0F, 0xF3,
  0xC0, 0x00, 0x0F, 0xF3, 0xC0, 0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x0F, 0xF1,
  0xF0, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x0F, 0xF0,
  0x78, 0x00, 0x0F, 0xF0, 0x3C, 0x00, 0x0F, 0xF0, 0x3C, 0x00, 0x0F, 0xF0,
  0x1E, 0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0xF0,
  0x0F, 0x80, 0x0F, 0xF0, 0x07, 0x80, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0,
  0x03, 0xC0, 0x0F, 0xF0, 0x01, 0xE0, 0x0F, 0xF0, 0x01, 0xE0, 0x0F, 0xF0,
  0x00, 0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x0F, 0xF0, 0x00, 0x78, 0x0F, 0xF0,
  0x00, 0x7C, 0x0F, 0xF0, 0x00, 0x3C, 0x0F, 0xF0, 0x00, 0x1E, 0x0F, 0xF0,
  0x00, 0x1E, 0x0F, 0xF0, 0x00, 0x0F, 0x0F, 0xF0, 0x00, 0x0F, 0x0F, 0xF0,
  0x00, 0x07, 0x8F, 0xF0, 0x00, 0x07, 0xCF, 0xF0, 0x00, 0x03, 0xCF, 0xF0,
  0x00, 0x03, 0xEF, 0xF0, 0x00, 0x01, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x0F,
  0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x1E, 0x00, 0x00, 0x78, 0x3E,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0x78, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x07,
  0xF8, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x01,
  0xFC, 0x78, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3E,
  0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x07, 0xE7, 0x80, 0x00, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0x3C, 0xF8, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x3F, 0x83,
  0xC0, 0x00, 0x3F, 0x0F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xF0, 0xF0,
  0x00, 0x1F, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0F,
  0x80, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0xF0,
  0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3E, 0x3C, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x3E, 0x3F,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x80, 0xFE, 0x01, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x00, 0x78,
  0xF8, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x7C, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0x83, 0x80, 0x00, 0xF7, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1E,
  0x70, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xCE, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x71, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x03, 0xC0,
  0x03, 0xC7, 0x80, 0x03, 0x80, 0x78, 0x00, 0x78, 0x70, 0x00, 0xF0, 0x0F,
  0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xC1, 0xE0, 0x03, 0xC0,
  0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0x00, 0x1C, 0x01, 0xE0, 0x1C,
  0x01, 0xE0, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x00, 0x78, 0x07, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x3C,
  0x00, 0xE0, 0x3C, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x03, 0xC0,
  0xE0, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x0F,
  0x07, 0x80, 0x07, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0xF0, 0x00,
  0x1C, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xC7, 0x80,
  0x00, 0x78, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x1E,
  0x70, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x3B, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x78, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01,
  0xF0, 0x78, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x3C,
  0x7C, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x1E, 0x1F, 0x00,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00,
  0x79, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0F, 0x0F, 0x00, 0xE0, 0x70,
  0x0E, 0x07, 0x01, 0xE0, 0x78, 0x1C, 0x03, 0x83, 0xC0, 0x3C, 0x3C, 0x03,
  0xC3, 0x80, 0x1C, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x70, 0x00, 0xEF, 0x00,
  0x0F, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xF8, 0x0F, 0xC1, 0xF0,
  0x01, 0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x38,
  0x00, 0x07, 0xBC, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0x00,
  0xF1, 0xF8, 0x00, 0x79, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xF8, 0x00,
  0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x3E, 0xF0,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x9F, 0x00, 0x3F, 0xCF, 0xE0, 0x7D, 0xE3,
  0xFF, 0xFC, 0xF8, 0xFF, 0xFC, 0x3C, 0x3F, 0xF8, 0x1E, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x01, 0xF0,
  0x03, 0xC3, 0xFF, 0x80, 0xF1, 0xFF, 0xF8, 0x3C, 0xFF, 0xFF, 0x0F, 0x7C,
  0x0F, 0xE3, 0xFC, 0x00, 0xF8, 0xFE, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0,
  0x00, 0x07, 0xBE, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0xF3, 0xF0, 0x00, 0x7C,
  0xFF, 0x00, 0x3E, 0x3D, 0xF0, 0x3F, 0x8F, 0x3F, 0xFF, 0xC3, 0xC7, 0xFF,
  0xE0, 0xF0, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xC0, 0x7E,
  0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x1E, 0x3C, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x3C, 0xF0, 0x00, 0x0E, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xF0,
  0x01, 0xF0, 0x3F, 0x01, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x01, 0xF8, 0x0E, 0x07, 0xFF, 0x07, 0x07, 0xFF, 0xE3, 0x87,
  0xFF, 0xF9, 0xC7, 0xE0, 0x3E, 0xE7, 0xE0, 0x07, 0x73, 0xE0, 0x01, 0xFB,
  0xE0, 0x00, 0x7D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x3F,
  0x3F, 0x00, 0x3B, 0x8F, 0xC0, 0x7D, 0xC3, 0xFF, 0xFC, 0xE0, 0xFF, 0xFC,
  0x70, 0x1F, 0xF8, 0x38, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xE0, 0x07, 0xC1, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x1E, 0x3C, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0x07, 0xC0, 0x00, 0xE1, 0xF8, 0x00,
  0x7C, 0x3F, 0x80, 0x7E, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFF, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF,
  0xC1, 0xC1, 0xFF, 0xF8, 0xE1, 0xFF, 0xFE, 0x71, 0xF8, 0x0F, 0xB9, 0xF8,
  0x01, 0xDC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xBC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x7C,
  0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xCF, 0xC0, 0x0E, 0xE3, 0xF0, 0x1F, 0x70,
  0xFF, 0xFF, 0x38, 0x3F, 0xFF, 0x1C, 0x07, 0xFE, 0x0E, 0x00, 0xFC, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x80, 0x00, 0x7C, 0x60, 0x00, 0x3C, 0x78, 0x00,
  0x3E, 0x3F, 0x00, 0x7E, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x0F, 0x80, 0xF0, 0x7F, 0xE0, 0xF0, 0xFF, 0xF8, 0xF3, 0xFF, 0xF8, 0xF3,
  0xC0, 0xFC, 0xF7, 0x00, 0x3E, 0xFE, 0x00, 0x1E, 0xFC, 0x00, 0x1E, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x27, 0xFF, 0xFF, 0xB8,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE0, 0x00, 0x40, 0x1E, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03,
  0xE0, 0x7C, 0xFF, 0xCF, 0xF8, 0xFF, 0x0F, 0xC0, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0xF0, 0x00,
  0x3C, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x0F, 0x00,
  0x3E, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x1F, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x0F, 0x80, 0x07, 0x8F, 0x80, 0x03, 0xCF, 0x80, 0x01, 0xEF, 0xC0, 0x00,
  0xF7, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xCF, 0x00,
  0x0F, 0xC3, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x1E, 0x00,
  0x7C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x03, 0xE1, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0x9E,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x0F, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0xF1, 0xFF, 0xF0, 0x1F, 0xFF, 0x8F, 0x3F, 0xFF, 0x83, 0xFF, 0xF8,
  0xF7, 0xC0, 0xFC, 0x7C, 0x0F, 0xCF, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xFE,
  0x00, 0x3E, 0xE0, 0x01, 0xEF, 0xC0, 0x01, 0xFC, 0x00, 0x1E, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x7F, 0xE0, 0xF0, 0xFF, 0xF8, 0xF3, 0xFF,
  0xF8, 0xF3, 0xC0, 0xFC, 0xF7, 0x00, 0x3E, 0xFE, 0x00, 0x1E, 0xFC, 0x00,
  0x1E, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0xFC, 0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0x3C, 0x7C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x78,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x3C, 0x3C, 0x00,
  0x07, 0x87, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x3F, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x3C, 0x3F, 0xF8, 0x0F, 0x1F, 0xFF, 0x83, 0xCF,
  0xFF, 0xF0, 0xF7, 0x80, 0xFE, 0x3F, 0x80, 0x0F, 0x8F, 0xC0, 0x01, 0xF3,
  0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x0F,
  0x3F, 0x00, 0x07, 0xCF, 0xE0, 0x03, 0xE3, 0xDE, 0x03, 0xF0, 0xF3, 0xFF,
  0xFC, 0x3C, 0x7F, 0xFE, 0x0F, 0x0F, 0xFE, 0x03, 0xC0, 0x7C, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xC1,
  0xC1, 0xFF, 0xF8, 0xE1, 0xFF, 0xFE, 0x71, 0xF8, 0x0F, 0xB9, 0xF8, 0x01,
  0xDC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xBC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x7C, 0x00,
  0x0F, 0x9F, 0x00, 0x0F, 0xCF, 0xC0, 0x0F, 0xE3, 0xF0, 0x1F, 0x70, 0xFF,
  0xFF, 0x38, 0x3F, 0xFF, 0x1C, 0x07, 0xFE, 0x0E, 0x00, 0xFC, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x3D, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF,
  0x7E, 0x3F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0x01, 0xF8, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0E,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x7C, 0x00, 0x3E, 0x3F, 0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3C,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x3F, 0x01, 0xFF, 0x1F, 0xFF, 0xEF,
  0x0F, 0xFF, 0xCF, 0x07, 0xFF, 0x0F, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0x78, 0x00,
  0x07, 0x9E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78,
  0x0E, 0x00, 0x1C, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x1C, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x0E,
  0x01, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0x83, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0F, 0x1C,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xDE, 0x00, 0x07, 0x80, 0x01, 0xE7,
  0x80, 0x01, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x7C, 0x00, 0x1E, 0x38, 0x00,
  0x3F, 0x00, 0x07, 0x8F, 0x00, 0x0F, 0xC0, 0x01, 0xC3, 0xC0, 0x03, 0xF0,
  0x00, 0xF0, 0xF0, 0x01, 0xFE, 0x00, 0x3C, 0x3C, 0x00, 0x7F, 0x80, 0x0F,
  0x07, 0x80, 0x1C, 0xE0, 0x03, 0x81, 0xE0, 0x07, 0x38, 0x01, 0xE0, 0x78,
  0x03, 0xCF, 0x00, 0x78, 0x1E, 0x00, 0xF3, 0xC0, 0x1E, 0x03, 0x80, 0x38,
  0x70, 0x07, 0x00, 0xF0, 0x0E, 0x1C, 0x01, 0xC0, 0x3C, 0x07, 0x87, 0x80,
  0xF0, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x00,
  0x78, 0x1C, 0x0F, 0x03, 0x80, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x07, 0x83,
  0x80, 0x70, 0x78, 0x00, 0xE0, 0xE0, 0x1C, 0x1E, 0x00, 0x3C, 0x38, 0x07,
  0x87, 0x00, 0x0F, 0x1E, 0x01, 0xE1, 0xC0, 0x03, 0xC7, 0x00, 0x38, 0xF0,
  0x00, 0x71, 0xC0, 0x0E, 0x3C, 0x00, 0x1C, 0xF0, 0x03, 0xCE, 0x00, 0x07,
  0xBC, 0x00, 0xF3, 0x80, 0x01, 0xEE, 0x00, 0x1D, 0xE0, 0x00, 0x3B, 0x80,
  0x07, 0x78, 0x00, 0x0E, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x07,
  0xDF, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x1E, 0x00,
  0x1E, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x07,
  0xC0, 0x78, 0x00, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF1, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xBC, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x03, 0xC0, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x03, 0xC0, 0x3C, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x07, 0x80, 0x07, 0xC3,
  0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x79, 0xE0,
  0x00, 0x1E, 0x78, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01,
  0xE0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00,
  0x38, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C,
  0x00, 0x1E, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C,
  0x70, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x04, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0x1F, 0xFE, 0x00,
  0x07, 0x3F, 0xFF, 0x00, 0x07, 0x3C, 0x1F, 0x80, 0x07, 0x78, 0x0F, 0xC0,
  0x0F, 0x70, 0x03, 0xE0, 0x0E, 0xF0, 0x03, 0xF0, 0x1E, 0xF0, 0x01, 0xF8,
  0x3C, 0xF0, 0x00, 0xFF, 0xFC, 0xE0, 0x00, 0x3F, 0xF8, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_Light71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 5, 51, 15, 5, -50 },
  { 33, 12, 16, 20, 5, -53 },
  { 57, 33, 50, 36, 3, -50 },
  { 264, 27, 65, 35, 4, -58 },
  { 484, 38, 52, 45, 4, -51 },
  { 731, 33, 52, 38, 4, -51 },
  { 946, 4, 16, 12, 4, -53 },
  { 954, 14, 73, 21, 5, -57 },
  { 1082, 14, 73, 21, 2, -57 },
  { 1210, 28, 28, 30, 1, -50 },
  { 1308, 29, 37, 35, 3, -42 },
  { 1443, 7, 16, 14, 2, -7 },
  { 1457, 14, 4, 18, 2, -24 },
  { 1464, 6, 6, 17, 5, -5 },
  { 1469, 21, 54, 25, 2, -50 },
  { 1611, 26, 52, 35, 4, -51 },
  { 1780, 15, 50, 35, 6, -50 },
  { 1874, 27, 51, 35, 4, -51 },
  { 2047, 26, 52, 35, 4, -51 },
  { 2216, 30, 50, 35, 3, -50 },
  { 2404, 25, 51, 35, 6, -50 },
  { 2564, 27, 51, 35, 4, -50 },
  { 2737, 28, 50, 35, 3, -50 },
  { 2912, 27, 52, 35, 4, -51 },
  { 3088, 26, 51, 35, 4, -51 },
  { 3254, 6, 38, 14, 5, -37 },
  { 3283, 8, 46, 13, 2, -37 },
  { 3329, 24, 30, 32, 3, -38 },
  { 3419, 24, 19, 34, 5, -33 },
  { 3476, 25, 30, 32, 4, -38 },
  { 3570, 23, 52, 29, 3, -51 },
  { 3720, 48, 65, 56, 4, -49 },
  { 4110, 35, 50, 39, 2, -50 },
  { 4329, 28, 50, 38, 6, -50 },
  { 4504, 31, 52, 40, 5, -51 },
  { 4706, 30, 50, 40, 6, -50 },
  { 4894, 26, 50, 35, 6, -50 },
  { 5057, 26, 50, 35, 6, -50 },
  { 5220, 32, 52, 42, 5, -51 },
  { 5428, 32, 50, 44, 6, -50 },
  { 5628, 4, 50, 17, 7, -50 },
  { 5653, 26, 51, 34, 3, -50 },
  { 5819, 31, 50, 39, 6, -50 },
  { 6013, 25, 50, 33, 6, -50 },
  { 6170, 41, 50, 53, 6, -50 },
  { 6427, 32, 50, 44, 6, -50 },
  { 6627, 32, 52, 42, 5, -51 },
  { 6835, 29, 50, 38, 6, -50 },
  { 7017, 33, 60, 42, 4, -51 },
  { 7265, 30, 50, 39, 6, -50 },
  { 7453, 31, 52, 37, 3, -51 },
  { 7655, 33, 50, 37, 2, -50 },
  { 7862, 30, 51, 41, 5, -50 },
  { 8054, 35, 50, 38, 2, -50 },
  { 8273, 51, 50, 55, 2, -50 },
  { 8592, 34, 50, 38, 2, -50 },
  { 8805, 35, 50, 37, 1, -50 },
  { 9024, 31, 50, 37, 3, -50 },
  { 9218, 10, 69, 16, 5, -58 },
  { 9305, 22, 54, 25, 2, -50 },
  { 9454, 10, 69, 16, 1, -58 },
  { 9541, 20, 25, 26, 3, -50 },
  { 9604, 26, 4, 27, 1, 0 },
  { 9617, 11, 10, 20, 4, -54 },
  { 9631, 25, 40, 33, 4, -39 },
  { 9756, 26, 54, 35, 5, -53 },
  { 9932, 26, 40, 32, 3, -39 },
  { 10062, 25, 54, 35, 4, -53 },
  { 10231, 26, 40, 33, 3, -39 },
  { 10361, 18, 54, 21, 3, -54 },
  { 10483, 25, 53, 35, 4, -39 },
  { 10649, 24, 53, 34, 5, -53 },
  { 10808, 5, 52, 15, 5, -52 },
  { 10841, 12, 66, 15, -2, -52 },
  { 10940, 25, 53, 31, 5, -53 },
  { 11106, 3, 53, 15, 6, -53 },
  { 11126, 44, 39, 54, 5, -39 },
  { 11341, 24, 39, 34, 5, -39 },
  { 11458, 27, 40, 35, 4, -39 },
  { 11593, 26, 53, 35, 5, -39 },
  { 11766, 25, 53, 35, 4, -39 },
  { 11932, 15, 39, 22, 5, -39 },
  { 12006, 24, 40, 32, 4, -39 },
  { 12126, 17, 48, 21, 1, -47 },
  { 12228, 24, 39, 34, 5, -38 },
  { 12345, 26, 38, 30, 2, -38 },
  { 12469, 42, 38, 46, 2, -38 },
  { 12669, 26, 38, 31, 2, -38 },
  { 12793, 26, 52, 30, 2, -38 },
  { 12962, 25, 38, 31, 3, -38 },
  { 13081, 17, 69, 21, 3, -55 },
  { 13228, 4, 59, 16, 6, -50 },
  { 13258, 17, 69, 21, 1, -55 },
  { 13405, 32, 13, 42, 5, -28 },
};

const GFXfont RobotoCondensed_Light71pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light71pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light71pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _ROBOTOCONDENSED_LIGHT71PT7B_H_
