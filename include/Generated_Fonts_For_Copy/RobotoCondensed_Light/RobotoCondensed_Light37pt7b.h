#ifndef _ROBOTOCONDENSED_LIGHT37PT7B_H_
#define _ROBOTOCONDENSED_LIGHT37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x8E, 0x38, 0xE3, 0x8E,
  0x28, 0xA2, 0x03, 0x04, 0x01, 0x82, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x30,
  0xC0, 0x10, 0x60, 0x08, 0x20, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0x0C, 0x01,
  0x86, 0x00, 0x83, 0x00, 0x41, 0x00, 0x60, 0x80, 0x30, 0xC0, 0x18, 0x60,
  0x0C, 0x30, 0x7F, 0xFF, 0xBF, 0xFF, 0xC3, 0x04, 0x01, 0x82, 0x00, 0xC3,
  0x00, 0x61, 0x80, 0x20, 0xC0, 0x10, 0x60, 0x18, 0x20, 0x00, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x07, 0xC0, 0x7F, 0x83, 0x87, 0x1C, 0x0E,
  0x60, 0x19, 0x80, 0x76, 0x00, 0xD8, 0x03, 0x60, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x80, 0x76, 0x01, 0x8E, 0x0E, 0x1F,
  0xF0, 0x3F, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x3C, 0x00, 0x07, 0xE0,
  0x00, 0x43, 0x00, 0x0C, 0x10, 0x20, 0xC1, 0x82, 0x0C, 0x18, 0x60, 0xC1,
  0x84, 0x0C, 0x18, 0xC0, 0xC1, 0x08, 0x04, 0x31, 0x80, 0x7F, 0x30, 0x03,
  0xC3, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC7, 0x80, 0x08, 0xFE,
  0x01, 0x88, 0x60, 0x11, 0x83, 0x03, 0x18, 0x30, 0x61, 0x83, 0x06, 0x18,
  0x30, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x00, 0xC6, 0x00, 0x0F, 0xE0, 0x00,
  0x78, 0x07, 0x80, 0x0F, 0xF0, 0x06, 0x18, 0x06, 0x06, 0x03, 0x03, 0x01,
  0x81, 0x80, 0xC0, 0xC0, 0x60, 0xC0, 0x38, 0xE0, 0x0C, 0xE0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xD8, 0x00, 0xCE, 0x0C, 0xC3, 0x86, 0x60,
  0xC3, 0x60, 0x31, 0xB0, 0x1D, 0x98, 0x06, 0xCC, 0x01, 0xE7, 0x00, 0xE1,
  0x80, 0x78, 0xE0, 0xFC, 0x3F, 0xE3, 0x07, 0xE1, 0xC0, 0xFF, 0xFF, 0x01,
  0x03, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60,
  0x60, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x60,
  0x60, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x03,
  0x01, 0x81, 0x81, 0x81, 0x03, 0x02, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x60, 0x83, 0x0C, 0x10, 0x00, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x03, 0x8C, 0x7F, 0xFF, 0xC7,
  0xF8, 0x07, 0x00, 0x1E, 0x00, 0xCC, 0x06, 0x38, 0x18, 0x60, 0xC0, 0xC0,
  0x02, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x33, 0x33, 0x76, 0x64, 0xFF, 0xFC, 0xDF, 0x00, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60,
  0x00, 0x0F, 0xC0, 0x7F, 0x83, 0x87, 0x1C, 0x0E, 0x60, 0x19, 0x80, 0x66,
  0x01, 0xB0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xD8, 0x06,
  0x60, 0x19, 0x80, 0x63, 0x03, 0x8E, 0x1C, 0x1F, 0xE0, 0x3E, 0x00, 0x03,
  0x0F, 0x3F, 0xF3, 0xC3, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x0F, 0xC0, 0x7F, 0x83, 0x87, 0x18, 0x0E, 0x60, 0x1B, 0x00, 0x6C,
  0x01, 0xB0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xC0, 0x7F, 0x83, 0x07, 0x18, 0x0E, 0xE0, 0x1B, 0x00, 0x6C, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x0F, 0xC0, 0x3F, 0x80,
  0x07, 0x00, 0x06, 0x00, 0x18, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x66, 0x01, 0x8E, 0x0C, 0x1F, 0xE0, 0x3F, 0x00, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0xD8, 0x00, 0xD8, 0x01, 0x98, 0x01, 0x98, 0x03,
  0x18, 0x03, 0x18, 0x06, 0x18, 0x0E, 0x18, 0x0C, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x30, 0x18, 0x30, 0x18, 0x60, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x3F, 0xF9, 0xFF, 0xC8, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x7C, 0x1F, 0xF8, 0xE1, 0xE6, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0D, 0x80, 0xCE, 0x0E, 0x3F, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x1F, 0x80,
  0xF0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x9F, 0x06, 0xFF, 0x36, 0x0E, 0xF0, 0x1B, 0x80, 0x6E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xD8, 0x03, 0x60, 0x0D, 0x80, 0x63, 0x01,
  0x8E, 0x0C, 0x1F, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0x87, 0x1C, 0x0E, 0x60,
  0x19, 0x80, 0x66, 0x01, 0x98, 0x07, 0x60, 0x19, 0x80, 0x67, 0x03, 0x8E,
  0x1C, 0x1F, 0xE0, 0x7F, 0x83, 0x87, 0x18, 0x06, 0xE0, 0x1F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x36, 0x01, 0x9C, 0x0E, 0x3F, 0xF0,
  0x3F, 0x00, 0x0F, 0x80, 0x7F, 0x83, 0x87, 0x18, 0x0C, 0x60, 0x1B, 0x00,
  0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xE0,
  0x1D, 0x80, 0xF3, 0x06, 0xCF, 0xF2, 0x0F, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x1F, 0x80, 0x78, 0x00,
  0x7D, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xB0, 0x37, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x33, 0x33, 0x66, 0x40, 0x00, 0x10, 0x07,
  0x00, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x70, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80,
  0x07, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x03, 0x80, 0x10,
  0x00, 0x1F, 0x07, 0xF1, 0xC3, 0x70, 0x7C, 0x07, 0x80, 0xF0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xE0, 0x1E, 0x00, 0xE0,
  0x03, 0x80, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x08, 0x60,
  0x00, 0x06, 0x30, 0x1F, 0x01, 0x10, 0x1F, 0xC0, 0x98, 0x18, 0x30, 0x6C,
  0x0C, 0x18, 0x34, 0x0C, 0x08, 0x1A, 0x06, 0x04, 0x0F, 0x06, 0x02, 0x07,
  0x83, 0x01, 0x03, 0xC1, 0x81, 0x81, 0xE0, 0xC0, 0xC0, 0xF0, 0x60, 0x60,
  0x78, 0x30, 0x30, 0x3C, 0x18, 0x18, 0x16, 0x0C, 0x0C, 0x1B, 0x06, 0x0E,
  0x0C, 0x83, 0x8D, 0x0C, 0x60, 0xFC, 0xFC, 0x30, 0x3C, 0x3C, 0x08, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x01, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1B, 0x00,
  0x06, 0x60, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00,
  0x18, 0x20, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x01, 0x80,
  0xC0, 0x30, 0x18, 0x06, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x18, 0x01, 0x83,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x06, 0xC0, 0x00, 0xD8,
  0x00, 0x18, 0xFF, 0xC1, 0xFF, 0xE3, 0x00, 0xE6, 0x00, 0xCC, 0x00, 0xD8,
  0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x33, 0x00, 0xE7, 0xFF,
  0x0F, 0xFF, 0x18, 0x07, 0x30, 0x07, 0x60, 0x06, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xB0, 0x07, 0x60, 0x1C, 0xFF,
  0xF1, 0xFF, 0x80, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x03, 0x87, 0x00, 0xC3,
  0x00, 0x33, 0x00, 0x19, 0x80, 0x0E, 0xC0, 0x03, 0x60, 0x01, 0xF0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x76, 0x00, 0x31,
  0x80, 0x18, 0xE0, 0x18, 0x38, 0x1C, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0xFF,
  0xC0, 0xFF, 0xF0, 0xC0, 0x78, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x78, 0xFF,
  0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xFF, 0xF3, 0xFF, 0xCC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xF3,
  0xFF, 0xCC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x07,
  0xE0, 0x1F, 0xF8, 0x38, 0x1C, 0x70, 0x0E, 0x60, 0x06, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0x60, 0x03, 0x70, 0x07, 0x3C, 0x0E, 0x1F,
  0xFC, 0x07, 0xF0, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0x60, 0x1D, 0x80, 0x67,
  0x03, 0x8E, 0x1C, 0x1F, 0xE0, 0x3F, 0x00, 0xC0, 0x06, 0x60, 0x07, 0x30,
  0x07, 0x18, 0x07, 0x0C, 0x03, 0x06, 0x03, 0x03, 0x03, 0x81, 0x83, 0x80,
  0xC3, 0x80, 0x61, 0x80, 0x31, 0x80, 0x19, 0xC0, 0x0D, 0xE0, 0x07, 0xF8,
  0x03, 0xCE, 0x01, 0xC3, 0x00, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x18,
  0x06, 0x0C, 0x03, 0x86, 0x00, 0xC3, 0x00, 0x31, 0x80, 0x1C, 0xC0, 0x07,
  0x60, 0x01, 0x80, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x6F,
  0x60, 0x01, 0xBD, 0x80, 0x06, 0xF6, 0x00, 0x33, 0xCC, 0x00, 0xCF, 0x30,
  0x07, 0x3C, 0xC0, 0x18, 0xF1, 0x80, 0x63, 0xC6, 0x03, 0x1F, 0x0C, 0x0C,
  0x7C, 0x30, 0x31, 0xF0, 0xC1, 0x87, 0xC1, 0x86, 0x1F, 0x06, 0x18, 0x7C,
  0x18, 0xC1, 0xF0, 0x33, 0x07, 0xC0, 0xCC, 0x1F, 0x03, 0x60, 0x7C, 0x07,
  0x81, 0xF0, 0x1E, 0x07, 0xC0, 0x30, 0x1F, 0x00, 0xC0, 0x70, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3D, 0x80, 0x1E, 0xC0, 0x0F, 0x30,
  0x07, 0x98, 0x03, 0xC6, 0x01, 0xE3, 0x80, 0xF0, 0xC0, 0x78, 0x70, 0x3C,
  0x18, 0x1E, 0x06, 0x0F, 0x03, 0x07, 0x80, 0xC3, 0xC0, 0x61, 0xE0, 0x18,
  0xF0, 0x0E, 0x78, 0x03, 0x3C, 0x00, 0xDE, 0x00, 0x6F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x03,
  0x87, 0x00, 0xE7, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xD8, 0x00, 0x6C, 0x00,
  0x36, 0x00, 0x19, 0x80, 0x18, 0xE0, 0x1C, 0x38, 0x1C, 0x0F, 0xFC, 0x01,
  0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0xF3, 0x00, 0xF6, 0x00, 0x6C, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x6C, 0x01, 0xDF, 0xFF, 0x3F, 0xF8, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x03, 0x87, 0x00, 0xE7,
  0x00, 0x33, 0x00, 0x1D, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x3B,
  0x80, 0x18, 0xE0, 0x1C, 0x38, 0x1C, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x04, 0xFF, 0xC0, 0xFF,
  0xF0, 0xC0, 0x38, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x38, 0xFF,
  0xF0, 0xFF, 0xC0, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x30, 0xC0,
  0x38, 0xC0, 0x18, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0,
  0x07, 0x07, 0xE0, 0x1F, 0xF0, 0x38, 0x3C, 0x70, 0x0C, 0x60, 0x06, 0xE0,
  0x06, 0xC0, 0x06, 0xE0, 0x06, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xE0, 0x06, 0x70, 0x0E, 0x38,
  0x1C, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xD8, 0x03, 0x3C, 0x0E, 0x3F, 0xF8,
  0x1F, 0xC0, 0xC0, 0x00, 0xF8, 0x00, 0x76, 0x00, 0x19, 0x80, 0x06, 0x60,
  0x01, 0x8C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x18, 0x07, 0x06, 0x01,
  0x81, 0x80, 0x60, 0x70, 0x38, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0,
  0x18, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x03,
  0x30, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0xE0, 0x0C, 0x00, 0xD8, 0x03, 0x80, 0x36, 0x00, 0xE0, 0x0D, 0x80,
  0x38, 0x03, 0x60, 0x1A, 0x01, 0x9C, 0x06, 0xC0, 0x63, 0x01, 0xB0, 0x18,
  0xC0, 0x4C, 0x06, 0x30, 0x31, 0x01, 0x8C, 0x0C, 0x60, 0xC1, 0x83, 0x18,
  0x30, 0x60, 0x86, 0x0C, 0x18, 0x60, 0x83, 0x06, 0x18, 0x31, 0xC1, 0x86,
  0x0C, 0x60, 0x31, 0x03, 0x18, 0x0C, 0xC0, 0x46, 0x03, 0x30, 0x19, 0x80,
  0xCC, 0x06, 0xC0, 0x32, 0x01, 0xB0, 0x07, 0x80, 0x2C, 0x01, 0xE0, 0x0B,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x01, 0x9C, 0x00, 0xE3, 0x00, 0x30, 0xE0, 0x18, 0x18,
  0x0E, 0x03, 0x03, 0x00, 0xC1, 0xC0, 0x18, 0x60, 0x07, 0x38, 0x00, 0xCC,
  0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0xC0, 0x03, 0x30, 0x01, 0x8E, 0x00, 0xE1, 0x80, 0x30, 0x30, 0x1C,
  0x0E, 0x06, 0x01, 0x83, 0x80, 0x70, 0xC0, 0x0C, 0x70, 0x03, 0xB8, 0x00,
  0x60, 0xC0, 0x01, 0xB8, 0x00, 0xE6, 0x00, 0x31, 0xC0, 0x0C, 0x30, 0x06,
  0x0E, 0x01, 0x81, 0x80, 0xC0, 0x70, 0x30, 0x0C, 0x18, 0x03, 0x86, 0x00,
  0x63, 0x00, 0x18, 0xC0, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x3F, 0xF0, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xFF, 0x06, 0x00, 0xC0,
  0x38, 0x07, 0x81, 0xB0, 0x32, 0x06, 0x61, 0x8C, 0x30, 0x86, 0x19, 0x83,
  0x30, 0x36, 0x06, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC3, 0x06, 0x0C, 0x0F,
  0xC1, 0xFF, 0x1C, 0x1C, 0xC0, 0x6E, 0x03, 0xE0, 0x0C, 0x00, 0x60, 0x03,
  0x0F, 0xF9, 0xFF, 0xDC, 0x06, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x7B, 0x06, 0xDF, 0xE6, 0x3E, 0x30, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xCF, 0x86, 0xFF,
  0x3C, 0x1D, 0xC0, 0x6C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x06, 0xE0,
  0x37, 0x83, 0xB7, 0xF9, 0x9F, 0x00, 0x0F, 0x81, 0xFF, 0x1C, 0x1C, 0xC0,
  0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x7C, 0x03, 0x60, 0x1B, 0x83, 0x8F,
  0xF8, 0x1F, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x0F, 0x99, 0xFE, 0xDC, 0x1E, 0xC0, 0x76, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x6C, 0x03, 0x60, 0x3B, 0x83, 0xCF, 0xF6, 0x1F,
  0x30, 0x0F, 0xC1, 0xFF, 0x0C, 0x1C, 0xC0, 0x7E, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x1C, 0x00, 0x60, 0x13, 0xC1, 0xCF, 0xFC, 0x1F, 0x80, 0x03, 0xC3,
  0xF0, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0xFF, 0xBF, 0xE1, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x0F, 0x99, 0xFE,
  0xDC, 0x1E, 0xC0, 0x76, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x6C, 0x03, 0x60,
  0x3B, 0x83, 0xCF, 0xF6, 0x1F, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x20, 0x3B, 0x83, 0x8F, 0xF8, 0x1F, 0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC7, 0x8D, 0xFE, 0xF0, 0x6E,
  0x07, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C, 0x30, 0xC0, 0x00,
  0x00, 0x03, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC7, 0x1B, 0xEF, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x76, 0x07, 0x30, 0x71, 0x83, 0x0C, 0x30, 0x63, 0x03, 0x38, 0x1B,
  0x80, 0xD8, 0x07, 0xE0, 0x3B, 0x01, 0x8C, 0x0C, 0x70, 0x61, 0x83, 0x06,
  0x18, 0x38, 0xC0, 0xC6, 0x03, 0x30, 0x1D, 0x80, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0x81, 0xF1, 0xBF, 0xCF, 0xF3, 0xC3, 0xB8,
  0x77, 0x03, 0xC0, 0x6C, 0x03, 0x80, 0xD8, 0x06, 0x00, 0xF0, 0x0C, 0x01,
  0xE0, 0x18, 0x03, 0xC0, 0x30, 0x07, 0x80, 0x60, 0x0F, 0x00, 0xC0, 0x1E,
  0x01, 0x80, 0x3C, 0x03, 0x00, 0x78, 0x06, 0x00, 0xF0, 0x0C, 0x01, 0xE0,
  0x18, 0x03, 0xC0, 0x30, 0x07, 0x80, 0x60, 0x0F, 0x00, 0xC0, 0x1E, 0x01,
  0x80, 0x30, 0xC7, 0x8D, 0xFE, 0xF0, 0x6E, 0x07, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x0F, 0xC0, 0x7F, 0x83,
  0x87, 0x1C, 0x06, 0x60, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xD8, 0x06,
  0x70, 0x18, 0xE0, 0xC1, 0xFE, 0x03, 0xF0, 0xCF, 0x86, 0xFF, 0x3C, 0x1D,
  0xC0, 0x6C, 0x03, 0x60, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x06, 0xE0, 0x37, 0x83,
  0xB7, 0xF9, 0x9F, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x0F, 0x99, 0xFE, 0xDC, 0x1E, 0xC0, 0x76,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x6C, 0x03, 0x60, 0x3B, 0x83, 0xCF, 0xF6,
  0x1F, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0xCF, 0xBF, 0xC7, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x00, 0x0F, 0x83, 0xFE,
  0x70, 0x66, 0x03, 0xC0, 0x3C, 0x03, 0x60, 0x07, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x37, 0x07,
  0x3F, 0xE1, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x1F, 0x0F, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x76, 0x0F, 0x7F, 0xB1, 0xF3, 0xC0, 0x0F,
  0x00, 0x66, 0x01, 0x98, 0x06, 0x60, 0x30, 0xC0, 0xC3, 0x03, 0x0C, 0x08,
  0x10, 0x60, 0x61, 0x81, 0x86, 0x06, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xC8,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0xC0, 0x30, 0x0D,
  0x80, 0xC0, 0x66, 0x03, 0x81, 0x98, 0x1E, 0x06, 0x60, 0x78, 0x18, 0xC1,
  0xE0, 0xC3, 0x0C, 0xC3, 0x0C, 0x33, 0x0C, 0x30, 0xCC, 0x30, 0x42, 0x30,
  0xC1, 0x98, 0x66, 0x06, 0x61, 0x98, 0x19, 0x86, 0x60, 0x64, 0x09, 0x80,
  0xF0, 0x34, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x60,
  0x18, 0x01, 0x80, 0x60, 0x60, 0x19, 0x80, 0xE3, 0x03, 0x0E, 0x1C, 0x18,
  0x60, 0x73, 0x00, 0xCC, 0x01, 0xE0, 0x07, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xE0, 0x0D, 0xC0, 0x33, 0x01, 0x8E, 0x06, 0x18, 0x30, 0x31, 0xC0, 0xC6,
  0x01, 0xB8, 0x07, 0xC0, 0x1F, 0x00, 0x66, 0x01, 0x98, 0x06, 0x60, 0x30,
  0xC0, 0xC3, 0x03, 0x0C, 0x18, 0x38, 0x60, 0x61, 0x81, 0x86, 0x06, 0x30,
  0x0C, 0xC0, 0x33, 0x00, 0xD8, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x70,
  0x07, 0x80, 0x1C, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x80, 0xE0, 0x70, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x38, 0x3C, 0x0F,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x70, 0x1C, 0x06, 0x03, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18,
  0x0E, 0x03, 0xC1, 0xE1, 0xC0, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x38, 0x38, 0x10, 0x00, 0x3C,
  0x01, 0x7E, 0x01, 0xE3, 0x03, 0xC1, 0x83, 0x80, 0xC6, 0x80, 0x7E, 0x00,
  0x3C,
};

const GFXglyph RobotoCondensed_Light37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 26, 8, 3, -26 },
  { 8, 6, 8, 11, 3, -28 },
  { 14, 17, 26, 19, 2, -26 },
  { 70, 14, 33, 18, 2, -30 },
  { 128, 20, 26, 24, 2, -26 },
  { 193, 17, 26, 20, 2, -26 },
  { 249, 2, 8, 6, 2, -28 },
  { 251, 8, 38, 11, 2, -30 },
  { 289, 7, 38, 11, 1, -30 },
  { 323, 14, 15, 16, 1, -26 },
  { 350, 15, 19, 18, 2, -21 },
  { 386, 4, 8, 7, 1, -3 },
  { 390, 7, 2, 10, 1, -13 },
  { 392, 3, 3, 9, 3, -3 },
  { 394, 11, 28, 13, 1, -26 },
  { 433, 14, 26, 18, 2, -26 },
  { 479, 8, 26, 18, 3, -26 },
  { 505, 14, 26, 18, 2, -26 },
  { 551, 14, 26, 18, 2, -26 },
  { 597, 16, 26, 18, 1, -26 },
  { 649, 13, 26, 18, 3, -26 },
  { 692, 14, 26, 18, 2, -26 },
  { 738, 14, 26, 18, 2, -26 },
  { 784, 14, 26, 18, 2, -26 },
  { 830, 14, 26, 18, 2, -26 },
  { 876, 3, 20, 7, 2, -20 },
  { 884, 4, 25, 7, 1, -20 },
  { 897, 12, 16, 17, 2, -20 },
  { 921, 12, 9, 18, 3, -17 },
  { 935, 13, 16, 17, 2, -20 },
  { 961, 11, 26, 15, 2, -26 },
  { 997, 25, 34, 29, 2, -26 },
  { 1104, 19, 26, 20, 1, -26 },
  { 1166, 15, 26, 20, 3, -26 },
  { 1215, 17, 26, 21, 2, -26 },
  { 1271, 16, 26, 21, 3, -26 },
  { 1323, 14, 26, 18, 3, -26 },
  { 1369, 14, 26, 18, 3, -26 },
  { 1415, 16, 26, 22, 3, -26 },
  { 1467, 17, 26, 23, 3, -26 },
  { 1523, 3, 26, 9, 3, -26 },
  { 1533, 14, 26, 18, 1, -26 },
  { 1579, 17, 26, 20, 3, -26 },
  { 1635, 13, 26, 17, 3, -26 },
  { 1678, 22, 26, 28, 3, -26 },
  { 1750, 17, 26, 23, 3, -26 },
  { 1806, 17, 26, 22, 2, -26 },
  { 1862, 15, 26, 20, 3, -26 },
  { 1911, 17, 31, 22, 2, -26 },
  { 1977, 16, 26, 20, 3, -26 },
  { 2029, 16, 26, 19, 2, -26 },
  { 2081, 17, 26, 19, 1, -26 },
  { 2137, 15, 26, 21, 3, -26 },
  { 2186, 18, 26, 20, 1, -26 },
  { 2245, 26, 26, 29, 1, -26 },
  { 2330, 18, 26, 20, 1, -26 },
  { 2389, 18, 26, 19, 1, -26 },
  { 2448, 16, 26, 19, 2, -26 },
  { 2500, 5, 36, 8, 3, -30 },
  { 2523, 11, 28, 13, 1, -26 },
  { 2562, 6, 36, 8, 0, -30 },
  { 2589, 11, 13, 14, 1, -26 },
  { 2607, 14, 2, 14, 0, 0 },
  { 2611, 6, 5, 11, 2, -28 },
  { 2615, 13, 20, 17, 2, -20 },
  { 2648, 13, 28, 18, 3, -28 },
  { 2694, 13, 20, 17, 2, -20 },
  { 2727, 13, 28, 18, 2, -28 },
  { 2773, 13, 20, 17, 2, -20 },
  { 2806, 10, 28, 11, 1, -28 },
  { 2841, 13, 28, 18, 2, -20 },
  { 2887, 12, 28, 18, 3, -28 },
  { 2929, 2, 27, 8, 3, -27 },
  { 2936, 6, 35, 8, -1, -27 },
  { 2963, 13, 28, 16, 3, -28 },
  { 3009, 2, 28, 8, 3, -28 },
  { 3016, 23, 20, 28, 3, -20 },
  { 3074, 12, 20, 18, 3, -20 },
  { 3104, 14, 20, 18, 2, -20 },
  { 3139, 13, 28, 18, 3, -20 },
  { 3185, 13, 28, 18, 2, -20 },
  { 3231, 7, 20, 11, 3, -20 },
  { 3249, 12, 20, 17, 2, -20 },
  { 3279, 8, 25, 11, 1, -25 },
  { 3304, 12, 20, 18, 3, -20 },
  { 3334, 14, 20, 16, 1, -20 },
  { 3369, 22, 20, 24, 1, -20 },
  { 3424, 14, 20, 16, 1, -20 },
  { 3459, 14, 28, 15, 1, -20 },
  { 3508, 13, 20, 16, 2, -20 },
  { 3541, 10, 36, 11, 1, -29 },
  { 3586, 2, 31, 8, 3, -26 },
  { 3594, 9, 36, 11, 1, -29 },
  { 3635, 16, 7, 22, 3, -15 },
};

const GFXfont RobotoCondensed_Light37pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light37pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light37pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _ROBOTOCONDENSED_LIGHT37PT7B_H_
