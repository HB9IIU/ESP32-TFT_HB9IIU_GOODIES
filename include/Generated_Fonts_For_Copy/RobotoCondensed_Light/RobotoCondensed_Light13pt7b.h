#ifndef _ROBOTOCONDENSED_LIGHT13PT7B_H_
#define _ROBOTOCONDENSED_LIGHT13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFC, 0x80, 0xFC, 0x28, 0xAF, 0xD4, 0x51, 0x4F, 0x94, 0x90, 0x23,
  0xA5, 0x18, 0x30, 0x51, 0x8B, 0x88, 0xC1, 0x52, 0xA6, 0x81, 0x05, 0x8C,
  0xA9, 0x0C, 0x62, 0x49, 0x18, 0x42, 0xA9, 0xA2, 0x78, 0xE0, 0x5A, 0xAA,
  0xA9, 0x40, 0x89, 0x12, 0x49, 0x25, 0x28, 0x25, 0x1E, 0x64, 0x80, 0x21,
  0x09, 0xF2, 0x10, 0x80, 0x58, 0xE0, 0x80, 0x11, 0x12, 0x22, 0x44, 0x48,
  0x74, 0xA3, 0x18, 0xC6, 0x32, 0x70, 0x74, 0x92, 0x49, 0x20, 0x74, 0xA2,
  0x21, 0x11, 0x10, 0xF8, 0x74, 0xA2, 0x26, 0x0A, 0x31, 0x70, 0x08, 0x61,
  0x8A, 0x49, 0x2F, 0xC2, 0x08, 0x7C, 0x21, 0xE0, 0x86, 0x31, 0x70, 0x32,
  0x21, 0xE8, 0xC6, 0x32, 0x70, 0xF8, 0x84, 0x22, 0x11, 0x08, 0x40, 0x74,
  0xA3, 0x26, 0x4A, 0x31, 0x70, 0x64, 0xA3, 0x19, 0x34, 0x42, 0x60, 0x82,
  0x40, 0x05, 0x80, 0x16, 0x88, 0x61, 0xF0, 0x0F, 0x86, 0x11, 0x68, 0xE9,
  0x12, 0x44, 0x00, 0x40, 0x3E, 0x41, 0x81, 0x9D, 0xA5, 0xA5, 0xA5, 0xA5,
  0x9F, 0x80, 0x40, 0x3C, 0x10, 0x20, 0xA1, 0x42, 0x4F, 0x91, 0x22, 0x82,
  0xF4, 0x63, 0x1F, 0x46, 0x31, 0xF0, 0x7A, 0x28, 0x60, 0x82, 0x08, 0x62,
  0x78, 0xF2, 0x28, 0x61, 0x86, 0x18, 0x62, 0xF0, 0xFC, 0x21, 0x0F, 0x42,
  0x10, 0xF8, 0xFC, 0x21, 0x0F, 0x42, 0x10, 0x80, 0x7A, 0x28, 0x60, 0x9E,
  0x18, 0x61, 0x78, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x84, 0xFF, 0x80,
  0x08, 0x42, 0x10, 0x86, 0x29, 0x70, 0x8A, 0x49, 0x28, 0xE2, 0x89, 0x22,
  0x84, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0x83, 0xC3, 0xC3, 0xC5, 0xA5,
  0xA5, 0x99, 0x99, 0x91, 0x87, 0x1C, 0x69, 0x96, 0x58, 0xE3, 0x84, 0x7A,
  0x28, 0x61, 0x86, 0x18, 0x62, 0x78, 0xFC, 0x63, 0x1F, 0xC2, 0x10, 0x80,
  0x7A, 0x28, 0x61, 0x86, 0x18, 0x62, 0x78, 0x20, 0x40, 0xF2, 0x28, 0xA2,
  0xF2, 0x48, 0xA2, 0x88, 0x74, 0x63, 0x07, 0x06, 0x31, 0x70, 0xFC, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x70, 0x82,
  0x89, 0x12, 0x22, 0x85, 0x0A, 0x08, 0x10, 0x88, 0x53, 0x24, 0xC9, 0x32,
  0x52, 0x94, 0xA3, 0x30, 0x84, 0x21, 0x00, 0x44, 0x88, 0xA1, 0x41, 0x05,
  0x0A, 0x22, 0x44, 0x84, 0x89, 0x21, 0x43, 0x02, 0x04, 0x08, 0x10, 0xF8,
  0x44, 0x42, 0x21, 0x10, 0xF8, 0xEA, 0xAA, 0xAA, 0xC0, 0x84, 0x44, 0x22,
  0x21, 0x11, 0xD5, 0x55, 0x55, 0xC0, 0x5A, 0xDA, 0xF8, 0x90, 0x79, 0x1F,
  0x99, 0xF0, 0x84, 0x21, 0xE8, 0xC6, 0x31, 0x8F, 0x80, 0x79, 0x88, 0x89,
  0x70, 0x11, 0x17, 0x99, 0x99, 0x97, 0x79, 0x9F, 0x88, 0x70, 0x34, 0x4E,
  0x44, 0x44, 0x44, 0x79, 0x99, 0x99, 0x71, 0x17, 0x88, 0x8F, 0x99, 0x99,
  0x99, 0xBF, 0x80, 0x45, 0x55, 0x56, 0x88, 0x89, 0xAC, 0xCA, 0x99, 0xFF,
  0xC0, 0xF6, 0x99, 0x91, 0x91, 0x91, 0x91, 0x91, 0xF9, 0x99, 0x99, 0x90,
  0x74, 0x63, 0x18, 0xC5, 0xC0, 0xF4, 0x63, 0x18, 0xC7, 0xD0, 0x84, 0x00,
  0x79, 0x99, 0x99, 0x71, 0x11, 0xF2, 0x49, 0x20, 0xE9, 0x86, 0x19, 0xF0,
  0x4B, 0xA4, 0x92, 0x20, 0x99, 0x99, 0x99, 0x70, 0x8A, 0x52, 0xA3, 0x18,
  0x80, 0x89, 0x49, 0x59, 0x56, 0x56, 0x26, 0x24, 0x4A, 0x8C, 0x43, 0x29,
  0x20, 0x8A, 0x52, 0xA3, 0x18, 0x84, 0x22, 0x00, 0xF2, 0x24, 0x48, 0xF0,
  0x12, 0x22, 0x24, 0xC4, 0x22, 0x22, 0x10, 0xFF, 0xE0, 0x89, 0x24, 0x89,
  0x49, 0x28, 0xE6, 0x60,
};

const GFXglyph RobotoCondensed_Light13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 2, 3, 4, 1, -10 },
  { 4, 6, 9, 7, 1, -9 },
  { 11, 5, 11, 6, 1, -10 },
  { 18, 7, 9, 8, 1, -9 },
  { 26, 6, 9, 7, 1, -9 },
  { 33, 1, 3, 2, 1, -10 },
  { 34, 2, 13, 4, 1, -10 },
  { 38, 3, 13, 4, 0, -10 },
  { 43, 5, 5, 6, 0, -9 },
  { 47, 5, 7, 6, 1, -8 },
  { 52, 2, 3, 3, 0, -1 },
  { 53, 3, 1, 3, 0, -5 },
  { 54, 1, 1, 3, 1, -1 },
  { 55, 4, 10, 5, 0, -9 },
  { 60, 5, 9, 6, 1, -9 },
  { 66, 3, 9, 6, 1, -9 },
  { 70, 5, 9, 6, 1, -9 },
  { 76, 5, 9, 6, 1, -9 },
  { 82, 6, 9, 6, 0, -9 },
  { 89, 5, 9, 6, 1, -9 },
  { 95, 5, 9, 6, 1, -9 },
  { 101, 5, 9, 6, 1, -9 },
  { 107, 5, 9, 6, 1, -9 },
  { 113, 5, 9, 6, 1, -9 },
  { 119, 1, 7, 3, 1, -7 },
  { 120, 2, 9, 2, 0, -7 },
  { 123, 4, 6, 6, 1, -7 },
  { 126, 4, 4, 6, 1, -6 },
  { 128, 4, 6, 6, 1, -7 },
  { 131, 4, 9, 5, 1, -9 },
  { 136, 8, 12, 10, 1, -9 },
  { 148, 7, 9, 7, 0, -9 },
  { 156, 5, 9, 7, 1, -9 },
  { 162, 6, 9, 7, 1, -9 },
  { 169, 6, 9, 7, 1, -9 },
  { 176, 5, 9, 6, 1, -9 },
  { 182, 5, 9, 6, 1, -9 },
  { 188, 6, 9, 8, 1, -9 },
  { 195, 6, 9, 8, 1, -9 },
  { 202, 1, 9, 3, 1, -9 },
  { 204, 5, 9, 6, 0, -9 },
  { 210, 6, 9, 7, 1, -9 },
  { 217, 5, 9, 6, 1, -9 },
  { 223, 8, 9, 10, 1, -9 },
  { 232, 6, 9, 8, 1, -9 },
  { 239, 6, 9, 8, 1, -9 },
  { 246, 5, 9, 7, 1, -9 },
  { 252, 6, 11, 8, 1, -9 },
  { 261, 6, 9, 7, 1, -9 },
  { 268, 5, 9, 7, 1, -9 },
  { 274, 6, 9, 7, 0, -9 },
  { 281, 5, 9, 7, 1, -9 },
  { 287, 7, 9, 7, 0, -9 },
  { 295, 10, 9, 10, 0, -9 },
  { 307, 7, 9, 7, 0, -9 },
  { 315, 7, 9, 7, 0, -9 },
  { 323, 5, 9, 7, 1, -9 },
  { 329, 2, 13, 3, 1, -11 },
  { 333, 4, 10, 5, 0, -9 },
  { 338, 2, 13, 3, 0, -11 },
  { 342, 3, 5, 5, 1, -9 },
  { 344, 5, 1, 5, 0, 0 },
  { 345, 2, 2, 4, 1, -10 },
  { 346, 4, 7, 6, 1, -7 },
  { 350, 5, 10, 6, 1, -10 },
  { 357, 4, 7, 6, 1, -7 },
  { 361, 4, 10, 6, 1, -10 },
  { 366, 4, 7, 6, 1, -7 },
  { 370, 4, 10, 4, 0, -10 },
  { 375, 4, 10, 6, 1, -7 },
  { 380, 4, 10, 6, 1, -10 },
  { 385, 1, 9, 3, 1, -9 },
  { 387, 2, 12, 3, 0, -9 },
  { 390, 4, 10, 6, 1, -10 },
  { 395, 1, 10, 3, 1, -10 },
  { 397, 8, 7, 10, 1, -7 },
  { 404, 4, 7, 6, 1, -7 },
  { 408, 5, 7, 6, 1, -7 },
  { 413, 5, 10, 6, 1, -7 },
  { 420, 4, 10, 6, 1, -7 },
  { 425, 3, 7, 4, 1, -7 },
  { 428, 4, 7, 6, 1, -7 },
  { 432, 3, 9, 4, 0, -9 },
  { 436, 4, 7, 6, 1, -7 },
  { 440, 5, 7, 6, 0, -7 },
  { 445, 8, 7, 8, 0, -7 },
  { 452, 5, 7, 6, 0, -7 },
  { 457, 5, 10, 5, 0, -7 },
  { 464, 4, 7, 6, 1, -7 },
  { 468, 4, 13, 4, 0, -10 },
  { 475, 1, 11, 3, 1, -9 },
  { 477, 3, 13, 4, 0, -10 },
  { 482, 6, 2, 8, 1, -5 },
};

const GFXfont RobotoCondensed_Light13pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light13pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light13pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOCONDENSED_LIGHT13PT7B_H_
