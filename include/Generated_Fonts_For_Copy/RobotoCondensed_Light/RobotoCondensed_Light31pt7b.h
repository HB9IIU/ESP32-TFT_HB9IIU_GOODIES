#ifndef _ROBOTOCONDENSED_LIGHT31PT7B_H_
#define _ROBOTOCONDENSED_LIGHT31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light31pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xD9, 0x24, 0x92, 0x00, 0x0D, 0x80, 0xCE, 0x73,
  0x9C, 0xC6, 0x20, 0x02, 0x18, 0x04, 0x30, 0x08, 0x40, 0x10, 0x80, 0x61,
  0x00, 0xC2, 0x01, 0x8C, 0x3F, 0xFF, 0x04, 0x20, 0x08, 0x40, 0x10, 0x80,
  0x61, 0x00, 0xC6, 0x01, 0x0C, 0x3F, 0xFF, 0x04, 0x20, 0x08, 0x40, 0x30,
  0x80, 0x63, 0x00, 0x86, 0x01, 0x0C, 0x02, 0x10, 0x00, 0x06, 0x00, 0xC0,
  0x18, 0x0F, 0x83, 0xF8, 0xC1, 0x98, 0x1E, 0x03, 0xC0, 0x78, 0x05, 0x00,
  0x30, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xD8, 0x39, 0xFE, 0x1F, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x38, 0x00, 0x6C, 0x00, 0x86, 0x00, 0x82, 0x18, 0x82, 0x10, 0x82, 0x30,
  0x82, 0x20, 0x86, 0x60, 0x6C, 0x40, 0x38, 0xC0, 0x00, 0x80, 0x01, 0x00,
  0x03, 0x1C, 0x02, 0x36, 0x06, 0x63, 0x04, 0x41, 0x0C, 0x41, 0x08, 0x41,
  0x18, 0x41, 0x10, 0x63, 0x00, 0x36, 0x00, 0x1C, 0x0F, 0x00, 0xFE, 0x03,
  0x08, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x06, 0x18, 0x0C, 0xC0, 0x36, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x80, 0x66, 0x0B, 0x0C, 0x6C, 0x19, 0xA0, 0x66,
  0x80, 0xD3, 0x01, 0xCC, 0x07, 0x38, 0x3C, 0x7F, 0xD8, 0x7C, 0x30, 0xFE,
  0x04, 0x30, 0x86, 0x10, 0xC2, 0x18, 0x61, 0x04, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC1, 0x04, 0x18, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC1,
  0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x18, 0x20, 0x83, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x20, 0x86, 0x18, 0x43, 0x0C, 0x61, 0x0C, 0x20,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x07, 0x23, 0x9F, 0xF8, 0x1C, 0x00,
  0xE0, 0x0D, 0x80, 0xC6, 0x06, 0x18, 0x20, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x1F, 0xFF, 0xFF, 0xF8, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x6D, 0xB7,
  0xA0, 0xFF, 0xF0, 0x5F, 0x80, 0x01, 0x80, 0x80, 0x40, 0x60, 0x20, 0x10,
  0x18, 0x08, 0x04, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30,
  0x10, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x00, 0x1F, 0x07, 0xF1, 0x83,
  0x30, 0x2C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0D, 0x81, 0x30, 0x63,
  0xF8, 0x3E, 0x00, 0x04, 0xFF, 0x71, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x1F, 0x03, 0xF8, 0x60,
  0xCC, 0x04, 0xC0, 0x68, 0x06, 0x80, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30,
  0x06, 0x00, 0xFF, 0xFF, 0xFF, 0x1F, 0x07, 0xF1, 0x83, 0x60, 0x2C, 0x07,
  0x80, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x7E, 0x0F, 0xC0, 0x1C, 0x00,
  0xC0, 0x18, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xF0, 0x67, 0xFC, 0x3E, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x02, 0x80, 0x34, 0x03, 0x20, 0x19, 0x01,
  0x88, 0x08, 0x40, 0xC2, 0x04, 0x10, 0x60, 0x86, 0x04, 0x30, 0x23, 0xFF,
  0xFF, 0xFF, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x3F, 0xE3, 0xFE, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x6F, 0x87, 0xFC, 0x60, 0xE0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03,
  0xC0, 0x34, 0x02, 0x60, 0x67, 0x06, 0x3F, 0xC0, 0xF8, 0x03, 0x81, 0xF0,
  0x60, 0x18, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xCF, 0x1B, 0xFB, 0x83,
  0x60, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0D, 0x81, 0xB8,
  0x63, 0xFC, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0x1F, 0x07, 0xF1, 0x83, 0x60, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0x60, 0xC7, 0xF0, 0x7E, 0x38, 0xEC, 0x07, 0x80, 0xE0,
  0x0C, 0x01, 0x80, 0x38, 0x0F, 0x01, 0xB0, 0x67, 0xFC, 0x3E, 0x00, 0x1E,
  0x07, 0xF1, 0x83, 0x60, 0x6C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0F, 0x01, 0xE0, 0x76, 0x0E, 0x7E, 0xC7, 0x98, 0x03, 0x00, 0x40, 0x18,
  0x06, 0x01, 0xC3, 0xF0, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x2D, 0x80, 0x00, 0x00, 0x00, 0x1B, 0x6D, 0xEC, 0x00, 0x20, 0x1C,
  0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x30, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x02, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x08, 0x00, 0x1F, 0x0F,
  0xE6, 0x19, 0x03, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x30,
  0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0xFC, 0x00, 0x1E, 0xF8, 0x03, 0x80, 0x60, 0x30, 0x01,
  0x81, 0x00, 0x06, 0x18, 0x00, 0x10, 0x80, 0x00, 0xCC, 0x0F, 0x02, 0x40,
  0xFC, 0x12, 0x0C, 0x20, 0xB0, 0x41, 0x05, 0x86, 0x08, 0x38, 0x20, 0x41,
  0xC1, 0x02, 0x0E, 0x08, 0x10, 0x70, 0xC1, 0x82, 0x86, 0x0C, 0x14, 0x30,
  0x60, 0xA0, 0x83, 0x0D, 0x84, 0x28, 0x4C, 0x3F, 0x66, 0x20, 0xE1, 0xC1,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x3F, 0x80, 0x00, 0x01, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x14, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0x10, 0x06, 0x30, 0x0C, 0x60,
  0x10, 0x40, 0x60, 0xC0, 0xC1, 0x81, 0x01, 0x06, 0x03, 0x0F, 0xFE, 0x1F,
  0xFC, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x36, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xC0, 0xFF, 0x0F, 0xFC, 0x80, 0xE8, 0x06, 0x80, 0x68, 0x06, 0x80, 0x68,
  0x06, 0x80, 0xCF, 0xF8, 0xFF, 0x88, 0x0C, 0x80, 0x68, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x68, 0x06, 0xFF, 0xCF, 0xF8, 0x0F, 0xC0,
  0x7F, 0xC3, 0x03, 0x98, 0x06, 0x60, 0x0B, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x03, 0xC0, 0x0D, 0x80, 0x26, 0x01, 0x8C, 0x0C, 0x1F, 0xF0, 0x3F,
  0x00, 0xFF, 0x07, 0xFE, 0x20, 0x39, 0x00, 0xC8, 0x03, 0x40, 0x1A, 0x00,
  0x50, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x02, 0x80, 0x34, 0x01, 0xA0, 0x19, 0x01, 0xCF, 0xFC, 0x7F,
  0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x1F, 0xFB, 0xFF, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0xFF, 0x7F,
  0xE8, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0x03, 0x98, 0x06, 0x60, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x7F,
  0xC1, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x40, 0x0D, 0x80, 0x36, 0x00,
  0xCC, 0x07, 0x1F, 0xF8, 0x1F, 0x80, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0xC0, 0x38,
  0x0D, 0x01, 0xB0, 0x63, 0xFC, 0x3E, 0x00, 0x80, 0x34, 0x03, 0xA0, 0x19,
  0x01, 0x88, 0x18, 0x41, 0x82, 0x1C, 0x10, 0xC0, 0x8C, 0x04, 0xC0, 0x2F,
  0x01, 0xF8, 0x0E, 0x60, 0x63, 0x82, 0x0C, 0x10, 0x30, 0x80, 0xC4, 0x06,
  0x20, 0x19, 0x00, 0x68, 0x03, 0x40, 0x0C, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xFF, 0xF0, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xA0, 0x02, 0xEC, 0x01,
  0xBB, 0x00, 0x6E, 0x40, 0x13, 0x98, 0x0C, 0xE6, 0x03, 0x38, 0xC0, 0x8E,
  0x30, 0x63, 0x84, 0x18, 0xE1, 0x84, 0x38, 0x63, 0x0E, 0x08, 0xC3, 0x83,
  0x20, 0xE0, 0xD8, 0x38, 0x16, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x20,
  0x30, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0x40, 0x1B, 0x00, 0xC8, 0x06, 0x60,
  0x31, 0x81, 0x8C, 0x0C, 0x30, 0x61, 0x83, 0x06, 0x18, 0x30, 0xC0, 0xC6,
  0x02, 0x30, 0x19, 0x80, 0x6C, 0x03, 0x60, 0x0F, 0x00, 0x78, 0x01, 0xC0,
  0x0C, 0x0F, 0xC0, 0x7F, 0xC3, 0x03, 0x98, 0x06, 0x60, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x80, 0x36, 0x01, 0x8C, 0x0E,
  0x1F, 0xF0, 0x3F, 0x00, 0xFF, 0x8F, 0xFC, 0x80, 0x68, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x6F, 0xFE, 0xFF, 0x88,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0x03, 0x98, 0x06, 0x40, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x00, 0x36, 0x01, 0x8C, 0x0E,
  0x1F, 0xF0, 0x3F, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x20, 0xFF,
  0x07, 0xFE, 0x20, 0x39, 0x00, 0xC8, 0x03, 0x40, 0x1A, 0x00, 0xD0, 0x06,
  0x80, 0x34, 0x03, 0x20, 0x19, 0xFF, 0x8F, 0xF0, 0x40, 0xC2, 0x06, 0x10,
  0x18, 0x80, 0xC4, 0x03, 0x20, 0x19, 0x00, 0x68, 0x03, 0x40, 0x0C, 0x0F,
  0xC0, 0x7F, 0x83, 0x03, 0x18, 0x06, 0x60, 0x19, 0x80, 0x26, 0x00, 0xD8,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xB0, 0x03, 0x40, 0x0D, 0x80, 0x36, 0x01, 0x8C, 0x0E, 0x1F, 0xF0,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0A, 0x00, 0xD8, 0x06,
  0xE0, 0x63, 0xFE, 0x07, 0xE0, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x33, 0x00,
  0x66, 0x00, 0xCC, 0x01, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x10, 0x20, 0x60,
  0x60, 0xC0, 0xC1, 0x80, 0x86, 0x01, 0x8C, 0x03, 0x18, 0x02, 0x20, 0x06,
  0xC0, 0x0D, 0x80, 0x1A, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x30, 0x0F, 0x00, 0xC0, 0x34, 0x03, 0x00, 0x98, 0x1E, 0x06, 0x60, 0x78,
  0x19, 0x81, 0x20, 0x66, 0x04, 0x81, 0x88, 0x33, 0x04, 0x30, 0xCC, 0x30,
  0xC3, 0x10, 0xC3, 0x08, 0x43, 0x04, 0x61, 0x8C, 0x11, 0x86, 0x20, 0x66,
  0x09, 0x81, 0x90, 0x26, 0x06, 0xC0, 0xD8, 0x0B, 0x03, 0x40, 0x2C, 0x05,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x06, 0x00,
  0xE0, 0x0C, 0xC0, 0x18, 0xC0, 0x61, 0x81, 0x81, 0x83, 0x03, 0x0C, 0x03,
  0x18, 0x06, 0x60, 0x06, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xD8, 0x03, 0x30, 0x06, 0x30, 0x18, 0x30, 0x30, 0x60, 0xC0, 0x63,
  0x00, 0xC6, 0x00, 0xD8, 0x01, 0x80, 0xC0, 0x0D, 0x80, 0x19, 0x80, 0x63,
  0x00, 0xC3, 0x03, 0x06, 0x06, 0x06, 0x08, 0x0C, 0x30, 0x0C, 0x40, 0x19,
  0x80, 0x13, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x7F, 0xF9, 0xFF, 0xE0, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFC, 0xC0, 0x60,
  0x10, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x00,
  0xC0, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x08, 0x06,
  0x03, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0xFC, 0x08, 0x06, 0x07, 0x02,
  0xC3, 0x61, 0x90, 0x8C, 0xC6, 0x61, 0x20, 0xF0, 0x60, 0xFF, 0xFF, 0xFF,
  0xC3, 0x0C, 0x20, 0x1F, 0x0F, 0xF1, 0x83, 0x60, 0x6C, 0x04, 0x00, 0x80,
  0x10, 0xFE, 0x7C, 0x58, 0x0B, 0x01, 0x40, 0x28, 0x05, 0x01, 0xB0, 0x73,
  0xFA, 0x3C, 0x60, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x33,
  0xE6, 0xFE, 0xE0, 0xD8, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3E, 0x0D, 0xBF, 0xB3, 0xC0, 0x0F,
  0x83, 0xFC, 0x30, 0x66, 0x02, 0x60, 0x34, 0x03, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x36, 0x03, 0x30, 0x63, 0xFC, 0x0F,
  0x80, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC7, 0x9B, 0xFB,
  0x60, 0xF8, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0F, 0x01, 0xE0, 0x36, 0x0E, 0xFF, 0xC7, 0x98, 0x0F, 0x81, 0xFC,
  0x30, 0x66, 0x06, 0x60, 0x34, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x06, 0x00, 0x30, 0x23, 0xFE, 0x0F, 0x80, 0x0F,
  0x1F, 0x18, 0x30, 0x30, 0x30, 0xFE, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1E, 0x6F,
  0xED, 0x83, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0xD8, 0x3B, 0xFF, 0x1E, 0x60, 0x0C, 0x01,
  0x80, 0x34, 0x0C, 0xFF, 0x07, 0xC0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x33, 0xC6, 0xFE, 0xF0, 0xDC, 0x0B, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x18, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x18, 0xC0, 0x00, 0x00,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC7, 0xEE, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x36, 0x0C, 0xC3, 0x98, 0x63, 0x18, 0x66, 0x0D, 0x81, 0xF0, 0x3F, 0x07,
  0x60, 0xC6, 0x18, 0x63, 0x0C, 0x60, 0xCC, 0x19, 0x81, 0xB0, 0x18, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xCF, 0x07, 0x8D, 0xFD, 0xFC, 0xE0, 0xD0,
  0x6E, 0x06, 0x06, 0xC0, 0x60, 0x2C, 0x06, 0x02, 0xC0, 0x60, 0x3C, 0x06,
  0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0,
  0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x30,
  0xCF, 0x1B, 0xFB, 0xC3, 0x70, 0x2C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x60,
  0x1F, 0x03, 0xFC, 0x60, 0xCC, 0x06, 0xC0, 0x6C, 0x02, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x3C, 0x02, 0xC0, 0x6C, 0x06, 0x60, 0xC3, 0xFC,
  0x1F, 0x00, 0xCF, 0x9B, 0xFB, 0x83, 0x60, 0x3C, 0x07, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF8, 0x36, 0xFE,
  0xCF, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x1E, 0x6F,
  0xFD, 0x83, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xD8, 0x3B, 0xFF, 0x1E, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0xCF, 0xBF, 0xC7, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x1E, 0x1F, 0xEC,
  0x1F, 0x03, 0xC0, 0xF0, 0x06, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03,
  0x80, 0xE0, 0x3C, 0x0D, 0xFE, 0x3F, 0x00, 0x30, 0x60, 0xC1, 0x8F, 0xFF,
  0xCC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0,
  0xF1, 0xE0, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xD8, 0x3B, 0xFB,
  0x1E, 0x60, 0xC0, 0x78, 0x0D, 0x01, 0xB0, 0x26, 0x0C, 0xC1, 0x88, 0x21,
  0x8C, 0x31, 0x82, 0x30, 0x64, 0x0D, 0x80, 0xB0, 0x14, 0x03, 0x80, 0x70,
  0x04, 0x00, 0xC0, 0xC0, 0xF0, 0x30, 0x34, 0x0C, 0x0D, 0x87, 0x82, 0x61,
  0xE1, 0x98, 0x48, 0x62, 0x12, 0x18, 0x8C, 0xC4, 0x33, 0x33, 0x0C, 0x84,
  0xC1, 0x21, 0x30, 0x58, 0x68, 0x1E, 0x1A, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x30, 0x30, 0x0C, 0x04, 0x00, 0xC0, 0x6C, 0x19, 0x83, 0x18, 0xC1, 0x18,
  0x36, 0x02, 0xC0, 0x70, 0x06, 0x01, 0xC0, 0x2C, 0x0C, 0x83, 0x18, 0x61,
  0x18, 0x33, 0x03, 0xC0, 0x60, 0xC0, 0x78, 0x0F, 0x01, 0xB0, 0x66, 0x0C,
  0xC1, 0x8C, 0x21, 0x8C, 0x31, 0x82, 0x20, 0x6C, 0x0D, 0x80, 0xB0, 0x1C,
  0x03, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x04, 0x01, 0x81, 0xE0, 0x38,
  0x00, 0x7F, 0xEF, 0xFC, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0x06, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x10, 0x30, 0xE0, 0xE0, 0x30, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x08, 0x0C, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x40,
  0x60, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x08,
  0x0C, 0x07, 0x07, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x30, 0x60, 0x40, 0x3C, 0x05, 0xF8, 0x14, 0x30, 0xF0, 0x63,
  0xC1, 0xFB, 0x01, 0xC0,
};

const GFXglyph RobotoCondensed_Light31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 22, 7, 2, -22 },
  { 10, 5, 7, 9, 2, -23 },
  { 15, 15, 22, 16, 1, -22 },
  { 57, 11, 28, 15, 2, -25 },
  { 96, 16, 22, 20, 2, -22 },
  { 140, 14, 22, 17, 2, -22 },
  { 179, 1, 7, 5, 2, -23 },
  { 180, 6, 32, 9, 2, -25 },
  { 204, 6, 32, 9, 1, -25 },
  { 228, 13, 12, 13, 0, -22 },
  { 248, 13, 16, 15, 1, -18 },
  { 274, 3, 7, 6, 1, -3 },
  { 277, 6, 2, 8, 1, -11 },
  { 279, 3, 3, 7, 2, -3 },
  { 281, 9, 24, 11, 1, -22 },
  { 308, 11, 22, 15, 2, -22 },
  { 339, 6, 22, 15, 3, -22 },
  { 356, 12, 22, 15, 2, -22 },
  { 389, 11, 22, 15, 2, -22 },
  { 420, 13, 22, 15, 1, -22 },
  { 456, 12, 22, 15, 2, -22 },
  { 489, 11, 22, 15, 2, -22 },
  { 520, 13, 22, 15, 1, -22 },
  { 556, 11, 22, 15, 2, -22 },
  { 587, 11, 22, 15, 2, -22 },
  { 618, 3, 17, 6, 2, -17 },
  { 625, 3, 21, 6, 1, -17 },
  { 633, 11, 13, 14, 1, -16 },
  { 651, 11, 9, 15, 2, -15 },
  { 664, 11, 13, 14, 2, -16 },
  { 682, 10, 22, 13, 1, -22 },
  { 710, 21, 29, 24, 2, -22 },
  { 787, 15, 22, 17, 1, -22 },
  { 829, 12, 22, 17, 3, -22 },
  { 862, 14, 22, 18, 2, -22 },
  { 901, 13, 22, 18, 3, -22 },
  { 937, 11, 22, 15, 3, -22 },
  { 968, 11, 22, 15, 3, -22 },
  { 999, 14, 22, 18, 2, -22 },
  { 1038, 13, 22, 19, 3, -22 },
  { 1074, 2, 22, 8, 3, -22 },
  { 1080, 11, 22, 15, 1, -22 },
  { 1111, 13, 22, 17, 3, -22 },
  { 1147, 10, 22, 14, 3, -22 },
  { 1175, 18, 22, 23, 3, -22 },
  { 1225, 13, 22, 19, 3, -22 },
  { 1261, 14, 22, 18, 2, -22 },
  { 1300, 12, 22, 17, 3, -22 },
  { 1333, 14, 26, 18, 2, -22 },
  { 1379, 13, 22, 17, 3, -22 },
  { 1415, 14, 22, 16, 1, -22 },
  { 1454, 14, 22, 16, 1, -22 },
  { 1493, 13, 22, 18, 2, -22 },
  { 1529, 15, 22, 17, 1, -22 },
  { 1571, 22, 22, 24, 1, -22 },
  { 1632, 15, 22, 17, 1, -22 },
  { 1674, 15, 22, 16, 1, -22 },
  { 1716, 14, 22, 16, 1, -22 },
  { 1755, 5, 30, 7, 2, -25 },
  { 1774, 9, 24, 11, 1, -22 },
  { 1801, 5, 30, 7, 0, -25 },
  { 1820, 9, 11, 11, 1, -22 },
  { 1833, 12, 2, 12, 0, 0 },
  { 1836, 5, 4, 9, 2, -23 },
  { 1839, 11, 17, 15, 2, -17 },
  { 1863, 11, 23, 15, 2, -23 },
  { 1895, 12, 17, 14, 1, -17 },
  { 1921, 11, 23, 15, 2, -23 },
  { 1953, 12, 17, 14, 1, -17 },
  { 1979, 8, 23, 9, 1, -23 },
  { 2002, 11, 23, 15, 2, -17 },
  { 2034, 11, 23, 15, 2, -23 },
  { 2066, 2, 23, 7, 2, -23 },
  { 2072, 5, 29, 7, -1, -23 },
  { 2091, 11, 23, 13, 2, -23 },
  { 2123, 2, 23, 7, 2, -23 },
  { 2129, 20, 17, 24, 2, -17 },
  { 2172, 11, 17, 15, 2, -17 },
  { 2196, 12, 17, 15, 2, -17 },
  { 2222, 11, 23, 15, 2, -17 },
  { 2254, 11, 23, 15, 2, -17 },
  { 2286, 7, 17, 9, 2, -17 },
  { 2301, 10, 17, 14, 2, -17 },
  { 2323, 7, 21, 9, 1, -21 },
  { 2342, 11, 17, 15, 2, -17 },
  { 2366, 11, 17, 13, 1, -17 },
  { 2390, 18, 17, 20, 1, -17 },
  { 2429, 11, 17, 13, 1, -17 },
  { 2453, 11, 23, 13, 1, -17 },
  { 2485, 11, 17, 13, 1, -17 },
  { 2509, 8, 30, 9, 1, -24 },
  { 2539, 1, 26, 7, 3, -22 },
  { 2543, 8, 30, 9, 0, -24 },
  { 2573, 14, 6, 18, 2, -12 },
};

const GFXfont RobotoCondensed_Light31pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light31pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light31pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOCONDENSED_LIGHT31PT7B_H_
