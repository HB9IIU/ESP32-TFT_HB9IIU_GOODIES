#ifndef _ROBOTOCONDENSED_LIGHT29PT7B_H_
#define _ROBOTOCONDENSED_LIGHT29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x9C, 0xE7, 0x39, 0xCC, 0x02,
  0x10, 0x18, 0xC0, 0x63, 0x01, 0x08, 0x04, 0x20, 0x10, 0x87, 0xFF, 0xC1,
  0x18, 0x0C, 0x60, 0x31, 0x00, 0x84, 0x02, 0x10, 0x08, 0x40, 0x21, 0x0F,
  0xFF, 0x86, 0x30, 0x10, 0x80, 0x42, 0x01, 0x08, 0x04, 0x20, 0x11, 0x80,
  0x04, 0x01, 0x00, 0x40, 0x7C, 0x3F, 0x98, 0x3C, 0x0F, 0x01, 0xC0, 0x70,
  0x04, 0x01, 0x80, 0x38, 0x07, 0x80, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x06,
  0x01, 0xC0, 0xF0, 0x37, 0xF8, 0x7C, 0x04, 0x01, 0x00, 0x40, 0x78, 0x01,
  0x98, 0x02, 0x10, 0x04, 0x21, 0x88, 0x42, 0x10, 0x8C, 0x21, 0x10, 0x42,
  0x60, 0xCC, 0x80, 0xF3, 0x00, 0x04, 0x00, 0x11, 0xC0, 0x26, 0xC0, 0x88,
  0xC1, 0x30, 0x84, 0x41, 0x18, 0x82, 0x21, 0x84, 0x41, 0x18, 0x03, 0x60,
  0x03, 0x80, 0x1E, 0x01, 0xF8, 0x18, 0x60, 0xC3, 0x06, 0x18, 0x30, 0xC1,
  0x8C, 0x06, 0xC0, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0xD8, 0x2C, 0x61, 0x61,
  0x9A, 0x04, 0xD0, 0x34, 0x80, 0xE6, 0x03, 0x30, 0x38, 0xFF, 0x63, 0xE1,
  0x80, 0xFC, 0x04, 0x21, 0x84, 0x30, 0x86, 0x10, 0x43, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08,
  0x10, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x04, 0x18, 0x60, 0x82, 0x08, 0x20,
  0xC3, 0x08, 0x20, 0x82, 0x18, 0x61, 0x04, 0x30, 0x86, 0x10, 0xC2, 0x00,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x62, 0x77, 0xFE, 0x07, 0x00, 0x70,
  0x0D, 0x81, 0x98, 0x30, 0xC1, 0x04, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x6D, 0xB5, 0xA0, 0xFC, 0xF0, 0x01,
  0x03, 0x02, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x18, 0x10,
  0x10, 0x30, 0x20, 0x20, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x1E, 0x0F,
  0xE6, 0x1B, 0x03, 0xC0, 0xF0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0xF0, 0x36, 0x18, 0xFE, 0x1E,
  0x00, 0x06, 0x3D, 0xDE, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x1E, 0x0F, 0xF3, 0x06,
  0x60, 0x68, 0x0D, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0F,
  0xFE, 0x0F, 0x07, 0xF8, 0x83, 0x30, 0x34, 0x06, 0x80, 0xC0, 0x18, 0x03,
  0x00, 0xC1, 0xF0, 0x3E, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0E, 0x01, 0x40,
  0x2C, 0x0D, 0x81, 0x9F, 0xE0, 0xF0, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x3C,
  0x02, 0xC0, 0x6C, 0x04, 0xC0, 0xCC, 0x18, 0xC1, 0x8C, 0x30, 0xC3, 0x0C,
  0x60, 0xC6, 0x0C, 0xC0, 0xCF, 0xFF, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x3F, 0xC7, 0xF9, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0xF8, 0x7F, 0x8C, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x1E, 0x03,
  0xC0, 0x68, 0x09, 0x83, 0x1D, 0xC1, 0xF0, 0x07, 0x03, 0xE0, 0xE0, 0x10,
  0x06, 0x00, 0x80, 0x30, 0x06, 0xF8, 0xFF, 0x9C, 0x1B, 0x03, 0x60, 0x28,
  0x07, 0x00, 0xE0, 0x1E, 0x02, 0xC0, 0x48, 0x19, 0x83, 0x1F, 0xC1, 0xF0,
  0xFF, 0xF0, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x00, 0x1E, 0x0F, 0xF1, 0x86,
  0x60, 0x6C, 0x0D, 0x80, 0xB0, 0x36, 0x06, 0x60, 0x87, 0xE0, 0xFC, 0x30,
  0xCC, 0x0D, 0x00, 0xA0, 0x1C, 0x03, 0x80, 0x78, 0x0B, 0x03, 0x3F, 0xC1,
  0xE0, 0x0F, 0x07, 0xF0, 0xC3, 0x30, 0x24, 0x06, 0x80, 0xF0, 0x0E, 0x01,
  0x40, 0x28, 0x0D, 0x81, 0xB0, 0x73, 0xFA, 0x3E, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0x18, 0x06, 0x0F, 0x81, 0xC0, 0xF0, 0x00, 0x00, 0x3C, 0x6C, 0x00,
  0x00, 0x00, 0x06, 0xDB, 0x5A, 0x00, 0x00, 0x40, 0x70, 0x78, 0x38, 0x38,
  0x38, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x80, 0x38, 0x07,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x1C, 0x1C, 0x1C, 0x1E, 0x0E, 0x02, 0x00,
  0x1E, 0x3F, 0x98, 0x78, 0x1C, 0x08, 0x04, 0x02, 0x03, 0x01, 0x81, 0x81,
  0x81, 0x80, 0xC0, 0x40, 0x20, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x80,
  0x01, 0xF8, 0x00, 0xE1, 0xC0, 0x30, 0x0C, 0x0C, 0x00, 0xC3, 0x00, 0x0C,
  0x40, 0x00, 0x98, 0x3C, 0x12, 0x0E, 0xC3, 0xC3, 0x08, 0x30, 0x41, 0x06,
  0x08, 0x20, 0xC3, 0x04, 0x18, 0x60, 0x83, 0x08, 0x10, 0x61, 0x02, 0x0C,
  0x20, 0xC3, 0x86, 0x18, 0x50, 0xC5, 0x0B, 0x0D, 0xB6, 0x61, 0xE3, 0x84,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x38, 0x00,
  0x7E, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xE0, 0x04, 0x80, 0x32,
  0x00, 0xCC, 0x02, 0x10, 0x08, 0x40, 0x61, 0x81, 0x06, 0x04, 0x08, 0x30,
  0x30, 0xFF, 0xC3, 0xFF, 0x18, 0x06, 0x60, 0x19, 0x00, 0x2C, 0x00, 0xF0,
  0x03, 0x80, 0x0C, 0xFF, 0x0F, 0xFC, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x02,
  0xC0, 0x2C, 0x06, 0xC0, 0x4F, 0xFC, 0xFF, 0x8C, 0x0E, 0xC0, 0x2C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x6F, 0xFC, 0xFF, 0x80, 0x0F,
  0x81, 0xFF, 0x1C, 0x0C, 0xC0, 0x6C, 0x01, 0x60, 0x0F, 0x00, 0x78, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x78,
  0x03, 0xC0, 0x13, 0x01, 0x9C, 0x0C, 0x7F, 0xC0, 0xF8, 0x00, 0xFF, 0x07,
  0xFE, 0x30, 0x19, 0x80, 0x6C, 0x03, 0x60, 0x0B, 0x00, 0x58, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x58, 0x02,
  0xC0, 0x36, 0x01, 0xB0, 0x19, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFB, 0xFF,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x1F, 0xFB, 0xFF, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x0F, 0xC1, 0xFF, 0x1C, 0x0C,
  0xC0, 0x24, 0x01, 0xE0, 0x0F, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x7F, 0x83, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x40, 0x1B, 0x00,
  0xCC, 0x0E, 0x3F, 0xE0, 0xFC, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x1E, 0x03, 0xC0, 0x58, 0x19, 0x83, 0x1F, 0xC1,
  0xF0, 0xC0, 0x36, 0x01, 0xB0, 0x19, 0x81, 0x8C, 0x18, 0x61, 0xC3, 0x0C,
  0x18, 0xC0, 0xCC, 0x06, 0xE0, 0x37, 0x01, 0xEC, 0x0E, 0x30, 0x61, 0x83,
  0x06, 0x18, 0x18, 0xC0, 0xC6, 0x03, 0x30, 0x0D, 0x80, 0x6C, 0x01, 0x80,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x7F, 0xFF, 0xFE, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x2E, 0x80, 0x37, 0x60, 0x13, 0x90, 0x09, 0xC8, 0x0C,
  0xE6, 0x04, 0x71, 0x02, 0x38, 0x83, 0x1C, 0x61, 0x0E, 0x11, 0x87, 0x08,
  0xC3, 0x86, 0x41, 0xC1, 0x60, 0xE0, 0xF0, 0x70, 0x70, 0x38, 0x18, 0x1C,
  0x0C, 0x08, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1D, 0x80, 0xEC, 0x07,
  0x30, 0x39, 0x81, 0xC6, 0x0E, 0x10, 0x70, 0xC3, 0x82, 0x1C, 0x18, 0xE0,
  0x47, 0x03, 0x38, 0x0D, 0xC0, 0x6E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x00,
  0x80, 0x0F, 0x81, 0xFF, 0x1C, 0x0C, 0xC0, 0x6C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1B, 0x01, 0x9C, 0x0C, 0x7F, 0xC0, 0xF8, 0x00,
  0xFF, 0x8F, 0xFE, 0xC0, 0x6C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x3C, 0x07, 0xFF, 0xEF, 0xF8, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x0F, 0x81, 0xFF, 0x18,
  0x1C, 0xC0, 0x6C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1B,
  0x01, 0x9C, 0x0C, 0x7F, 0xC0, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0xFF, 0x87, 0xFE, 0x30, 0x19, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00,
  0xD8, 0x06, 0xC0, 0x36, 0x03, 0x3F, 0xF1, 0xFF, 0x0C, 0x18, 0x60, 0x43,
  0x03, 0x18, 0x18, 0xC0, 0x66, 0x03, 0x30, 0x0D, 0x80, 0x6C, 0x01, 0x80,
  0x0F, 0x81, 0xFF, 0x0C, 0x0C, 0xC0, 0x66, 0x01, 0xB0, 0x0D, 0x80, 0x0C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x08, 0x00,
  0x78, 0x03, 0xC0, 0x1B, 0x00, 0x9C, 0x0C, 0x7F, 0xC0, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x14,
  0x03, 0x60, 0x63, 0xFE, 0x0F, 0x80, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x90,
  0x06, 0x60, 0x19, 0x80, 0x42, 0x03, 0x0C, 0x0C, 0x30, 0x20, 0x41, 0x81,
  0x06, 0x06, 0x18, 0x18, 0x40, 0x23, 0x00, 0xCC, 0x03, 0x20, 0x05, 0x80,
  0x1E, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x60, 0x1C, 0x06, 0x01,
  0x40, 0x70, 0x34, 0x07, 0x03, 0x60, 0xD0, 0x36, 0x0D, 0x02, 0x60, 0x98,
  0x22, 0x09, 0x86, 0x20, 0x88, 0x63, 0x18, 0x84, 0x31, 0x08, 0x43, 0x10,
  0xC4, 0x11, 0x04, 0xC1, 0x30, 0x4C, 0x1B, 0x04, 0x81, 0xA0, 0x68, 0x1A,
  0x06, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x19, 0x80, 0x66, 0x03, 0x0C, 0x0C, 0x10, 0x60, 0x61, 0x00, 0xCC,
  0x03, 0x60, 0x07, 0x80, 0x1C, 0x00, 0x30, 0x01, 0xC0, 0x05, 0x80, 0x33,
  0x00, 0x8C, 0x06, 0x18, 0x30, 0x60, 0xC0, 0xC6, 0x03, 0x18, 0x06, 0xC0,
  0x18, 0xC0, 0x1B, 0x00, 0x66, 0x01, 0x18, 0x0C, 0x20, 0x20, 0xC1, 0x81,
  0x06, 0x06, 0x30, 0x08, 0xC0, 0x36, 0x00, 0x58, 0x01, 0xC0, 0x07, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCF, 0xC0, 0x60, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x60,
  0x10, 0x08, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00,
  0x80, 0x60, 0x30, 0x08, 0x04, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x08, 0x18, 0x1C, 0x34, 0x34,
  0x26, 0x62, 0x63, 0x43, 0xC1, 0xFF, 0xE0, 0x61, 0x8C, 0x30, 0x3E, 0x1F,
  0xEC, 0x1B, 0x02, 0x80, 0x80, 0x20, 0x08, 0xFE, 0x70, 0xB0, 0x28, 0x0A,
  0x02, 0x80, 0xB0, 0x6F, 0xED, 0xF3, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x33, 0xC7, 0xFC, 0xE0, 0xD8, 0x1B, 0x01, 0x60, 0x2C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x58, 0x0B, 0x03, 0x70, 0x6F, 0xF9, 0xBE,
  0x00, 0x1F, 0x07, 0xF9, 0x81, 0x30, 0x34, 0x07, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x20, 0x36, 0x06, 0xC0, 0x8F, 0xF0, 0xF8, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x33, 0xED, 0xFF, 0xC1, 0xF0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x07,
  0x7F, 0xCF, 0x90, 0x0F, 0x07, 0xF9, 0x83, 0x30, 0x34, 0x07, 0x80, 0xF0,
  0x1F, 0xFF, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x8F, 0xF0,
  0x7C, 0x0F, 0x1E, 0x30, 0x30, 0x30, 0x30, 0xFE, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3E,
  0x5F, 0xFC, 0x1F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0xF0, 0x77, 0xFC, 0xFB, 0x00, 0xC0, 0x30, 0x0D, 0x02,
  0x7F, 0x87, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0xF3,
  0xFE, 0xE0, 0xB0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x30, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x18, 0xC0, 0x00, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xB8, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x1B, 0x06, 0xC3, 0x31, 0x8C, 0xC3, 0x60, 0xD8, 0x3E, 0x0E,
  0x83, 0x30, 0xC6, 0x30, 0x8C, 0x33, 0x06, 0xC1, 0xB0, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xCF, 0x0F, 0x3F, 0xEF, 0xEE, 0x1A, 0x0F, 0x03,
  0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x1C, 0x0C, 0x07, 0x03, 0x01, 0xC0, 0xC0,
  0x70, 0x30, 0x1C, 0x0C, 0x07, 0x03, 0x01, 0xC0, 0xC0, 0x70, 0x30, 0x1C,
  0x0C, 0x07, 0x03, 0x01, 0xCF, 0x3F, 0xEE, 0x0B, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0x1E, 0x0F, 0xF1, 0x83, 0x60, 0x68, 0x05, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x2C, 0x0C, 0xC1, 0x9F, 0xE0, 0xF0, 0xDF, 0x1F,
  0xF3, 0x83, 0x60, 0x6C, 0x05, 0x80, 0xB0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0x60, 0x2C, 0x0D, 0xC1, 0xBF, 0xE6, 0xF8, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x00, 0x3E, 0xDF, 0xFC, 0x1F, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x37, 0xFC,
  0xFB, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xDF, 0xFE, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x1F, 0x0F, 0xE6,
  0x0D, 0x81, 0x60, 0x18, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0C, 0x01,
  0x40, 0x58, 0x33, 0xB8, 0x7C, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x30, 0xF1, 0xC0, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xD0, 0x77, 0xFC, 0xFB, 0xC0, 0x58, 0x0B, 0x03, 0x20, 0x66, 0x08, 0xC3,
  0x08, 0x61, 0x08, 0x31, 0x02, 0x60, 0x48, 0x0D, 0x01, 0xE0, 0x1C, 0x03,
  0x00, 0x60, 0xC0, 0x81, 0xE0, 0xC0, 0xD0, 0x70, 0x48, 0x38, 0x66, 0x14,
  0x33, 0x1A, 0x19, 0x89, 0x88, 0x44, 0x44, 0x22, 0x26, 0x1B, 0x13, 0x0D,
  0x0D, 0x02, 0x82, 0x81, 0x41, 0x40, 0xE0, 0xE0, 0x60, 0x60, 0x10, 0x10,
  0xC0, 0xCC, 0x19, 0x86, 0x18, 0x83, 0x30, 0x34, 0x03, 0x80, 0x60, 0x0C,
  0x03, 0xC0, 0x6C, 0x19, 0x83, 0x18, 0xC3, 0x10, 0x36, 0x06, 0xC0, 0x58,
  0x1B, 0x03, 0x20, 0x66, 0x08, 0xC3, 0x08, 0x61, 0x88, 0x33, 0x02, 0x60,
  0x48, 0x0D, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20,
  0x0C, 0x0F, 0x01, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x03,
  0xFF, 0x02, 0x1C, 0x20, 0xC1, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x83,
  0x1C, 0x38, 0x18, 0x30, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x18, 0x30,
  0x20, 0x70, 0x20, 0xFF, 0xFF, 0xFF, 0x80, 0x40, 0x60, 0x30, 0x10, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x07, 0x07, 0x0C, 0x08,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x60, 0x40,
  0x38, 0x0B, 0xF0, 0x71, 0xC7, 0x83, 0xE8, 0x0E, 0x00,
};

const GFXglyph RobotoCondensed_Light29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 21, 6, 2, -21 },
  { 7, 5, 6, 8, 2, -22 },
  { 11, 14, 21, 15, 1, -21 },
  { 48, 10, 27, 14, 2, -24 },
  { 82, 15, 21, 19, 2, -21 },
  { 122, 13, 21, 16, 2, -21 },
  { 157, 1, 6, 5, 2, -22 },
  { 158, 6, 30, 8, 2, -23 },
  { 181, 6, 30, 9, 1, -23 },
  { 204, 12, 12, 12, 0, -21 },
  { 222, 12, 16, 14, 1, -18 },
  { 246, 3, 7, 6, 1, -3 },
  { 249, 6, 1, 7, 1, -9 },
  { 250, 2, 2, 7, 2, -2 },
  { 251, 8, 23, 10, 1, -21 },
  { 274, 10, 21, 14, 2, -21 },
  { 301, 7, 21, 14, 2, -21 },
  { 320, 11, 21, 14, 2, -21 },
  { 349, 11, 21, 14, 1, -21 },
  { 378, 12, 21, 14, 1, -21 },
  { 410, 11, 21, 14, 2, -21 },
  { 439, 11, 21, 14, 2, -21 },
  { 468, 12, 21, 14, 1, -21 },
  { 500, 11, 21, 14, 2, -21 },
  { 529, 11, 21, 14, 1, -21 },
  { 558, 2, 15, 6, 2, -15 },
  { 562, 3, 19, 5, 1, -15 },
  { 570, 10, 12, 13, 1, -15 },
  { 585, 10, 9, 14, 2, -14 },
  { 597, 10, 12, 13, 2, -15 },
  { 612, 9, 21, 12, 1, -21 },
  { 636, 19, 26, 23, 2, -20 },
  { 698, 14, 21, 16, 1, -21 },
  { 735, 12, 21, 16, 2, -21 },
  { 767, 13, 21, 16, 2, -21 },
  { 802, 13, 21, 17, 2, -21 },
  { 837, 11, 21, 14, 2, -21 },
  { 866, 11, 21, 14, 2, -21 },
  { 895, 13, 21, 17, 2, -21 },
  { 930, 13, 21, 18, 2, -21 },
  { 965, 1, 21, 7, 3, -21 },
  { 968, 11, 21, 14, 1, -21 },
  { 997, 13, 21, 16, 2, -21 },
  { 1032, 11, 21, 13, 2, -21 },
  { 1061, 17, 21, 22, 2, -21 },
  { 1106, 13, 21, 18, 2, -21 },
  { 1141, 13, 21, 17, 2, -21 },
  { 1176, 12, 21, 16, 2, -21 },
  { 1208, 13, 25, 17, 2, -21 },
  { 1249, 13, 21, 16, 2, -21 },
  { 1284, 13, 21, 15, 1, -21 },
  { 1319, 13, 21, 15, 1, -21 },
  { 1354, 12, 21, 17, 2, -21 },
  { 1386, 14, 21, 16, 1, -21 },
  { 1423, 20, 21, 22, 1, -21 },
  { 1476, 14, 21, 16, 1, -21 },
  { 1513, 14, 21, 15, 1, -21 },
  { 1550, 13, 21, 15, 1, -21 },
  { 1585, 4, 28, 7, 2, -24 },
  { 1599, 9, 23, 10, 1, -21 },
  { 1625, 4, 28, 7, 0, -24 },
  { 1639, 8, 10, 11, 1, -21 },
  { 1649, 11, 1, 11, 0, 0 },
  { 1651, 5, 4, 8, 1, -22 },
  { 1654, 10, 16, 14, 2, -16 },
  { 1674, 11, 22, 14, 2, -22 },
  { 1705, 11, 16, 13, 1, -16 },
  { 1727, 10, 22, 14, 2, -22 },
  { 1755, 11, 16, 13, 1, -16 },
  { 1777, 8, 22, 9, 1, -22 },
  { 1799, 10, 22, 14, 2, -16 },
  { 1827, 10, 22, 14, 2, -22 },
  { 1855, 2, 21, 6, 2, -21 },
  { 1861, 5, 27, 6, -1, -21 },
  { 1878, 10, 22, 13, 2, -22 },
  { 1906, 2, 22, 6, 2, -22 },
  { 1912, 18, 16, 22, 2, -16 },
  { 1948, 10, 16, 14, 2, -16 },
  { 1968, 11, 16, 14, 2, -16 },
  { 1990, 11, 22, 14, 2, -16 },
  { 2021, 10, 22, 14, 2, -16 },
  { 2049, 6, 16, 9, 2, -16 },
  { 2061, 10, 16, 13, 1, -16 },
  { 2081, 6, 19, 8, 1, -19 },
  { 2096, 10, 16, 14, 2, -16 },
  { 2116, 11, 16, 12, 1, -16 },
  { 2138, 17, 16, 19, 1, -16 },
  { 2172, 11, 16, 12, 1, -16 },
  { 2194, 11, 22, 12, 1, -16 },
  { 2225, 10, 16, 12, 1, -16 },
  { 2245, 7, 29, 9, 1, -23 },
  { 2271, 1, 25, 6, 3, -21 },
  { 2275, 8, 29, 9, 0, -23 },
  { 2304, 13, 5, 17, 2, -11 },
};

const GFXfont RobotoCondensed_Light29pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light29pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light29pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOCONDENSED_LIGHT29PT7B_H_
