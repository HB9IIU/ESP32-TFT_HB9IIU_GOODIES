#ifndef _ROBOTOCONDENSED_LIGHT19PT7B_H_
#define _ROBOTOCONDENSED_LIGHT19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light19pt7bBitmaps[] PROGMEM = {
  0x00, 0xF5, 0x55, 0x50, 0xF0, 0xB6, 0xD0, 0x12, 0x09, 0x04, 0x82, 0x4F,
  0xF9, 0x10, 0x88, 0x48, 0x24, 0x7F, 0x89, 0x04, 0x84, 0x42, 0x40, 0x10,
  0x20, 0xF2, 0x34, 0x38, 0x50, 0x20, 0x30, 0x18, 0x18, 0x18, 0x30, 0x51,
  0x9E, 0x10, 0x20, 0x70, 0x24, 0x08, 0x92, 0x28, 0x92, 0x1D, 0x00, 0x40,
  0x20, 0x09, 0x84, 0x91, 0x24, 0x89, 0x22, 0x40, 0x60, 0x38, 0x32, 0x11,
  0x08, 0x84, 0xC1, 0xC0, 0xC0, 0xA0, 0xC9, 0x46, 0xA1, 0x50, 0x44, 0x71,
  0xC8, 0xF0, 0x12, 0x24, 0x44, 0x48, 0x88, 0x88, 0x44, 0x44, 0x22, 0x10,
  0x84, 0x22, 0x11, 0x11, 0x11, 0x11, 0x11, 0x12, 0x24, 0x80, 0x08, 0x08,
  0x09, 0xEF, 0x18, 0x18, 0x24, 0x02, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10,
  0x10, 0x10, 0x10, 0xFA, 0xE0, 0x30, 0x04, 0x10, 0x82, 0x08, 0x41, 0x04,
  0x20, 0x82, 0x10, 0x41, 0x04, 0x00, 0x38, 0x89, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0A, 0x14, 0x47, 0x00, 0x3F, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x38, 0x8A, 0x0C, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20, 0x83,
  0x04, 0x1F, 0xC0, 0x38, 0x8A, 0x0C, 0x10, 0x20, 0x8E, 0x02, 0x02, 0x06,
  0x0C, 0x14, 0x47, 0x00, 0x04, 0x0C, 0x0C, 0x14, 0x24, 0x24, 0x44, 0x44,
  0x84, 0xFF, 0x04, 0x04, 0x04, 0x04, 0x7E, 0x81, 0x02, 0x04, 0x0F, 0x91,
  0x81, 0x02, 0x05, 0x0A, 0x14, 0x67, 0x80, 0x1C, 0x61, 0x02, 0x04, 0x17,
  0xB1, 0xE1, 0x83, 0x06, 0x0A, 0x14, 0x47, 0x80, 0xFE, 0x04, 0x08, 0x20,
  0x40, 0x82, 0x04, 0x10, 0x20, 0x41, 0x02, 0x04, 0x00, 0x38, 0x8A, 0x0C,
  0x18, 0x28, 0x8E, 0x22, 0x83, 0x06, 0x0C, 0x14, 0x67, 0x80, 0x38, 0x8A,
  0x0C, 0x18, 0x30, 0x60, 0xA3, 0x3A, 0x04, 0x08, 0x20, 0x86, 0x00, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x3E, 0x80, 0x04, 0x73, 0x30, 0xC0, 0xC1, 0xC1,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0xC0, 0x60, 0x30, 0x63, 0x18, 0x40,
  0x7A, 0x28, 0x41, 0x04, 0x21, 0x84, 0x20, 0x80, 0x00, 0x00, 0x80, 0x0F,
  0x80, 0x83, 0x08, 0x04, 0x80, 0x24, 0x30, 0xA2, 0x46, 0x22, 0x31, 0x11,
  0x88, 0x8C, 0x84, 0x62, 0x23, 0x13, 0x24, 0xEE, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x0F, 0x80, 0x04, 0x03, 0x00, 0xC0, 0x28, 0x12, 0x04, 0x81, 0x10,
  0x84, 0x21, 0x0F, 0xE6, 0x09, 0x02, 0x40, 0xD0, 0x10, 0xF9, 0x0A, 0x0C,
  0x18, 0x30, 0xBE, 0x42, 0x83, 0x06, 0x0C, 0x18, 0x5F, 0x00, 0x1E, 0x30,
  0x90, 0x58, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30, 0x28, 0x26,
  0x10, 0xF0, 0xF8, 0x84, 0x82, 0x82, 0x83, 0x81, 0x81, 0x81, 0x81, 0x83,
  0x82, 0x82, 0x84, 0xF8, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x3F, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x1F, 0xC0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x3F, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x00, 0x1E, 0x30, 0x90, 0x68, 0x18, 0x04,
  0x02, 0x01, 0x0F, 0x80, 0xC0, 0x50, 0x28, 0x12, 0x18, 0xF0, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xFF, 0xFC, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x06, 0x0C,
  0x2C, 0x4F, 0x00, 0x82, 0x86, 0x8C, 0x88, 0x90, 0xA0, 0xE0, 0xD0, 0x90,
  0x88, 0x8C, 0x84, 0x82, 0x83, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x83, 0xF0, 0x80, 0x70, 0x0F, 0x02, 0xE0, 0x5C, 0x0B, 0x42,
  0x68, 0x4D, 0x09, 0x92, 0x32, 0x46, 0x48, 0xC6, 0x18, 0xC3, 0x08, 0x40,
  0x81, 0x81, 0xC1, 0xE1, 0xA1, 0x91, 0x91, 0x89, 0x89, 0x85, 0x85, 0x83,
  0x83, 0x81, 0x1E, 0x31, 0x90, 0x58, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x70, 0x28, 0x26, 0x30, 0xF0, 0xFD, 0x0E, 0x0C, 0x18, 0x30, 0x61,
  0xFE, 0x81, 0x02, 0x04, 0x08, 0x10, 0x00, 0x3E, 0x31, 0x90, 0x50, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x28, 0x26, 0x31, 0xF0, 0x04,
  0x01, 0xF8, 0x84, 0x82, 0x82, 0x82, 0x82, 0x84, 0xF8, 0x88, 0x8C, 0x84,
  0x86, 0x82, 0x82, 0x3C, 0x42, 0x81, 0x81, 0x80, 0x40, 0x38, 0x0E, 0x03,
  0x01, 0x81, 0x81, 0x42, 0x3C, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0xC1, 0x41, 0x63, 0x3E, 0x40, 0x50, 0x24,
  0x09, 0x82, 0x21, 0x88, 0x42, 0x10, 0x44, 0x12, 0x04, 0x80, 0xA0, 0x30,
  0x0C, 0x03, 0x00, 0x82, 0x0C, 0x10, 0x61, 0x87, 0x0A, 0x24, 0x51, 0x22,
  0x89, 0x24, 0x49, 0x12, 0x48, 0xA1, 0x45, 0x0C, 0x28, 0x60, 0xC3, 0x06,
  0x18, 0x20, 0x81, 0x21, 0x90, 0x84, 0xC2, 0x40, 0xE0, 0x60, 0x30, 0x1C,
  0x12, 0x09, 0x88, 0x4C, 0x14, 0x08, 0x40, 0x90, 0x22, 0x10, 0x84, 0x32,
  0x04, 0x81, 0x60, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0xFF, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x30, 0x20, 0x40, 0x40,
  0x80, 0xFF, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0x9C, 0x84, 0x20, 0x84,
  0x20, 0x84, 0x20, 0x84, 0x20, 0x84, 0x20, 0xE4, 0x92, 0x49, 0x24, 0x92,
  0x49, 0x3C, 0x21, 0x14, 0xA5, 0x46, 0x20, 0xFE, 0xC8, 0x80, 0x38, 0x8A,
  0x10, 0x33, 0xF8, 0xE1, 0xC3, 0x8E, 0xE4, 0x81, 0x02, 0x04, 0x0B, 0xD8,
  0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x77, 0x80, 0x38, 0x8A, 0x0C, 0x18,
  0x10, 0x20, 0x41, 0x44, 0x70, 0x02, 0x04, 0x08, 0x17, 0xA8, 0xE0, 0xC1,
  0x83, 0x06, 0x0C, 0x14, 0x67, 0x40, 0x38, 0x8A, 0x0C, 0x1F, 0xF0, 0x20,
  0x40, 0x42, 0x78, 0x3B, 0x10, 0x8F, 0x21, 0x08, 0x42, 0x10, 0x84, 0x20,
  0x7A, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x46, 0x74, 0x08, 0x14, 0x47,
  0x00, 0x81, 0x02, 0x04, 0x0B, 0xD4, 0xB0, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x40, 0x30, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x32, 0x2E, 0x81, 0x02, 0x04, 0x08, 0x51, 0x26, 0x58, 0xA1, 0xA2,
  0x64, 0x48, 0x50, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xBC, 0xEC, 0x51, 0xC2,
  0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0xBD,
  0x4B, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x3C, 0x8E, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x46, 0x78, 0xBD, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0xC7, 0x7A, 0x04, 0x08, 0x10, 0x00, 0x7A, 0x8E, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x46, 0x74, 0x08, 0x10, 0x20, 0x40, 0xBC, 0xC8, 0x88, 0x88, 0x88,
  0x7B, 0x18, 0x70, 0x70, 0x60, 0x61, 0xC5, 0xE0, 0x21, 0x09, 0xF2, 0x10,
  0x84, 0x21, 0x08, 0x41, 0x80, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE1,
  0x46, 0xF4, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x14, 0x18, 0x18, 0x18,
  0x84, 0x31, 0x8A, 0x31, 0x25, 0x25, 0x24, 0xA5, 0x14, 0xA2, 0x8C, 0x21,
  0x84, 0x20, 0x84, 0x99, 0x21, 0x83, 0x06, 0x0E, 0x24, 0xC5, 0x08, 0x42,
  0x42, 0x42, 0x24, 0x24, 0x24, 0x34, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10,
  0x60, 0xFC, 0x08, 0x20, 0xC1, 0x04, 0x08, 0x20, 0x81, 0xFC, 0x12, 0x22,
  0x66, 0x64, 0x48, 0x44, 0x66, 0x62, 0x22, 0x10, 0xFF, 0xFF, 0x80, 0xC2,
  0x08, 0x42, 0x10, 0x84, 0x10, 0x44, 0x42, 0x10, 0x84, 0x22, 0x30, 0x70,
  0xA4, 0x61, 0xC0,
};

const GFXglyph RobotoCondensed_Light19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 14, 4, 1, -14 },
  { 5, 3, 4, 5, 1, -14 },
  { 7, 9, 14, 10, 1, -14 },
  { 23, 7, 18, 9, 1, -16 },
  { 39, 10, 14, 12, 1, -14 },
  { 57, 9, 14, 10, 1, -14 },
  { 73, 1, 4, 3, 1, -14 },
  { 74, 4, 19, 6, 1, -15 },
  { 84, 4, 19, 6, 0, -15 },
  { 94, 8, 8, 8, 0, -14 },
  { 102, 8, 9, 9, 1, -11 },
  { 111, 2, 4, 4, 1, -2 },
  { 112, 3, 1, 5, 1, -6 },
  { 113, 2, 2, 5, 1, -2 },
  { 114, 6, 15, 7, 0, -14 },
  { 126, 7, 14, 9, 1, -14 },
  { 139, 4, 14, 9, 2, -14 },
  { 146, 7, 14, 9, 1, -14 },
  { 159, 7, 14, 9, 1, -14 },
  { 172, 8, 14, 9, 1, -14 },
  { 186, 7, 14, 9, 1, -14 },
  { 199, 7, 14, 9, 1, -14 },
  { 212, 7, 14, 9, 1, -14 },
  { 225, 7, 14, 9, 1, -14 },
  { 238, 7, 14, 9, 1, -14 },
  { 251, 2, 11, 4, 1, -11 },
  { 254, 2, 13, 4, 1, -11 },
  { 258, 6, 8, 9, 1, -10 },
  { 264, 7, 5, 9, 1, -9 },
  { 269, 7, 8, 9, 1, -10 },
  { 276, 6, 14, 8, 1, -14 },
  { 287, 13, 17, 15, 1, -13 },
  { 315, 10, 14, 10, 0, -14 },
  { 333, 7, 14, 10, 2, -14 },
  { 346, 9, 14, 11, 1, -14 },
  { 362, 8, 14, 11, 2, -14 },
  { 376, 7, 14, 9, 2, -14 },
  { 389, 7, 14, 9, 2, -14 },
  { 402, 9, 14, 11, 1, -14 },
  { 418, 8, 14, 12, 2, -14 },
  { 432, 1, 14, 5, 2, -14 },
  { 434, 7, 14, 9, 1, -14 },
  { 447, 8, 14, 10, 2, -14 },
  { 461, 6, 14, 9, 2, -14 },
  { 472, 11, 14, 14, 2, -14 },
  { 492, 8, 14, 12, 2, -14 },
  { 506, 9, 14, 11, 1, -14 },
  { 522, 7, 14, 10, 2, -14 },
  { 535, 9, 16, 11, 1, -14 },
  { 553, 8, 14, 10, 2, -14 },
  { 567, 8, 14, 10, 1, -14 },
  { 581, 8, 14, 10, 1, -14 },
  { 595, 8, 14, 11, 1, -14 },
  { 609, 10, 14, 10, 0, -14 },
  { 627, 13, 14, 15, 1, -14 },
  { 650, 9, 14, 10, 1, -14 },
  { 666, 10, 14, 10, 0, -14 },
  { 684, 8, 14, 10, 1, -14 },
  { 698, 3, 18, 4, 1, -15 },
  { 705, 5, 15, 7, 1, -14 },
  { 715, 3, 18, 4, 0, -15 },
  { 722, 5, 7, 7, 1, -14 },
  { 727, 7, 1, 7, 0, 0 },
  { 728, 3, 3, 5, 1, -15 },
  { 730, 7, 10, 9, 1, -10 },
  { 739, 7, 14, 9, 1, -14 },
  { 752, 7, 10, 9, 1, -10 },
  { 761, 7, 14, 9, 1, -14 },
  { 774, 7, 10, 9, 1, -10 },
  { 783, 5, 14, 6, 1, -14 },
  { 792, 7, 14, 9, 1, -10 },
  { 805, 7, 14, 9, 1, -14 },
  { 818, 2, 14, 4, 1, -14 },
  { 822, 4, 18, 4, -1, -14 },
  { 831, 7, 14, 8, 1, -14 },
  { 844, 2, 14, 4, 1, -14 },
  { 848, 12, 10, 14, 1, -10 },
  { 863, 7, 10, 9, 1, -10 },
  { 872, 7, 10, 9, 1, -10 },
  { 881, 7, 14, 9, 1, -10 },
  { 894, 7, 14, 9, 1, -10 },
  { 907, 4, 10, 6, 1, -10 },
  { 912, 6, 10, 8, 1, -10 },
  { 920, 5, 13, 6, 0, -13 },
  { 929, 7, 10, 9, 1, -10 },
  { 938, 8, 10, 8, 0, -10 },
  { 948, 11, 10, 12, 1, -10 },
  { 962, 7, 10, 8, 1, -10 },
  { 971, 8, 14, 8, 0, -10 },
  { 985, 7, 10, 8, 1, -10 },
  { 994, 4, 19, 6, 1, -15 },
  { 1004, 1, 17, 4, 2, -14 },
  { 1007, 5, 19, 6, 0, -15 },
  { 1019, 9, 3, 11, 1, -7 },
};

const GFXfont RobotoCondensed_Light19pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light19pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light19pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOCONDENSED_LIGHT19PT7B_H_
