#ifndef _ROBOTOCONDENSED_LIGHT63PT7B_H_
#define _ROBOTOCONDENSED_LIGHT63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light63pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1B, 0x83, 0x70, 0x6E, 0x0D, 0xC1, 0x80, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01,
  0xC0, 0x30, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x70, 0x1C, 0x00, 0x03, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x18, 0x07, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x1C, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xE0, 0x1C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x60, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7E, 0x07, 0xC0,
  0xF0, 0x07, 0xC3, 0xC0, 0x07, 0x87, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C,
  0x00, 0x0E, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xEF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x3F, 0x01,
  0xF8, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x04, 0x01,
  0x80, 0x38, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x70,
  0x0E, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x18, 0x0E, 0x00, 0xE0, 0x06, 0x03,
  0x00, 0x38, 0x03, 0x81, 0xC0, 0x06, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0x38,
  0x38, 0x00, 0x70, 0x0E, 0x0C, 0x00, 0x0E, 0x07, 0x07, 0x00, 0x03, 0xC7,
  0x83, 0x80, 0x00, 0x7F, 0xE0, 0xE0, 0x00, 0x0F, 0xE0, 0x70, 0x00, 0x00,
  0x40, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x1F,
  0xC0, 0x00, 0x0E, 0x0F, 0xF8, 0x00, 0x07, 0x07, 0x8F, 0x00, 0x01, 0xC3,
  0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x38, 0x00, 0x38, 0x30, 0x07, 0x00, 0x1C,
  0x1C, 0x01, 0xC0, 0x06, 0x07, 0x00, 0x70, 0x03, 0x81, 0xC0, 0x1C, 0x00,
  0xC0, 0x70, 0x07, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70,
  0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x07, 0x01, 0xC0, 0x0E, 0x01,
  0xC0, 0x20, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0xF0, 0x07, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x38, 0x01, 0xE0, 0x00, 0xE0, 0x07, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3D, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x07, 0x07, 0x83, 0xC0, 0x3C, 0x3C,
  0x07, 0x80, 0xF1, 0xE0, 0x0F, 0x03, 0xC7, 0x80, 0x3E, 0x0E, 0x1C, 0x00,
  0x78, 0x38, 0x70, 0x00, 0xF0, 0xE3, 0xC0, 0x01, 0xE7, 0x8F, 0x00, 0x07,
  0x9C, 0x3C, 0x00, 0x0F, 0x70, 0xF0, 0x00, 0x1F, 0xC1, 0xC0, 0x00, 0x7E,
  0x07, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x1F, 0xC0,
  0xF0, 0x00, 0xFF, 0x01, 0xF0, 0x0F, 0xDE, 0x03, 0xFF, 0xFE, 0x3C, 0x07,
  0xFF, 0xE0, 0xF8, 0x0F, 0xFF, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x10, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x02, 0x40, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x38, 0x01, 0x80, 0x08, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x70, 0x1C,
  0x07, 0x7F, 0x0E, 0x0F, 0xFF, 0xE7, 0x3F, 0xE3, 0xFF, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x0F, 0x00, 0x38, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1C, 0x00, 0x70,
  0x04, 0x00, 0x10, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCF, 0x3C, 0xE7, 0xBC, 0xE1, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x31, 0xEF, 0xDF, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x1E, 0x0F,
  0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0x38, 0xE0, 0x00, 0x79, 0xC0,
  0x00, 0x77, 0x80, 0x00, 0xEF, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x77, 0x80,
  0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x9E, 0x00, 0x0E, 0x1C, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0x7F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0xF0, 0x1F, 0xC1, 0xFF, 0x1F, 0xFD, 0xFE, 0xFF, 0xC3, 0xFC, 0x0F,
  0xC0, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x1F, 0x80, 0xF0, 0x03, 0xC0,
  0xF0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x0F,
  0x1C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x80, 0xF8, 0x1E, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x3E, 0x00, 0x3C, 0x1F,
  0x00, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78,
  0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x38, 0x00,
  0x1E, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x03,
  0x80, 0x07, 0x00, 0x70, 0x01, 0xE0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x78, 0x00, 0xE0, 0x0E, 0x00, 0x1C,
  0x03, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x70, 0x1E, 0x00, 0x0E, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0xFE, 0x00, 0x77,
  0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFE, 0x7F, 0x07, 0xC0, 0x1F, 0x0F, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x77, 0x80, 0x00, 0xEF, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x9E,
  0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x7F, 0x00,
  0xE3, 0xFF, 0x83, 0xCF, 0xFF, 0x87, 0xBE, 0x1F, 0x8F, 0xF0, 0x0F, 0x9F,
  0x80, 0x0F, 0x3E, 0x00, 0x0F, 0x7C, 0x00, 0x0E, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xF7, 0x80, 0x01, 0xE7, 0x00, 0x03,
  0x8F, 0x00, 0x0F, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x78, 0x1F, 0x03, 0xE0,
  0x1F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x0E,
  0x78, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x1C, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x78, 0x07, 0xC3, 0xF0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0x81, 0xF8, 0x1E, 0x00, 0x7C,
  0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0F,
  0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x1F, 0x80, 0xFC,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x0F, 0x81, 0xF0, 0x1E, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x3C, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x1F, 0x00, 0xEE, 0x0F, 0xC3, 0xEE,
  0x07, 0xFF, 0xCE, 0x03, 0xFF, 0x0E, 0x00, 0xFC, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x37, 0xFF, 0xF7, 0x90, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x7F, 0xFF, 0x79, 0x00, 0x18, 0x7C, 0xF9, 0xF3, 0xC1, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xF1, 0xE3,
  0x8F, 0x1C, 0x78, 0x60, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x3E, 0x07, 0xC7, 0xC0, 0x3C, 0x78, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x03, 0xF0, 0x01, 0xC1, 0xC0, 0x03, 0xFE, 0x00, 0x30, 0xE0, 0x01,
  0xFF, 0xE0, 0x0E, 0x38, 0x00, 0xF0, 0x78, 0x03, 0x8E, 0x00, 0x78, 0x0E,
  0x00, 0xE7, 0x00, 0x1C, 0x03, 0x80, 0x19, 0xC0, 0x0E, 0x00, 0xE0, 0x06,
  0x70, 0x07, 0x80, 0x38, 0x01, 0xDC, 0x01, 0xC0, 0x0E, 0x00, 0x7E, 0x00,
  0x70, 0x03, 0x80, 0x1F, 0x80, 0x38, 0x00, 0xE0, 0x07, 0xE0, 0x0E, 0x00,
  0x38, 0x01, 0xF8, 0x03, 0x80, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x03, 0x80,
  0x1F, 0x80, 0x70, 0x00, 0xE0, 0x07, 0xE0, 0x1C, 0x00, 0x38, 0x01, 0xF8,
  0x07, 0x00, 0x0C, 0x00, 0x7E, 0x01, 0xC0, 0x03, 0x00, 0x1F, 0x80, 0x70,
  0x01, 0xC0, 0x07, 0xE0, 0x1C, 0x00, 0x70, 0x01, 0xB8, 0x07, 0x00, 0x1C,
  0x00, 0x6E, 0x01, 0xC0, 0x07, 0x00, 0x3B, 0x80, 0x70, 0x01, 0xC0, 0x0E,
  0xE0, 0x1C, 0x00, 0xF0, 0x03, 0x38, 0x07, 0x00, 0x3C, 0x01, 0xCE, 0x00,
  0xE0, 0x1F, 0x00, 0x73, 0x80, 0x38, 0x06, 0xE0, 0x38, 0x70, 0x0F, 0x03,
  0xB8, 0x1E, 0x1C, 0x01, 0xF7, 0xCF, 0x0F, 0x07, 0x00, 0x7F, 0xE1, 0xFF,
  0x81, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x38, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x00, 0x07,
  0xE0, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x1E, 0x38, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x78, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0xF0, 0x07, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x80,
  0x00, 0xE0, 0x03, 0x80, 0x01, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xE0,
  0x03, 0x80, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1E, 0x00, 0x7F, 0x0F, 0x00, 0x07, 0xC7,
  0x80, 0x01, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x0F,
  0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1C, 0xF0, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x7F, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE1, 0xE0, 0x00, 0xF8, 0xF0,
  0x00, 0x3E, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x3D, 0xE0, 0x00,
  0x3C, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0xF8,
  0x00, 0x78, 0x1F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x1C, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x1F, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x78, 0x03, 0xFC, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x3C, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00,
  0x03, 0xBC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0E, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F,
  0x78, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x3C, 0x00,
  0x07, 0xC7, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0xFC, 0x1E, 0x01, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F,
  0x1E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x02, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xF7, 0x00, 0x01,
  0xEF, 0x00, 0x03, 0x9E, 0x00, 0x0F, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x78,
  0x3E, 0x03, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x02, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x0F, 0x00,
  0x1F, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0,
  0x3C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x1F, 0x00,
  0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x3F, 0x00, 0x00, 0xF7, 0xF8, 0x00, 0x0F,
  0xF3, 0xC0, 0x00, 0xFF, 0x3C, 0x00, 0x0F, 0xE1, 0xE0, 0x00, 0xFC, 0x0F,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3E,
  0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x0E, 0xFF, 0xE0, 0x00, 0x00, 0x77, 0xFF, 0x00,
  0x00, 0x07, 0xBF, 0xB8, 0x00, 0x00, 0x39, 0xFD, 0xE0, 0x00, 0x03, 0xDF,
  0xEF, 0x00, 0x00, 0x1E, 0xFF, 0x38, 0x00, 0x00, 0xE7, 0xF9, 0xE0, 0x00,
  0x0F, 0x3F, 0xCF, 0x00, 0x00, 0x79, 0xFE, 0x38, 0x00, 0x03, 0x8F, 0xF1,
  0xE0, 0x00, 0x3C, 0x7F, 0x87, 0x00, 0x01, 0xE3, 0xFC, 0x38, 0x00, 0x0E,
  0x1F, 0xE1, 0xE0, 0x00, 0xF0, 0xFF, 0x07, 0x00, 0x07, 0x07, 0xF8, 0x38,
  0x00, 0x38, 0x3F, 0xC1, 0xE0, 0x03, 0xC1, 0xFE, 0x07, 0x00, 0x1C, 0x0F,
  0xF0, 0x38, 0x00, 0xE0, 0x7F, 0x81, 0xE0, 0x0F, 0x03, 0xFC, 0x07, 0x00,
  0x70, 0x1F, 0xE0, 0x38, 0x03, 0x80, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0xF8,
  0x07, 0x01, 0xC0, 0x3F, 0xC0, 0x38, 0x0E, 0x01, 0xFE, 0x01, 0xE0, 0xF0,
  0x0F, 0xF0, 0x07, 0x07, 0x00, 0x7F, 0x80, 0x38, 0x38, 0x03, 0xFC, 0x01,
  0xE3, 0xC0, 0x1F, 0xE0, 0x07, 0x1C, 0x00, 0xFF, 0x00, 0x38, 0xE0, 0x07,
  0xF8, 0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x07, 0x70, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x03, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF7, 0x80, 0x00, 0x7F, 0xBC,
  0x00, 0x03, 0xFC, 0xF0, 0x00, 0x1F, 0xE3, 0x80, 0x00, 0xFF, 0x1E, 0x00,
  0x07, 0xF8, 0x70, 0x00, 0x3F, 0xC3, 0xC0, 0x01, 0xFE, 0x0E, 0x00, 0x0F,
  0xF0, 0x78, 0x00, 0x7F, 0x81, 0xE0, 0x03, 0xFC, 0x0F, 0x00, 0x1F, 0xE0,
  0x3C, 0x00, 0xFF, 0x01, 0xE0, 0x07, 0xF8, 0x07, 0x80, 0x3F, 0xC0, 0x1C,
  0x01, 0xFE, 0x00, 0xF0, 0x0F, 0xF0, 0x03, 0x80, 0x7F, 0x80, 0x1E, 0x03,
  0xFC, 0x00, 0x70, 0x1F, 0xE0, 0x03, 0xC0, 0xFF, 0x00, 0x0F, 0x07, 0xF8,
  0x00, 0x78, 0x3F, 0xC0, 0x01, 0xE1, 0xFE, 0x00, 0x07, 0x0F, 0xF0, 0x00,
  0x3C, 0x7F, 0x80, 0x00, 0xE3, 0xFC, 0x00, 0x07, 0x9F, 0xE0, 0x00, 0x1C,
  0xFF, 0x00, 0x00, 0xF7, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x7E, 0x03, 0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0F,
  0x1C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x3C, 0x1F,
  0x00, 0x03, 0xC0, 0x7C, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x08, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xC0,
  0x07, 0xF8, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x03,
  0xCF, 0x00, 0x03, 0xF3, 0xC0, 0x07, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xC0,
  0x07, 0xC0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x7C,
  0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x08, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x78, 0x01, 0xFE, 0x0F, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x38, 0xF0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x1C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1C,
  0x78, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00,
  0x7F, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03,
  0xC0, 0x07, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x01,
  0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0xF0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFC, 0x03, 0xE0, 0x3E, 0x00, 0x3E,
  0x0F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E,
  0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0xC3, 0xE0,
  0x01, 0xF0, 0x7F, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x79, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x78, 0x0E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0xF0, 0x07, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x01,
  0xE0, 0x03, 0x80, 0x01, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xE0, 0x07,
  0x80, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xF0, 0x07,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xE0,
  0x00, 0x1C, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x77, 0x00, 0x03,
  0x87, 0x00, 0x03, 0xB8, 0x00, 0x1C, 0x3C, 0x00, 0x1D, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0xEE, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x38, 0x00, 0x70, 0x38,
  0x00, 0x71, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x0F, 0x00,
  0x1C, 0x70, 0x01, 0xE0, 0x78, 0x01, 0xE1, 0xC0, 0x0F, 0x03, 0xC0, 0x0E,
  0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x80, 0x70, 0x03, 0x83,
  0x80, 0x1C, 0x03, 0xC0, 0x3C, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x70,
  0x0F, 0x00, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x03, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x00, 0xF0, 0x38, 0x03, 0x81, 0xE0,
  0x07, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x00,
  0xE0, 0x70, 0x07, 0x03, 0x80, 0x07, 0x07, 0x00, 0x1C, 0x3C, 0x00, 0x3C,
  0x38, 0x00, 0xE1, 0xE0, 0x01, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x07, 0x0E,
  0x00, 0x38, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00,
  0x07, 0x3C, 0x00, 0x0F, 0x38, 0x00, 0x39, 0xE0, 0x00, 0x79, 0xC0, 0x01,
  0xCE, 0x00, 0x01, 0xDC, 0x00, 0x06, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x3B,
  0x80, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x3C, 0x01, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03,
  0xC7, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x78,
  0xF8, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x70,
  0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xFF, 0xF8,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3B, 0x80, 0x1D,
  0xC0, 0x0E, 0xE0, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x03, 0x83, 0x81,
  0xC1, 0xC0, 0xE0, 0xF0, 0xE0, 0x38, 0x70, 0x1C, 0x78, 0x0F, 0x38, 0x03,
  0x9C, 0x01, 0xDE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xF0, 0x0F, 0x87, 0x80, 0x0F,
  0x0F, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xE0, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7E,
  0x00, 0xF1, 0xF0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9C, 0x00,
  0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00,
  0xF7, 0x80, 0x03, 0xE7, 0x00, 0x07, 0xCF, 0x00, 0x3B, 0x9F, 0x81, 0xF7,
  0x1F, 0xFF, 0xCE, 0x1F, 0xFF, 0x1C, 0x0F, 0xF8, 0x3C, 0x01, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x1F, 0xF0, 0x38, 0xFF, 0xF0, 0xEF, 0xFF, 0xE3, 0xB8,
  0x0F, 0xCF, 0xC0, 0x0F, 0x3E, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0E, 0xF0, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0xC0, 0x0F, 0x3B, 0x80,
  0xFC, 0xEF, 0xFF, 0xE3, 0x9F, 0xFF, 0x0E, 0x1F, 0xF0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81,
  0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0x00, 0x0F, 0x3C, 0x00, 0x0E, 0x78,
  0x00, 0x1C, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xE3, 0xC0, 0x03, 0xC7,
  0xC0, 0x0F, 0x07, 0xC0, 0x3E, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0xFF, 0xC3,
  0x83, 0xFF, 0xC7, 0x0F, 0xFF, 0xCE, 0x3E, 0x03, 0xDC, 0xF8, 0x01, 0xF9,
  0xE0, 0x01, 0xF3, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xBC, 0x00, 0x0F,
  0x38, 0x00, 0x1E, 0x78, 0x00, 0x7C, 0xF8, 0x01, 0xF8, 0xF8, 0x0F, 0x70,
  0xFF, 0xFC, 0xE0, 0xFF, 0xF1, 0xC0, 0x7F, 0xC3, 0x80, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xF0,
  0x0F, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00,
  0x1C, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x87, 0xC0,
  0x03, 0x87, 0xE0, 0x1F, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x01,
  0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x1C, 0x1F, 0xFE, 0x38, 0x7F, 0xFE, 0x71, 0xF0, 0x1E,
  0xE7, 0xC0, 0x0F, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xF0, 0x00,
  0x1D, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0xF3, 0xC0, 0x03, 0xE7, 0xC0, 0x0F,
  0xC7, 0xC0, 0x3B, 0x87, 0xFF, 0xE7, 0x07, 0xFF, 0x8E, 0x07, 0xFE, 0x1C,
  0x00, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x10, 0x00, 0x1C, 0x30, 0x00, 0x78, 0xF8,
  0x01, 0xE0, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x83, 0xFC, 0x1C, 0x7F, 0xF8, 0xE7, 0xFF, 0xE7, 0x78,
  0x1F, 0x3F, 0x80, 0x3D, 0xF8, 0x01, 0xEF, 0x80, 0x07, 0x78, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x73, 0xFE, 0xF7, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x01,
  0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C,
  0x0F, 0xA3, 0xE7, 0xF8, 0xFF, 0x1F, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x0F,
  0x38, 0x00, 0x78, 0xE0, 0x03, 0xC3, 0x80, 0x1F, 0x0E, 0x00, 0xF8, 0x38,
  0x03, 0xC0, 0xE0, 0x1E, 0x03, 0x80, 0xF0, 0x0E, 0x07, 0x80, 0x38, 0x3C,
  0x00, 0xE1, 0xF0, 0x03, 0x87, 0x80, 0x0E, 0x3C, 0x00, 0x39, 0xE0, 0x00,
  0xEF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xDE, 0x00, 0x3F, 0x78, 0x00, 0xF8,
  0xF0, 0x03, 0xC1, 0xE0, 0x0E, 0x07, 0x80, 0x38, 0x0F, 0x00, 0xE0, 0x3E,
  0x03, 0x80, 0x78, 0x0E, 0x00, 0xF0, 0x38, 0x03, 0xE0, 0xE0, 0x07, 0x83,
  0x80, 0x0F, 0x0E, 0x00, 0x3E, 0x38, 0x00, 0x78, 0xE0, 0x00, 0xF3, 0x80,
  0x03, 0xEE, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x02, 0x00, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0xF1, 0xFF, 0xE0,
  0xFF, 0xF0, 0xF3, 0xFF, 0xE1, 0xFF, 0xF8, 0xF7, 0x01, 0xF3, 0xC0, 0x7C,
  0xFE, 0x00, 0xFB, 0x80, 0x3E, 0xFC, 0x00, 0x7F, 0x00, 0x1E, 0xF8, 0x00,
  0x3E, 0x00, 0x0E, 0xF8, 0x00, 0x3E, 0x00, 0x0E, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x07, 0xF8, 0x38, 0xFF, 0xF1, 0xCF, 0xFF, 0xCE,
  0xF0, 0x3E, 0x7F, 0x00, 0x7B, 0xF0, 0x03, 0xDF, 0x00, 0x0E, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xC0, 0x00, 0x08, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xF8, 0x0F, 0x80, 0xF0,
  0x01, 0xE0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3C,
  0x00, 0x07, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00,
  0x07, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xC3, 0xC0,
  0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x87, 0xFC, 0x0E, 0x7F, 0xFC, 0x3B, 0xFF, 0xF8, 0xEE, 0x03, 0xF3, 0xF0,
  0x03, 0xCF, 0x80, 0x07, 0xBC, 0x00, 0x1E, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xBC,
  0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xE0, 0x03, 0xCF, 0xE0, 0x3F, 0x3B, 0xFF,
  0xF8, 0xE7, 0xFF, 0xC3, 0x87, 0xFC, 0x0E, 0x01, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFE,
  0x1C, 0x1F, 0xFE, 0x38, 0x7F, 0xFE, 0x71, 0xF0, 0x0E, 0xE7, 0xC0, 0x0F,
  0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1D,
  0xC0, 0x00, 0x3B, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xDC, 0x00,
  0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xE0, 0x00,
  0x39, 0xC0, 0x00, 0xF3, 0xC0, 0x03, 0xE7, 0xC0, 0x0F, 0xC7, 0xC0, 0x3B,
  0x87, 0xFF, 0xF7, 0x07, 0xFF, 0x8E, 0x07, 0xFE, 0x1C, 0x00, 0xC0, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x0F, 0xF9, 0xFF, 0xDF, 0xFE, 0xF0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1E, 0x01, 0xF0, 0xF0, 0x03, 0xC3,
  0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x39, 0xE0, 0x00, 0xE7, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xDC, 0x00, 0x0E,
  0x78, 0x00, 0x79, 0xF0, 0x01, 0xE3, 0xE0, 0x1F, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x81, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x40, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x70,
  0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x3C, 0x00,
  0xFC, 0xF8, 0x0F, 0xF1, 0xFF, 0xFB, 0xC3, 0xFF, 0xCF, 0x07, 0xFC, 0x3C,
  0x01, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x73,
  0x80, 0x00, 0xE7, 0x00, 0x03, 0xCF, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C,
  0x00, 0x3C, 0x3C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x03, 0xC0, 0xF0,
  0x07, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x80,
  0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x07, 0x80, 0x1E, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0x78, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80,
  0x01, 0xCE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x7B, 0x80, 0x03, 0x80, 0x03, 0x9C,
  0x00, 0x3E, 0x00, 0x1C, 0xE0, 0x01, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x80,
  0x0F, 0x1C, 0x00, 0x7C, 0x00, 0x70, 0xE0, 0x07, 0xF0, 0x03, 0x87, 0x00,
  0x3B, 0x80, 0x1C, 0x3C, 0x01, 0xDC, 0x01, 0xE1, 0xE0, 0x1E, 0xE0, 0x0E,
  0x07, 0x00, 0xE3, 0x80, 0x70, 0x38, 0x07, 0x1C, 0x03, 0x81, 0xE0, 0x38,
  0xE0, 0x3C, 0x0F, 0x03, 0x87, 0x81, 0xC0, 0x38, 0x1C, 0x1C, 0x0E, 0x01,
  0xC0, 0xE0, 0xE0, 0x70, 0x0F, 0x07, 0x07, 0x03, 0x80, 0x78, 0x70, 0x3C,
  0x38, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x0E, 0x1C, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0x38, 0x70, 0x03, 0xCE, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x07, 0x38,
  0x00, 0x73, 0x80, 0x39, 0xC0, 0x03, 0xB8, 0x01, 0xCE, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x1E, 0xF0, 0x00, 0x78, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC1, 0xE0,
  0x0F, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x78, 0x03, 0x80, 0xE0, 0x07, 0x83,
  0xC0, 0x07, 0x07, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x1E, 0xF0, 0x00,
  0x38, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x1E,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x87, 0x80,
  0x0F, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x70, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x1E, 0x00,
  0x38, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x0F, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xE0, 0x03, 0x80,
  0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC3,
  0xC0, 0x01, 0xE3, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0x80, 0x00, 0xF7,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x77, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x02, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x01, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x3F, 0x00, 0xF8, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x07, 0x80, 0x04, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xC7, 0xFF, 0x00, 0x0E, 0x7C, 0xFC,
  0x00, 0x77, 0x81, 0xF0, 0x03, 0xB8, 0x07, 0xC0, 0x39, 0xC0, 0x1F, 0x03,
  0xDE, 0x00, 0x7E, 0x7C, 0xE0, 0x01, 0xFF, 0xE7, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xC0,
};

const GFXglyph RobotoCondensed_Light63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 46, 14, 5, -45 },
  { 24, 11, 14, 18, 4, -47 },
  { 44, 29, 45, 32, 3, -45 },
  { 208, 23, 59, 31, 4, -52 },
  { 378, 34, 47, 40, 3, -46 },
  { 578, 30, 47, 34, 3, -46 },
  { 755, 3, 14, 11, 4, -47 },
  { 761, 13, 64, 18, 4, -50 },
  { 865, 13, 64, 19, 1, -50 },
  { 969, 25, 25, 27, 1, -45 },
  { 1048, 25, 33, 31, 3, -37 },
  { 1152, 6, 14, 12, 2, -6 },
  { 1163, 12, 3, 16, 2, -21 },
  { 1168, 6, 6, 15, 4, -5 },
  { 1173, 19, 49, 22, 1, -45 },
  { 1290, 23, 47, 31, 4, -46 },
  { 1426, 14, 45, 31, 5, -45 },
  { 1505, 25, 46, 31, 3, -46 },
  { 1649, 24, 47, 31, 3, -46 },
  { 1790, 27, 45, 31, 2, -45 },
  { 1942, 23, 46, 31, 5, -45 },
  { 2075, 23, 46, 31, 4, -45 },
  { 2208, 24, 45, 31, 3, -45 },
  { 2343, 24, 47, 31, 3, -46 },
  { 2484, 24, 46, 31, 3, -46 },
  { 2622, 5, 34, 13, 4, -33 },
  { 2644, 7, 41, 12, 2, -33 },
  { 2680, 21, 26, 28, 3, -33 },
  { 2749, 21, 15, 30, 5, -28 },
  { 2789, 22, 26, 29, 4, -33 },
  { 2861, 20, 47, 25, 3, -46 },
  { 2979, 42, 58, 49, 4, -44 },
  { 3284, 32, 45, 35, 1, -45 },
  { 3464, 25, 45, 34, 5, -45 },
  { 3605, 28, 47, 36, 4, -46 },
  { 3770, 27, 45, 36, 5, -45 },
  { 3922, 24, 45, 31, 5, -45 },
  { 4057, 24, 45, 31, 5, -45 },
  { 4192, 28, 47, 37, 5, -46 },
  { 4357, 28, 45, 39, 5, -45 },
  { 4515, 4, 45, 15, 6, -45 },
  { 4538, 23, 46, 30, 2, -45 },
  { 4671, 28, 45, 35, 5, -45 },
  { 4829, 22, 45, 29, 5, -45 },
  { 4953, 37, 45, 47, 5, -45 },
  { 5162, 29, 45, 39, 5, -45 },
  { 5326, 29, 47, 37, 4, -46 },
  { 5497, 26, 45, 34, 5, -45 },
  { 5644, 29, 54, 37, 4, -46 },
  { 5840, 27, 45, 35, 5, -45 },
  { 5992, 27, 47, 33, 3, -46 },
  { 6151, 29, 45, 33, 2, -45 },
  { 6315, 26, 46, 36, 5, -45 },
  { 6465, 32, 45, 34, 1, -45 },
  { 6645, 45, 45, 49, 2, -45 },
  { 6899, 30, 45, 34, 2, -45 },
  { 7068, 31, 45, 33, 1, -45 },
  { 7243, 27, 45, 33, 3, -45 },
  { 7395, 9, 61, 14, 5, -51 },
  { 7464, 19, 49, 22, 2, -45 },
  { 7581, 8, 61, 14, 1, -51 },
  { 7642, 17, 22, 23, 3, -45 },
  { 7689, 23, 3, 24, 1, 0 },
  { 7698, 11, 9, 18, 3, -48 },
  { 7711, 23, 35, 30, 3, -34 },
  { 7812, 22, 48, 31, 5, -47 },
  { 7944, 23, 35, 29, 3, -34 },
  { 8045, 23, 48, 31, 3, -47 },
  { 8183, 23, 35, 29, 3, -34 },
  { 8284, 17, 48, 19, 2, -48 },
  { 8386, 23, 47, 31, 3, -34 },
  { 8522, 21, 47, 30, 5, -47 },
  { 8646, 5, 45, 13, 4, -45 },
  { 8675, 11, 58, 13, -2, -45 },
  { 8755, 22, 47, 27, 5, -47 },
  { 8885, 3, 47, 13, 5, -47 },
  { 8903, 40, 34, 48, 4, -34 },
  { 9073, 21, 34, 30, 5, -34 },
  { 9163, 25, 35, 31, 3, -34 },
  { 9273, 22, 47, 31, 5, -34 },
  { 9403, 23, 47, 31, 3, -34 },
  { 9539, 13, 34, 19, 5, -34 },
  { 9595, 22, 35, 28, 3, -34 },
  { 9692, 15, 43, 18, 1, -42 },
  { 9773, 22, 34, 30, 4, -33 },
  { 9867, 23, 33, 27, 2, -33 },
  { 9962, 37, 33, 41, 2, -33 },
  { 10115, 23, 33, 27, 2, -33 },
  { 10210, 24, 46, 26, 1, -33 },
  { 10348, 22, 33, 27, 3, -33 },
  { 10439, 16, 61, 19, 2, -49 },
  { 10561, 4, 53, 14, 5, -45 },
  { 10588, 15, 61, 19, 1, -49 },
  { 10703, 29, 11, 37, 4, -24 },
};

const GFXfont RobotoCondensed_Light63pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light63pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light63pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOCONDENSED_LIGHT63PT7B_H_
