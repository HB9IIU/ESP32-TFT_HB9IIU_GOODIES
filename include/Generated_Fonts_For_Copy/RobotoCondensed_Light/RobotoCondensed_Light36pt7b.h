#ifndef _ROBOTOCONDENSED_LIGHT36PT7B_H_
#define _ROBOTOCONDENSED_LIGHT36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x02, 0x0C, 0x02, 0x08, 0x02,
  0x08, 0x06, 0x18, 0x7F, 0xFF, 0x7F, 0xFF, 0x04, 0x18, 0x04, 0x10, 0x04,
  0x10, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x08, 0x20, 0xFF,
  0xFE, 0xFF, 0xFE, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x10, 0x60, 0x10,
  0x40, 0x10, 0x40, 0x30, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0xFC, 0x0F, 0xF0, 0xE1, 0xCE, 0x06, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0,
  0x36, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0x80, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x1B, 0x00, 0xD8,
  0x0E, 0x70, 0xE3, 0xFE, 0x07, 0xE0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x3C,
  0x00, 0x0F, 0xC0, 0x01, 0x0C, 0x00, 0x60, 0x81, 0x0C, 0x10, 0x61, 0x82,
  0x08, 0x30, 0x43, 0x06, 0x08, 0x40, 0xC1, 0x18, 0x08, 0x62, 0x01, 0xF8,
  0xC0, 0x1E, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x31, 0xE0, 0x0C,
  0x7E, 0x01, 0x98, 0x60, 0x63, 0x0C, 0x08, 0x40, 0x83, 0x08, 0x10, 0x41,
  0x02, 0x18, 0x20, 0x42, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x0F, 0xC0, 0x00,
  0xF0, 0x07, 0x80, 0x0F, 0xE0, 0x06, 0x18, 0x06, 0x0C, 0x03, 0x03, 0x01,
  0x81, 0x80, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0xC0, 0x0C, 0xE0, 0x07, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xCC, 0x0C, 0xC3, 0x04, 0xE0,
  0xC2, 0x60, 0x73, 0x30, 0x19, 0x98, 0x06, 0xCC, 0x03, 0xC6, 0x00, 0xE1,
  0x80, 0x70, 0xE0, 0xEC, 0x3F, 0xE7, 0x07, 0xC1, 0x80, 0xFF, 0xFF, 0x02,
  0x03, 0x06, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60,
  0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x60,
  0x60, 0x60, 0x20, 0x30, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x06, 0x03, 0x02,
  0x81, 0x81, 0x81, 0x03, 0x02, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x18, 0x30,
  0x60, 0xC3, 0x06, 0x08, 0x30, 0x41, 0x86, 0x08, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x83, 0x0B, 0xCC, 0xF7, 0xFF, 0x03, 0xE0, 0x07,
  0x00, 0x36, 0x01, 0x8C, 0x06, 0x18, 0x30, 0x70, 0x80, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x33, 0x33, 0x66, 0xE4,
  0xFF, 0xFC, 0xDF, 0x00, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60,
  0x10, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30,
  0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x10,
  0x0C, 0x03, 0x00, 0x0F, 0x80, 0xFF, 0x0E, 0x1C, 0xE0, 0x66, 0x03, 0xB0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x36,
  0x01, 0xB0, 0x1D, 0xC0, 0xC7, 0x0E, 0x1F, 0xE0, 0x7C, 0x00, 0x03, 0x0F,
  0x3F, 0xF3, 0xC3, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x0F, 0x80, 0xFF, 0x83, 0x07, 0x18, 0x0C, 0xE0, 0x3B, 0x00, 0x6C, 0x01,
  0xB0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x81,
  0xFF, 0x1C, 0x1C, 0xC0, 0x6E, 0x01, 0xE0, 0x0F, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0xFC, 0x07, 0xF0, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0D, 0x80, 0xEE,
  0x0E, 0x3F, 0xE0, 0x7C, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xB0, 0x01, 0xB0, 0x03, 0x30, 0x06, 0x30, 0x06,
  0x30, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x30, 0x18, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x60, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x3F, 0xF3, 0xFF,
  0x98, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x7C, 0x1F, 0xF0, 0xE1, 0xC4, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x19, 0x80, 0xCE, 0x0C,
  0x3F, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x1F, 0x80, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x9F, 0x0C, 0xFE, 0x36,
  0x1C, 0xF0, 0x3B, 0x80, 0x6C, 0x01, 0xB0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xD8, 0x02, 0x60, 0x19, 0x80, 0x63, 0x03, 0x8E, 0x1C, 0x1F, 0xE0,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x0F, 0x80, 0x7F, 0x83, 0x87, 0x18, 0x0C, 0x60, 0x19,
  0x80, 0x6C, 0x01, 0xB0, 0x06, 0x60, 0x19, 0x80, 0x66, 0x03, 0x0C, 0x1C,
  0x1F, 0xE0, 0x7F, 0x03, 0x87, 0x18, 0x0E, 0xC0, 0x1B, 0x00, 0x6C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x66, 0x01, 0x9C, 0x1C, 0x3F, 0xE0, 0x3F,
  0x00, 0x0F, 0x81, 0xFE, 0x0C, 0x18, 0xC0, 0x66, 0x03, 0x60, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x03, 0xB0, 0x1D,
  0xC1, 0xE7, 0xFB, 0x0F, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x03, 0x80, 0x38, 0x1F, 0x80, 0xF0, 0x00, 0x7D, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x7D, 0x80, 0x37, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x33, 0x33, 0x76, 0x64, 0x00, 0x08, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0,
  0x0E, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x00, 0x70, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x02, 0x00, 0x00, 0x1F, 0x0F, 0xF1,
  0x87, 0x60, 0x6C, 0x07, 0x80, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03,
  0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x3F, 0x00,
  0x01, 0xFF, 0xE0, 0x03, 0x80, 0x70, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x0C,
  0x18, 0x00, 0x04, 0x18, 0x00, 0x06, 0x30, 0x00, 0x02, 0x20, 0x1E, 0x02,
  0x60, 0x3F, 0x83, 0x60, 0x61, 0x83, 0x40, 0xC1, 0x81, 0x40, 0xC1, 0x81,
  0xC1, 0x81, 0x81, 0xC1, 0x81, 0x81, 0xC1, 0x81, 0x81, 0xC1, 0x01, 0x81,
  0xC1, 0x01, 0x01, 0xC1, 0x01, 0x03, 0xC1, 0x01, 0x03, 0xC1, 0x03, 0x02,
  0xC1, 0x83, 0x06, 0x41, 0x85, 0x84, 0x40, 0xFD, 0xFC, 0x60, 0x70, 0xF0,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x07, 0x00, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0x60, 0x00,
  0xCC, 0x00, 0x33, 0x00, 0x08, 0xC0, 0x06, 0x10, 0x01, 0x86, 0x00, 0x61,
  0x80, 0x30, 0x60, 0x0C, 0x0C, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18,
  0x18, 0x06, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xC0, 0x0C, 0x30, 0x03, 0x18,
  0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x01, 0xF0, 0x00, 0x30, 0xFF,
  0xC3, 0xFF, 0xCC, 0x03, 0x30, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x00, 0xF0,
  0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x07, 0x3F, 0xF8, 0xFF, 0xE3, 0x00, 0xEC,
  0x01, 0xB0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xB0, 0x0E, 0xFF, 0xF3, 0xFF, 0x00, 0x03, 0xF0, 0x0F,
  0xFC, 0x1C, 0x0E, 0x38, 0x06, 0x70, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60,
  0x03, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x03, 0x60,
  0x03, 0x60, 0x03, 0x30, 0x03, 0x38, 0x06, 0x1C, 0x0E, 0x0F, 0xFC, 0x03,
  0xF0, 0xFF, 0x81, 0xFF, 0xC3, 0x01, 0xC6, 0x00, 0xCC, 0x00, 0xD8, 0x01,
  0xB0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xD8, 0x01, 0xB0, 0x06, 0x60, 0x38, 0xFF, 0xE1,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0x7F,
  0xFB, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0x7F, 0xFB, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x38, 0x1C, 0x70, 0x0C,
  0x60, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03,
  0x70, 0x07, 0x38, 0x1E, 0x1F, 0xFC, 0x07, 0xE0, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0x80, 0x3E, 0x01, 0xB0, 0x0D, 0x80, 0xE6, 0x0E, 0x3F, 0xE0,
  0x7E, 0x00, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x70,
  0xC0, 0x60, 0xC0, 0xC0, 0xC1, 0xC0, 0xC3, 0x80, 0xC7, 0x00, 0xC6, 0x00,
  0xCC, 0x00, 0xDE, 0x00, 0xFF, 0x00, 0xF3, 0x00, 0xE1, 0x80, 0xC1, 0xC0,
  0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x1C,
  0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xEC, 0x00, 0x6F, 0x60, 0x03, 0x7B, 0x00, 0x1B, 0xCC, 0x01,
  0x9E, 0x60, 0x0C, 0xF3, 0x00, 0x67, 0x8C, 0x06, 0x3C, 0x60, 0x31, 0xE3,
  0x01, 0x8F, 0x0C, 0x18, 0x78, 0x60, 0xC3, 0xC3, 0x06, 0x1E, 0x0C, 0x60,
  0xF0, 0x63, 0x07, 0x83, 0x10, 0x3C, 0x0D, 0x81, 0xE0, 0x6C, 0x0F, 0x03,
  0x40, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x00, 0xC0, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xD8, 0x03, 0xCC, 0x03,
  0xCC, 0x03, 0xC6, 0x03, 0xC6, 0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC1, 0x83,
  0xC1, 0x83, 0xC0, 0xC3, 0xC0, 0xE3, 0xC0, 0x63, 0xC0, 0x73, 0xC0, 0x33,
  0xC0, 0x1B, 0xC0, 0x1B, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0x07, 0x86, 0x00, 0xC7, 0x00,
  0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x66, 0x00, 0x33, 0x80,
  0x18, 0xE0, 0x18, 0x38, 0x3C, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xE1,
  0xFF, 0xE3, 0x00, 0xE6, 0x00, 0xEC, 0x00, 0xD8, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x36, 0x00, 0x6C, 0x03, 0x9F, 0xFE,
  0x3F, 0xF8, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x03,
  0xF0, 0x07, 0xFC, 0x07, 0x07, 0x06, 0x00, 0xC7, 0x00, 0x73, 0x00, 0x19,
  0x80, 0x0D, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x6C, 0x00, 0x66, 0x00, 0x33, 0x80, 0x18, 0xC0, 0x18,
  0x38, 0x38, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x08, 0xFF, 0xC1, 0xFF, 0xE3, 0x00, 0xE6, 0x00, 0xCC, 0x00,
  0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x36,
  0x00, 0xCC, 0x03, 0x9F, 0xFE, 0x3F, 0xF0, 0x60, 0x60, 0xC0, 0x61, 0x80,
  0xC3, 0x00, 0xC6, 0x01, 0x8C, 0x01, 0x98, 0x03, 0x30, 0x03, 0x60, 0x06,
  0xC0, 0x0F, 0x80, 0x0C, 0x07, 0xC0, 0x3F, 0xE0, 0xE0, 0xE3, 0x00, 0xE6,
  0x00, 0xD8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x60, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xD8, 0x03, 0x1C,
  0x0E, 0x1F, 0xF8, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0x98, 0x03, 0x38, 0x1C, 0x3F, 0xF0,
  0x1F, 0x80, 0xC0, 0x01, 0xF0, 0x00, 0x66, 0x00, 0x19, 0x80, 0x0E, 0x60,
  0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x18, 0x38, 0x06, 0x06, 0x01,
  0x81, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC1, 0x80,
  0x18, 0x60, 0x06, 0x18, 0x01, 0x8C, 0x00, 0x23, 0x00, 0x0C, 0xC0, 0x03,
  0x60, 0x00, 0xD8, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0xC0, 0x0C, 0x01, 0xD8, 0x03, 0x00, 0x66, 0x01, 0xC0, 0x19, 0x80,
  0x78, 0x06, 0x60, 0x1E, 0x01, 0x98, 0x07, 0x80, 0xE3, 0x01, 0x20, 0x30,
  0xC0, 0xCC, 0x0C, 0x30, 0x33, 0x03, 0x0C, 0x0C, 0xC0, 0xC3, 0x02, 0x10,
  0x60, 0x61, 0x86, 0x18, 0x18, 0x61, 0x86, 0x06, 0x18, 0x61, 0x81, 0x84,
  0x08, 0x60, 0x23, 0x03, 0x30, 0x0C, 0xC0, 0xCC, 0x03, 0x30, 0x33, 0x00,
  0xC8, 0x04, 0xC0, 0x36, 0x01, 0x30, 0x05, 0x80, 0x68, 0x01, 0xE0, 0x1E,
  0x00, 0x70, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0xB8, 0x01, 0x8C, 0x01, 0xC7, 0x00, 0xC1, 0x80,
  0xC0, 0xE0, 0x60, 0x30, 0x60, 0x0C, 0x30, 0x06, 0x30, 0x01, 0xB8, 0x00,
  0xD8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x06, 0xC0,
  0x07, 0x30, 0x03, 0x18, 0x03, 0x86, 0x01, 0x83, 0x81, 0xC0, 0xC0, 0xC0,
  0x70, 0xC0, 0x18, 0x60, 0x0E, 0x60, 0x03, 0x70, 0x01, 0xC0, 0xC0, 0x01,
  0xF0, 0x01, 0x98, 0x00, 0xCE, 0x00, 0xC3, 0x00, 0x61, 0xC0, 0x70, 0x60,
  0x30, 0x30, 0x38, 0x0C, 0x18, 0x06, 0x1C, 0x01, 0x8C, 0x00, 0xC6, 0x00,
  0x36, 0x00, 0x1B, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF1, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xFF, 0xC0, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0xFF, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0xFF, 0xC0, 0x06, 0x01, 0xC0, 0x38, 0x05, 0x81,
  0xB0, 0x36, 0x04, 0x61, 0x8C, 0x31, 0x84, 0x19, 0x83, 0x30, 0x66, 0x06,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0x83, 0x06, 0x18, 0x0F, 0x81, 0xFF, 0x1C,
  0x1C, 0xC0, 0x6C, 0x03, 0x60, 0x18, 0x00, 0xC0, 0x06, 0x0F, 0xF1, 0xFF,
  0x9C, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x0E, 0xE0, 0xF3,
  0xFD, 0x87, 0xC6, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xCF, 0x86, 0xFF, 0x3C, 0x19, 0x80, 0x6C, 0x03,
  0x60, 0x1B, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x1B, 0x00, 0xD8, 0x0E, 0xF0, 0xE6, 0xFE, 0x23, 0xE0, 0x0F,
  0x81, 0xFF, 0x1C, 0x1C, 0xC0, 0x6C, 0x03, 0x60, 0x0F, 0x00, 0x78, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x0F, 0x00, 0x6C,
  0x06, 0x70, 0x71, 0xFF, 0x03, 0xE0, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x0F, 0x99, 0xFE, 0xDC, 0x1E,
  0xC0, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x6C, 0x07, 0x70, 0x79, 0xFE,
  0xC3, 0xE6, 0x0F, 0x81, 0xFF, 0x1C, 0x1C, 0xC0, 0x6C, 0x03, 0x60, 0x0F,
  0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x02, 0x70, 0x39, 0xFF, 0x83, 0xF0, 0x07, 0xC3, 0xF0,
  0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0xFF, 0xBF, 0xE1, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x0F, 0x99, 0xFE, 0xDC, 0x1E,
  0xC0, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x6C, 0x07, 0x70, 0x79, 0xFE,
  0xC3, 0xE6, 0x00, 0x30, 0x01, 0x80, 0x0D, 0x00, 0xCE, 0x0E, 0x3F, 0xE0,
  0x7C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xCF, 0x8D, 0xFC, 0xF0, 0xEE, 0x06, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0C, 0x70, 0xC0, 0x00, 0x00, 0x03, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x71, 0xBE, 0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x6C, 0x0C, 0xC1, 0x8C, 0x38, 0xC7, 0x0C, 0x60,
  0xCC, 0x0D, 0x80, 0xF8, 0x0F, 0xC0, 0xEE, 0x0C, 0x60, 0xC3, 0x0C, 0x38,
  0xC1, 0x8C, 0x0C, 0xC0, 0xCC, 0x06, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x8F, 0x83, 0xE2, 0x7F, 0x1F, 0xCB, 0x0E, 0xC1, 0xB8,
  0x1E, 0x07, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C,
  0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03,
  0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0,
  0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xC0, 0xCF, 0x8D, 0xFC, 0xF0,
  0xEE, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x30, 0x0F, 0xC0, 0xFF, 0x83, 0x07, 0x18, 0x0E, 0x60, 0x1B, 0x00, 0x6C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x66, 0x01, 0x98, 0x0E, 0x30, 0x70, 0x7F, 0x80, 0xFC, 0x00, 0x8F,
  0x84, 0xFF, 0x3C, 0x39, 0x80, 0xEC, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0x60, 0x1B, 0x00, 0xD8,
  0x0E, 0xE0, 0xE7, 0xFE, 0x33, 0xE1, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x1F, 0x99, 0xFE, 0xDC, 0x1E, 0xC0,
  0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x6C, 0x07, 0x70, 0x79, 0xFE, 0xC3,
  0xE6, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0xCF, 0xBF, 0xC7, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x00, 0x1F, 0x83, 0xFC, 0x70, 0xE6, 0x07,
  0xC0, 0x3C, 0x03, 0x60, 0x07, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xC0, 0x0E,
  0x00, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x60, 0x63, 0xFE, 0x1F, 0x80, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1F, 0x0F, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xE0,
  0xF7, 0xFB, 0x3E, 0x30, 0xC0, 0x1E, 0x00, 0xD8, 0x06, 0xC0, 0x66, 0x03,
  0x18, 0x18, 0xC1, 0x86, 0x0C, 0x10, 0x60, 0xC2, 0x06, 0x30, 0x11, 0x80,
  0xC8, 0x06, 0xC0, 0x36, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0xC0,
  0x30, 0x1B, 0x03, 0x80, 0xD8, 0x1C, 0x06, 0xC0, 0xE0, 0x66, 0x05, 0x83,
  0x10, 0x6C, 0x18, 0xC3, 0x60, 0xC6, 0x19, 0x0C, 0x30, 0x8C, 0x60, 0x8C,
  0x63, 0x06, 0x61, 0x18, 0x33, 0x0C, 0x81, 0x90, 0x6C, 0x05, 0x83, 0x60,
  0x3C, 0x0B, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x30, 0x1C, 0x01, 0x80,
  0x60, 0x60, 0x1B, 0x01, 0x8C, 0x0C, 0x60, 0xC1, 0x8E, 0x0E, 0x60, 0x36,
  0x00, 0xF0, 0x07, 0x00, 0x18, 0x01, 0xC0, 0x1B, 0x00, 0xCC, 0x0C, 0x60,
  0x61, 0x86, 0x0C, 0x70, 0x33, 0x01, 0xF8, 0x06, 0xC0, 0x1E, 0x00, 0xD8,
  0x0E, 0xC0, 0x66, 0x03, 0x18, 0x18, 0xC1, 0x86, 0x0C, 0x18, 0x60, 0xC6,
  0x06, 0x30, 0x19, 0x80, 0xC8, 0x06, 0xC0, 0x16, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x80, 0x78,
  0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18,
  0x03, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x70, 0x06, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x81, 0xC1, 0x80,
  0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x60, 0x70, 0xF0, 0x78, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0xE0, 0x70, 0x30,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x0C,
  0x07, 0x07, 0x0E, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x30, 0x30, 0x60, 0xE0, 0x80, 0x1E, 0x01, 0x9F, 0x80, 0xD8,
  0x70, 0x6C, 0x1C, 0x64, 0x07, 0xE6, 0x01, 0xE0,
};

const GFXglyph RobotoCondensed_Light36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 26, 8, 3, -26 },
  { 8, 5, 8, 10, 3, -27 },
  { 13, 16, 26, 19, 2, -26 },
  { 65, 13, 33, 18, 2, -30 },
  { 119, 19, 26, 23, 2, -26 },
  { 181, 17, 26, 19, 2, -26 },
  { 237, 2, 8, 6, 2, -27 },
  { 239, 8, 37, 11, 2, -29 },
  { 276, 7, 37, 11, 1, -29 },
  { 309, 14, 14, 15, 1, -26 },
  { 334, 15, 18, 18, 1, -21 },
  { 368, 4, 8, 7, 1, -3 },
  { 372, 7, 2, 9, 1, -12 },
  { 374, 3, 3, 9, 3, -3 },
  { 376, 10, 28, 13, 1, -26 },
  { 411, 13, 26, 18, 2, -26 },
  { 454, 8, 26, 18, 3, -26 },
  { 480, 14, 26, 18, 2, -26 },
  { 526, 13, 26, 18, 2, -26 },
  { 569, 16, 26, 18, 1, -26 },
  { 621, 13, 26, 18, 3, -26 },
  { 664, 14, 26, 18, 2, -26 },
  { 710, 15, 26, 18, 1, -26 },
  { 759, 14, 26, 18, 2, -26 },
  { 805, 13, 26, 18, 2, -26 },
  { 848, 3, 19, 7, 2, -19 },
  { 856, 4, 24, 7, 1, -19 },
  { 868, 13, 15, 16, 1, -19 },
  { 893, 12, 10, 17, 3, -17 },
  { 908, 13, 15, 16, 2, -19 },
  { 933, 11, 26, 15, 2, -26 },
  { 969, 24, 33, 28, 2, -25 },
  { 1068, 18, 26, 20, 1, -26 },
  { 1127, 14, 26, 19, 3, -26 },
  { 1173, 16, 26, 20, 2, -26 },
  { 1225, 15, 26, 21, 3, -26 },
  { 1274, 13, 26, 18, 3, -26 },
  { 1317, 13, 26, 18, 3, -26 },
  { 1360, 16, 26, 21, 3, -26 },
  { 1412, 16, 26, 22, 3, -26 },
  { 1464, 2, 26, 9, 3, -26 },
  { 1471, 13, 26, 17, 1, -26 },
  { 1514, 16, 26, 20, 3, -26 },
  { 1566, 13, 26, 17, 3, -26 },
  { 1609, 21, 26, 27, 3, -26 },
  { 1678, 16, 26, 22, 3, -26 },
  { 1730, 17, 26, 21, 2, -26 },
  { 1786, 15, 26, 19, 3, -26 },
  { 1835, 17, 30, 21, 2, -26 },
  { 1899, 15, 26, 20, 3, -26 },
  { 1948, 15, 26, 19, 2, -26 },
  { 1997, 17, 26, 19, 1, -26 },
  { 2053, 15, 26, 21, 3, -26 },
  { 2102, 18, 26, 19, 1, -26 },
  { 2161, 26, 26, 28, 1, -26 },
  { 2246, 17, 26, 19, 1, -26 },
  { 2302, 17, 26, 19, 1, -26 },
  { 2358, 15, 26, 19, 2, -26 },
  { 2407, 5, 34, 8, 3, -29 },
  { 2429, 11, 28, 13, 1, -26 },
  { 2468, 5, 34, 8, 0, -29 },
  { 2490, 11, 13, 13, 1, -26 },
  { 2508, 14, 2, 14, 0, 0 },
  { 2512, 6, 5, 10, 2, -27 },
  { 2516, 13, 19, 17, 2, -19 },
  { 2547, 13, 27, 18, 3, -27 },
  { 2591, 13, 19, 16, 2, -19 },
  { 2622, 13, 27, 18, 2, -27 },
  { 2666, 13, 19, 16, 2, -19 },
  { 2697, 10, 27, 11, 1, -27 },
  { 2731, 13, 26, 18, 2, -19 },
  { 2774, 12, 27, 17, 3, -27 },
  { 2815, 2, 26, 8, 3, -26 },
  { 2822, 6, 33, 8, -1, -26 },
  { 2847, 12, 27, 16, 3, -27 },
  { 2888, 2, 27, 8, 3, -27 },
  { 2895, 22, 19, 27, 3, -19 },
  { 2948, 12, 19, 17, 3, -19 },
  { 2977, 14, 19, 18, 2, -19 },
  { 3011, 13, 26, 18, 3, -19 },
  { 3054, 13, 26, 18, 2, -19 },
  { 3097, 7, 19, 11, 3, -19 },
  { 3114, 12, 19, 16, 2, -19 },
  { 3143, 8, 24, 10, 1, -24 },
  { 3167, 12, 19, 17, 3, -19 },
  { 3196, 13, 19, 15, 1, -19 },
  { 3227, 21, 19, 24, 1, -19 },
  { 3277, 13, 19, 15, 1, -19 },
  { 3308, 13, 26, 15, 1, -19 },
  { 3351, 12, 19, 15, 2, -19 },
  { 3380, 9, 35, 11, 1, -28 },
  { 3420, 2, 31, 8, 3, -26 },
  { 3428, 8, 35, 11, 1, -28 },
  { 3463, 17, 6, 21, 2, -13 },
};

const GFXfont RobotoCondensed_Light36pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light36pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light36pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOCONDENSED_LIGHT36PT7B_H_
