#ifndef _ROBOTOCONDENSED_LIGHT33PT7B_H_
#define _ROBOTOCONDENSED_LIGHT33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light33pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x00, 0x07, 0xD8, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0x80, 0x02, 0x18, 0x0C, 0x20, 0x18, 0x40, 0x30, 0x80,
  0x43, 0x00, 0x86, 0x1F, 0xFF, 0xBF, 0xFF, 0x0C, 0x20, 0x18, 0x40, 0x20,
  0x80, 0x43, 0x00, 0x86, 0x03, 0x0C, 0x06, 0x10, 0x7F, 0xFE, 0xFF, 0xFC,
  0x21, 0x80, 0x43, 0x00, 0x86, 0x03, 0x08, 0x06, 0x10, 0x08, 0x20, 0x00,
  0x02, 0x00, 0x20, 0x02, 0x00, 0xF8, 0x3F, 0xC7, 0x06, 0x60, 0x66, 0x03,
  0x40, 0x34, 0x03, 0x60, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0F, 0x80, 0x3C,
  0x00, 0xE0, 0x03, 0x00, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x37, 0x06,
  0x3F, 0xE0, 0xF8, 0x02, 0x00, 0x20, 0x02, 0x00, 0x38, 0x00, 0x37, 0x00,
  0x30, 0x80, 0x10, 0x41, 0x88, 0x30, 0x84, 0x18, 0xC2, 0x0C, 0x41, 0x04,
  0x60, 0xC2, 0x20, 0x37, 0x20, 0x0E, 0x30, 0x00, 0x10, 0x00, 0x18, 0xE0,
  0x08, 0xD8, 0x0C, 0xC6, 0x04, 0x41, 0x06, 0x20, 0x82, 0x10, 0x42, 0x08,
  0x23, 0x04, 0x10, 0x03, 0x18, 0x00, 0xD8, 0x00, 0x38, 0x0F, 0x00, 0x3F,
  0x00, 0xC3, 0x01, 0x82, 0x02, 0x04, 0x04, 0x08, 0x0C, 0x30, 0x18, 0xC0,
  0x33, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x03, 0x60, 0xCC, 0x61, 0xB0,
  0x63, 0x60, 0xE6, 0xC0, 0xC9, 0x80, 0xF3, 0x00, 0xE6, 0x01, 0xC6, 0x07,
  0x87, 0xF9, 0x87, 0xC1, 0x80, 0xFF, 0xE8, 0x02, 0x0C, 0x30, 0x41, 0x86,
  0x0C, 0x10, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x10, 0x30, 0x60, 0xC0, 0x81, 0x83, 0x03, 0x06, 0x06, 0x06,
  0x04, 0x83, 0x04, 0x18, 0x30, 0xC1, 0x86, 0x08, 0x20, 0xC3, 0x0C, 0x30,
  0x41, 0x04, 0x10, 0x41, 0x0C, 0x30, 0xC3, 0x0C, 0x21, 0x86, 0x10, 0xC2,
  0x18, 0xC2, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x63, 0x1B,
  0xFD, 0xF0, 0xFE, 0x00, 0xC0, 0x07, 0x80, 0x33, 0x01, 0x86, 0x06, 0x18,
  0x10, 0x20, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x6D, 0xB7, 0xB0, 0xFF,
  0xF0, 0x5D, 0x80, 0x00, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x20,
  0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x40, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x80, 0x00, 0x0F,
  0x03, 0xFC, 0x70, 0xE6, 0x06, 0x40, 0x2C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x40, 0x26, 0x06, 0x70, 0xE3, 0xFC, 0x0F, 0x00, 0x06, 0x3D,
  0xFF, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x1F, 0x01, 0xFE, 0x18, 0x39,
  0x80, 0xCC, 0x02, 0x60, 0x1B, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0x03, 0xFC,
  0x60, 0xEC, 0x06, 0xC0, 0x3C, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0E,
  0x0F, 0x80, 0xF8, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x3C, 0x03,
  0xC0, 0x3C, 0x02, 0x60, 0x63, 0xFC, 0x1F, 0x80, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0x60, 0x0D, 0x80, 0x26, 0x01, 0x98, 0x0C, 0x60,
  0x31, 0x81, 0x86, 0x06, 0x18, 0x30, 0x60, 0x81, 0x86, 0x06, 0x3F, 0xFF,
  0xFF, 0xFC, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x7F, 0xE7, 0xFE, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xDF, 0x0F, 0xFC, 0xE0, 0xC0, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x03, 0x80, 0x3C, 0x02, 0xC0, 0x6C, 0x06, 0x60, 0xC3, 0xFC, 0x1F, 0x00,
  0x03, 0xC0, 0xFC, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0x60, 0x04, 0x00,
  0xCF, 0x8D, 0xFC, 0xF0, 0x6E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0x60, 0x36, 0x03, 0x30, 0x61, 0xFC, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x00, 0x0F, 0x83, 0xFC, 0x70, 0xE6, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0x60, 0x67, 0x06, 0x3F, 0xC1, 0xF8, 0x70, 0xE6, 0x06, 0xC0, 0x3C,
  0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x60, 0x63, 0xFC, 0x1F, 0x80,
  0x1F, 0x03, 0xFC, 0x60, 0xC6, 0x06, 0xC0, 0x6C, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x60, 0xF3, 0xFB, 0x1F, 0x30, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x0C, 0x03, 0x83, 0xF0, 0x3C, 0x00, 0x5F,
  0x80, 0x00, 0x00, 0x00, 0x02, 0xFC, 0x27, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x22, 0x66, 0x4C, 0x00, 0x10, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x03, 0x01, 0xC0, 0xE0, 0x78, 0x3C, 0x0E, 0x01, 0x00, 0x00, 0x0F,
  0x07, 0xF1, 0xC3, 0x30, 0x34, 0x07, 0x80, 0xC0, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x1C, 0x03, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x70, 0x0C, 0x03, 0x00, 0x18, 0x18, 0x00, 0x30, 0xC0, 0x00, 0x63,
  0x00, 0x01, 0x98, 0x0F, 0x02, 0x60, 0x7E, 0x0D, 0x03, 0x08, 0x34, 0x18,
  0x20, 0xF0, 0x40, 0x81, 0xC1, 0x02, 0x07, 0x0C, 0x08, 0x18, 0x30, 0x20,
  0x60, 0xC1, 0x81, 0x82, 0x06, 0x0E, 0x08, 0x18, 0x3C, 0x30, 0x60, 0xB0,
  0xC3, 0x82, 0xC3, 0x0A, 0x19, 0x07, 0xCD, 0xC4, 0x0E, 0x1E, 0x18, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0xDE, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x80, 0x01, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x02, 0x40, 0x06, 0x60, 0x06, 0x60, 0x06, 0x20, 0x0C, 0x30,
  0x0C, 0x30, 0x0C, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x0C,
  0x3F, 0xFC, 0x3F, 0xFC, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x40, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xFF, 0x87, 0xFE, 0x30, 0x19, 0x80, 0x6C, 0x03,
  0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x36, 0x03, 0x3F, 0xF1, 0xFF, 0x8C,
  0x06, 0x60, 0x1B, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x6C, 0x07, 0x7F, 0xF3, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0x63,
  0x80, 0x66, 0x00, 0xCC, 0x00, 0xB0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x03,
  0xC0, 0x06, 0xC0, 0x0D, 0x80, 0x33, 0x80, 0x63, 0x81, 0x83, 0xFE, 0x01,
  0xF0, 0x00, 0xFF, 0x03, 0xFF, 0x0C, 0x06, 0x30, 0x0C, 0xC0, 0x1B, 0x00,
  0x6C, 0x01, 0xB0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB0,
  0x0C, 0xC0, 0x63, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xEF,
  0xFE, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xEF, 0xFE,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xE0, 0x73, 0x80,
  0x66, 0x00, 0x6C, 0x00, 0xD0, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0x40,
  0x06, 0xC0, 0x0D, 0x80, 0x19, 0x80, 0x33, 0x80, 0xE3, 0xFF, 0x81, 0xFC,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x07, 0x70, 0x63, 0xFC, 0x0F, 0x80, 0xC0,
  0x1B, 0x00, 0xEC, 0x07, 0x30, 0x18, 0xC0, 0xC3, 0x06, 0x0C, 0x38, 0x31,
  0xC0, 0xC6, 0x03, 0x30, 0x0D, 0xC0, 0x3F, 0x80, 0xF6, 0x03, 0x8C, 0x0C,
  0x38, 0x30, 0x60, 0xC0, 0xC3, 0x03, 0x8C, 0x06, 0x30, 0x0C, 0xC0, 0x3B,
  0x00, 0x6C, 0x00, 0xC0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF, 0xFF, 0xF8,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xD0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x06, 0xF4, 0x00, 0xDE, 0xC0, 0x1B, 0xD8, 0x06, 0x79, 0x80, 0xCF,
  0x30, 0x19, 0xE6, 0x06, 0x3C, 0x60, 0xC7, 0x8C, 0x10, 0xF0, 0x86, 0x1E,
  0x18, 0xC3, 0xC3, 0x10, 0x78, 0x26, 0x0F, 0x06, 0xC1, 0xE0, 0xD0, 0x3C,
  0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x30, 0x18, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x7B, 0x00, 0xF6, 0x01, 0xE6, 0x03, 0xC4, 0x07,
  0x8C, 0x0F, 0x0C, 0x1E, 0x18, 0x3C, 0x18, 0x78, 0x30, 0xF0, 0x31, 0xE0,
  0x63, 0xC0, 0x67, 0x80, 0x6F, 0x00, 0xDE, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0x80, 0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0x63, 0x80, 0x66, 0x00,
  0x6C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x06, 0xC0,
  0x0D, 0x80, 0x1B, 0x80, 0x63, 0x81, 0x83, 0xFE, 0x01, 0xF8, 0x00, 0xFF,
  0x87, 0xFF, 0x30, 0x1D, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0xEF, 0xFE, 0x7F, 0xE3, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0x63, 0x80, 0x66, 0x00, 0xD8, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0D, 0x80,
  0x33, 0x80, 0x63, 0x81, 0x83, 0xFE, 0x01, 0xFC, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x10, 0xFF, 0x83, 0xFF, 0x8C, 0x07, 0x30, 0x0C, 0xC0,
  0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0xCC, 0x07, 0x3F,
  0xF8, 0xFF, 0x83, 0x06, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0x63, 0x01, 0x8C,
  0x03, 0x30, 0x0C, 0xC0, 0x1B, 0x00, 0x6C, 0x00, 0xC0, 0x07, 0xE0, 0x3F,
  0xE0, 0xE0, 0x61, 0x80, 0x66, 0x00, 0xCC, 0x00, 0x98, 0x01, 0xB0, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x40, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x80, 0x63, 0x81,
  0xC3, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x05, 0x00, 0x36, 0x00, 0xD8, 0x03,
  0x30, 0x18, 0x7F, 0xC0, 0xFC, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x08,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30,
  0x04, 0x60, 0x06, 0x60, 0x06, 0x60, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0xC0, 0x18, 0x07, 0x80, 0x30, 0x0D, 0x80, 0xE0,
  0x1B, 0x01, 0xE0, 0x36, 0x03, 0xC0, 0x4C, 0x05, 0x81, 0x88, 0x19, 0x03,
  0x18, 0x32, 0x06, 0x30, 0x66, 0x0C, 0x60, 0x8C, 0x10, 0xC3, 0x08, 0x60,
  0x86, 0x10, 0xC1, 0x8C, 0x31, 0x83, 0x10, 0x63, 0x06, 0x60, 0x44, 0x04,
  0xC0, 0x98, 0x0D, 0x81, 0xB0, 0x1A, 0x03, 0x60, 0x3C, 0x02, 0x80, 0x78,
  0x05, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x00, 0x60,
  0x06, 0x60, 0x0E, 0x30, 0x0C, 0x30, 0x18, 0x18, 0x18, 0x1C, 0x30, 0x0C,
  0x30, 0x06, 0x60, 0x06, 0x60, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x03,
  0xC0, 0x07, 0xC0, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x30, 0x18, 0x30, 0x18,
  0x18, 0x30, 0x1C, 0x70, 0x0C, 0x60, 0x06, 0xE0, 0x06, 0xC0, 0x06, 0xC0,
  0x06, 0x60, 0x0C, 0x60, 0x0C, 0x30, 0x18, 0x30, 0x18, 0x18, 0x30, 0x18,
  0x30, 0x0C, 0x60, 0x0C, 0x60, 0x06, 0x40, 0x06, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFB, 0xFF, 0xE0, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0xFF, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x20, 0x0C,
  0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60,
  0x18, 0x02, 0x00, 0xC0, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFF,
  0x0C, 0x03, 0x00, 0xE0, 0x78, 0x12, 0x04, 0xC3, 0x30, 0xC4, 0x21, 0x98,
  0x66, 0x09, 0x03, 0xFF, 0xFF, 0xFF, 0xC3, 0x1C, 0x61, 0x80, 0x1F, 0x83,
  0xFC, 0x60, 0xEC, 0x06, 0xC0, 0x60, 0x06, 0x00, 0x61, 0xFE, 0x7F, 0xEE,
  0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC1, 0xE7, 0xF6, 0x3E, 0x60,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xCF, 0x8D, 0xFE, 0xF0, 0x6E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xF0, 0x6D, 0xFE,
  0xCF, 0x80, 0x1F, 0x03, 0xFC, 0x60, 0xEC, 0x06, 0xC0, 0x2C, 0x03, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x03, 0xC0, 0x2C, 0x06, 0x60,
  0xE3, 0xFC, 0x1F, 0x00, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x1F, 0x33, 0xFB, 0x60, 0xFC, 0x07, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0x60, 0xF3, 0xFB, 0x1F, 0x30, 0x1F, 0x03, 0xFC, 0x60, 0xEC, 0x06,
  0xC0, 0x2C, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x63, 0xFE, 0x1F, 0x80, 0x07, 0x87, 0xC6, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x20, 0xFF, 0x7F, 0x84, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x00, 0x1F, 0x33, 0xFB, 0x60, 0xFC, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x60, 0xF3,
  0xFB, 0x1F, 0x30, 0x03, 0x00, 0x30, 0x03, 0x40, 0x66, 0x06, 0x3F, 0xC1,
  0xF8, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC7, 0x8D, 0xFC, 0xF0, 0x6E, 0x06, 0xE0, 0x2C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x30, 0x5D, 0x00, 0x02, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92,
  0x08, 0x71, 0x80, 0x00, 0x00, 0x02, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x21, 0x86, 0x1B, 0xEE, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x6C, 0x0C, 0xC1, 0x8C, 0x30, 0xC7, 0x0C, 0xE0, 0xCC, 0x0D, 0x80,
  0xFC, 0x0E, 0x60, 0xC6, 0x0C, 0x30, 0xC1, 0x8C, 0x1C, 0xC0, 0xCC, 0x06,
  0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0x80, 0xC7, 0x83, 0xC6, 0xFE, 0x7F, 0xBC,
  0x1A, 0x0D, 0xC0, 0xE0, 0x3C, 0x03, 0x01, 0xE0, 0x18, 0x0F, 0x00, 0x80,
  0x78, 0x04, 0x03, 0xC0, 0x20, 0x1E, 0x01, 0x00, 0xF0, 0x08, 0x07, 0x80,
  0x40, 0x3C, 0x02, 0x01, 0xE0, 0x10, 0x0F, 0x00, 0x80, 0x78, 0x04, 0x03,
  0xC0, 0x20, 0x18, 0xC7, 0x8D, 0xFC, 0xF0, 0x6E, 0x06, 0xE0, 0x2C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x30, 0x1F, 0x83, 0xFC, 0x70, 0x6E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x36, 0x03, 0x70, 0x63, 0xFC, 0x1F, 0x80, 0xCF, 0x8D, 0xFE, 0xF0, 0x6E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3E, 0x03, 0xF0, 0x6D, 0xFC, 0xCF, 0x8C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x1F, 0x33, 0xFB, 0x60, 0xFC,
  0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0x60, 0xF3, 0xFB, 0x1F, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xCF, 0xBF, 0xC7, 0x0E, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x1F, 0x0F,
  0xF1, 0x83, 0x60, 0x3C, 0x07, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x00, 0x3C, 0x07, 0x80, 0xF8, 0x33, 0xFE, 0x1F, 0x00, 0x30, 0x60,
  0xC1, 0x83, 0x1F, 0xFF, 0x98, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x81, 0xE1, 0xC0, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x36, 0x07, 0x60, 0xF3, 0xFB, 0x1F, 0x30, 0xC0, 0x3C, 0x03, 0x40,
  0x26, 0x06, 0x60, 0x62, 0x04, 0x30, 0xC3, 0x0C, 0x10, 0x81, 0x98, 0x19,
  0x80, 0x98, 0x09, 0x00, 0xF0, 0x0F, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x60,
  0x78, 0x0C, 0x0D, 0x83, 0x81, 0xB0, 0x70, 0x26, 0x0B, 0x0C, 0xC3, 0x61,
  0x8C, 0x64, 0x31, 0x8C, 0xC4, 0x31, 0x18, 0x86, 0x63, 0x30, 0x4C, 0x26,
  0x0D, 0x06, 0x81, 0xA0, 0xD0, 0x3C, 0x0E, 0x03, 0x81, 0xC0, 0x60, 0x30,
  0x0C, 0x06, 0x00, 0xE0, 0x36, 0x06, 0x30, 0xE3, 0x0C, 0x19, 0x81, 0x98,
  0x0F, 0x00, 0x70, 0x06, 0x00, 0xF0, 0x0F, 0x01, 0x98, 0x18, 0xC3, 0x0C,
  0x60, 0x66, 0x06, 0xC0, 0x30, 0xC0, 0x3C, 0x03, 0x40, 0x66, 0x06, 0x60,
  0x62, 0x04, 0x30, 0xC3, 0x0C, 0x30, 0x81, 0x98, 0x19, 0x81, 0x98, 0x0D,
  0x00, 0xF0, 0x0F, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x78, 0x07, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0,
  0x30, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0x07, 0x06, 0x0C, 0x0C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0xF0, 0xE0, 0x30, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x0C, 0x06, 0x07,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0x30, 0x0C, 0x03,
  0x01, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x18, 0x0F, 0x03, 0x83, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x02, 0x03, 0x01, 0x81, 0x81, 0xC0, 0x80, 0x1C, 0x02, 0x7E, 0x05,
  0x8E, 0x1A, 0x0E, 0x3C, 0x0F, 0xD8, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_Light33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 23, 7, 2, -23 },
  { 10, 6, 7, 9, 2, -25 },
  { 16, 15, 23, 17, 2, -23 },
  { 60, 12, 29, 16, 2, -26 },
  { 104, 17, 23, 21, 2, -23 },
  { 153, 15, 23, 18, 2, -23 },
  { 197, 2, 7, 6, 2, -25 },
  { 199, 7, 34, 10, 2, -26 },
  { 229, 6, 34, 10, 1, -26 },
  { 255, 14, 13, 14, 0, -23 },
  { 278, 14, 17, 16, 1, -19 },
  { 308, 3, 7, 6, 1, -3 },
  { 311, 6, 2, 9, 1, -12 },
  { 313, 3, 3, 8, 2, -3 },
  { 315, 10, 25, 12, 1, -23 },
  { 347, 12, 23, 16, 2, -23 },
  { 382, 7, 23, 16, 3, -23 },
  { 403, 13, 23, 16, 2, -23 },
  { 441, 12, 23, 16, 2, -23 },
  { 476, 14, 23, 16, 1, -23 },
  { 517, 12, 23, 16, 3, -23 },
  { 552, 12, 23, 16, 2, -23 },
  { 587, 13, 23, 16, 1, -23 },
  { 625, 12, 23, 16, 2, -23 },
  { 660, 12, 23, 16, 2, -23 },
  { 695, 3, 18, 7, 2, -18 },
  { 702, 4, 22, 6, 1, -18 },
  { 713, 12, 13, 15, 1, -17 },
  { 733, 12, 9, 16, 2, -15 },
  { 747, 11, 14, 15, 2, -18 },
  { 767, 11, 23, 13, 1, -23 },
  { 799, 22, 30, 26, 2, -23 },
  { 882, 16, 23, 18, 1, -23 },
  { 928, 13, 23, 18, 3, -23 },
  { 966, 15, 23, 19, 2, -23 },
  { 1010, 14, 23, 19, 3, -23 },
  { 1051, 12, 23, 16, 3, -23 },
  { 1086, 12, 23, 16, 3, -23 },
  { 1121, 15, 23, 20, 2, -23 },
  { 1165, 14, 23, 20, 3, -23 },
  { 1206, 2, 23, 8, 3, -23 },
  { 1212, 12, 23, 16, 1, -23 },
  { 1247, 14, 23, 18, 3, -23 },
  { 1288, 11, 23, 15, 3, -23 },
  { 1320, 19, 23, 25, 3, -23 },
  { 1375, 15, 23, 20, 3, -23 },
  { 1419, 15, 23, 19, 2, -23 },
  { 1463, 13, 23, 18, 3, -23 },
  { 1501, 15, 27, 19, 2, -23 },
  { 1552, 14, 23, 18, 3, -23 },
  { 1593, 15, 23, 17, 1, -23 },
  { 1637, 15, 23, 17, 1, -23 },
  { 1681, 14, 23, 19, 2, -23 },
  { 1722, 16, 23, 18, 1, -23 },
  { 1768, 23, 23, 25, 1, -23 },
  { 1835, 16, 23, 18, 1, -23 },
  { 1881, 16, 23, 17, 1, -23 },
  { 1927, 14, 23, 17, 2, -23 },
  { 1968, 5, 32, 7, 2, -27 },
  { 1988, 10, 25, 12, 1, -23 },
  { 2020, 5, 32, 7, 0, -27 },
  { 2040, 10, 12, 12, 1, -23 },
  { 2055, 12, 2, 13, 0, 0 },
  { 2058, 5, 5, 9, 2, -25 },
  { 2062, 12, 17, 16, 2, -17 },
  { 2088, 12, 25, 16, 2, -25 },
  { 2126, 12, 17, 15, 2, -17 },
  { 2152, 12, 25, 16, 2, -25 },
  { 2190, 12, 17, 15, 2, -17 },
  { 2216, 9, 25, 10, 1, -25 },
  { 2245, 12, 24, 16, 2, -17 },
  { 2281, 12, 25, 16, 2, -25 },
  { 2319, 3, 24, 7, 2, -24 },
  { 2328, 6, 31, 7, -1, -24 },
  { 2352, 12, 25, 14, 2, -25 },
  { 2390, 1, 25, 7, 3, -25 },
  { 2394, 21, 17, 25, 2, -17 },
  { 2439, 12, 17, 16, 2, -17 },
  { 2465, 12, 17, 16, 2, -17 },
  { 2491, 12, 24, 16, 2, -17 },
  { 2527, 12, 24, 16, 2, -17 },
  { 2563, 7, 17, 10, 2, -17 },
  { 2578, 11, 17, 15, 2, -17 },
  { 2602, 7, 22, 10, 1, -22 },
  { 2622, 12, 17, 16, 2, -17 },
  { 2648, 12, 17, 14, 1, -17 },
  { 2674, 19, 17, 22, 1, -17 },
  { 2715, 12, 17, 14, 1, -17 },
  { 2741, 12, 24, 14, 1, -17 },
  { 2777, 11, 17, 14, 2, -17 },
  { 2801, 8, 32, 10, 1, -26 },
  { 2833, 2, 27, 7, 3, -23 },
  { 2840, 9, 32, 10, 0, -26 },
  { 2876, 15, 6, 20, 2, -13 },
};

const GFXfont RobotoCondensed_Light33pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light33pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light33pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _ROBOTOCONDENSED_LIGHT33PT7B_H_
