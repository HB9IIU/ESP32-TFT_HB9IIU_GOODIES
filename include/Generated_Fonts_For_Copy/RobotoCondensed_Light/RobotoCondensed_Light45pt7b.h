#ifndef _ROBOTOCONDENSED_LIGHT45PT7B_H_
#define _ROBOTOCONDENSED_LIGHT45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light45pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x00, 0x00, 0x00, 0x6E, 0xF6, 0xC7, 0xC7, 0xC7, 0xC7, 0xC6, 0xC6, 0xC6,
  0xC6, 0xC6, 0xC6, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01,
  0x83, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30,
  0x01, 0x81, 0x81, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x03, 0x06, 0x00, 0x30,
  0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x80, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x60, 0x60, 0x03,
  0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0x60,
  0x03, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07,
  0xE0, 0x1F, 0xF8, 0x3E, 0x7C, 0x38, 0x1E, 0x70, 0x0E, 0x60, 0x07, 0x60,
  0x07, 0x60, 0x07, 0x60, 0x03, 0x60, 0x03, 0x60, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x07, 0x70, 0x07, 0x78, 0x0E, 0x3F, 0x7C, 0x1F,
  0xF8, 0x07, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x18, 0x00, 0x06,
  0x06, 0x02, 0x06, 0x03, 0x03, 0x03, 0x01, 0x81, 0x81, 0x80, 0xC1, 0x80,
  0xC0, 0x60, 0xC0, 0x60, 0x30, 0xC0, 0x18, 0x18, 0xE0, 0x0C, 0x18, 0x60,
  0x03, 0x1C, 0x60, 0x01, 0xFC, 0x30, 0x00, 0x3C, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x3C, 0x00, 0x0C, 0x3F, 0x80, 0x06,
  0x30, 0xC0, 0x06, 0x38, 0x30, 0x07, 0x18, 0x18, 0x03, 0x0C, 0x0C, 0x03,
  0x06, 0x02, 0x01, 0x83, 0x01, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x60, 0x60, 0x20, 0x38, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xCF, 0x00, 0x38,
  0x18, 0x01, 0xC0, 0xE0, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x01, 0xC0,
  0x18, 0x0C, 0x00, 0xE0, 0xE0, 0x07, 0x06, 0x00, 0x1C, 0xF0, 0x00, 0xEF,
  0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0xE7, 0x01, 0x8E, 0x1C, 0x0C, 0xE0, 0xE0, 0x67, 0x03, 0x87, 0x30, 0x0E,
  0x33, 0x80, 0x31, 0x9C, 0x01, 0xDC, 0xE0, 0x07, 0xE3, 0x00, 0x1E, 0x18,
  0x00, 0xE0, 0xE0, 0x07, 0x83, 0x80, 0x7E, 0x1F, 0x1F, 0x38, 0x3F, 0xF1,
  0xC0, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0xC0, 0xC0, 0xE0, 0x60,
  0x60, 0x30, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x80,
  0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x04, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0,
  0x70, 0x18, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03,
  0x81, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x38, 0x18, 0x18, 0x0C, 0x0C, 0x0C,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x20, 0x30, 0x2E, 0x0C, 0x3B, 0xF3, 0x7E, 0x3F, 0xFE, 0x01, 0xFC,
  0x00, 0x1C, 0x00, 0x0D, 0x80, 0x07, 0x70, 0x03, 0x8E, 0x00, 0xC1, 0xC0,
  0x70, 0x70, 0x38, 0x0E, 0x04, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x39, 0xCE, 0x73, 0x9C, 0xCE, 0x62, 0x00, 0xFF, 0xFF, 0xC0, 0x6F,
  0xF6, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x00, 0x07, 0xE0,
  0x1F, 0xF0, 0x3C, 0x78, 0x38, 0x1C, 0x70, 0x0E, 0x60, 0x06, 0xE0, 0x06,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x06, 0x60, 0x06, 0x70, 0x0E, 0x38, 0x1C, 0x3E, 0x7C, 0x1F, 0xF8,
  0x07, 0xE0, 0x00, 0x81, 0xC7, 0xEF, 0xFF, 0x1E, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xE3, 0xE0, 0xE0, 0x38, 0x30,
  0x07, 0x1C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0xFD,
  0xFF, 0xFF, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x8F, 0x87, 0x01, 0xC3, 0x00,
  0x73, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x07, 0x60, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xD8, 0x00, 0xEE,
  0x00, 0x63, 0x80, 0x70, 0xF0, 0xF0, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xDC,
  0x00, 0x3B, 0x80, 0x06, 0x70, 0x01, 0xCE, 0x00, 0x31, 0xC0, 0x0E, 0x38,
  0x01, 0x87, 0x00, 0x70, 0xE0, 0x0C, 0x1C, 0x03, 0x03, 0x80, 0xE0, 0x70,
  0x18, 0x0E, 0x07, 0x01, 0xC0, 0xC0, 0x38, 0x38, 0x07, 0x06, 0x00, 0xE1,
  0xC0, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x1F, 0xFF, 0x0F, 0xFF, 0x86, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x7E, 0x03, 0xFF, 0x81, 0xFB, 0xE1, 0xE0, 0x38, 0x20, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0xC0, 0x07, 0x60, 0x03, 0xB0, 0x01, 0x9C, 0x01, 0xC6,
  0x00, 0xE3, 0x80, 0xE0, 0xF1, 0xF0, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x78,
  0x01, 0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x7E, 0x0E,
  0xFF, 0x86, 0xF1, 0xE3, 0xE0, 0x39, 0xE0, 0x0C, 0xE0, 0x07, 0x70, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x06, 0xE0, 0x03, 0x30, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC3, 0x80, 0xE0,
  0xF1, 0xE0, 0x3F, 0xE0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xE3,
  0xE0, 0xF0, 0x3C, 0x38, 0x07, 0x1C, 0x00, 0xC7, 0x00, 0x39, 0xC0, 0x0E,
  0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x38, 0xC0, 0x0C, 0x38, 0x07, 0x07,
  0x03, 0x81, 0xF3, 0xC0, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0x07, 0x83, 0x80,
  0x71, 0xC0, 0x0E, 0x60, 0x03, 0x98, 0x00, 0x6E, 0x00, 0x1B, 0x80, 0x07,
  0xE0, 0x01, 0x98, 0x00, 0x67, 0x00, 0x39, 0xC0, 0x0E, 0x38, 0x07, 0x07,
  0x87, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0x8F,
  0x07, 0x01, 0xC3, 0x00, 0x63, 0x80, 0x39, 0x80, 0x0C, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1B, 0x00, 0x1D,
  0x80, 0x0E, 0xE0, 0x07, 0x70, 0x07, 0x9C, 0x06, 0xC7, 0x8E, 0x61, 0xFE,
  0x70, 0x7E, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x1F, 0x80, 0x3F, 0x80,
  0x1E, 0x00, 0x6F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x6F, 0xFE, 0x11, 0xCE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x9C, 0xE7, 0x39, 0xCC, 0xE6, 0x30, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0C,
  0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0,
  0x01, 0xC0, 0x02, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0xCF, 0x9C, 0x0E,
  0x60, 0x1F, 0x80, 0x7E, 0x00, 0xF0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x06, 0x07, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x63, 0x00, 0x3C, 0x01, 0x98, 0x03, 0xFC, 0x06, 0x60, 0x1C,
  0x38, 0x19, 0x80, 0xE0, 0x60, 0x2E, 0x03, 0x01, 0x80, 0xF0, 0x18, 0x06,
  0x03, 0xC0, 0x60, 0x38, 0x0F, 0x01, 0x80, 0xC0, 0x3C, 0x0C, 0x03, 0x00,
  0xF0, 0x30, 0x0C, 0x03, 0xC0, 0xC0, 0x30, 0x0F, 0x03, 0x00, 0xC0, 0x3C,
  0x0C, 0x03, 0x00, 0xB0, 0x30, 0x0C, 0x06, 0xC0, 0xC0, 0x30, 0x1B, 0x03,
  0x01, 0xC0, 0x6C, 0x0C, 0x07, 0x03, 0x30, 0x38, 0x3C, 0x0C, 0xC0, 0x73,
  0xB8, 0x63, 0x81, 0xFC, 0x7F, 0x06, 0x01, 0xE0, 0xF8, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x06,
  0xC0, 0x00, 0x1D, 0x80, 0x00, 0x33, 0x80, 0x00, 0x63, 0x00, 0x01, 0xC6,
  0x00, 0x03, 0x8E, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x30,
  0x00, 0x60, 0x70, 0x00, 0xC0, 0x60, 0x03, 0x80, 0xC0, 0x06, 0x01, 0xC0,
  0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x07, 0x00, 0xC0, 0x06, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0C, 0x00, 0x38, 0x38, 0x00, 0x30, 0x70,
  0x00, 0x70, 0xC0, 0x00, 0xE3, 0x80, 0x00, 0xC7, 0x00, 0x01, 0xCC, 0x00,
  0x03, 0xB8, 0x00, 0x03, 0x70, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x0C,
  0x07, 0xE3, 0x00, 0x38, 0xC0, 0x07, 0x30, 0x00, 0xCC, 0x00, 0x3B, 0x00,
  0x0E, 0xC0, 0x03, 0xB0, 0x00, 0xEC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x07,
  0x30, 0x03, 0x8C, 0x03, 0xC3, 0xFF, 0xE0, 0xFF, 0xFC, 0x30, 0x03, 0x8C,
  0x00, 0x73, 0x00, 0x0E, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x6C, 0x00, 0x3B, 0x00, 0x0E, 0xC0, 0x07,
  0x30, 0x0F, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xF0,
  0x1F, 0x8F, 0x81, 0xC0, 0x1C, 0x38, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00,
  0x66, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x06,
  0x70, 0x00, 0xE3, 0x80, 0x0E, 0x1C, 0x01, 0xC0, 0xF8, 0xF8, 0x07, 0xFF,
  0x00, 0x1F, 0xC0, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0x01, 0xF8, 0x60, 0x07,
  0x8C, 0x00, 0x71, 0x80, 0x07, 0x30, 0x00, 0x76, 0x00, 0x0E, 0xC0, 0x00,
  0xD8, 0x00, 0x1B, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x36, 0x00, 0x06,
  0xC0, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x0E, 0x60, 0x03, 0x8C, 0x00, 0xF1,
  0x80, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xB0,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0,
  0x0F, 0x8F, 0xC1, 0xC0, 0x1C, 0x38, 0x00, 0xE7, 0x00, 0x07, 0x70, 0x00,
  0x76, 0x00, 0x07, 0x60, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x36, 0x00, 0x03, 0x70, 0x00, 0x37, 0x00, 0x03,
  0x38, 0x00, 0x33, 0x80, 0x07, 0x1E, 0x00, 0xF0, 0xF8, 0x7E, 0x07, 0xFF,
  0x80, 0x1F, 0xE0, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0x70, 0x1C, 0x3E, 0x7C, 0x1F,
  0xF8, 0x07, 0xE0, 0xC0, 0x01, 0xCC, 0x00, 0x1C, 0xC0, 0x03, 0x8C, 0x00,
  0x70, 0xC0, 0x0E, 0x0C, 0x01, 0xE0, 0xC0, 0x1C, 0x0C, 0x03, 0x80, 0xC0,
  0x70, 0x0C, 0x0E, 0x00, 0xC1, 0xE0, 0x0C, 0x1C, 0x00, 0xC3, 0x80, 0x0C,
  0x70, 0x00, 0xCF, 0x00, 0x0C, 0xF8, 0x00, 0xDF, 0x80, 0x0F, 0x9C, 0x00,
  0xF0, 0xE0, 0x0E, 0x0E, 0x00, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0xC0, 0x38,
  0x0C, 0x01, 0xC0, 0xC0, 0x0E, 0x0C, 0x00, 0xE0, 0xC0, 0x07, 0x0C, 0x00,
  0x38, 0xC0, 0x03, 0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xEC, 0x00, 0x0E, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x06, 0xF6, 0x00, 0x01, 0xBD, 0x80, 0x00, 0xEF, 0x70, 0x00,
  0x37, 0xCC, 0x00, 0x0D, 0xF3, 0x00, 0x07, 0x7C, 0xE0, 0x01, 0x9F, 0x18,
  0x00, 0x67, 0xC6, 0x00, 0x39, 0xF1, 0xC0, 0x0C, 0x7C, 0x30, 0x03, 0x1F,
  0x0C, 0x01, 0xC7, 0xC3, 0x80, 0x61, 0xF0, 0x60, 0x38, 0x7C, 0x18, 0x0E,
  0x1F, 0x07, 0x03, 0x07, 0xC0, 0xC1, 0xC1, 0xF0, 0x38, 0x60, 0x7C, 0x06,
  0x18, 0x1F, 0x01, 0x8E, 0x07, 0xC0, 0x73, 0x01, 0xF0, 0x0C, 0xC0, 0x7C,
  0x03, 0x70, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x07, 0x80,
  0x7C, 0x01, 0xC0, 0x1F, 0x00, 0x30, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7D, 0x80, 0x07, 0xDC, 0x00,
  0x7C, 0xC0, 0x07, 0xCE, 0x00, 0x7C, 0x70, 0x07, 0xC3, 0x00, 0x7C, 0x38,
  0x07, 0xC1, 0x80, 0x7C, 0x1C, 0x07, 0xC0, 0xC0, 0x7C, 0x0E, 0x07, 0xC0,
  0x60, 0x7C, 0x07, 0x07, 0xC0, 0x38, 0x7C, 0x03, 0x87, 0xC0, 0x1C, 0x7C,
  0x00, 0xC7, 0xC0, 0x0E, 0x7C, 0x00, 0x67, 0xC0, 0x07, 0x7C, 0x00, 0x37,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xE7, 0xE0, 0x78,
  0x07, 0x83, 0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x01, 0xCC, 0x00, 0x0E,
  0xE0, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xDC, 0x00, 0x06, 0x60, 0x00, 0x73, 0x80, 0x03, 0x9C,
  0x00, 0x38, 0x70, 0x01, 0xC1, 0xC0, 0x3C, 0x0F, 0xEF, 0xC0, 0x1F, 0xFC,
  0x00, 0x3F, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x8C, 0x03, 0xF3, 0x00, 0x1E,
  0xC0, 0x03, 0xB0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3B, 0x00, 0x1E, 0xC0, 0x3F, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xE7, 0xE0, 0x78,
  0x07, 0x83, 0x80, 0x0E, 0x38, 0x00, 0x71, 0x80, 0x01, 0xDC, 0x00, 0x0E,
  0xE0, 0x00, 0x37, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1B, 0x80, 0x00, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x73, 0x80, 0x03, 0x9C,
  0x00, 0x38, 0x70, 0x01, 0xC3, 0xC0, 0x3C, 0x0F, 0xEF, 0xC0, 0x1F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xF0, 0x1F, 0xFF, 0x83,
  0x00, 0xF8, 0x60, 0x03, 0x8C, 0x00, 0x39, 0x80, 0x07, 0x30, 0x00, 0x66,
  0x00, 0x0E, 0xC0, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x07, 0x60, 0x00, 0xEC,
  0x00, 0x19, 0x80, 0x07, 0x30, 0x00, 0xE6, 0x00, 0x38, 0xC0, 0x3E, 0x1F,
  0xFF, 0x83, 0xFF, 0xC0, 0x60, 0x1C, 0x0C, 0x01, 0x81, 0x80, 0x38, 0x30,
  0x03, 0x06, 0x00, 0x70, 0xC0, 0x0E, 0x18, 0x00, 0xE3, 0x00, 0x1C, 0x60,
  0x01, 0xCC, 0x00, 0x39, 0x80, 0x03, 0xB0, 0x00, 0x76, 0x00, 0x07, 0x01,
  0xF8, 0x01, 0xFF, 0xC0, 0x7C, 0x7C, 0x1E, 0x01, 0xC3, 0x80, 0x1C, 0xE0,
  0x01, 0x9C, 0x00, 0x3B, 0x00, 0x07, 0x60, 0x00, 0x6E, 0x00, 0x0D, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x6C, 0x00,
  0x0D, 0xC0, 0x03, 0xBC, 0x00, 0x73, 0xC0, 0x3C, 0x3F, 0x1F, 0x01, 0xFF,
  0xC0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x6C, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0xE3, 0xC0, 0x3C,
  0x3E, 0x3F, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x77, 0x00, 0x01, 0xDC, 0x00, 0x06, 0x70, 0x00, 0x38, 0xC0, 0x00, 0xE3,
  0x80, 0x03, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x70, 0x01, 0x81, 0xC0,
  0x0E, 0x03, 0x00, 0x38, 0x0C, 0x00, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x1C,
  0x01, 0x80, 0x70, 0x07, 0x01, 0x80, 0x1C, 0x0E, 0x00, 0x30, 0x38, 0x00,
  0xE0, 0xC0, 0x03, 0x87, 0x00, 0x06, 0x1C, 0x00, 0x18, 0x60, 0x00, 0x71,
  0x80, 0x00, 0xCE, 0x00, 0x03, 0x30, 0x00, 0x0E, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x3F, 0x00,
  0x1C, 0x00, 0x76, 0x00, 0x6C, 0x00, 0xCC, 0x00, 0xD8, 0x01, 0x98, 0x01,
  0xB0, 0x07, 0x38, 0x03, 0x60, 0x0E, 0x70, 0x0E, 0x60, 0x1C, 0x60, 0x18,
  0xC0, 0x30, 0xC0, 0x31, 0x80, 0x61, 0xC0, 0x63, 0x01, 0xC3, 0x81, 0xC7,
  0x03, 0x87, 0x03, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x18,
  0x18, 0x1C, 0x38, 0x38, 0x70, 0x38, 0x60, 0x30, 0xE0, 0x30, 0xC0, 0x61,
  0x80, 0x61, 0x80, 0xC3, 0x00, 0xC7, 0x01, 0xC6, 0x01, 0xCC, 0x01, 0x9C,
  0x03, 0x98, 0x03, 0x38, 0x03, 0x30, 0x06, 0x60, 0x06, 0xE0, 0x0C, 0xC0,
  0x0D, 0x80, 0x0D, 0x80, 0x1B, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x07,
  0x00, 0x18, 0x1C, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0xE0, 0x07, 0x03, 0x80, 0x0E, 0x1C, 0x00, 0x18, 0x70, 0x00, 0x73, 0x80,
  0x00, 0xEC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xCE,
  0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xC0, 0xE0, 0x07, 0x01, 0x80,
  0x38, 0x07, 0x00, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x38, 0x00, 0x70, 0xE0,
  0x01, 0xC7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0xE0, 0x00, 0x39, 0x80, 0x00,
  0xE7, 0x00, 0x03, 0x0C, 0x00, 0x1C, 0x38, 0x00, 0x60, 0x60, 0x03, 0x81,
  0xC0, 0x0C, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x70,
  0x38, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x18, 0xE0,
  0x00, 0x73, 0x00, 0x00, 0xDC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0xFF, 0xF0, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0xFF, 0xFC, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xF0, 0x06,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xD8, 0x0E, 0xC0, 0x66, 0x03, 0x18,
  0x38, 0xC1, 0x86, 0x0C, 0x18, 0xE0, 0xC6, 0x06, 0x30, 0x1B, 0x80, 0xD8,
  0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x06,
  0x03, 0xF0, 0x0F, 0xFC, 0x1E, 0x3E, 0x38, 0x0E, 0x70, 0x07, 0x60, 0x07,
  0x60, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x03, 0xFF, 0x1F, 0xFF,
  0x3E, 0x07, 0x78, 0x07, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0x60, 0x0F, 0x70, 0x1F, 0x7E, 0xF7, 0x3F, 0xE3, 0x0F, 0xC3,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0xFC, 0x1D,
  0xFF, 0x8F, 0xE3, 0xC7, 0xC0, 0x73, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x03,
  0x70, 0x01, 0xB8, 0x00, 0xDC, 0x00, 0x6E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0x70, 0x01, 0xB8, 0x00, 0xDC, 0x00, 0x6E,
  0x00, 0x77, 0x80, 0x3B, 0xE0, 0x39, 0xFC, 0x78, 0xEF, 0xF8, 0x71, 0xF8,
  0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x8F, 0x87, 0x01, 0xC7, 0x00, 0x73,
  0x00, 0x19, 0x80, 0x0D, 0xC0, 0x06, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x03, 0x30, 0x01, 0x98, 0x00, 0xCE, 0x00, 0xE3, 0x80, 0xE0, 0xF1, 0xF0,
  0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC1, 0xF8, 0xE3, 0xFF, 0x71, 0xE3, 0xF9, 0xC0, 0x7D, 0xC0, 0x1E,
  0xE0, 0x07, 0x60, 0x03, 0xB0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xD8,
  0x00, 0xEC, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x3C, 0xE0, 0x3E, 0x3C, 0x7F,
  0x0F, 0xFB, 0x83, 0xF1, 0xC0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xCF, 0x87,
  0x01, 0xC7, 0x00, 0x73, 0x80, 0x19, 0x80, 0x0D, 0xC0, 0x06, 0xE0, 0x03,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x70, 0xF8, 0xF8, 0x3F, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x3C,
  0x87, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x03, 0xFF, 0x7F,
  0xE1, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x07, 0xE3, 0x8F, 0xFD, 0xCF,
  0x8F, 0xE7, 0x01, 0xF7, 0x00, 0x7B, 0x80, 0x1D, 0x80, 0x0E, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0x60, 0x03, 0xB0, 0x01, 0xDC, 0x00, 0xEE,
  0x00, 0xF3, 0x80, 0xF8, 0xF1, 0xFC, 0x3F, 0xEE, 0x0F, 0xC7, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x62, 0x00, 0x71, 0xC0, 0x78, 0xF8,
  0xF8, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x87, 0xC7, 0x3F, 0xCE, 0xE3, 0xDF, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0C, 0x5F, 0xB0,
  0x00, 0x0D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x04,
  0x1C, 0x38, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x1E, 0xF9, 0xE0,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0xE0, 0x1C,
  0xE0, 0x38, 0xE0, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE1, 0xC0, 0xE3, 0x80,
  0xE7, 0x00, 0xEE, 0x00, 0xEE, 0x00, 0xFF, 0x00, 0xFB, 0x00, 0xF3, 0x80,
  0xE1, 0xC0, 0xE0, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x38,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0xF0, 0x1F, 0x0E, 0x7F, 0x87, 0xFC,
  0xEE, 0x3C, 0xF3, 0xEF, 0x81, 0xFC, 0x0E, 0xF0, 0x0F, 0x80, 0x7E, 0x00,
  0x70, 0x07, 0xE0, 0x07, 0x00, 0x3E, 0x00, 0x70, 0x03, 0xE0, 0x06, 0x00,
  0x3E, 0x00, 0x60, 0x03, 0xE0, 0x06, 0x00, 0x3E, 0x00, 0x60, 0x03, 0xE0,
  0x06, 0x00, 0x3E, 0x00, 0x60, 0x03, 0xE0, 0x06, 0x00, 0x3E, 0x00, 0x60,
  0x03, 0xE0, 0x06, 0x00, 0x3E, 0x00, 0x60, 0x03, 0xE0, 0x06, 0x00, 0x3E,
  0x00, 0x60, 0x03, 0xE0, 0x06, 0x00, 0x3E, 0x00, 0x60, 0x03, 0xE0, 0x06,
  0x00, 0x3E, 0x00, 0x60, 0x03, 0xE1, 0xF1, 0xCF, 0xF3, 0xB8, 0xF7, 0xC0,
  0x7F, 0x00, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xF1, 0xE0, 0xF0, 0x1C, 0x38,
  0x03, 0x1C, 0x00, 0xE6, 0x00, 0x19, 0x80, 0x06, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0x60, 0x01, 0x98, 0x00, 0x67, 0x00, 0x38, 0xE0, 0x0C, 0x38,
  0x07, 0x07, 0xC7, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0xE3, 0xF0, 0xEF, 0xF8,
  0xFE, 0x3C, 0xF8, 0x0E, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x06,
  0xF8, 0x0E, 0xFE, 0x3C, 0xEF, 0xF8, 0xE3, 0xF0, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x07, 0xE3, 0x8F, 0xFD, 0xCF, 0x8F, 0xE7, 0x01, 0xF7, 0x00,
  0x7B, 0x80, 0x1D, 0x80, 0x0E, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0x60, 0x03, 0xB0, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0xF3, 0x80, 0xF8, 0xF1,
  0xFC, 0x3F, 0xEE, 0x0F, 0xC7, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0xE3, 0xFB, 0xFE, 0xFF, 0xE0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x07, 0xE0, 0x1F, 0xF8, 0x3C,
  0x3C, 0x30, 0x1E, 0x70, 0x0E, 0x60, 0x06, 0x60, 0x06, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x06, 0x70,
  0x0E, 0x3E, 0x3C, 0x1F, 0xF8, 0x07, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x0F, 0xFF, 0xFF, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x03, 0x00, 0xC0, 0x3C, 0x07, 0xC0, 0xF0, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3B, 0x00, 0x77, 0x01,
  0xE7, 0x9E, 0xCF, 0xF9, 0x87, 0xE3, 0xE0, 0x03, 0xB0, 0x01, 0x98, 0x00,
  0xCE, 0x00, 0xE3, 0x00, 0x71, 0x80, 0x30, 0xE0, 0x18, 0x70, 0x1C, 0x18,
  0x0C, 0x0C, 0x06, 0x07, 0x07, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x71, 0xC0,
  0x18, 0xC0, 0x0C, 0x60, 0x07, 0x30, 0x01, 0xB8, 0x00, 0xD8, 0x00, 0x6C,
  0x00, 0x3E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xC0, 0x1C, 0x01,
  0xF0, 0x07, 0x00, 0x6E, 0x01, 0xC0, 0x1B, 0x80, 0x78, 0x0E, 0x60, 0x3E,
  0x03, 0x98, 0x0D, 0x80, 0xC7, 0x03, 0x60, 0x31, 0xC0, 0xDC, 0x0C, 0x30,
  0x73, 0x07, 0x0C, 0x18, 0xC1, 0x83, 0x06, 0x30, 0x60, 0xE1, 0x8E, 0x18,
  0x18, 0xC1, 0x8E, 0x06, 0x30, 0x63, 0x01, 0x8C, 0x18, 0xC0, 0x77, 0x03,
  0x30, 0x0D, 0x80, 0xCC, 0x03, 0x60, 0x36, 0x00, 0xD8, 0x0D, 0x80, 0x36,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x1E, 0x00, 0x70, 0x07, 0x00,
  0x1C, 0x00, 0xC0, 0x70, 0x03, 0x38, 0x03, 0x8E, 0x03, 0x83, 0x01, 0xC1,
  0xC1, 0xC0, 0x60, 0xE0, 0x38, 0xE0, 0x0C, 0x60, 0x07, 0x70, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x0D, 0xC0, 0x0E,
  0x60, 0x06, 0x38, 0x07, 0x0C, 0x07, 0x07, 0x03, 0x81, 0x83, 0x80, 0xE1,
  0xC0, 0x39, 0xC0, 0x1C, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0x98, 0x00,
  0xCE, 0x00, 0xE7, 0x00, 0x61, 0x80, 0x30, 0xE0, 0x38, 0x70, 0x1C, 0x18,
  0x0C, 0x0E, 0x0E, 0x07, 0x07, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x71, 0xC0,
  0x18, 0xC0, 0x0C, 0x60, 0x07, 0x70, 0x01, 0xB8, 0x00, 0xD8, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x3C, 0x0E, 0x03, 0x80, 0x70,
  0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x07, 0x81, 0xE0, 0x3C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x07, 0x80, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x78,
  0x1C, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x38,
  0x0E, 0x03, 0x80, 0x60, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x01, 0xDE, 0xF8,
  0x0E, 0xC1, 0xC0, 0x6E, 0x07, 0x87, 0x60, 0x1E, 0x73, 0x00, 0x7F, 0x80,
  0x00, 0xF0,
};

const GFXglyph RobotoCondensed_Light45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 32, 10, 3, -32 },
  { 17, 8, 10, 13, 3, -34 },
  { 27, 21, 32, 23, 2, -32 },
  { 111, 16, 40, 22, 3, -36 },
  { 191, 25, 32, 29, 2, -32 },
  { 291, 21, 32, 24, 2, -32 },
  { 375, 2, 10, 8, 3, -34 },
  { 378, 9, 46, 13, 3, -36 },
  { 430, 9, 46, 13, 1, -36 },
  { 482, 18, 18, 19, 1, -32 },
  { 523, 18, 24, 22, 2, -27 },
  { 577, 5, 10, 9, 1, -4 },
  { 584, 9, 2, 12, 1, -15 },
  { 587, 4, 4, 11, 3, -4 },
  { 589, 13, 35, 16, 1, -32 },
  { 646, 16, 32, 22, 3, -32 },
  { 710, 9, 32, 22, 4, -32 },
  { 746, 18, 32, 22, 2, -32 },
  { 818, 17, 32, 22, 2, -32 },
  { 886, 19, 32, 22, 2, -32 },
  { 962, 17, 32, 22, 3, -32 },
  { 1030, 17, 32, 22, 3, -32 },
  { 1098, 18, 32, 22, 2, -32 },
  { 1170, 18, 32, 22, 2, -32 },
  { 1242, 17, 32, 22, 2, -32 },
  { 1310, 4, 24, 9, 3, -24 },
  { 1322, 5, 30, 8, 1, -24 },
  { 1341, 15, 19, 20, 2, -24 },
  { 1377, 16, 10, 22, 3, -20 },
  { 1397, 15, 19, 21, 3, -24 },
  { 1433, 14, 32, 18, 2, -32 },
  { 1489, 30, 41, 35, 3, -31 },
  { 1643, 23, 32, 25, 1, -32 },
  { 1735, 18, 32, 24, 4, -32 },
  { 1807, 20, 32, 25, 3, -32 },
  { 1887, 19, 32, 26, 4, -32 },
  { 1963, 17, 32, 22, 4, -32 },
  { 2031, 16, 32, 22, 4, -32 },
  { 2095, 20, 32, 27, 3, -32 },
  { 2175, 20, 32, 28, 4, -32 },
  { 2255, 3, 32, 11, 4, -32 },
  { 2267, 16, 32, 22, 2, -32 },
  { 2331, 20, 32, 25, 4, -32 },
  { 2411, 15, 32, 21, 4, -32 },
  { 2471, 26, 32, 34, 4, -32 },
  { 2575, 20, 32, 28, 4, -32 },
  { 2655, 21, 32, 27, 3, -32 },
  { 2739, 18, 32, 24, 4, -32 },
  { 2811, 21, 38, 27, 3, -32 },
  { 2911, 19, 32, 25, 4, -32 },
  { 2987, 19, 32, 23, 2, -32 },
  { 3063, 21, 32, 23, 1, -32 },
  { 3147, 19, 32, 26, 3, -32 },
  { 3223, 22, 32, 24, 1, -32 },
  { 3311, 31, 32, 35, 2, -32 },
  { 3435, 22, 32, 24, 1, -32 },
  { 3523, 22, 32, 24, 1, -32 },
  { 3611, 19, 32, 24, 2, -32 },
  { 3687, 7, 44, 10, 3, -37 },
  { 3726, 14, 35, 16, 1, -32 },
  { 3788, 7, 44, 10, 0, -37 },
  { 3827, 13, 16, 17, 2, -32 },
  { 3853, 17, 2, 17, 0, 0 },
  { 3858, 8, 6, 13, 2, -34 },
  { 3864, 16, 24, 21, 2, -24 },
  { 3912, 17, 34, 22, 3, -34 },
  { 3985, 17, 24, 20, 2, -24 },
  { 4036, 17, 34, 22, 2, -34 },
  { 4109, 17, 24, 21, 2, -24 },
  { 4160, 11, 34, 14, 2, -34 },
  { 4207, 17, 33, 22, 2, -24 },
  { 4278, 15, 34, 22, 3, -34 },
  { 4342, 3, 33, 10, 3, -33 },
  { 4355, 7, 42, 10, -1, -33 },
  { 4392, 16, 34, 20, 3, -34 },
  { 4460, 2, 34, 10, 4, -34 },
  { 4469, 28, 24, 34, 3, -24 },
  { 4553, 15, 24, 22, 3, -24 },
  { 4598, 18, 24, 22, 2, -24 },
  { 4652, 16, 33, 22, 3, -24 },
  { 4718, 17, 33, 22, 2, -24 },
  { 4789, 10, 24, 14, 3, -24 },
  { 4819, 16, 24, 20, 2, -24 },
  { 4867, 10, 30, 13, 1, -30 },
  { 4905, 15, 24, 22, 3, -24 },
  { 4950, 17, 24, 19, 1, -24 },
  { 5001, 26, 24, 29, 2, -24 },
  { 5079, 17, 24, 19, 1, -24 },
  { 5130, 17, 33, 19, 1, -24 },
  { 5201, 16, 24, 19, 2, -24 },
  { 5249, 11, 44, 13, 2, -35 },
  { 5310, 2, 38, 10, 4, -32 },
  { 5320, 11, 44, 13, 1, -35 },
  { 5381, 21, 8, 27, 3, -17 },
};

const GFXfont RobotoCondensed_Light45pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light45pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light45pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOCONDENSED_LIGHT45PT7B_H_
