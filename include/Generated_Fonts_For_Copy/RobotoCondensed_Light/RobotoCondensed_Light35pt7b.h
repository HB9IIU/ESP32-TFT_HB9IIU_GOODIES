#ifndef _ROBOTOCONDENSED_LIGHT35PT7B_H_
#define _ROBOTOCONDENSED_LIGHT35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0xC7, 0x1C, 0x71, 0xCF,
  0x3C, 0xF3, 0x03, 0x0C, 0x02, 0x08, 0x02, 0x08, 0x02, 0x18, 0x06, 0x18,
  0x06, 0x18, 0x06, 0x18, 0x7F, 0xFF, 0x7F, 0xFF, 0x04, 0x10, 0x0C, 0x30,
  0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x20, 0x08, 0x20, 0x08, 0x20, 0xFF, 0xFE,
  0xFF, 0xFE, 0x18, 0x60, 0x18, 0x60, 0x10, 0x40, 0x10, 0x40, 0x10, 0xC0,
  0x30, 0xC0, 0x30, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x1F, 0x01, 0xFE,
  0x18, 0x39, 0x80, 0xCC, 0x06, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0x60, 0x3B, 0x83, 0x8F, 0xF8,
  0x1F, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x03,
  0x0C, 0x00, 0x61, 0x83, 0x08, 0x10, 0x41, 0x02, 0x18, 0x20, 0x42, 0x04,
  0x08, 0xC0, 0xC3, 0x10, 0x18, 0x66, 0x01, 0xF8, 0x80, 0x1E, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x8E, 0x00, 0x63, 0xE0, 0x08, 0xC6, 0x03, 0x10, 0x40,
  0x46, 0x0C, 0x18, 0xC1, 0x82, 0x18, 0x30, 0xC3, 0x06, 0x10, 0x20, 0x82,
  0x06, 0x30, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x38,
  0xE0, 0x30, 0x60, 0x30, 0x60, 0x30, 0x60, 0x30, 0x60, 0x30, 0xC0, 0x31,
  0xC0, 0x1B, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x33, 0x06, 0x63,
  0x86, 0x61, 0x86, 0xC0, 0xC6, 0xC0, 0xE4, 0xC0, 0x6C, 0xC0, 0x3C, 0xC0,
  0x18, 0xE0, 0x3C, 0x70, 0x7C, 0x3F, 0xE6, 0x0F, 0x87, 0xFF, 0xFF, 0x02,
  0x0C, 0x10, 0x61, 0x83, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x08, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x10, 0x30, 0x60, 0xC1, 0x81, 0x83,
  0x06, 0x06, 0x0C, 0x0C, 0x08, 0x18, 0x10, 0x81, 0x81, 0x83, 0x03, 0x02,
  0x06, 0x0C, 0x08, 0x18, 0x30, 0x60, 0x40, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x61, 0x83, 0x04, 0x18, 0x20,
  0xC3, 0x04, 0x00, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x41, 0x05,
  0xE4, 0xF3, 0xFF, 0x81, 0xF0, 0x03, 0x80, 0x1B, 0x00, 0xC6, 0x07, 0x18,
  0x18, 0x30, 0x40, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x33, 0x33, 0x66, 0xC4, 0xFF, 0xFC, 0x7D, 0x80, 0x00, 0xC0,
  0x30, 0x08, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60,
  0x10, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30,
  0x08, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x00, 0x0F, 0x80, 0xFE, 0x0C,
  0x18, 0xC0, 0x66, 0x03, 0x20, 0x0B, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x06, 0x80, 0x26, 0x03, 0x30, 0x18, 0xC1, 0x83, 0xF8, 0x0F,
  0x80, 0x02, 0x1D, 0xFF, 0x98, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x0F,
  0x81, 0xFF, 0x1C, 0x18, 0xC0, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0x58, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0x81, 0xFF, 0x1C, 0x18, 0xC0, 0x6C, 0x03,
  0x60, 0x0B, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18, 0x1F, 0x80,
  0xFC, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xF0, 0x19, 0xC1, 0xC7, 0xFC, 0x0F, 0x80, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x1B, 0x00, 0x36, 0x00, 0xCC, 0x01, 0x98,
  0x06, 0x30, 0x0C, 0x60, 0x30, 0xC0, 0x61, 0x81, 0x83, 0x03, 0x06, 0x0C,
  0x0C, 0x38, 0x18, 0x60, 0x31, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x7F, 0xF7, 0xFF, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0xF8, 0x7F,
  0xC6, 0x0E, 0x40, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x10, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x36, 0x07, 0x70, 0xE3, 0xFC, 0x0F, 0x80, 0x01, 0xC0,
  0x3E, 0x03, 0x80, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x02, 0x3E, 0x37, 0xF9, 0xF0, 0xEE, 0x03, 0x70, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x06, 0xC0, 0x36, 0x01, 0xB8, 0x18, 0xE1, 0xC3,
  0xFC, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x0F,
  0x81, 0xFF, 0x1C, 0x1C, 0xC0, 0x66, 0x03, 0x60, 0x0F, 0x00, 0x78, 0x03,
  0x60, 0x33, 0x01, 0x8C, 0x18, 0x3F, 0x81, 0xFC, 0x18, 0x31, 0x80, 0xD8,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xB0, 0x1D, 0xC1,
  0xC7, 0xFC, 0x0F, 0x80, 0x0F, 0x81, 0xFE, 0x1C, 0x38, 0xC0, 0xEE, 0x03,
  0x60, 0x1B, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xB0, 0x3D, 0xC3, 0x67, 0xFB, 0x1F, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x70, 0x07, 0x03, 0xF0, 0x1E, 0x00, 0x7D, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7D, 0x80, 0x27, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x33, 0x33, 0x66, 0xE4, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0x70, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x00, 0x10, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x00, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78,
  0x0E, 0x00, 0x80, 0x00, 0x1F, 0x0F, 0xF3, 0x87, 0x60, 0x6C, 0x0D, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0x80, 0x70,
  0x0E, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x04,
  0x30, 0x1E, 0x06, 0x60, 0x7F, 0x06, 0x60, 0x61, 0x82, 0x60, 0xC1, 0x02,
  0x41, 0x81, 0x02, 0xC1, 0x81, 0x02, 0xC1, 0x81, 0x02, 0xC1, 0x01, 0x02,
  0xC3, 0x03, 0x02, 0xC3, 0x03, 0x02, 0xC3, 0x03, 0x02, 0xC3, 0x03, 0x02,
  0xC3, 0x03, 0x06, 0xC1, 0x07, 0x04, 0xC1, 0x8D, 0x0C, 0x41, 0xF9, 0xF8,
  0x40, 0xF0, 0xF0, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x01, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x2C, 0x00,
  0x36, 0x00, 0x1B, 0x00, 0x08, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x0C,
  0x03, 0x06, 0x01, 0x83, 0x00, 0xC0, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x30,
  0x08, 0x3F, 0xFE, 0x1F, 0xFF, 0x0C, 0x01, 0x86, 0x00, 0x66, 0x00, 0x33,
  0x00, 0x19, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0x80, 0xFF, 0x83, 0xFF,
  0x8C, 0x07, 0x30, 0x0E, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0,
  0x1B, 0x00, 0xCC, 0x07, 0x3F, 0xF8, 0xFF, 0xE3, 0x01, 0xCC, 0x01, 0xB0,
  0x06, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1B, 0x00, 0x6C,
  0x03, 0xBF, 0xFC, 0xFF, 0xC0, 0x07, 0xE0, 0x0F, 0xF8, 0x1C, 0x1C, 0x30,
  0x0E, 0x70, 0x06, 0x60, 0x06, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x03, 0x60, 0x03, 0x60, 0x07, 0x70, 0x06, 0x30,
  0x06, 0x18, 0x1C, 0x0F, 0xF8, 0x07, 0xE0, 0xFF, 0x81, 0xFF, 0xC3, 0x01,
  0xC6, 0x01, 0xCC, 0x01, 0x98, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x6C, 0x01, 0xD8, 0x07,
  0x30, 0x1C, 0x7F, 0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0xFF, 0xEF, 0xFF, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF, 0xCF, 0xFE, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xE0, 0x73, 0x00, 0x6E,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x36, 0x00, 0x6E, 0x00, 0xCE, 0x07, 0x0F,
  0xFC, 0x07, 0xE0, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xF0, 0x07, 0x80, 0x36, 0x01, 0xB0, 0x19,
  0xC1, 0xC7, 0xFC, 0x0F, 0x80, 0xC0, 0x0D, 0x80, 0x3B, 0x00, 0xE6, 0x01,
  0x8C, 0x06, 0x18, 0x18, 0x30, 0x70, 0x61, 0xC0, 0xC3, 0x01, 0x8C, 0x03,
  0x38, 0x06, 0xE0, 0x0D, 0xE0, 0x1E, 0xE0, 0x38, 0xC0, 0x60, 0xC0, 0xC1,
  0xC1, 0x81, 0x83, 0x01, 0x86, 0x03, 0x8C, 0x03, 0x18, 0x03, 0x30, 0x07,
  0x60, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xD8, 0x01, 0xBD,
  0x80, 0x1B, 0xC8, 0x01, 0xBC, 0xC0, 0x33, 0xCC, 0x03, 0x3C, 0x40, 0x33,
  0xC6, 0x06, 0x3C, 0x60, 0x63, 0xC3, 0x06, 0x3C, 0x30, 0xC3, 0xC3, 0x0C,
  0x3C, 0x18, 0x83, 0xC1, 0x98, 0x3C, 0x19, 0x83, 0xC0, 0xD0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x30, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xD8, 0x03, 0xDC, 0x03, 0xCC,
  0x03, 0xC6, 0x03, 0xC6, 0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC1, 0x83, 0xC1,
  0x83, 0xC0, 0xC3, 0xC0, 0xC3, 0xC0, 0x63, 0xC0, 0x33, 0xC0, 0x33, 0xC0,
  0x1B, 0xC0, 0x1B, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0x07,
  0xE0, 0x0F, 0xF8, 0x38, 0x1C, 0x30, 0x06, 0x60, 0x06, 0x60, 0x03, 0x60,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60,
  0x03, 0x60, 0x03, 0x60, 0x06, 0x30, 0x0E, 0x3C, 0x1C, 0x0F, 0xF8, 0x07,
  0xE0, 0xFF, 0xC3, 0xFF, 0xCC, 0x03, 0xB0, 0x06, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x3B,
  0xFF, 0xCF, 0xFC, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0x1F,
  0xF8, 0x38, 0x1C, 0x30, 0x0E, 0x60, 0x06, 0x60, 0x03, 0x60, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03, 0x60,
  0x03, 0x60, 0x06, 0x30, 0x0E, 0x38, 0x1C, 0x1F, 0xF8, 0x07, 0xF8, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x02, 0xFF, 0xC1, 0xFF, 0xC3, 0x01,
  0xC6, 0x00, 0xCC, 0x01, 0x98, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D,
  0x80, 0x1B, 0x00, 0x66, 0x00, 0xCC, 0x03, 0x1F, 0xFC, 0x3F, 0xF0, 0x60,
  0x60, 0xC0, 0xE1, 0x80, 0xC3, 0x01, 0xC6, 0x01, 0x8C, 0x03, 0x98, 0x03,
  0x30, 0x07, 0x60, 0x06, 0xC0, 0x0E, 0x0F, 0xC0, 0x3F, 0xE0, 0xC0, 0xE3,
  0x00, 0xEE, 0x00, 0xD8, 0x01, 0xB0, 0x01, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xDC, 0x01, 0x9C,
  0x0E, 0x1F, 0xF8, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x77, 0x03, 0x8F,
  0xFC, 0x0F, 0xC0, 0xC0, 0x01, 0xE0, 0x00, 0xD8, 0x00, 0xCC, 0x00, 0x66,
  0x00, 0x31, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x0E, 0x0C, 0x06,
  0x06, 0x03, 0x03, 0x01, 0x80, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x0C,
  0x60, 0x06, 0x30, 0x03, 0x18, 0x00, 0x88, 0x00, 0x6C, 0x00, 0x36, 0x00,
  0x1A, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x0C, 0x01,
  0xB0, 0x0E, 0x00, 0xD8, 0x07, 0x00, 0xCC, 0x03, 0x80, 0x66, 0x01, 0x60,
  0x33, 0x01, 0xB0, 0x18, 0xC0, 0xD8, 0x0C, 0x60, 0x64, 0x0C, 0x30, 0x23,
  0x06, 0x18, 0x31, 0x83, 0x0C, 0x18, 0xC1, 0x83, 0x0C, 0x20, 0x81, 0x84,
  0x10, 0xC0, 0xC6, 0x0C, 0x60, 0x63, 0x06, 0x30, 0x11, 0x83, 0x18, 0x0C,
  0x80, 0x88, 0x06, 0xC0, 0x6C, 0x03, 0x60, 0x36, 0x01, 0xB0, 0x1B, 0x00,
  0x50, 0x05, 0x80, 0x28, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x00, 0x60, 0x03, 0x30, 0x03, 0x8C, 0x01, 0x87, 0x01,
  0xC1, 0x80, 0xC0, 0xE0, 0xC0, 0x30, 0x60, 0x0C, 0x60, 0x06, 0x70, 0x01,
  0xB0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0D, 0x80,
  0x0E, 0xC0, 0x06, 0x30, 0x07, 0x18, 0x03, 0x06, 0x03, 0x03, 0x81, 0x80,
  0xC1, 0x80, 0x70, 0xC0, 0x18, 0xC0, 0x0E, 0xE0, 0x03, 0x00, 0xC0, 0x03,
  0x70, 0x01, 0x98, 0x01, 0x8E, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0x60, 0x60,
  0x60, 0x30, 0x30, 0x0C, 0x38, 0x06, 0x18, 0x01, 0x8C, 0x00, 0xCC, 0x00,
  0x36, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xF8,
  0xC0, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18,
  0x01, 0x00, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7F, 0xF8, 0x04,
  0x03, 0x80, 0xE0, 0x68, 0x1B, 0x04, 0xC3, 0x10, 0xC6, 0x21, 0x98, 0x26,
  0x0D, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0x83, 0x0E, 0x18, 0x0F, 0x83,
  0xFE, 0x70, 0x66, 0x03, 0xC0, 0x30, 0x03, 0x00, 0x30, 0x03, 0x1F, 0xF3,
  0xFF, 0x60, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7E, 0x0F, 0x7F, 0xB3,
  0xE3, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x8F, 0x8B, 0xFC, 0xA0, 0xEC, 0x06, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x6E,
  0x0E, 0xBF, 0xC8, 0xF8, 0x0F, 0x83, 0xFC, 0x70, 0x6E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C,
  0x03, 0xE0, 0x37, 0x06, 0x3F, 0xC1, 0xF8, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x1F, 0x19, 0xFE, 0xDC,
  0x1E, 0xC0, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0D, 0x80, 0xEE, 0x0F, 0x3F, 0xD8,
  0xF8, 0xC0, 0x0F, 0x81, 0xFF, 0x1C, 0x18, 0xC0, 0x6C, 0x03, 0x60, 0x1B,
  0x00, 0x5F, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x06, 0x3F, 0xE0, 0x7C, 0x00, 0x07, 0x87, 0xC7, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0xFF, 0x7F, 0x86, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x00, 0x1F, 0x19, 0xFE, 0xDC, 0x1E, 0xC0, 0x7C, 0x03, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0D, 0x80, 0xEE, 0x0F, 0x3F, 0xD8, 0xF8, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x19, 0x81, 0xC7, 0xFC, 0x0F, 0x80, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x8F, 0x93, 0xFA, 0xC3, 0xF0, 0x3C,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x5D, 0x80, 0x03, 0x6D, 0xB6,
  0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x08, 0x70, 0xC0, 0x00, 0x00, 0x03, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x18, 0x6F, 0xBC, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0xE8, 0x1C, 0x81, 0x88, 0x30, 0x86,
  0x08, 0xC0, 0x9C, 0x0B, 0x80, 0xB8, 0x0E, 0xC0, 0xCE, 0x08, 0x60, 0x83,
  0x08, 0x38, 0x81, 0x88, 0x0C, 0x80, 0xE8, 0x06, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC7, 0xC1, 0xF3, 0x3F, 0x9F, 0xED, 0x07, 0xC1, 0xFC,
  0x0E, 0x03, 0xE0, 0x38, 0x0F, 0x80, 0xE0, 0x3C, 0x03, 0x00, 0xF0, 0x0C,
  0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03,
  0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0,
  0x30, 0x0F, 0x00, 0xC0, 0x30, 0x8F, 0x93, 0xFA, 0xC3, 0xF0, 0x3C, 0x07,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x0F, 0x81, 0xFF, 0x1C, 0x1C, 0xC0,
  0x6C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0D, 0x80, 0xCE, 0x0E, 0x3F, 0xE0, 0x7C, 0x00,
  0x8F, 0x8B, 0xFC, 0xE0, 0xEC, 0x06, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x6E, 0x0E,
  0xBF, 0xC8, 0xF8, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x00, 0x1F, 0x13, 0xFD, 0x70, 0x76, 0x03, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x60,
  0x37, 0x07, 0x3F, 0xD1, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x8F, 0x7E, 0xC7, 0x0C, 0x18, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x00, 0x1F, 0x83, 0xFC, 0x60,
  0xEC, 0x06, 0xC0, 0x3C, 0x00, 0x60, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x06, 0x00, 0x3C, 0x03, 0xC0, 0x36, 0x06, 0x7F, 0xC1, 0xF8, 0x30,
  0x30, 0x30, 0x30, 0x30, 0xFF, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x18, 0x18, 0x1F, 0x0F, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x40, 0x36, 0x03, 0x60, 0x37, 0x0F, 0x3F, 0xF1,
  0xF3, 0xC0, 0x1E, 0x00, 0x98, 0x0C, 0xC0, 0x66, 0x03, 0x18, 0x30, 0xC1,
  0x86, 0x0C, 0x10, 0xC0, 0xC6, 0x06, 0x30, 0x11, 0x00, 0xD8, 0x06, 0xC0,
  0x14, 0x00, 0xE0, 0x07, 0x00, 0x10, 0x00, 0xC0, 0x60, 0x32, 0x03, 0x81,
  0x98, 0x1C, 0x0C, 0xC0, 0xE0, 0x66, 0x0D, 0x02, 0x10, 0x6C, 0x30, 0xC2,
  0x61, 0x86, 0x13, 0x0C, 0x31, 0x88, 0x40, 0x8C, 0x66, 0x06, 0x43, 0x30,
  0x36, 0x09, 0x81, 0xB0, 0x68, 0x05, 0x83, 0xC0, 0x38, 0x1E, 0x01, 0xC0,
  0x70, 0x0E, 0x03, 0x00, 0x20, 0x18, 0x00, 0x60, 0x33, 0x01, 0x8C, 0x18,
  0x60, 0xC1, 0x8C, 0x0E, 0xE0, 0x36, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0x60, 0x1B, 0x01, 0x8C, 0x0C, 0x60, 0xC1, 0x8E, 0x0E, 0x60, 0x37, 0x01,
  0xC0, 0xC0, 0x1E, 0x01, 0x98, 0x0C, 0xC0, 0x66, 0x02, 0x18, 0x30, 0xC1,
  0x86, 0x0C, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x13, 0x00, 0xD8, 0x06, 0xC0,
  0x14, 0x00, 0xE0, 0x07, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x70, 0x0F, 0x00, 0x70, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0xE0, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x30, 0x07, 0x00, 0x60, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0x81, 0xC1,
  0x81, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80,
  0xC0, 0x60, 0x70, 0xF0, 0x78, 0x0C, 0x03, 0x01, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x03, 0x80, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0xE0, 0x60, 0x30,
  0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C,
  0x07, 0x07, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x30, 0x30, 0x60, 0xE0, 0x80, 0x1E, 0x01, 0x3F, 0x01, 0x63, 0x83,
  0x60, 0xC3, 0xC0, 0x7E, 0xC0, 0x3C,
};

const GFXglyph RobotoCondensed_Light35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 25, 8, 3, -25 },
  { 8, 6, 8, 10, 2, -26 },
  { 14, 16, 25, 18, 2, -25 },
  { 64, 13, 31, 17, 2, -28 },
  { 115, 19, 25, 22, 2, -25 },
  { 175, 16, 25, 19, 2, -25 },
  { 225, 2, 8, 6, 2, -26 },
  { 227, 7, 36, 10, 2, -28 },
  { 259, 7, 36, 10, 1, -28 },
  { 291, 14, 14, 15, 0, -25 },
  { 316, 15, 18, 17, 1, -21 },
  { 350, 4, 8, 7, 1, -3 },
  { 354, 7, 2, 9, 1, -12 },
  { 356, 3, 3, 8, 2, -3 },
  { 358, 10, 27, 12, 1, -25 },
  { 392, 13, 25, 17, 2, -25 },
  { 433, 7, 25, 17, 3, -25 },
  { 455, 13, 25, 17, 2, -25 },
  { 496, 13, 25, 17, 2, -25 },
  { 537, 15, 25, 17, 1, -25 },
  { 584, 12, 25, 17, 3, -25 },
  { 622, 13, 25, 17, 2, -25 },
  { 663, 14, 25, 17, 1, -25 },
  { 707, 13, 25, 17, 2, -25 },
  { 748, 13, 25, 17, 2, -25 },
  { 789, 3, 19, 7, 2, -19 },
  { 797, 4, 24, 7, 1, -19 },
  { 809, 12, 15, 16, 1, -19 },
  { 832, 11, 9, 17, 3, -16 },
  { 845, 12, 15, 16, 2, -19 },
  { 868, 11, 25, 14, 2, -25 },
  { 903, 24, 32, 27, 2, -24 },
  { 999, 17, 25, 19, 1, -25 },
  { 1053, 14, 25, 19, 3, -25 },
  { 1097, 16, 25, 20, 2, -25 },
  { 1147, 15, 25, 20, 3, -25 },
  { 1194, 13, 25, 17, 3, -25 },
  { 1235, 13, 25, 17, 3, -25 },
  { 1276, 15, 25, 21, 3, -25 },
  { 1323, 16, 25, 22, 3, -25 },
  { 1373, 2, 25, 9, 3, -25 },
  { 1380, 13, 25, 17, 1, -25 },
  { 1421, 15, 25, 19, 3, -25 },
  { 1468, 12, 25, 16, 3, -25 },
  { 1506, 20, 25, 26, 3, -25 },
  { 1569, 16, 25, 22, 3, -25 },
  { 1619, 16, 25, 21, 2, -25 },
  { 1669, 14, 25, 19, 3, -25 },
  { 1713, 16, 29, 21, 2, -25 },
  { 1771, 15, 25, 19, 3, -25 },
  { 1818, 15, 25, 18, 2, -25 },
  { 1865, 16, 25, 18, 1, -25 },
  { 1915, 14, 25, 20, 3, -25 },
  { 1959, 17, 25, 19, 1, -25 },
  { 2013, 25, 25, 27, 1, -25 },
  { 2092, 17, 25, 19, 1, -25 },
  { 2146, 17, 25, 18, 1, -25 },
  { 2200, 15, 25, 18, 2, -25 },
  { 2247, 5, 33, 8, 3, -28 },
  { 2268, 11, 27, 12, 1, -25 },
  { 2306, 5, 33, 8, 0, -28 },
  { 2327, 10, 12, 13, 1, -25 },
  { 2342, 13, 2, 13, 0, 0 },
  { 2346, 6, 5, 10, 2, -26 },
  { 2350, 12, 18, 16, 2, -18 },
  { 2377, 12, 26, 17, 3, -26 },
  { 2416, 12, 18, 16, 2, -18 },
  { 2443, 13, 26, 17, 2, -26 },
  { 2486, 13, 18, 16, 2, -18 },
  { 2516, 9, 26, 11, 1, -26 },
  { 2546, 13, 25, 17, 2, -18 },
  { 2587, 11, 26, 17, 3, -26 },
  { 2623, 3, 25, 7, 2, -25 },
  { 2633, 6, 32, 7, -1, -25 },
  { 2657, 12, 26, 15, 3, -26 },
  { 2696, 2, 26, 7, 3, -26 },
  { 2703, 22, 18, 27, 2, -18 },
  { 2753, 11, 18, 17, 3, -18 },
  { 2778, 13, 18, 17, 2, -18 },
  { 2808, 12, 25, 17, 3, -18 },
  { 2846, 12, 25, 17, 2, -18 },
  { 2884, 7, 18, 11, 3, -18 },
  { 2900, 12, 18, 16, 2, -18 },
  { 2927, 8, 23, 10, 1, -23 },
  { 2950, 12, 18, 17, 2, -18 },
  { 2977, 13, 18, 15, 1, -18 },
  { 3007, 21, 18, 23, 1, -18 },
  { 3055, 13, 18, 15, 1, -18 },
  { 3085, 13, 25, 15, 1, -18 },
  { 3126, 12, 18, 15, 2, -18 },
  { 3153, 9, 34, 10, 1, -27 },
  { 3192, 2, 30, 8, 3, -25 },
  { 3200, 8, 34, 10, 1, -27 },
  { 3234, 16, 6, 21, 2, -13 },
};

const GFXfont RobotoCondensed_Light35pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light35pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light35pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _ROBOTOCONDENSED_LIGHT35PT7B_H_
