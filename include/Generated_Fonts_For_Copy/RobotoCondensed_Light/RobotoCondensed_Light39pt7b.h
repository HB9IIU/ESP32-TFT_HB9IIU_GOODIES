#ifndef _ROBOTOCONDENSED_LIGHT39PT7B_H_
#define _ROBOTOCONDENSED_LIGHT39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light39pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x00, 0x1B, 0xE0,
  0xCF, 0x3C, 0xF3, 0xCF, 0x38, 0xE3, 0x8C, 0x01, 0x82, 0x00, 0x61, 0x80,
  0x10, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x40, 0x0C,
  0x30, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x08,
  0x01, 0x82, 0x00, 0x61, 0x80, 0x10, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x0F,
  0xFF, 0xF3, 0xFF, 0xFC, 0x0C, 0x30, 0x02, 0x0C, 0x00, 0x83, 0x00, 0x60,
  0xC0, 0x18, 0x30, 0x06, 0x08, 0x01, 0x86, 0x00, 0x41, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x7C, 0x03, 0xFE, 0x0F, 0x0E, 0x18,
  0x0E, 0x70, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x76, 0x00, 0xEE, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x3B, 0x00, 0x67, 0x01, 0xC7, 0x07, 0x07, 0xFC, 0x03, 0xF0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x18,
  0x60, 0x01, 0x83, 0x02, 0x0C, 0x18, 0x18, 0x60, 0x41, 0x83, 0x02, 0x08,
  0x18, 0x10, 0xC0, 0xC1, 0x84, 0x06, 0x0C, 0x60, 0x18, 0x62, 0x00, 0x7E,
  0x30, 0x01, 0xE3, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x78,
  0x00, 0xC7, 0xF0, 0x06, 0x61, 0x80, 0x63, 0x06, 0x03, 0x18, 0x30, 0x30,
  0x81, 0x81, 0x04, 0x0C, 0x18, 0x20, 0x60, 0x81, 0x83, 0x0C, 0x0C, 0x18,
  0x00, 0x71, 0x80, 0x01, 0xFC, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xF8,
  0x01, 0xC7, 0x00, 0x60, 0xC0, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xC0, 0x38, 0x70, 0x06, 0x38, 0x01, 0xDC, 0x00, 0x3E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0xE6, 0x06, 0x71, 0xC1, 0x98, 0x38,
  0x6E, 0x06, 0x1B, 0x00, 0xCC, 0xC0, 0x3B, 0x30, 0x07, 0xCC, 0x00, 0xE1,
  0x80, 0x38, 0x70, 0x1F, 0x0E, 0x0E, 0xC1, 0xFF, 0x18, 0x3F, 0x07, 0xFF,
  0xFF, 0xC0, 0x02, 0x0C, 0x18, 0x61, 0x83, 0x0C, 0x18, 0x60, 0xC1, 0x83,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0xC0, 0xC1,
  0x81, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x0E,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x07, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18,
  0x30, 0x30, 0x60, 0xC0, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x18, 0x60, 0xFE, 0xCF, 0x9F, 0xFC, 0x07, 0xC0, 0x0F, 0x00,
  0x1B, 0x00, 0x67, 0x01, 0xC6, 0x03, 0x06, 0x0C, 0x0E, 0x08, 0x08, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x33, 0x33, 0x37, 0x6E, 0x40, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xE1, 0xE1,
  0x80, 0xC7, 0x01, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x06, 0xE0, 0x0D, 0x80,
  0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3F, 0x00, 0x76, 0x00, 0xCC, 0x01, 0x98,
  0x03, 0x38, 0x0E, 0x30, 0x18, 0x70, 0xF0, 0x7F, 0xC0, 0x3E, 0x00, 0x01,
  0x83, 0xC7, 0xFF, 0x7E, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x07, 0xC0, 0x3F, 0xE0, 0xE1,
  0xE3, 0x80, 0xC6, 0x01, 0xDC, 0x01, 0xB0, 0x03, 0x60, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0xFF, 0xFB, 0xFF, 0xF0,
  0x07, 0xC0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xC6, 0x01, 0xCC, 0x01, 0xB0,
  0x03, 0x60, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x07,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0x30, 0x06, 0x70, 0x1C, 0x70,
  0x70, 0x7F, 0xC0, 0x3E, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x03, 0x30, 0x03, 0x98,
  0x01, 0x8C, 0x01, 0xC6, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x60,
  0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x18, 0x06, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x3F, 0xFC, 0xFF, 0xF3, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x7C,
  0x1F, 0xF8, 0x78, 0x71, 0x80, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xD8, 0x06, 0x70,
  0x18, 0xE1, 0xC1, 0xFF, 0x03, 0xF0, 0x00, 0xF0, 0x07, 0xE0, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x8F, 0x83, 0x7F, 0x87, 0xC3, 0x9E, 0x03, 0xB8, 0x03, 0x70, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8,
  0x03, 0x18, 0x06, 0x38, 0x1C, 0x38, 0x70, 0x3F, 0xC0, 0x3F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xE0, 0xE1, 0x80, 0xC6,
  0x01, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x80,
  0x31, 0x80, 0xC3, 0x83, 0x81, 0xFC, 0x07, 0xFC, 0x1C, 0x1C, 0x70, 0x1C,
  0xC0, 0x1B, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xB0,
  0x06, 0x70, 0x1C, 0x70, 0x70, 0x7F, 0xC0, 0x7F, 0x00, 0x07, 0xC0, 0x7F,
  0x83, 0x87, 0x1C, 0x0E, 0x60, 0x19, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x36, 0x01, 0xDC,
  0x0F, 0x38, 0x7C, 0x7F, 0xB0, 0xF8, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x70, 0x07, 0x81, 0xFC, 0x07, 0x80, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x33, 0xCC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x8C, 0x63, 0x18, 0xCC, 0x62, 0x00, 0x00,
  0x08, 0x01, 0xC0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x00,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x03, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0C,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x38, 0x00,
  0x80, 0x00, 0x1F, 0x83, 0xFC, 0x70, 0xEE, 0x06, 0xC0, 0x7C, 0x03, 0xC0,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03,
  0x80, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x1C, 0x03, 0xC0, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06, 0x30, 0x0F,
  0x80, 0x8C, 0x07, 0xF0, 0x32, 0x03, 0x06, 0x0D, 0x81, 0x81, 0x83, 0x60,
  0x60, 0x60, 0x58, 0x30, 0x10, 0x14, 0x0C, 0x04, 0x07, 0x03, 0x03, 0x01,
  0xC0, 0x80, 0xC0, 0x70, 0x60, 0x30, 0x1C, 0x18, 0x0C, 0x07, 0x06, 0x03,
  0x01, 0xC1, 0x80, 0xC0, 0xF0, 0x60, 0x30, 0x3C, 0x18, 0x1C, 0x09, 0x03,
  0x07, 0x06, 0x60, 0xC3, 0x63, 0x18, 0x1F, 0x9F, 0xC6, 0x03, 0xC3, 0xC1,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x10, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xB0, 0x00, 0x1B, 0x00, 0x01, 0x98, 0x00, 0x31,
  0x80, 0x03, 0x18, 0x00, 0x30, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x06,
  0x06, 0x00, 0xE0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x70, 0x1C, 0x03, 0x01,
  0x80, 0x30, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x30, 0x01, 0x83, 0x00, 0x1C,
  0x30, 0x00, 0xC7, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x06, 0xE0, 0x00,
  0x6C, 0x00, 0x06, 0xFF, 0xE0, 0xFF, 0xF0, 0xC0, 0x38, 0xC0, 0x1C, 0xC0,
  0x0C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0,
  0x0C, 0xC0, 0x1C, 0xC0, 0x38, 0xFF, 0xF0, 0xFF, 0xF8, 0xC0, 0x1C, 0xC0,
  0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x1C, 0xFF, 0xF8, 0xFF, 0xE0, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0x07, 0x86, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x1B,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1D, 0x80, 0x0C,
  0xC0, 0x06, 0x30, 0x06, 0x1E, 0x0F, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x30, 0x0F, 0x18, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x3B,
  0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x1D,
  0x80, 0x0C, 0xC0, 0x1C, 0x60, 0x1E, 0x3F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1F,
  0xFF, 0x3F, 0xFE, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0x3F, 0xFE, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x07, 0xF0, 0x0F,
  0xFE, 0x0F, 0x07, 0x86, 0x00, 0xE6, 0x00, 0x33, 0x00, 0x1F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0D, 0x80, 0x06, 0xE0, 0x03,
  0x38, 0x03, 0x8F, 0x07, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7E, 0x00, 0xEC, 0x01,
  0xD8, 0x03, 0x30, 0x06, 0x70, 0x1C, 0x70, 0x70, 0x7F, 0xC0, 0x3E, 0x00,
  0xC0, 0x03, 0x30, 0x01, 0xCC, 0x00, 0xE3, 0x00, 0x70, 0xC0, 0x18, 0x30,
  0x0E, 0x0C, 0x07, 0x03, 0x03, 0x80, 0xC1, 0xC0, 0x30, 0x60, 0x0C, 0x38,
  0x03, 0x1C, 0x00, 0xCE, 0x00, 0x33, 0xC0, 0x0D, 0xB8, 0x03, 0xE6, 0x00,
  0xF1, 0xC0, 0x38, 0x38, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0xC0, 0x38, 0x30,
  0x06, 0x0C, 0x01, 0xC3, 0x00, 0x38, 0xC0, 0x06, 0x30, 0x01, 0xCC, 0x00,
  0x3B, 0x00, 0x06, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFD, 0x80, 0x03, 0xFB, 0x00, 0x06, 0xF6, 0x00, 0x0D,
  0xE6, 0x00, 0x3B, 0xCC, 0x00, 0x67, 0x98, 0x00, 0xCF, 0x18, 0x03, 0x9E,
  0x30, 0x06, 0x3C, 0x60, 0x0C, 0x78, 0x60, 0x30, 0xF0, 0xC0, 0x61, 0xE1,
  0x80, 0xC3, 0xC1, 0x83, 0x07, 0x83, 0x06, 0x0F, 0x06, 0x0C, 0x1E, 0x06,
  0x30, 0x3C, 0x0C, 0x60, 0x78, 0x1C, 0xC0, 0xF0, 0x1B, 0x01, 0xE0, 0x36,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x00, 0xC0,
  0x30, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x3E, 0xC0, 0x0F, 0xB8, 0x03, 0xE6, 0x00, 0xF9, 0xC0, 0x3E,
  0x30, 0x0F, 0x86, 0x03, 0xE1, 0x80, 0xF8, 0x30, 0x3E, 0x0C, 0x0F, 0x81,
  0x83, 0xE0, 0x70, 0xF8, 0x0C, 0x3E, 0x03, 0x8F, 0x80, 0x63, 0xE0, 0x1C,
  0xF8, 0x03, 0x3E, 0x00, 0x6F, 0x80, 0x1B, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0x07, 0x8E, 0x00,
  0xE6, 0x00, 0x37, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x0E, 0xC0, 0x06, 0x70, 0x07, 0x1E, 0x0F, 0x07,
  0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xC0, 0x1C, 0xC0, 0x0E,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0E, 0xC0, 0x1C, 0xFF, 0xF8,
  0xFF, 0xF0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x03, 0xF8, 0x03, 0xFF, 0x81, 0xE0, 0xF0, 0xE0, 0x0C, 0x30, 0x01, 0x9C,
  0x00, 0x66, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8,
  0x00, 0x37, 0x00, 0x18, 0xC0, 0x06, 0x38, 0x03, 0x07, 0x83, 0xC0, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0x80, 0xFF, 0xE0, 0x7F, 0xFC, 0x30, 0x0F, 0x18, 0x01, 0xCC,
  0x00, 0x66, 0x00, 0x3B, 0x00, 0x1D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x03,
  0xB0, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xE6, 0x00, 0xE3, 0xFF, 0xE1, 0xFF,
  0xC0, 0xC0, 0x70, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x03, 0x0C, 0x01, 0x86,
  0x00, 0xE3, 0x00, 0x31, 0x80, 0x1C, 0xC0, 0x06, 0x60, 0x03, 0xB0, 0x00,
  0xD8, 0x00, 0x70, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0x07, 0x0E, 0x01, 0xC6,
  0x00, 0x73, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x6C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0D, 0xC0, 0x06, 0x70, 0x07, 0x1E, 0x0F, 0x07, 0xFF,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0x60, 0x07, 0x70, 0x0E, 0x3C, 0x1C, 0x1F, 0xF8,
  0x07, 0xE0, 0xC0, 0x00, 0x7C, 0x00, 0x1D, 0x80, 0x03, 0x30, 0x00, 0x67,
  0x00, 0x0C, 0x60, 0x03, 0x8C, 0x00, 0x61, 0x80, 0x0C, 0x18, 0x03, 0x83,
  0x00, 0x60, 0x60, 0x0C, 0x0E, 0x03, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x03,
  0x81, 0x80, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x70, 0x01,
  0x8C, 0x00, 0x31, 0x80, 0x03, 0x70, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01,
  0xB0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0xE0, 0x06, 0x00,
  0x36, 0x00, 0x60, 0x07, 0x60, 0x07, 0x00, 0x66, 0x00, 0xF0, 0x06, 0x70,
  0x0F, 0x00, 0x63, 0x00, 0xD0, 0x06, 0x30, 0x0D, 0x80, 0xE3, 0x01, 0x98,
  0x0C, 0x30, 0x19, 0x80, 0xC3, 0x81, 0x88, 0x0C, 0x18, 0x18, 0xC0, 0xC1,
  0x83, 0x0C, 0x18, 0x18, 0x30, 0xC1, 0x81, 0x83, 0x0C, 0x18, 0x1C, 0x30,
  0x61, 0x80, 0xC6, 0x06, 0x18, 0x0C, 0x60, 0x63, 0x00, 0xC6, 0x06, 0x30,
  0x0C, 0x60, 0x33, 0x00, 0xEC, 0x03, 0x30, 0x06, 0xC0, 0x33, 0x00, 0x6C,
  0x03, 0x60, 0x06, 0xC0, 0x16, 0x00, 0x68, 0x01, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x38, 0x01, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x60,
  0x00, 0xCE, 0x00, 0x38, 0xC0, 0x0E, 0x1C, 0x01, 0x81, 0xC0, 0x70, 0x18,
  0x0C, 0x03, 0x83, 0x80, 0x30, 0x60, 0x07, 0x1C, 0x00, 0x63, 0x00, 0x0E,
  0xE0, 0x00, 0xD8, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x80, 0x01, 0xB0, 0x00, 0x77, 0x00, 0x0C, 0x60, 0x03, 0x0E, 0x00, 0xE0,
  0xC0, 0x18, 0x0C, 0x07, 0x01, 0xC0, 0xC0, 0x18, 0x38, 0x03, 0x86, 0x00,
  0x31, 0xC0, 0x07, 0x30, 0x00, 0x60, 0xE0, 0x00, 0xDC, 0x00, 0x39, 0x80,
  0x06, 0x38, 0x01, 0xC3, 0x00, 0x30, 0x70, 0x06, 0x06, 0x01, 0xC0, 0xE0,
  0x30, 0x0C, 0x0E, 0x01, 0xC1, 0x80, 0x18, 0x70, 0x03, 0x0C, 0x00, 0x33,
  0x80, 0x06, 0x60, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F,
  0xFC, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0xFF, 0xF0,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0xFF, 0xF0, 0x0C, 0x01, 0x80, 0x38, 0x0F, 0x01, 0xA0, 0x66, 0x0C,
  0xC1, 0x88, 0x61, 0x8C, 0x31, 0x83, 0x60, 0x6C, 0x0D, 0x80, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE1, 0xC3, 0x86, 0x0C, 0x0F, 0xC0, 0x7F, 0xC3, 0x83,
  0x98, 0x06, 0x60, 0x1B, 0x80, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x3F,
  0xE3, 0xFF, 0x9E, 0x06, 0x60, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0,
  0x1B, 0x80, 0xE7, 0x0F, 0xDF, 0xF7, 0x1F, 0x0C, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC7, 0xC3,
  0x7F, 0xCF, 0x87, 0x38, 0x0E, 0xE0, 0x1B, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0xC0, 0x1B, 0x80, 0xEF, 0x87, 0x37, 0xF8, 0xC7, 0xC0, 0x0F,
  0xC0, 0x7F, 0xC3, 0x83, 0x9C, 0x06, 0x60, 0x1F, 0x80, 0x3C, 0x00, 0xF0,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0xF8, 0x03, 0x60, 0x1D, 0xC0, 0x63, 0x83, 0x87, 0xFC, 0x0F, 0xC0,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x0F, 0x8C, 0x7F, 0xB3, 0x87, 0xDC, 0x07, 0x60, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0x60, 0x0D, 0xC0, 0x73, 0x87, 0xC7,
  0xFB, 0x0F, 0x8C, 0x07, 0xC0, 0x7F, 0xC3, 0x87, 0x9C, 0x06, 0x60, 0x1F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x23, 0x83,
  0xC7, 0xFE, 0x07, 0xE0, 0x03, 0xC1, 0xF0, 0xE0, 0x30, 0x1C, 0x06, 0x01,
  0x80, 0x60, 0xFF, 0xBF, 0xE1, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x00, 0x0F, 0x8C, 0x7F, 0xB3, 0x87, 0xDC, 0x07,
  0x60, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0x60, 0x0D, 0xC0,
  0x73, 0x87, 0xC7, 0xFB, 0x0F, 0x8C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x80, 0x67, 0x83, 0x87, 0xFC, 0x07, 0xC0, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC7, 0xC6, 0x7F,
  0x36, 0x1D, 0xE0, 0x6E, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0x80, 0xDF, 0x00, 0x06, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x0C, 0x30, 0xC0, 0x00, 0x00,
  0x03, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x7F, 0xBC, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x36, 0x03, 0xB0, 0x39, 0x83, 0x8C, 0x38, 0x61, 0x83, 0x18, 0x19, 0xC0,
  0xDC, 0x07, 0xE0, 0x3F, 0x81, 0xCC, 0x0C, 0x70, 0x61, 0xC3, 0x06, 0x18,
  0x38, 0xC0, 0xE6, 0x03, 0x30, 0x1D, 0x80, 0x6C, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC7, 0xC0, 0xF8, 0xDF, 0xE3, 0xFC,
  0xF8, 0x77, 0x0E, 0xE0, 0x36, 0x06, 0xE0, 0x3C, 0x03, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC7, 0xC6, 0x7F,
  0x36, 0x1D, 0xE0, 0x6E, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0x80, 0x07, 0xC0, 0x3F, 0xE0,
  0xE0, 0xE3, 0x80, 0xE6, 0x00, 0xCC, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xB0, 0x07, 0x60, 0x0C, 0xE0, 0x38, 0xE0, 0xE0, 0xFF, 0x80, 0x7C, 0x00,
  0xC7, 0xC3, 0x7F, 0xCF, 0x07, 0x38, 0x0E, 0xC0, 0x1B, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1B, 0x80, 0xEF, 0x07, 0x37, 0xF8, 0xC7,
  0xC3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x0F, 0x8C, 0x7F, 0xB3, 0x83, 0xDC, 0x07, 0x60, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0x60, 0x0D, 0xC0, 0x73, 0x83,
  0xC7, 0xFB, 0x0F, 0x8C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0xC7, 0xDF, 0xF8, 0xF0, 0xE0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x0F, 0xC1, 0xFF, 0x1C, 0x1C, 0xC0, 0x76, 0x01, 0xB0,
  0x0D, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x78, 0x03, 0xC0, 0x1B, 0x00, 0xDC, 0x1C, 0x7F, 0xE0,
  0xFC, 0x00, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x87, 0xFF, 0xFE, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x38, 0x0F, 0x83, 0xC0, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3F,
  0x01, 0xDC, 0x3E, 0x7F, 0xB1, 0xF1, 0x80, 0xC0, 0x0D, 0xC0, 0x19, 0x80,
  0x33, 0x00, 0xC6, 0x01, 0x86, 0x03, 0x0C, 0x0E, 0x18, 0x18, 0x18, 0x30,
  0x30, 0x60, 0x61, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x98, 0x03, 0x30, 0x03,
  0x60, 0x06, 0xC0, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x18, 0x06, 0xC0, 0x70, 0x1D, 0x80, 0xE0, 0x33, 0x01, 0xC0, 0x67, 0x02,
  0xC0, 0xC6, 0x0D, 0x81, 0x8C, 0x1B, 0x06, 0x18, 0x33, 0x0C, 0x30, 0x46,
  0x18, 0x31, 0x8C, 0x30, 0x63, 0x18, 0xE0, 0xC6, 0x19, 0x81, 0x98, 0x33,
  0x01, 0xB0, 0x66, 0x03, 0x60, 0xCC, 0x06, 0xC0, 0xF0, 0x0F, 0x01, 0xE0,
  0x0E, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0x60, 0x0C, 0xE0, 0x38, 0xC0, 0x61, 0xC1, 0x81, 0x87, 0x03, 0x8C, 0x03,
  0x38, 0x03, 0x60, 0x07, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x6C,
  0x01, 0xD8, 0x03, 0x18, 0x0E, 0x30, 0x18, 0x30, 0x70, 0x70, 0xC0, 0x63,
  0x00, 0xEE, 0x00, 0xC0, 0xC0, 0x0F, 0x80, 0x36, 0x01, 0xD8, 0x06, 0x70,
  0x18, 0xC0, 0x63, 0x03, 0x8C, 0x0C, 0x18, 0x30, 0x61, 0xC1, 0x86, 0x03,
  0x18, 0x0C, 0x60, 0x33, 0x00, 0xEC, 0x01, 0xB0, 0x07, 0xC0, 0x1E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x1E, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x70, 0x30, 0x1C, 0x06,
  0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x1C, 0x0E, 0x0F, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01,
  0x80, 0x70, 0x0C, 0x01, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x18, 0x0C, 0x03, 0x00,
  0xE0, 0x70, 0x60, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x0E, 0x0E, 0x04, 0x00, 0x3E, 0x00,
  0xBF, 0x80, 0x78, 0xE0, 0x78, 0x38, 0x3C, 0x0E, 0x36, 0x03, 0xF8, 0x00,
  0x78,
};

const GFXglyph RobotoCondensed_Light39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 28, 8, 3, -28 },
  { 12, 6, 9, 11, 3, -29 },
  { 19, 18, 28, 20, 2, -28 },
  { 82, 15, 36, 19, 2, -32 },
  { 150, 21, 28, 25, 2, -28 },
  { 224, 18, 28, 21, 2, -28 },
  { 287, 2, 9, 7, 2, -29 },
  { 290, 7, 40, 11, 3, -31 },
  { 325, 8, 40, 12, 1, -31 },
  { 365, 15, 16, 17, 1, -28 },
  { 395, 16, 20, 19, 2, -23 },
  { 435, 4, 9, 8, 1, -4 },
  { 440, 8, 2, 10, 1, -13 },
  { 442, 3, 3, 9, 3, -3 },
  { 444, 11, 30, 14, 1, -28 },
  { 486, 15, 28, 19, 2, -28 },
  { 539, 9, 28, 19, 3, -28 },
  { 571, 15, 28, 19, 2, -28 },
  { 624, 15, 28, 19, 2, -28 },
  { 677, 17, 28, 19, 1, -28 },
  { 737, 14, 28, 19, 3, -28 },
  { 786, 15, 28, 19, 2, -28 },
  { 839, 15, 28, 19, 2, -28 },
  { 892, 15, 28, 19, 2, -28 },
  { 945, 14, 28, 19, 2, -28 },
  { 994, 3, 21, 8, 3, -21 },
  { 1002, 5, 26, 7, 1, -21 },
  { 1019, 13, 17, 18, 2, -21 },
  { 1047, 13, 10, 19, 3, -18 },
  { 1064, 14, 17, 18, 2, -21 },
  { 1094, 12, 28, 16, 2, -28 },
  { 1136, 26, 36, 31, 2, -27 },
  { 1253, 20, 28, 21, 1, -28 },
  { 1323, 16, 28, 21, 3, -28 },
  { 1379, 17, 28, 22, 3, -28 },
  { 1439, 17, 28, 22, 3, -28 },
  { 1499, 15, 28, 19, 3, -28 },
  { 1552, 15, 28, 19, 3, -28 },
  { 1605, 17, 28, 23, 3, -28 },
  { 1665, 18, 28, 24, 3, -28 },
  { 1728, 2, 28, 10, 4, -28 },
  { 1735, 15, 28, 19, 1, -28 },
  { 1788, 18, 28, 21, 3, -28 },
  { 1851, 14, 28, 18, 3, -28 },
  { 1900, 23, 28, 29, 3, -28 },
  { 1981, 18, 28, 24, 3, -28 },
  { 2044, 17, 28, 23, 3, -28 },
  { 2104, 16, 28, 21, 3, -28 },
  { 2160, 18, 33, 23, 2, -28 },
  { 2235, 17, 28, 21, 3, -28 },
  { 2295, 17, 28, 20, 2, -28 },
  { 2355, 18, 28, 20, 1, -28 },
  { 2418, 16, 28, 22, 3, -28 },
  { 2474, 19, 28, 21, 1, -28 },
  { 2541, 28, 28, 30, 1, -28 },
  { 2639, 19, 28, 21, 1, -28 },
  { 2706, 19, 28, 20, 1, -28 },
  { 2773, 17, 28, 20, 2, -28 },
  { 2833, 5, 38, 9, 3, -32 },
  { 2857, 12, 30, 14, 1, -28 },
  { 2902, 6, 38, 9, 0, -32 },
  { 2931, 11, 14, 14, 2, -28 },
  { 2951, 15, 2, 15, 0, 0 },
  { 2955, 6, 5, 11, 2, -29 },
  { 2959, 14, 21, 18, 2, -21 },
  { 2996, 14, 29, 19, 3, -29 },
  { 3047, 14, 21, 18, 2, -21 },
  { 3084, 14, 29, 19, 2, -29 },
  { 3135, 14, 21, 18, 2, -21 },
  { 3172, 10, 29, 12, 1, -29 },
  { 3209, 14, 29, 19, 2, -21 },
  { 3260, 13, 29, 19, 3, -29 },
  { 3308, 3, 28, 8, 3, -28 },
  { 3319, 6, 36, 8, -1, -28 },
  { 3346, 13, 29, 17, 3, -29 },
  { 3394, 2, 29, 8, 3, -29 },
  { 3402, 24, 21, 30, 3, -21 },
  { 3465, 13, 21, 19, 3, -21 },
  { 3500, 15, 21, 19, 2, -21 },
  { 3540, 14, 29, 19, 3, -21 },
  { 3591, 14, 29, 19, 2, -21 },
  { 3642, 8, 21, 12, 3, -21 },
  { 3663, 13, 21, 17, 2, -21 },
  { 3698, 9, 26, 11, 1, -26 },
  { 3728, 13, 21, 19, 3, -21 },
  { 3763, 15, 21, 17, 1, -21 },
  { 3803, 23, 21, 25, 1, -21 },
  { 3864, 15, 21, 17, 1, -21 },
  { 3904, 14, 29, 16, 1, -21 },
  { 3955, 13, 21, 17, 2, -21 },
  { 3990, 10, 38, 12, 1, -30 },
  { 4038, 2, 33, 9, 3, -28 },
  { 4047, 9, 38, 12, 1, -30 },
  { 4090, 17, 7, 23, 3, -15 },
};

const GFXfont RobotoCondensed_Light39pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light39pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light39pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOCONDENSED_LIGHT39PT7B_H_
