#ifndef _ROBOTOCONDENSED_LIGHT60PT7B_H_
#define _ROBOTOCONDENSED_LIGHT60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light60pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0xFF, 0xDC, 0x40, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x00, 0x1C,
  0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x60, 0x18, 0x00, 0x1C, 0x03, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0x80,
  0x70, 0x00, 0x30, 0x0C, 0x00, 0x0E, 0x01, 0x80, 0x01, 0xC0, 0x70, 0x00,
  0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF8, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0C, 0x03, 0x80, 0x01, 0x80, 0x60,
  0x00, 0x70, 0x0C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x38,
  0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE0, 0x1C, 0x07, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x60, 0x18, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x30, 0x0E,
  0x00, 0x06, 0x01, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3E, 0x07, 0xC0, 0xF0, 0x03, 0xC1, 0xC0,
  0x07, 0x87, 0x80, 0x07, 0x8E, 0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0xF3, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x1E, 0xE0, 0x00,
  0x3D, 0xC0, 0x00, 0x73, 0xC0, 0x00, 0xE3, 0xC0, 0x03, 0xC7, 0xC0, 0x0F,
  0x07, 0xC0, 0x3E, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x60, 0x1C, 0x01, 0x80, 0xE0, 0x0C, 0x01,
  0xC0, 0xE0, 0x0C, 0x03, 0x80, 0xE0, 0x0C, 0x03, 0x00, 0xE0, 0x0C, 0x07,
  0x00, 0xE0, 0x0C, 0x06, 0x00, 0xE0, 0x0C, 0x0E, 0x00, 0xE0, 0x0C, 0x0C,
  0x00, 0x60, 0x1C, 0x1C, 0x00, 0x70, 0x1C, 0x18, 0x00, 0x70, 0x38, 0x38,
  0x00, 0x3C, 0x78, 0x30, 0x00, 0x1F, 0xF0, 0x70, 0x00, 0x0F, 0xE0, 0xE0,
  0x00, 0x01, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x40, 0x00, 0x07, 0x03,
  0xF8, 0x00, 0x07, 0x07, 0xFC, 0x00, 0x0E, 0x0E, 0x1E, 0x00, 0x0E, 0x1C,
  0x0E, 0x00, 0x1C, 0x1C, 0x07, 0x00, 0x1C, 0x38, 0x07, 0x00, 0x38, 0x38,
  0x03, 0x00, 0x30, 0x38, 0x03, 0x00, 0x70, 0x38, 0x03, 0x00, 0x60, 0x38,
  0x03, 0x00, 0xE0, 0x38, 0x03, 0x00, 0xC0, 0x38, 0x03, 0x01, 0xC0, 0x38,
  0x03, 0x01, 0x80, 0x38, 0x07, 0x01, 0x80, 0x1C, 0x07, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0,
  0x1E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x1E, 0x00, 0xF0,
  0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x70, 0x78,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFB, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x1C,
  0x3C, 0x0F, 0x01, 0xC3, 0x80, 0xF0, 0x1C, 0x78, 0x07, 0x81, 0xC7, 0x00,
  0x3C, 0x1C, 0xF0, 0x01, 0xC1, 0xCF, 0x00, 0x1E, 0x38, 0xF0, 0x00, 0xF3,
  0x8F, 0x00, 0x07, 0xB8, 0xF0, 0x00, 0x7F, 0x0F, 0x00, 0x03, 0xF0, 0x70,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3F, 0x03, 0xC0, 0x07,
  0xF8, 0x3E, 0x01, 0xF3, 0xC1, 0xFF, 0xFE, 0x3C, 0x07, 0xFF, 0xC1, 0xE0,
  0x3F, 0xF0, 0x0F, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xDB, 0x6C,
  0x00, 0x10, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0,
  0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x40, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x07, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x60, 0x04, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x40, 0x38, 0x02, 0xF8, 0x38, 0x1E, 0xFE, 0x18, 0x7F,
  0x7F, 0xDB, 0xFE, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xE7, 0x00, 0x01, 0xC7, 0x80,
  0x03, 0x83, 0xC0, 0x07, 0x81, 0xC0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xF0,
  0x0E, 0x00, 0x70, 0x04, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x71, 0xC7, 0x3C, 0xF3,
  0xCF, 0x39, 0xE7, 0x3C, 0xE1, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFE, 0xF2, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0,
  0x1E, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0x80, 0x0F, 0x1E, 0x00, 0x1C, 0x70,
  0x00, 0x71, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEF, 0x00,
  0x03, 0x9C, 0x00, 0x1E, 0x70, 0x00, 0x71, 0xE0, 0x03, 0xC3, 0x80, 0x0F,
  0x0F, 0x00, 0x78, 0x1E, 0x03, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x1F, 0xF3,
  0xFF, 0xFF, 0x1F, 0xE0, 0xFC, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x10, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x1F, 0x01, 0xF0, 0x3C, 0x00, 0xF0, 0x38, 0x00, 0x78,
  0x78, 0x00, 0x38, 0x70, 0x00, 0x38, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xFF, 0x01, 0xF0, 0x1F, 0x07, 0x80, 0x1E, 0x0E, 0x00, 0x1E, 0x3C,
  0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0xF7, 0x80,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x80, 0x00, 0xE7, 0x00,
  0x01, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x1F, 0x01,
  0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x1C, 0x00,
  0x3C, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x80, 0x70, 0x01, 0xC0, 0x1C,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0x70, 0x07, 0x00,
  0x1C, 0x03, 0x80, 0x07, 0x01, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x1F, 0x80, 0x77, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xC3, 0xF0, 0xF8,
  0x07, 0xC7, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0x3C, 0x00,
  0x78, 0xE0, 0x07, 0x87, 0xC0, 0x7C, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x1F,
  0x80, 0xF1, 0xFF, 0x83, 0x9F, 0xFF, 0x0E, 0xF8, 0x3E, 0x3F, 0x80, 0x7C,
  0xFC, 0x00, 0xF3, 0xE0, 0x01, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xF7, 0x00, 0x03, 0x9E, 0x00, 0x0E, 0x38, 0x00, 0x78, 0xF0,
  0x01, 0xC1, 0xE0, 0x0F, 0x07, 0xC0, 0x78, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xFF, 0x01, 0xF0, 0x1F, 0x03, 0xC0, 0x1F, 0x0F, 0x00, 0x1E, 0x1C,
  0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80,
  0x00, 0xE7, 0x00, 0x01, 0xCF, 0x00, 0x03, 0x9E, 0x00, 0x07, 0x1C, 0x00,
  0x1E, 0x3C, 0x00, 0x38, 0x38, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0x7C, 0x1F,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xC1, 0xF0,
  0x1E, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xE0, 0x00, 0xF3, 0xC0, 0x00, 0xE7,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xF7, 0x00,
  0x01, 0xEF, 0x00, 0x03, 0x9E, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x1F, 0x00,
  0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0,
  0x1F, 0x03, 0xE0, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x1E, 0x78,
  0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0,
  0x00, 0xF7, 0x80, 0x03, 0xCE, 0x00, 0x1F, 0x3C, 0x00, 0xFC, 0x78, 0x07,
  0x71, 0xF8, 0x7D, 0xC3, 0xFF, 0xE7, 0x07, 0xFE, 0x1C, 0x07, 0xE0, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01,
  0xF0, 0x00, 0xF7, 0xFF, 0xE2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xC4, 0x3C, 0x7C,
  0xF9, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x1E, 0x3C, 0x70, 0xE3, 0xCF, 0x1C, 0x10, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xC0,
  0xF8, 0xF0, 0x0F, 0x3C, 0x00, 0xF7, 0x80, 0x0E, 0xE0, 0x01, 0xDC, 0x00,
  0x3B, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x7C, 0x00, 0x30,
  0x70, 0x00, 0xFF, 0x80, 0x18, 0x38, 0x00, 0xFF, 0xE0, 0x0E, 0x38, 0x00,
  0xF0, 0x78, 0x07, 0x1C, 0x00, 0xE0, 0x1C, 0x01, 0x8E, 0x00, 0xF0, 0x0E,
  0x00, 0xC6, 0x00, 0x70, 0x07, 0x00, 0x67, 0x00, 0x70, 0x03, 0x00, 0x33,
  0x80, 0x38, 0x01, 0x80, 0x1D, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0xE0, 0x1C,
  0x00, 0x60, 0x07, 0x60, 0x0E, 0x00, 0x70, 0x03, 0xB0, 0x07, 0x00, 0x38,
  0x01, 0xD8, 0x03, 0x80, 0x1C, 0x00, 0xEC, 0x01, 0x80, 0x0E, 0x00, 0x76,
  0x01, 0xC0, 0x07, 0x00, 0x3B, 0x00, 0xE0, 0x03, 0x80, 0x19, 0x80, 0x70,
  0x01, 0xC0, 0x0C, 0xC0, 0x38, 0x00, 0xE0, 0x06, 0x60, 0x1C, 0x00, 0x70,
  0x07, 0x30, 0x0E, 0x00, 0x38, 0x03, 0x98, 0x07, 0x00, 0x38, 0x01, 0x8E,
  0x01, 0xC0, 0x1E, 0x01, 0xC7, 0x00, 0xE0, 0x1F, 0x00, 0xE3, 0x80, 0x70,
  0x1F, 0x80, 0xE1, 0xC0, 0x3C, 0x1D, 0xE0, 0x70, 0x60, 0x0F, 0xBC, 0x78,
  0xF0, 0x38, 0x03, 0xFE, 0x1F, 0xF0, 0x1C, 0x00, 0xFC, 0x07, 0xF0, 0x07,
  0x00, 0x10, 0x00, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xC0,
  0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x01,
  0xE0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x00, 0x70, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0xE0, 0x03, 0xF0, 0xE0, 0x00, 0xF8, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF8, 0xE0,
  0x03, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xE0,
  0x00, 0xF8, 0xE0, 0x00, 0x7C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0x7C, 0xE0, 0x01, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07,
  0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x07, 0x80,
  0x01, 0xE0, 0xF8, 0x00, 0x78, 0x0F, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1C, 0x00, 0xFE, 0x0E, 0x00,
  0x0F, 0x87, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x3C, 0xE0,
  0x00, 0x0F, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xDC,
  0x00, 0x03, 0xCE, 0x00, 0x03, 0xE7, 0x00, 0x03, 0xE3, 0x80, 0x03, 0xE1,
  0xC0, 0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0x1E, 0x38, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0x70,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xF7,
  0x00, 0x03, 0xDC, 0x00, 0x0E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE3, 0xC0,
  0x0F, 0x0F, 0xC0, 0x78, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x7C, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x38,
  0x00, 0x3C, 0x07, 0x00, 0x0F, 0x80, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x78,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x07, 0xC0, 0x0E, 0x00, 0xF0, 0x01, 0xC0,
  0x3C, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0xF8, 0x00,
  0x1C, 0x1E, 0x00, 0x03, 0x87, 0x80, 0x00, 0x71, 0xF0, 0x00, 0x0E, 0x7F,
  0x00, 0x01, 0xDF, 0xE0, 0x00, 0x3B, 0xDE, 0x00, 0x07, 0xF1, 0xE0, 0x00,
  0xFC, 0x3C, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x70, 0x07,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x80, 0x38, 0x00, 0xF0, 0x07,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x01,
  0xE0, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x38,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xBF, 0x70, 0x00, 0x00, 0x77, 0xEE, 0x00, 0x00,
  0x1E, 0xFD, 0xE0, 0x00, 0x03, 0x9F, 0x9C, 0x00, 0x00, 0x73, 0xF3, 0x80,
  0x00, 0x1E, 0x7E, 0x78, 0x00, 0x03, 0x8F, 0xC7, 0x00, 0x00, 0x71, 0xF8,
  0xE0, 0x00, 0x1E, 0x3F, 0x0E, 0x00, 0x03, 0x87, 0xE1, 0xC0, 0x00, 0x70,
  0xFC, 0x38, 0x00, 0x1E, 0x1F, 0x83, 0x80, 0x03, 0x83, 0xF0, 0x70, 0x00,
  0x70, 0x7E, 0x0E, 0x00, 0x1E, 0x1F, 0xC0, 0xE0, 0x03, 0x83, 0xF8, 0x1C,
  0x00, 0x70, 0x7F, 0x03, 0xC0, 0x1E, 0x0F, 0xE0, 0x38, 0x03, 0x81, 0xFC,
  0x07, 0x00, 0x70, 0x3F, 0x80, 0xF0, 0x1C, 0x07, 0xF0, 0x0E, 0x03, 0x80,
  0xFE, 0x01, 0xC0, 0x70, 0x1F, 0xC0, 0x3C, 0x1C, 0x03, 0xF8, 0x03, 0x83,
  0x80, 0x7F, 0x00, 0x70, 0x70, 0x0F, 0xE0, 0x0F, 0x1C, 0x01, 0xFC, 0x00,
  0xE3, 0x80, 0x3F, 0x80, 0x1C, 0x70, 0x07, 0xF0, 0x03, 0xDC, 0x00, 0xFE,
  0x00, 0x3B, 0x80, 0x1F, 0xC0, 0x07, 0x70, 0x03, 0xF8, 0x00, 0x7C, 0x00,
  0x7F, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x1C,
  0x00, 0x3F, 0x80, 0x03, 0x80, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFB, 0x80, 0x00, 0x3F, 0x78, 0x00, 0x07, 0xE7, 0x00,
  0x00, 0xFC, 0xF0, 0x00, 0x1F, 0x8E, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0x7E,
  0x1C, 0x00, 0x0F, 0xC3, 0xC0, 0x01, 0xF8, 0x38, 0x00, 0x3F, 0x07, 0x80,
  0x07, 0xE0, 0x78, 0x00, 0xFC, 0x07, 0x00, 0x1F, 0x80, 0xF0, 0x03, 0xF0,
  0x0E, 0x00, 0x7E, 0x01, 0xE0, 0x0F, 0xC0, 0x1C, 0x01, 0xF8, 0x03, 0xC0,
  0x3F, 0x00, 0x38, 0x07, 0xE0, 0x07, 0x80, 0xFC, 0x00, 0x70, 0x1F, 0x80,
  0x0F, 0x03, 0xF0, 0x00, 0xF0, 0x7E, 0x00, 0x0E, 0x0F, 0xC0, 0x01, 0xE1,
  0xF8, 0x00, 0x1C, 0x3F, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x38, 0xFC, 0x00,
  0x07, 0x9F, 0x80, 0x00, 0x73, 0xF0, 0x00, 0x0F, 0x7E, 0x00, 0x00, 0xEF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xC0, 0x3E, 0x01, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x38, 0x38, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x1E, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1C, 0x00, 0x3F, 0x0E,
  0x00, 0x07, 0xC7, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x1E,
  0xE0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xDC, 0x00,
  0x01, 0xCE, 0x00, 0x01, 0xE7, 0x00, 0x01, 0xE3, 0x80, 0x07, 0xF1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x1E, 0x0F, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x0F, 0x80,
  0x01, 0xE0, 0xF8, 0x00, 0x78, 0x0F, 0xC0, 0x3E, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x43, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x1C, 0x00, 0x3F, 0x0E, 0x00, 0x07, 0xC7, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x07, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0E,
  0x70, 0x00, 0x0F, 0x38, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x8E, 0x00, 0x07,
  0xC7, 0x00, 0x0F, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x0E, 0x00,
  0x1E, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0xE0,
  0x00, 0x78, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x8E,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1E,
  0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F,
  0x80, 0x7C, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x1C,
  0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x0E, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0x9E, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x0E,
  0x78, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0x7E, 0x00,
  0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0xE0, 0x07, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x1E, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x77, 0x00, 0x01, 0xE0, 0x00, 0x1D,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x70, 0x00, 0x1F, 0x00, 0x03, 0x9E, 0x00,
  0x07, 0xC0, 0x00, 0xE7, 0x80, 0x03, 0xB0, 0x00, 0x38, 0xE0, 0x00, 0xEE,
  0x00, 0x1E, 0x38, 0x00, 0x3B, 0x80, 0x07, 0x8E, 0x00, 0x0E, 0xE0, 0x01,
  0xC3, 0xC0, 0x07, 0x38, 0x00, 0x70, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x1C,
  0x00, 0x71, 0xC0, 0x0F, 0x07, 0x00, 0x1C, 0x70, 0x03, 0xC1, 0xC0, 0x0E,
  0x1C, 0x00, 0xE0, 0x78, 0x03, 0x83, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0xE0,
  0x0E, 0x03, 0x80, 0x38, 0x38, 0x07, 0x80, 0xE0, 0x1C, 0x0E, 0x01, 0xE0,
  0x38, 0x07, 0x01, 0x80, 0x70, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x00, 0x70, 0x38, 0x07, 0x03, 0xC0, 0x1C, 0x0E, 0x00,
  0xC0, 0xE0, 0x07, 0x83, 0x80, 0x38, 0x38, 0x01, 0xE0, 0xE0, 0x0E, 0x0E,
  0x00, 0x38, 0x70, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0xE1, 0xE0, 0x03,
  0x87, 0x00, 0x1C, 0x70, 0x00, 0xF1, 0xC0, 0x07, 0x1C, 0x00, 0x1C, 0xE0,
  0x01, 0xC7, 0x00, 0x07, 0x38, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x0E,
  0xF0, 0x00, 0x73, 0x80, 0x03, 0xB8, 0x00, 0x1C, 0xC0, 0x00, 0xEE, 0x00,
  0x03, 0xF0, 0x00, 0x3B, 0x80, 0x00, 0xFC, 0x00, 0x06, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x1E, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x38, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x03, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0,
  0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0xF0,
  0x0E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0xF0, 0x38, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x33, 0x00, 0x1C, 0xE0, 0x07, 0x38, 0x03,
  0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x0E,
  0x70, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF8, 0x3E, 0x01, 0xF0,
  0xF0, 0x03, 0xC7, 0x80, 0x07, 0x1C, 0x00, 0x1E, 0x70, 0x00, 0x79, 0xC0,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7C, 0x01, 0xE3,
  0xC0, 0x07, 0x9E, 0x00, 0x1E, 0x70, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00,
  0x07, 0xB8, 0x00, 0x1E, 0xE0, 0x00, 0x7B, 0x80, 0x01, 0xEF, 0x00, 0x0F,
  0xBC, 0x00, 0x3E, 0x78, 0x01, 0xB9, 0xF0, 0x1E, 0xE3, 0xFF, 0xF3, 0x87,
  0xFF, 0x8E, 0x0F, 0xF8, 0x3C, 0x02, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC7, 0xFC, 0x0F, 0x3F,
  0xFC, 0x3D, 0xFF, 0xF8, 0xFE, 0x01, 0xF3, 0xF0, 0x03, 0xCF, 0x80, 0x07,
  0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x07, 0xBE, 0x00, 0x1E, 0xFC, 0x00,
  0xF3, 0xF8, 0x07, 0xCE, 0x7F, 0xFE, 0x38, 0xFF, 0xF0, 0xE1, 0xFF, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF8, 0x1E, 0x01, 0xF0, 0xF0, 0x03, 0xC7, 0x80, 0x07, 0x9C, 0x00,
  0x0E, 0x70, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3D,
  0xC0, 0x00, 0xE7, 0x80, 0x03, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0x78,
  0x07, 0xC1, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x0F, 0xF8, 0x70, 0xFF, 0xF1, 0xC7, 0xFF, 0xE7, 0x1E, 0x01, 0xDC,
  0xF0, 0x03, 0xF3, 0x80, 0x07, 0xDE, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xC0,
  0x00, 0x77, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0xF7, 0x80, 0x03,
  0xCE, 0x00, 0x1F, 0x3C, 0x00, 0xFC, 0x78, 0x07, 0x71, 0xFF, 0xF9, 0xC1,
  0xFF, 0xC7, 0x03, 0xFE, 0x1C, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1E, 0x01, 0xF0, 0xF0, 0x03,
  0xC3, 0x80, 0x07, 0x9E, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0xC0, 0x00, 0xEF,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x04, 0x3C, 0x00, 0x38, 0x7C, 0x03, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x70, 0xFF, 0xF1, 0xC7, 0xFF,
  0xE7, 0x1E, 0x01, 0xDC, 0xF0, 0x03, 0xF3, 0x80, 0x07, 0xDE, 0x00, 0x0F,
  0x70, 0x00, 0x3D, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0,
  0x00, 0xF7, 0x80, 0x03, 0xCE, 0x00, 0x1F, 0x3C, 0x00, 0xFC, 0x78, 0x07,
  0x71, 0xFF, 0xF9, 0xC3, 0xFF, 0xC7, 0x03, 0xFE, 0x1C, 0x00, 0x80, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE1, 0x00,
  0x03, 0x86, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0x7C, 0x0F, 0xC0, 0xFF, 0xFE,
  0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x80, 0x78, 0x7F, 0x83, 0xCF, 0xFF, 0x1E, 0xFF, 0xFC,
  0xF7, 0x01, 0xE7, 0xF0, 0x07, 0xBF, 0x00, 0x3D, 0xF0, 0x00, 0xEF, 0x80,
  0x07, 0x78, 0x00, 0x3B, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0x80, 0x67, 0xBF, 0xE7, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0, 0x01, 0x80, 0xF0,
  0x3C, 0x0F, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xF0,
  0x3C, 0x1E, 0x0F, 0xBF, 0xCF, 0xE3, 0xF0, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x7B, 0xC0, 0x07, 0x9E, 0x00,
  0x78, 0xF0, 0x07, 0x87, 0x80, 0x7C, 0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x0F,
  0x03, 0xC0, 0x78, 0x3C, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF1, 0xE0,
  0x07, 0x9E, 0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x03, 0xF3, 0xC0, 0x1F, 0x0E, 0x00, 0xF0, 0x78, 0x07, 0x81, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x78, 0x03, 0x83, 0xC0,
  0x1E, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x3D,
  0xE0, 0x01, 0xEF, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x83, 0xFC, 0x03, 0xFE, 0x0E, 0x3F, 0xFC, 0x1F,
  0xFE, 0x39, 0xFF, 0xF0, 0xFF, 0xF8, 0xEF, 0x03, 0xE7, 0x80, 0xF3, 0xB0,
  0x03, 0xF8, 0x01, 0xEF, 0x80, 0x0F, 0xC0, 0x07, 0xBE, 0x00, 0x1F, 0x00,
  0x0E, 0xF0, 0x00, 0x78, 0x00, 0x3B, 0xC0, 0x01, 0xE0, 0x00, 0xEF, 0x00,
  0x07, 0x80, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x00,
  0x3F, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x00,
  0x1E, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x00,
  0x78, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x03,
  0xFC, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x01,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x0F,
  0xF0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0x80, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x08, 0x07, 0x87, 0xF8, 0x3C, 0xFF, 0xF1, 0xEF, 0xFF, 0xCF, 0x70,
  0x1E, 0x7F, 0x00, 0x7B, 0xF0, 0x03, 0xDF, 0x00, 0x0E, 0xF8, 0x00, 0x77,
  0x80, 0x03, 0xBC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xFF, 0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x0F, 0x0F, 0x00, 0x0F, 0x3C,
  0x00, 0x1E, 0x78, 0x00, 0x1C, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xB8, 0x00, 0x07,
  0x70, 0x00, 0x1E, 0xF0, 0x00, 0x39, 0xE0, 0x00, 0xF1, 0xE0, 0x01, 0xE1,
  0xE0, 0x07, 0x83, 0xE0, 0x1E, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0x87, 0xFC, 0x0E, 0x3F,
  0xFC, 0x39, 0xFF, 0xF8, 0xFE, 0x01, 0xF3, 0xF0, 0x03, 0xCF, 0x80, 0x07,
  0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x07, 0xBE, 0x00, 0x1E, 0xFC, 0x00,
  0xF3, 0xF8, 0x07, 0xCF, 0x7F, 0xFE, 0x3C, 0xFF, 0xF0, 0xF1, 0xFF, 0x03,
  0xC0, 0x40, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x70, 0xFF, 0xF1, 0xC7, 0xFF, 0xE7, 0x1E, 0x01, 0xDC, 0xF0,
  0x03, 0xF3, 0x80, 0x07, 0xDE, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x80, 0x03, 0xCE,
  0x00, 0x1F, 0x3C, 0x00, 0x7C, 0x78, 0x07, 0x71, 0xFF, 0xFD, 0xC3, 0xFF,
  0xE7, 0x03, 0xFE, 0x1C, 0x00, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x07, 0x8F, 0xFC, 0xFF, 0xEF, 0xFF, 0xF0, 0x7E, 0x03, 0xF0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xE0,
  0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3E, 0x03, 0xE3, 0x80, 0x1E, 0x78, 0x00,
  0xF7, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x77, 0x00, 0x07, 0x78, 0x00, 0xF3, 0xC0, 0x1E, 0x1F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x02, 0x00, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x20, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x70,
  0x00, 0x7B, 0x80, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x03, 0xF3, 0xC0, 0x7F,
  0x9F, 0xFF, 0xBC, 0x7F, 0xF9, 0xE0, 0xFF, 0x8F, 0x00, 0x80, 0x00, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xEF, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00,
  0x79, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xE0,
  0xF0, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x70, 0x1E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x1E,
  0x00, 0x70, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x00,
  0x38, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x3D,
  0xC0, 0x07, 0xC0, 0x07, 0x38, 0x00, 0xF8, 0x00, 0xE7, 0x00, 0x1F, 0x00,
  0x1C, 0xF0, 0x03, 0xE0, 0x07, 0x8E, 0x00, 0xEE, 0x00, 0xE1, 0xC0, 0x1D,
  0xC0, 0x1C, 0x38, 0x03, 0xB8, 0x03, 0x87, 0x80, 0x77, 0x00, 0xF0, 0x70,
  0x1C, 0x70, 0x1C, 0x0E, 0x03, 0x8E, 0x03, 0x81, 0xC0, 0x71, 0xC0, 0x70,
  0x38, 0x0C, 0x38, 0x0E, 0x03, 0x83, 0x83, 0x83, 0x80, 0x70, 0x70, 0x70,
  0x70, 0x0E, 0x0E, 0x0E, 0x0E, 0x01, 0xC3, 0x80, 0xC1, 0xC0, 0x1C, 0x70,
  0x1C, 0x70, 0x03, 0x8E, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x71, 0xC0, 0x0E,
  0x70, 0x06, 0x38, 0x01, 0xEE, 0x00, 0xE6, 0x00, 0x1D, 0xC0, 0x1D, 0xC0,
  0x03, 0xB8, 0x03, 0xB8, 0x00, 0x7E, 0x00, 0x37, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x39, 0xE0, 0x01, 0xE3, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x1C, 0x01,
  0xE0, 0x78, 0x07, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0xE0, 0x07, 0x07, 0x80,
  0x0E, 0x1C, 0x00, 0x3C, 0xF0, 0x00, 0x73, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x77, 0x80, 0x03, 0xCE, 0x00, 0x0E, 0x3C, 0x00,
  0x78, 0x78, 0x01, 0xC0, 0xE0, 0x0F, 0x03, 0xC0, 0x78, 0x07, 0x01, 0xE0,
  0x1E, 0x0F, 0x00, 0x38, 0x38, 0x00, 0xF1, 0xE0, 0x01, 0xE7, 0x00, 0x07,
  0xBC, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0x73,
  0xC0, 0x01, 0xE3, 0x80, 0x03, 0x87, 0x80, 0x07, 0x0F, 0x00, 0x1E, 0x0E,
  0x00, 0x3C, 0x1E, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x38, 0x03, 0xC0, 0x70,
  0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x3C, 0x01, 0xC0, 0x70, 0x03, 0xC0,
  0xE0, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x78, 0x00, 0x38, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80,
  0x00, 0xEE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x04,
  0x00, 0x3C, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x40, 0x01, 0xE0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x78, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x06, 0x3F, 0xF8, 0x00, 0x63, 0xC7,
  0xC0, 0x0E, 0x78, 0x1E, 0x00, 0xE7, 0x00, 0xF0, 0x0E, 0xF0, 0x07, 0x81,
  0xCE, 0x00, 0x3E, 0x3C, 0xE0, 0x01, 0xFF, 0x8E, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7E, 0x00,
};

const GFXglyph RobotoCondensed_Light60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 44, 13, 4, -43 },
  { 29, 10, 13, 17, 4, -45 },
  { 46, 27, 43, 31, 3, -43 },
  { 192, 23, 56, 29, 3, -50 },
  { 353, 32, 45, 38, 3, -44 },
  { 533, 28, 45, 32, 3, -44 },
  { 691, 3, 13, 10, 4, -45 },
  { 696, 12, 62, 17, 4, -48 },
  { 789, 12, 62, 18, 1, -48 },
  { 882, 24, 24, 25, 1, -43 },
  { 954, 25, 31, 30, 2, -35 },
  { 1051, 6, 14, 12, 2, -6 },
  { 1062, 12, 3, 16, 2, -20 },
  { 1067, 5, 5, 14, 4, -4 },
  { 1071, 18, 47, 21, 1, -43 },
  { 1177, 22, 45, 29, 4, -44 },
  { 1301, 13, 43, 29, 5, -43 },
  { 1371, 24, 44, 29, 3, -44 },
  { 1503, 23, 45, 29, 3, -44 },
  { 1633, 26, 43, 29, 2, -43 },
  { 1773, 21, 44, 29, 5, -43 },
  { 1889, 22, 44, 29, 4, -43 },
  { 2010, 24, 43, 29, 2, -43 },
  { 2139, 23, 45, 29, 3, -44 },
  { 2269, 22, 44, 29, 3, -44 },
  { 2390, 5, 32, 12, 4, -31 },
  { 2410, 7, 39, 11, 2, -31 },
  { 2445, 21, 25, 27, 2, -32 },
  { 2511, 21, 15, 29, 4, -27 },
  { 2551, 21, 25, 27, 4, -32 },
  { 2617, 19, 45, 24, 3, -44 },
  { 2724, 41, 55, 47, 3, -42 },
  { 3006, 31, 43, 33, 1, -43 },
  { 3173, 24, 43, 32, 5, -43 },
  { 3302, 27, 45, 34, 4, -44 },
  { 3454, 25, 43, 34, 5, -43 },
  { 3589, 22, 43, 30, 5, -43 },
  { 3708, 22, 43, 29, 5, -43 },
  { 3827, 27, 45, 36, 4, -44 },
  { 3979, 27, 43, 37, 5, -43 },
  { 4125, 3, 43, 15, 6, -43 },
  { 4142, 22, 44, 29, 2, -43 },
  { 4263, 27, 43, 33, 5, -43 },
  { 4409, 21, 43, 28, 5, -43 },
  { 4522, 35, 43, 45, 5, -43 },
  { 4711, 27, 43, 37, 5, -43 },
  { 4857, 28, 45, 35, 4, -44 },
  { 5015, 25, 43, 32, 5, -43 },
  { 5150, 27, 51, 35, 4, -44 },
  { 5323, 25, 43, 33, 5, -43 },
  { 5458, 26, 45, 31, 3, -44 },
  { 5605, 27, 43, 31, 2, -43 },
  { 5751, 26, 44, 34, 4, -43 },
  { 5894, 30, 43, 32, 1, -43 },
  { 6056, 42, 43, 46, 2, -43 },
  { 6282, 28, 43, 32, 2, -43 },
  { 6433, 29, 43, 31, 1, -43 },
  { 6589, 26, 43, 31, 3, -43 },
  { 6729, 8, 58, 14, 5, -49 },
  { 6787, 18, 47, 21, 2, -43 },
  { 6893, 8, 58, 14, 1, -49 },
  { 6951, 18, 21, 22, 2, -43 },
  { 6999, 22, 3, 23, 1, 0 },
  { 7008, 10, 8, 17, 3, -45 },
  { 7018, 22, 34, 28, 3, -33 },
  { 7112, 22, 46, 29, 4, -45 },
  { 7239, 22, 34, 27, 3, -33 },
  { 7333, 22, 46, 29, 3, -45 },
  { 7460, 22, 34, 27, 3, -33 },
  { 7554, 16, 46, 18, 2, -46 },
  { 7646, 22, 45, 29, 3, -33 },
  { 7770, 21, 45, 29, 4, -45 },
  { 7889, 5, 44, 13, 4, -44 },
  { 7917, 10, 56, 13, -2, -44 },
  { 7987, 21, 45, 26, 4, -45 },
  { 8106, 3, 45, 13, 5, -45 },
  { 8123, 38, 33, 46, 4, -33 },
  { 8280, 21, 33, 29, 4, -33 },
  { 8367, 23, 34, 29, 3, -33 },
  { 8465, 22, 45, 29, 4, -33 },
  { 8589, 22, 45, 29, 3, -33 },
  { 8713, 13, 33, 18, 4, -33 },
  { 8767, 20, 34, 27, 3, -33 },
  { 8852, 14, 41, 17, 1, -40 },
  { 8924, 21, 33, 29, 4, -32 },
  { 9011, 22, 32, 25, 2, -32 },
  { 9099, 35, 32, 39, 2, -32 },
  { 9239, 22, 32, 26, 2, -32 },
  { 9327, 23, 44, 25, 1, -32 },
  { 9454, 21, 32, 26, 3, -32 },
  { 9538, 15, 59, 18, 2, -47 },
  { 9649, 3, 51, 13, 5, -43 },
  { 9669, 15, 59, 18, 1, -47 },
  { 9780, 28, 11, 36, 4, -23 },
};

const GFXfont RobotoCondensed_Light60pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light60pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light60pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _ROBOTOCONDENSED_LIGHT60PT7B_H_
