#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/RobotoCondensed_Light
// Headers: 67

#include "RobotoCondensed_Light6pt7b.h"
#include "RobotoCondensed_Light7pt7b.h"
#include "RobotoCondensed_Light8pt7b.h"
#include "RobotoCondensed_Light9pt7b.h"
#include "RobotoCondensed_Light10pt7b.h"
#include "RobotoCondensed_Light11pt7b.h"
#include "RobotoCondensed_Light12pt7b.h"
#include "RobotoCondensed_Light13pt7b.h"
#include "RobotoCondensed_Light14pt7b.h"
#include "RobotoCondensed_Light15pt7b.h"
#include "RobotoCondensed_Light16pt7b.h"
#include "RobotoCondensed_Light17pt7b.h"
#include "RobotoCondensed_Light18pt7b.h"
#include "RobotoCondensed_Light19pt7b.h"
#include "RobotoCondensed_Light20pt7b.h"
#include "RobotoCondensed_Light21pt7b.h"
#include "RobotoCondensed_Light22pt7b.h"
#include "RobotoCondensed_Light23pt7b.h"
#include "RobotoCondensed_Light24pt7b.h"
#include "RobotoCondensed_Light25pt7b.h"
#include "RobotoCondensed_Light26pt7b.h"
#include "RobotoCondensed_Light27pt7b.h"
#include "RobotoCondensed_Light28pt7b.h"
#include "RobotoCondensed_Light29pt7b.h"
#include "RobotoCondensed_Light30pt7b.h"
#include "RobotoCondensed_Light31pt7b.h"
#include "RobotoCondensed_Light32pt7b.h"
#include "RobotoCondensed_Light33pt7b.h"
#include "RobotoCondensed_Light34pt7b.h"
#include "RobotoCondensed_Light35pt7b.h"
#include "RobotoCondensed_Light36pt7b.h"
#include "RobotoCondensed_Light37pt7b.h"
#include "RobotoCondensed_Light38pt7b.h"
#include "RobotoCondensed_Light39pt7b.h"
#include "RobotoCondensed_Light40pt7b.h"
#include "RobotoCondensed_Light41pt7b.h"
#include "RobotoCondensed_Light42pt7b.h"
#include "RobotoCondensed_Light43pt7b.h"
#include "RobotoCondensed_Light44pt7b.h"
#include "RobotoCondensed_Light45pt7b.h"
#include "RobotoCondensed_Light46pt7b.h"
#include "RobotoCondensed_Light47pt7b.h"
#include "RobotoCondensed_Light48pt7b.h"
#include "RobotoCondensed_Light49pt7b.h"
#include "RobotoCondensed_Light50pt7b.h"
#include "RobotoCondensed_Light51pt7b.h"
#include "RobotoCondensed_Light52pt7b.h"
#include "RobotoCondensed_Light53pt7b.h"
#include "RobotoCondensed_Light54pt7b.h"
#include "RobotoCondensed_Light55pt7b.h"
#include "RobotoCondensed_Light56pt7b.h"
#include "RobotoCondensed_Light57pt7b.h"
#include "RobotoCondensed_Light58pt7b.h"
#include "RobotoCondensed_Light59pt7b.h"
#include "RobotoCondensed_Light60pt7b.h"
#include "RobotoCondensed_Light61pt7b.h"
#include "RobotoCondensed_Light62pt7b.h"
#include "RobotoCondensed_Light63pt7b.h"
#include "RobotoCondensed_Light64pt7b.h"
#include "RobotoCondensed_Light65pt7b.h"
#include "RobotoCondensed_Light66pt7b.h"
#include "RobotoCondensed_Light67pt7b.h"
#include "RobotoCondensed_Light68pt7b.h"
#include "RobotoCondensed_Light69pt7b.h"
#include "RobotoCondensed_Light70pt7b.h"
#include "RobotoCondensed_Light71pt7b.h"
#include "RobotoCondensed_Light72pt7b.h"
