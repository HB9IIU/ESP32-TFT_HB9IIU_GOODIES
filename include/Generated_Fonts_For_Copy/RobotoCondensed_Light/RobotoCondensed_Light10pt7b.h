#ifndef _ROBOTOCONDENSED_LIGHT10PT7B_H_
#define _ROBOTOCONDENSED_LIGHT10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light10pt7bBitmaps[] PROGMEM = {
  0x00, 0xF2, 0x00, 0x21, 0x8C, 0xA5, 0x39, 0x00, 0x5E, 0xC4, 0x6F, 0x40,
  0xC6, 0xB8, 0x45, 0x94, 0x60, 0xEA, 0xCC, 0xBB, 0xF0, 0x80, 0x6A, 0xAA,
  0x90, 0x95, 0x55, 0x60, 0x0F, 0x25, 0x21, 0x3E, 0x42, 0x00, 0xC0, 0xC0,
  0x80, 0x04, 0xA4, 0xA4, 0xF6, 0xDB, 0x78, 0xD5, 0x54, 0xF4, 0x95, 0x38,
  0x79, 0x12, 0x19, 0x70, 0x11, 0x94, 0xAF, 0x88, 0x40, 0xF3, 0x93, 0x78,
  0x73, 0xDB, 0x78, 0xF1, 0x12, 0x22, 0x40, 0xF6, 0xFB, 0x78, 0xF6, 0xDE,
  0x70, 0x00, 0x06, 0x34, 0x43, 0xE3, 0x80, 0x8D, 0xC0, 0x69, 0x12, 0x40,
  0x00, 0x7A, 0x1A, 0x71, 0xD7, 0x5A, 0xE0, 0x70, 0x21, 0x14, 0xA7, 0x46,
  0x20, 0xE9, 0x9E, 0x99, 0xE0, 0xE9, 0x88, 0x89, 0x60, 0xE9, 0x99, 0x99,
  0xE0, 0xF8, 0x8E, 0x88, 0xF0, 0xF8, 0x8E, 0x88, 0x80, 0x79, 0x8B, 0x99,
  0x70, 0x99, 0x9F, 0x99, 0x90, 0xFE, 0x11, 0x11, 0x19, 0x60, 0x9A, 0xCC,
  0xAA, 0x90, 0x92, 0x49, 0x38, 0x86, 0x38, 0xF5, 0xD6, 0x9A, 0x40, 0x99,
  0xDB, 0xB9, 0x90, 0xE9, 0x99, 0x99, 0xE0, 0xE9, 0x9E, 0x88, 0x80, 0xE9,
  0x99, 0x99, 0xE1, 0xE9, 0x9E, 0xA9, 0x90, 0x74, 0x50, 0x60, 0xC5, 0xC0,
  0xF9, 0x08, 0x42, 0x10, 0x80, 0x99, 0x99, 0x99, 0xE0, 0x8C, 0x52, 0xA5,
  0x10, 0x80, 0x83, 0x35, 0x6A, 0xD6, 0xA4, 0x89, 0x00, 0x8A, 0x8C, 0x43,
  0x2A, 0x20, 0x8A, 0x94, 0x42, 0x10, 0x80, 0x78, 0x84, 0x44, 0x23, 0xE0,
  0xFF, 0xC0, 0x89, 0x24, 0x49, 0xD5, 0x55, 0x70, 0x49, 0xD0, 0xF0, 0x50,
  0xE7, 0xDE, 0x92, 0x7B, 0x6F, 0x79, 0x89, 0x70, 0x24, 0xFB, 0x6F, 0x79,
  0xF8, 0x70, 0x69, 0x24, 0x92, 0xF6, 0xDE, 0x78, 0x92, 0x7B, 0x6D, 0x3E,
  0x3F, 0x80, 0x92, 0x5D, 0x35, 0xFF, 0xFE, 0x9A, 0x69, 0xA4, 0xF6, 0xDA,
  0xF6, 0xDE, 0xF6, 0xDF, 0x20, 0xF6, 0xDE, 0x48, 0xEA, 0x80, 0xF5, 0x1E,
  0x49, 0x24, 0x90, 0xB6, 0xDE, 0x95, 0x66, 0x20, 0x96, 0x57, 0x5A, 0x48,
  0x96, 0x26, 0x90, 0x95, 0x66, 0x24, 0xC0, 0x72, 0x24, 0xF0, 0x29, 0x28,
  0x92, 0x44, 0xFF, 0x89, 0x22, 0x92, 0x50, 0xC3,
};

const GFXglyph RobotoCondensed_Light10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 1, -7 },
  { 2, 1, 2, 3, 1, -8 },
  { 3, 5, 7, 5, 0, -7 },
  { 8, 3, 9, 5, 1, -8 },
  { 12, 5, 7, 6, 1, -7 },
  { 17, 4, 7, 5, 1, -7 },
  { 21, 1, 2, 2, 0, -8 },
  { 22, 2, 10, 3, 1, -8 },
  { 25, 2, 10, 3, 0, -8 },
  { 28, 4, 4, 4, 0, -7 },
  { 30, 5, 5, 5, 0, -6 },
  { 34, 1, 2, 2, 0, -1 },
  { 35, 2, 1, 3, 0, -4 },
  { 36, 1, 1, 2, 1, -1 },
  { 37, 3, 8, 4, 0, -7 },
  { 40, 3, 7, 5, 1, -7 },
  { 43, 2, 7, 5, 1, -7 },
  { 45, 3, 7, 5, 1, -7 },
  { 48, 4, 7, 5, 0, -7 },
  { 52, 5, 7, 5, 0, -7 },
  { 57, 3, 7, 5, 1, -7 },
  { 60, 3, 7, 5, 1, -7 },
  { 63, 4, 7, 5, 0, -7 },
  { 67, 3, 7, 5, 1, -7 },
  { 70, 3, 7, 5, 1, -7 },
  { 73, 1, 6, 2, 1, -6 },
  { 74, 1, 7, 2, 0, -6 },
  { 75, 4, 4, 4, 0, -5 },
  { 77, 3, 3, 5, 1, -5 },
  { 79, 3, 4, 5, 1, -5 },
  { 81, 4, 7, 4, 0, -7 },
  { 85, 6, 9, 8, 1, -7 },
  { 92, 5, 7, 5, 0, -7 },
  { 97, 4, 7, 5, 1, -7 },
  { 101, 4, 7, 6, 1, -7 },
  { 105, 4, 7, 6, 1, -7 },
  { 109, 4, 7, 5, 1, -7 },
  { 113, 4, 7, 5, 1, -7 },
  { 117, 4, 7, 6, 1, -7 },
  { 121, 4, 7, 6, 1, -7 },
  { 125, 1, 7, 2, 1, -7 },
  { 126, 4, 7, 5, 0, -7 },
  { 130, 4, 7, 5, 1, -7 },
  { 134, 3, 7, 5, 1, -7 },
  { 137, 6, 7, 7, 1, -7 },
  { 143, 4, 7, 6, 1, -7 },
  { 147, 4, 7, 6, 1, -7 },
  { 151, 4, 7, 5, 1, -7 },
  { 155, 4, 8, 6, 1, -7 },
  { 159, 4, 7, 6, 1, -7 },
  { 163, 5, 7, 5, 0, -7 },
  { 168, 5, 7, 5, 0, -7 },
  { 173, 4, 7, 6, 1, -7 },
  { 177, 5, 7, 5, 0, -7 },
  { 182, 7, 7, 8, 0, -7 },
  { 189, 5, 7, 5, 0, -7 },
  { 194, 5, 7, 5, 0, -7 },
  { 199, 5, 7, 5, 0, -7 },
  { 204, 1, 10, 2, 1, -8 },
  { 206, 3, 8, 4, 0, -7 },
  { 209, 2, 10, 2, 0, -8 },
  { 212, 3, 4, 4, 0, -7 },
  { 214, 4, 1, 4, 0, 0 },
  { 215, 2, 2, 3, 0, -8 },
  { 216, 3, 5, 5, 1, -5 },
  { 218, 3, 8, 5, 1, -8 },
  { 221, 4, 5, 5, 0, -5 },
  { 224, 3, 8, 5, 1, -8 },
  { 227, 4, 5, 5, 0, -5 },
  { 230, 3, 8, 3, 0, -8 },
  { 233, 3, 7, 5, 1, -5 },
  { 236, 3, 8, 5, 1, -8 },
  { 239, 1, 7, 2, 1, -7 },
  { 240, 1, 9, 2, 0, -7 },
  { 242, 3, 8, 4, 1, -8 },
  { 245, 1, 8, 2, 1, -8 },
  { 246, 6, 5, 8, 1, -5 },
  { 250, 3, 5, 5, 1, -5 },
  { 252, 3, 5, 5, 1, -5 },
  { 254, 3, 7, 5, 1, -5 },
  { 257, 3, 7, 5, 1, -5 },
  { 260, 2, 5, 3, 1, -5 },
  { 262, 3, 5, 4, 1, -5 },
  { 264, 3, 7, 3, 0, -7 },
  { 267, 3, 5, 5, 1, -5 },
  { 269, 4, 5, 4, 0, -5 },
  { 272, 6, 5, 7, 0, -5 },
  { 276, 4, 5, 4, 0, -5 },
  { 279, 4, 7, 4, 0, -5 },
  { 283, 4, 5, 4, 0, -5 },
  { 286, 3, 10, 3, 0, -8 },
  { 290, 1, 8, 2, 1, -7 },
  { 291, 3, 10, 3, 0, -8 },
  { 295, 4, 2, 6, 1, -4 },
};

const GFXfont RobotoCondensed_Light10pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light10pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOCONDENSED_LIGHT10PT7B_H_
