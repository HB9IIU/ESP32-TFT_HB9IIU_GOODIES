#ifndef _ROBOTOCONDENSED_LIGHT64PT7B_H_
#define _ROBOTOCONDENSED_LIGHT64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light64pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x60, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0xDC, 0x3B, 0x07,
  0x60, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0D, 0xC1, 0x80, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x60, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x18, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x1F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x0E, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x01,
  0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x03, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x03, 0x80,
  0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x00,
  0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x0E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3F,
  0x00, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0x7C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x1C,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x70, 0x03, 0x80, 0xE0,
  0x0E, 0x00, 0x70, 0x38, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x1C, 0x03, 0x81,
  0xC0, 0x03, 0x80, 0x70, 0x70, 0x00, 0x70, 0x0E, 0x0E, 0x00, 0x07, 0x03,
  0x83, 0x80, 0x00, 0x7F, 0xF0, 0x70, 0x00, 0x0F, 0xFC, 0x1C, 0x00, 0x00,
  0x7E, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x7E, 0x00, 0x00,
  0x38, 0x1F, 0xF0, 0x00, 0x0E, 0x07, 0xFF, 0x00, 0x01, 0xC1, 0xC0, 0xE0,
  0x00, 0x70, 0x78, 0x0E, 0x00, 0x0E, 0x0E, 0x01, 0xC0, 0x03, 0x81, 0xC0,
  0x18, 0x00, 0x70, 0x30, 0x03, 0x80, 0x1C, 0x06, 0x00, 0x70, 0x03, 0x80,
  0xC0, 0x0E, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x1C, 0x03, 0x00, 0x38, 0x07,
  0x00, 0x60, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x38,
  0x03, 0x00, 0x38, 0x07, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x0E,
  0x00, 0x78, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x0E, 0x1F, 0x00, 0x00, 0x3C, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x1C, 0x3C,
  0x07, 0x80, 0x70, 0xF0, 0x0F, 0x01, 0xC7, 0x80, 0x3C, 0x07, 0x1E, 0x00,
  0x78, 0x1C, 0x70, 0x00, 0xF0, 0xF1, 0xC0, 0x03, 0xE3, 0x8F, 0x00, 0x07,
  0x8E, 0x3C, 0x00, 0x0F, 0x78, 0xF0, 0x00, 0x1F, 0xE1, 0xC0, 0x00, 0x7F,
  0x07, 0x00, 0x00, 0xFC, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0xC0,
  0xF0, 0x00, 0x7F, 0x03, 0xE0, 0x03, 0xFE, 0x07, 0xC0, 0x1F, 0x7C, 0x0F,
  0xFF, 0xF8, 0xF0, 0x1F, 0xFF, 0xC1, 0xE0, 0x1F, 0xFC, 0x03, 0xC0, 0x1F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xC0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x40, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x08, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x60, 0x1C, 0x03, 0xFE, 0x0E, 0x07, 0xFF, 0xC7, 0x1F, 0xEF, 0xFF, 0xBF,
  0xE0, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x38,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x1C, 0x01, 0xE0, 0x1E,
  0x00, 0xF8, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x08, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x87, 0x0E, 0x3C, 0x78, 0xE3, 0xCF, 0x1E,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xBF, 0xFF, 0xB0, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xF0, 0x1F,
  0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x78, 0x00, 0x3C,
  0xF0, 0x00, 0x39, 0xC0, 0x00, 0x77, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xEE, 0x00, 0x03, 0x9E,
  0x00, 0x07, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x38, 0x78, 0x00, 0xF0, 0x78,
  0x03, 0xC0, 0xF8, 0x0F, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0x1F,
  0xFD, 0xFE, 0x7F, 0xE1, 0xFE, 0x07, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x01, 0xF0, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0x70,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x9E,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x3E, 0x00,
  0x3C, 0x1F, 0x00, 0x7C, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C,
  0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x70, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x1E,
  0x03, 0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x3C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0xC0, 0x1E,
  0x00, 0x3C, 0x01, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x71, 0xFC,
  0x00, 0xEF, 0xFE, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xC0, 0x3F,
  0x1E, 0x00, 0x3E, 0x08, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xEE, 0x00, 0x03, 0xDC, 0x00,
  0x07, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0x7C, 0x07,
  0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x3F, 0x00, 0x71, 0xFF, 0xC0, 0x73, 0xFF, 0xE0, 0xF7, 0xE3,
  0xF0, 0xFF, 0x00, 0xF8, 0xFE, 0x00, 0x7C, 0xFC, 0x00, 0x3C, 0xF8, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x3C, 0x00,
  0x1C, 0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x78, 0x0F, 0x80, 0xF8, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xF8,
  0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x78, 0x00, 0xF8, 0x78, 0x00, 0x3C, 0x3C,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x8E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x1E,
  0x38, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x03, 0xC0, 0x07,
  0x80, 0xF0, 0x07, 0x80, 0x3F, 0x1F, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x07, 0xE0, 0xFC, 0x07, 0xC0, 0x1F, 0x03, 0xC0,
  0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0x0E, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1C,
  0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x0F, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0x81, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x3F, 0x1E, 0x00,
  0x77, 0x1F, 0x00, 0xFF, 0x0F, 0xC3, 0xEF, 0x07, 0xFF, 0xCF, 0x03, 0xFF,
  0x0E, 0x00, 0xFC, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xEF, 0xBE, 0x78, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xBE, 0xFB, 0xE3, 0x00, 0x08, 0x7C, 0xF9, 0xF3, 0xE3, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x70, 0xE3,
  0xC7, 0x8E, 0x3C, 0x71, 0xE0, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0,
  0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8,
  0x3E, 0x07, 0xC7, 0x80, 0x3E, 0x78, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x00, 0x00, 0x07, 0x07, 0x00, 0x03, 0xF0, 0x00, 0xE1, 0xC0,
  0x01, 0xFF, 0x80, 0x0C, 0x38, 0x00, 0x7F, 0xF8, 0x01, 0xC7, 0x00, 0x1F,
  0x07, 0x80, 0x39, 0xC0, 0x07, 0x80, 0x70, 0x07, 0x38, 0x00, 0xE0, 0x0E,
  0x00, 0x67, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xB8, 0x01, 0xC0, 0x07, 0x00, 0x37, 0x00, 0x38, 0x00, 0xC0, 0x06, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0xFC, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x38,
  0x00, 0xE0, 0x03, 0xF0, 0x07, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xB8, 0x07, 0x00, 0x0E, 0x00,
  0x37, 0x00, 0xE0, 0x01, 0xC0, 0x06, 0xE0, 0x1C, 0x00, 0x38, 0x01, 0xDC,
  0x03, 0x80, 0x07, 0x00, 0x3B, 0x80, 0x70, 0x00, 0xE0, 0x07, 0x70, 0x0E,
  0x00, 0x3C, 0x00, 0xCE, 0x01, 0xE0, 0x07, 0x80, 0x39, 0xC0, 0x1C, 0x01,
  0xF0, 0x07, 0x38, 0x03, 0x80, 0x3E, 0x00, 0xC7, 0x00, 0x78, 0x0F, 0xC0,
  0x38, 0x70, 0x0F, 0x03, 0xBC, 0x0E, 0x0E, 0x00, 0xFB, 0xE3, 0xC3, 0xC1,
  0xC0, 0x0F, 0xF8, 0x7F, 0xF0, 0x3C, 0x00, 0xFE, 0x07, 0xFC, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x10, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x3C,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xC0, 0x0F,
  0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x8F, 0x00,
  0x03, 0xE3, 0xC0, 0x01, 0xF0, 0xF0, 0x03, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3C, 0xF0, 0x00,
  0x1F, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x1F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0xF8,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x1E, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x78, 0x03,
  0xFC, 0x0F, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x78, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x78, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0xC3, 0xC0, 0x3F,
  0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x07, 0x78, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0x3C, 0x00,
  0x3C, 0x3E, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x1E, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0xF8, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x3C,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x3C, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x79,
  0xF8, 0x00, 0x03, 0xDF, 0xE0, 0x00, 0x1E, 0xFF, 0x80, 0x00, 0xFF, 0x3C,
  0x00, 0x07, 0xF0, 0xF0, 0x00, 0x3F, 0x87, 0xC0, 0x01, 0xF8, 0x1E, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x1F, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03,
  0xBF, 0xB8, 0x00, 0x00, 0x3D, 0xFD, 0xE0, 0x00, 0x01, 0xEF, 0xE7, 0x00,
  0x00, 0x0E, 0x7F, 0x38, 0x00, 0x00, 0xF3, 0xF9, 0xE0, 0x00, 0x07, 0x9F,
  0xC7, 0x00, 0x00, 0x38, 0xFE, 0x38, 0x00, 0x03, 0xC7, 0xF1, 0xE0, 0x00,
  0x1E, 0x3F, 0x87, 0x00, 0x00, 0xE1, 0xFC, 0x38, 0x00, 0x0F, 0x0F, 0xE1,
  0xE0, 0x00, 0x78, 0x7F, 0x07, 0x00, 0x03, 0x83, 0xF8, 0x38, 0x00, 0x3C,
  0x1F, 0xC1, 0xE0, 0x01, 0xC0, 0xFE, 0x07, 0x00, 0x0E, 0x07, 0xF0, 0x38,
  0x00, 0xF0, 0x3F, 0x81, 0xE0, 0x07, 0x01, 0xFC, 0x07, 0x00, 0x38, 0x0F,
  0xE0, 0x38, 0x03, 0xC0, 0x7F, 0x01, 0xE0, 0x1C, 0x03, 0xF8, 0x07, 0x00,
  0xE0, 0x1F, 0xC0, 0x3C, 0x0F, 0x00, 0xFE, 0x01, 0xE0, 0x70, 0x07, 0xF0,
  0x07, 0x03, 0x80, 0x3F, 0x80, 0x3C, 0x3C, 0x01, 0xFC, 0x00, 0xE1, 0xC0,
  0x0F, 0xE0, 0x07, 0x0E, 0x00, 0x7F, 0x00, 0x3C, 0xF0, 0x03, 0xF8, 0x00,
  0xE7, 0x00, 0x1F, 0xC0, 0x07, 0x38, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x03, 0xF8,
  0x00, 0x38, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF7, 0x80, 0x00,
  0x7F, 0xBC, 0x00, 0x03, 0xFC, 0xF0, 0x00, 0x1F, 0xE3, 0x80, 0x00, 0xFF,
  0x1E, 0x00, 0x07, 0xF8, 0x70, 0x00, 0x3F, 0xC3, 0xC0, 0x01, 0xFE, 0x0E,
  0x00, 0x0F, 0xF0, 0x78, 0x00, 0x7F, 0x81, 0xE0, 0x03, 0xFC, 0x0F, 0x00,
  0x1F, 0xE0, 0x3C, 0x00, 0xFF, 0x00, 0xE0, 0x07, 0xF8, 0x07, 0x80, 0x3F,
  0xC0, 0x1C, 0x01, 0xFE, 0x00, 0xF0, 0x0F, 0xF0, 0x03, 0x80, 0x7F, 0x80,
  0x1E, 0x03, 0xFC, 0x00, 0x78, 0x1F, 0xE0, 0x03, 0xC0, 0xFF, 0x00, 0x0F,
  0x07, 0xF8, 0x00, 0x78, 0x3F, 0xC0, 0x01, 0xE1, 0xFE, 0x00, 0x07, 0x0F,
  0xF0, 0x00, 0x3C, 0x7F, 0x80, 0x00, 0xE3, 0xFC, 0x00, 0x07, 0x9F, 0xE0,
  0x00, 0x1C, 0xFF, 0x00, 0x00, 0xF7, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x1E,
  0x70, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x78, 0x00, 0xFF, 0x0F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1F, 0x3C,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xC7, 0x80, 0x0F, 0xF0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x03,
  0xE0, 0x78, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x1E, 0x3E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x03,
  0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x3F,
  0xC0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F,
  0x0F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0E,
  0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x78, 0x7C, 0x00, 0x1E, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1D, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E,
  0x7C, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0,
  0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x80,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0x70, 0x0F, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C, 0x1C, 0x00,
  0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3B, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x3C, 0x00, 0x07, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xC7, 0x00, 0x03, 0xF8, 0x00,
  0x1E, 0x3C, 0x00, 0x1D, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xE7, 0x00, 0x07,
  0x0F, 0x00, 0x07, 0x38, 0x00, 0x38, 0x38, 0x00, 0x39, 0xC0, 0x03, 0xC1,
  0xC0, 0x03, 0x8E, 0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0x78,
  0x00, 0xE1, 0xC0, 0x07, 0x03, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x0E, 0x00,
  0x70, 0x70, 0x03, 0xC0, 0x70, 0x03, 0x81, 0xC0, 0x1E, 0x03, 0xC0, 0x1C,
  0x0E, 0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0x70,
  0x1E, 0x00, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x07, 0x81, 0xE0, 0x1C, 0x07,
  0x00, 0x1C, 0x0E, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x70, 0x03, 0x83, 0xC0,
  0x07, 0x03, 0x80, 0x1C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xE0, 0xE0, 0x01,
  0xE1, 0xC0, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0x70, 0x00, 0xE3, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0x1E, 0x00, 0x0F, 0x38,
  0x00, 0x38, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00,
  0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x00, 0x01,
  0xDE, 0x00, 0x03, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x01, 0xE0, 0x1E, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x79,
  0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1F, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x77, 0x00, 0x1D, 0xE0, 0x07, 0x38, 0x03,
  0x8E, 0x00, 0xE3, 0xC0, 0x38, 0x70, 0x1C, 0x1C, 0x07, 0x07, 0x83, 0xC0,
  0xE0, 0xE0, 0x38, 0x38, 0x0F, 0x1E, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1E,
  0xF0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xF0, 0x0F, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0xF0, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7E, 0x00, 0x71,
  0xF0, 0x00, 0xE3, 0xC0, 0x01, 0xCF, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38,
  0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x80,
  0x01, 0xE7, 0x00, 0x03, 0xCF, 0x00, 0x0F, 0x9E, 0x00, 0x3F, 0x1E, 0x01,
  0xEF, 0x3F, 0xFF, 0x9E, 0x3F, 0xFE, 0x3C, 0x3F, 0xF8, 0x78, 0x0F, 0x80,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x0F, 0x80, 0x38, 0x7F, 0xE0, 0x71, 0xFF, 0xF0, 0xE7,
  0xFF, 0xE1, 0xDC, 0x03, 0xE3, 0xF0, 0x03, 0xE7, 0xC0, 0x03, 0xCF, 0x00,
  0x03, 0xDE, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xE0,
  0x00, 0x7B, 0xE0, 0x01, 0xE7, 0xE0, 0x07, 0xCE, 0xE0, 0x1F, 0x1D, 0xFF,
  0xFC, 0x39, 0xFF, 0xF0, 0x70, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xF0, 0x0F,
  0x87, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x1E,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x80, 0x01, 0xE7, 0x80, 0x03,
  0x8F, 0x80, 0x0F, 0x0F, 0x80, 0x3C, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x0F,
  0x03, 0xFF, 0x0F, 0x07, 0xFF, 0xCF, 0x0F, 0xFF, 0xEF, 0x1F, 0x00, 0xEF,
  0x3E, 0x00, 0x7F, 0x3C, 0x00, 0x3F, 0x38, 0x00, 0x1F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x38, 0x00, 0x1F,
  0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x3F, 0x1F, 0x00, 0xFF, 0x0F, 0xFF, 0xEF,
  0x07, 0xFF, 0xCF, 0x03, 0xFF, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x00, 0xF8,
  0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x0C, 0x3E, 0x00, 0x1C, 0x1F, 0x80, 0x3E, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x0F,
  0x07, 0xFF, 0xCF, 0x0F, 0xFF, 0xEF, 0x1F, 0x00, 0xEF, 0x3E, 0x00, 0x7F,
  0x3C, 0x00, 0x3F, 0x38, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x38, 0x00, 0x1F, 0x3C, 0x00, 0x1F,
  0x1E, 0x00, 0x3F, 0x1F, 0x00, 0xFF, 0x0F, 0xFF, 0xEF, 0x07, 0xFF, 0xCF,
  0x03, 0xFF, 0x0F, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x10, 0x00, 0x1E,
  0x1C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1F, 0xC1, 0xF8, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x1F, 0x03, 0x87, 0xFE, 0x1C, 0x7F, 0xF8,
  0xE7, 0xFF, 0xE7, 0x78, 0x0F, 0xBF, 0x80, 0x3D, 0xF8, 0x00, 0xEF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0x73, 0xFE, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x81, 0xF4, 0x7C, 0xFF, 0x9F,
  0xE3, 0xF0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x0F, 0x38, 0x00, 0x7C, 0xE0,
  0x03, 0xE3, 0x80, 0x0F, 0x0E, 0x00, 0x78, 0x38, 0x03, 0xC0, 0xE0, 0x1E,
  0x03, 0x80, 0xF8, 0x0E, 0x07, 0xC0, 0x38, 0x1E, 0x00, 0xE0, 0xF0, 0x03,
  0x87, 0x80, 0x0E, 0x3C, 0x00, 0x39, 0xF0, 0x00, 0xE7, 0x80, 0x03, 0xBF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0x78, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xC0,
  0x0F, 0x07, 0x80, 0x38, 0x0F, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0E,
  0x00, 0xF0, 0x38, 0x03, 0xC0, 0xE0, 0x07, 0x83, 0x80, 0x0F, 0x0E, 0x00,
  0x3C, 0x38, 0x00, 0x78, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0xCE, 0x00, 0x07,
  0xB8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0xFF, 0xC0, 0x3F,
  0xF0, 0xF1, 0xFF, 0xE0, 0x7F, 0xF8, 0xF3, 0xFF, 0xF1, 0xFF, 0xFC, 0xF7,
  0x00, 0xF9, 0xE0, 0x3E, 0xFE, 0x00, 0x7B, 0x80, 0x1E, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x3E,
  0x07, 0x0F, 0xFC, 0x38, 0xFF, 0xF1, 0xCF, 0xFF, 0xCE, 0xF0, 0x1F, 0x7F,
  0x00, 0x7B, 0xF0, 0x01, 0xDF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0xF0, 0x01,
  0xE0, 0xF8, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00,
  0x03, 0x9E, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x01, 0xC3, 0xFF, 0x03, 0x9F, 0xFF, 0x07, 0x7F, 0xFF, 0x0E, 0xE0,
  0x1F, 0x1F, 0x80, 0x1F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xE0, 0x00,
  0x3D, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00,
  0x0F, 0x3E, 0x00, 0x3E, 0x7F, 0x00, 0xF8, 0xEF, 0xFF, 0xE1, 0xCF, 0xFF,
  0x83, 0x87, 0xFE, 0x07, 0x03, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x1C, 0x1F,
  0xFF, 0x38, 0x7F, 0xFF, 0x71, 0xF0, 0x0F, 0xE7, 0xC0, 0x07, 0xCF, 0x00,
  0x0F, 0x9E, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xC0, 0x00,
  0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xE0, 0x00, 0x3B, 0xC0,
  0x00, 0x73, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x80,
  0x7F, 0x0F, 0xFF, 0xEE, 0x0F, 0xFF, 0x9C, 0x0F, 0xFE, 0x38, 0x03, 0xE0,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x7F, 0x0F, 0xF9, 0xFF, 0xDF, 0xFE, 0xF0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x1E, 0x01, 0xF0, 0xF0, 0x01,
  0xE3, 0x80, 0x07, 0x9E, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0x70, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0xC0, 0x07, 0x8F, 0x80, 0x3E,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0,
  0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xF0, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xBC, 0x00, 0xFD, 0xF0, 0x0E, 0xE7, 0xFF, 0xF7, 0x1F, 0xFF, 0x38, 0x7F,
  0xE1, 0xC0, 0x7C, 0x00, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0x38, 0x00,
  0x3C, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x1C, 0x00,
  0x70, 0x1E, 0x00, 0x70, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0F, 0x00,
  0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x81,
  0xC0, 0x03, 0x83, 0x80, 0x03, 0x83, 0x80, 0x03, 0xC3, 0x80, 0x01, 0xC7,
  0x80, 0x01, 0xC7, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xEF, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x3B, 0x80, 0x03, 0xC0, 0x03, 0xDC, 0x00, 0x1E, 0x00, 0x1E,
  0xF0, 0x01, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x80, 0x07, 0x1C, 0x00, 0x7E,
  0x00, 0x38, 0xE0, 0x03, 0xF0, 0x03, 0xC7, 0x00, 0x3B, 0x80, 0x1E, 0x3C,
  0x01, 0xDC, 0x00, 0xE1, 0xE0, 0x0E, 0x70, 0x07, 0x07, 0x00, 0x73, 0x80,
  0x78, 0x38, 0x07, 0x1C, 0x03, 0xC1, 0xE0, 0x38, 0xF0, 0x1C, 0x0F, 0x01,
  0xC3, 0x80, 0xE0, 0x38, 0x1E, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0xE0, 0x78,
  0x0F, 0x07, 0x07, 0x83, 0x80, 0x78, 0x38, 0x1C, 0x1C, 0x01, 0xC3, 0xC0,
  0xE0, 0xE0, 0x0E, 0x1C, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x1C, 0x70, 0x03,
  0xC7, 0x00, 0xE3, 0x80, 0x0E, 0x70, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x38,
  0xE0, 0x03, 0x9C, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x07, 0x70, 0x00, 0x7E,
  0x00, 0x3B, 0x80, 0x03, 0xF0, 0x01, 0xDC, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x1E, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x07, 0x01, 0xE0,
  0x07, 0x83, 0xC0, 0x03, 0x83, 0xC0, 0x03, 0xC7, 0x80, 0x01, 0xE7, 0x80,
  0x01, 0xEF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xEF, 0x00, 0x01, 0xE7, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xC3, 0xC0,
  0x07, 0x83, 0xC0, 0x07, 0x81, 0xE0, 0x0F, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x1E, 0x00, 0x70, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x0E, 0x00, 0x38, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x07, 0x00, 0x70,
  0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0x80, 0xE0, 0x03, 0xC0, 0xE0,
  0x03, 0xC1, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xE3, 0xC0,
  0x00, 0xE3, 0xC0, 0x00, 0xE3, 0x80, 0x00, 0xF3, 0x80, 0x00, 0x77, 0x80,
  0x00, 0x77, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x2F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x02, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x40, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x71, 0xFF, 0xC0, 0x01, 0xCF, 0xFF, 0x80,
  0x0E, 0x3C, 0x1F, 0x00, 0x39, 0xE0, 0x3E, 0x00, 0xE7, 0x00, 0x7C, 0x07,
  0x9C, 0x00, 0xF8, 0x3C, 0x70, 0x01, 0xFB, 0xF3, 0xC0, 0x03, 0xFF, 0x8F,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_Light64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 47, 14, 5, -46 },
  { 25, 11, 14, 18, 4, -48 },
  { 45, 29, 46, 33, 3, -46 },
  { 212, 24, 60, 31, 4, -53 },
  { 392, 35, 48, 41, 3, -47 },
  { 602, 30, 48, 34, 3, -47 },
  { 782, 3, 14, 11, 4, -48 },
  { 788, 13, 66, 19, 4, -51 },
  { 896, 12, 66, 19, 2, -51 },
  { 995, 25, 26, 27, 1, -46 },
  { 1077, 26, 34, 32, 3, -39 },
  { 1188, 7, 15, 12, 2, -6 },
  { 1202, 12, 3, 17, 2, -21 },
  { 1207, 5, 6, 15, 5, -5 },
  { 1211, 19, 50, 23, 1, -46 },
  { 1330, 23, 48, 31, 4, -47 },
  { 1468, 14, 46, 31, 5, -46 },
  { 1549, 25, 47, 31, 3, -47 },
  { 1696, 24, 48, 31, 3, -47 },
  { 1840, 28, 46, 31, 2, -46 },
  { 2001, 23, 47, 31, 5, -46 },
  { 2137, 24, 47, 31, 4, -46 },
  { 2278, 25, 46, 31, 3, -46 },
  { 2422, 25, 48, 31, 3, -47 },
  { 2572, 24, 47, 31, 3, -47 },
  { 2713, 6, 35, 13, 4, -34 },
  { 2740, 7, 43, 12, 2, -34 },
  { 2778, 21, 27, 29, 3, -34 },
  { 2849, 21, 16, 31, 5, -29 },
  { 2891, 22, 27, 29, 4, -34 },
  { 2966, 20, 48, 26, 3, -47 },
  { 3086, 43, 58, 50, 4, -44 },
  { 3398, 33, 46, 35, 1, -46 },
  { 3588, 26, 46, 34, 5, -46 },
  { 3738, 29, 48, 36, 4, -47 },
  { 3912, 27, 46, 36, 5, -46 },
  { 4068, 24, 46, 32, 5, -46 },
  { 4206, 24, 46, 31, 5, -46 },
  { 4344, 28, 48, 38, 5, -47 },
  { 4512, 29, 46, 39, 5, -46 },
  { 4679, 4, 46, 16, 6, -46 },
  { 4702, 24, 47, 31, 2, -46 },
  { 4843, 29, 46, 35, 5, -46 },
  { 5010, 23, 46, 30, 5, -46 },
  { 5143, 37, 46, 48, 5, -46 },
  { 5356, 29, 46, 39, 5, -46 },
  { 5523, 30, 48, 38, 4, -47 },
  { 5703, 27, 46, 35, 5, -46 },
  { 5859, 29, 55, 38, 4, -47 },
  { 6059, 28, 46, 35, 5, -46 },
  { 6220, 27, 48, 33, 3, -47 },
  { 6382, 29, 46, 33, 2, -46 },
  { 6549, 27, 47, 37, 5, -46 },
  { 6708, 32, 46, 35, 1, -46 },
  { 6892, 45, 46, 49, 2, -46 },
  { 7151, 30, 46, 34, 2, -46 },
  { 7324, 31, 46, 33, 1, -46 },
  { 7503, 28, 46, 33, 3, -46 },
  { 7664, 9, 62, 14, 5, -52 },
  { 7734, 19, 50, 23, 2, -46 },
  { 7853, 9, 62, 14, 1, -52 },
  { 7923, 18, 23, 24, 3, -46 },
  { 7975, 23, 3, 25, 1, 0 },
  { 7984, 11, 9, 18, 3, -48 },
  { 7997, 23, 36, 30, 3, -35 },
  { 8101, 23, 49, 31, 5, -48 },
  { 8242, 23, 36, 29, 3, -35 },
  { 8346, 24, 49, 31, 3, -48 },
  { 8493, 24, 36, 29, 3, -35 },
  { 8601, 17, 49, 19, 2, -49 },
  { 8706, 24, 48, 31, 3, -35 },
  { 8850, 21, 48, 31, 5, -48 },
  { 8976, 5, 46, 14, 4, -46 },
  { 9005, 11, 59, 14, -2, -46 },
  { 9087, 22, 48, 28, 5, -48 },
  { 9219, 4, 48, 14, 5, -48 },
  { 9243, 40, 35, 49, 4, -35 },
  { 9418, 21, 35, 31, 5, -35 },
  { 9510, 25, 36, 31, 3, -35 },
  { 9623, 23, 48, 31, 5, -35 },
  { 9761, 23, 48, 31, 3, -35 },
  { 9899, 13, 35, 19, 5, -35 },
  { 9956, 22, 36, 29, 3, -35 },
  { 10055, 15, 43, 19, 1, -42 },
  { 10136, 21, 35, 31, 5, -34 },
  { 10228, 24, 34, 27, 2, -34 },
  { 10330, 37, 34, 42, 2, -34 },
  { 10488, 24, 34, 28, 2, -34 },
  { 10590, 24, 47, 27, 1, -34 },
  { 10731, 22, 34, 28, 3, -34 },
  { 10825, 16, 63, 19, 2, -50 },
  { 10951, 3, 54, 14, 6, -46 },
  { 10972, 16, 63, 19, 1, -50 },
  { 11098, 30, 12, 38, 4, -25 },
};

const GFXfont RobotoCondensed_Light64pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light64pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light64pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _ROBOTOCONDENSED_LIGHT64PT7B_H_
