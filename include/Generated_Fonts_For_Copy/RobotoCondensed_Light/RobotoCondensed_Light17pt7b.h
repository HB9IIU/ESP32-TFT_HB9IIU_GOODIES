#ifndef _ROBOTOCONDENSED_LIGHT17PT7B_H_
#define _ROBOTOCONDENSED_LIGHT17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x90, 0xB6, 0xD0, 0x12, 0x14, 0x24, 0xFF, 0x24, 0x24, 0x24,
  0x28, 0xFE, 0x48, 0x48, 0x48, 0x10, 0x43, 0x91, 0x86, 0x14, 0x18, 0x18,
  0x18, 0x61, 0x45, 0xE1, 0x04, 0x60, 0x48, 0x24, 0x92, 0x89, 0x43, 0x40,
  0x2C, 0x29, 0x14, 0x92, 0x41, 0x20, 0x60, 0x38, 0x48, 0x48, 0x48, 0x50,
  0x20, 0x52, 0x9A, 0x8A, 0x86, 0x86, 0x7A, 0xF0, 0x12, 0x44, 0x48, 0x88,
  0x88, 0x88, 0x84, 0x44, 0x21, 0x84, 0x22, 0x21, 0x11, 0x11, 0x11, 0x12,
  0x22, 0x48, 0x10, 0x23, 0x49, 0xE1, 0x85, 0x11, 0x00, 0x10, 0x20, 0x40,
  0x8F, 0xE2, 0x04, 0x08, 0x10, 0x55, 0xF0, 0xC0, 0x08, 0x42, 0x21, 0x08,
  0x84, 0x22, 0x10, 0x88, 0x00, 0x79, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x14, 0x4E, 0x1F, 0x11, 0x11, 0x11, 0x11, 0x11, 0x78, 0x8A, 0x14, 0x20,
  0x41, 0x02, 0x08, 0x20, 0x81, 0x07, 0xF0, 0x7A, 0x18, 0x41, 0x04, 0xE0,
  0xC1, 0x06, 0x18, 0x5E, 0x08, 0x30, 0x61, 0x42, 0x89, 0x12, 0x44, 0xFE,
  0x10, 0x20, 0x40, 0x7C, 0x81, 0x02, 0x07, 0x88, 0x81, 0x01, 0x03, 0x09,
  0x11, 0xC0, 0x19, 0x84, 0x20, 0xBB, 0x18, 0x61, 0x86, 0x14, 0x4E, 0xFC,
  0x10, 0x42, 0x08, 0x21, 0x04, 0x20, 0x82, 0x10, 0x7B, 0x18, 0x61, 0x44,
  0xE4, 0x61, 0x86, 0x1C, 0x5E, 0x7B, 0x38, 0x61, 0x86, 0x1C, 0xDD, 0x04,
  0x10, 0x9C, 0xC0, 0x00, 0x80, 0x81, 0xE0, 0x08, 0xD9, 0x06, 0x0C, 0x20,
  0xFC, 0x00, 0x00, 0xFC, 0x81, 0x81, 0x81, 0x19, 0x88, 0x00, 0x74, 0x62,
  0x10, 0x88, 0xC4, 0x20, 0x00, 0x40, 0x0F, 0x06, 0x18, 0x81, 0x20, 0x14,
  0x73, 0x12, 0x64, 0x4C, 0x89, 0x91, 0x32, 0x26, 0x4C, 0xC6, 0xE4, 0x00,
  0x80, 0x08, 0x00, 0xF8, 0x08, 0x06, 0x05, 0x02, 0x81, 0x21, 0x10, 0x88,
  0x42, 0x7F, 0x20, 0x90, 0x48, 0x10, 0xFD, 0x0E, 0x0C, 0x18, 0x5F, 0x21,
  0xC1, 0x83, 0x06, 0x0F, 0xE0, 0x3C, 0x42, 0xC2, 0x81, 0x80, 0x80, 0x80,
  0x80, 0x81, 0xC2, 0x42, 0x3C, 0xF8, 0x86, 0x82, 0x82, 0x81, 0x81, 0x81,
  0x81, 0x82, 0x82, 0x86, 0xF8, 0xFF, 0x02, 0x04, 0x08, 0x1F, 0xA0, 0x40,
  0x81, 0x02, 0x07, 0xF0, 0xFF, 0x02, 0x04, 0x08, 0x1F, 0xA0, 0x40, 0x81,
  0x02, 0x04, 0x00, 0x3C, 0x42, 0x41, 0x81, 0x80, 0x80, 0x8F, 0x81, 0x81,
  0x41, 0x43, 0x3C, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xFF, 0xF0, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x86,
  0x18, 0x9C, 0x82, 0x84, 0x8C, 0x88, 0x90, 0xB0, 0xD0, 0xC8, 0x8C, 0x84,
  0x82, 0x83, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F, 0xC0,
  0x70, 0x3A, 0x0E, 0x83, 0xA1, 0x64, 0x59, 0x16, 0x49, 0x8A, 0x62, 0x98,
  0xC6, 0x11, 0xC1, 0xC1, 0xA1, 0xA1, 0x91, 0x91, 0x89, 0x85, 0x85, 0x83,
  0x83, 0x81, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x42, 0x3C, 0xFD, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0x40, 0x81, 0x02, 0x04,
  0x00, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42,
  0x3C, 0x02, 0x01, 0xFC, 0x82, 0x82, 0x82, 0x82, 0x86, 0xFC, 0x88, 0x84,
  0x84, 0x82, 0x82, 0x39, 0x8A, 0x0C, 0x1C, 0x0E, 0x03, 0x01, 0x83, 0x07,
  0x19, 0xE0, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x80, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0x09, 0xE0,
  0x40, 0xA0, 0x90, 0x48, 0x22, 0x21, 0x10, 0x88, 0x28, 0x14, 0x0A, 0x03,
  0x01, 0x00, 0x84, 0x28, 0x42, 0x8A, 0x28, 0xA2, 0x4A, 0x24, 0xA4, 0x49,
  0x45, 0x14, 0x51, 0x43, 0x14, 0x20, 0x82, 0x08, 0x82, 0x42, 0x44, 0x28,
  0x28, 0x10, 0x10, 0x28, 0x24, 0x44, 0xC2, 0x82, 0x41, 0x20, 0x88, 0x84,
  0x41, 0x40, 0xA0, 0x60, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFE, 0x08,
  0x10, 0x40, 0x82, 0x04, 0x10, 0x40, 0x82, 0x07, 0xF0, 0xF2, 0x49, 0x24,
  0x92, 0x49, 0x24, 0xE0, 0x41, 0x04, 0x08, 0x20, 0x81, 0x04, 0x10, 0x20,
  0x82, 0x04, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49, 0xE0, 0x23, 0x19, 0x29,
  0x48, 0xFC, 0x88, 0x7A, 0x18, 0x41, 0x7E, 0x18, 0x63, 0x74, 0x82, 0x08,
  0x20, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x71, 0xB8, 0x7A, 0x18, 0x60, 0x82,
  0x08, 0x61, 0x78, 0x04, 0x10, 0x41, 0x7E, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x7C, 0x7A, 0x38, 0x61, 0xFE, 0x08, 0x31, 0x78, 0x34, 0x44, 0xF4, 0x44,
  0x44, 0x44, 0x40, 0x76, 0x38, 0x61, 0x86, 0x18, 0x61, 0x7C, 0x10, 0x5E,
  0x82, 0x08, 0x20, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x9F, 0xF0,
  0x20, 0x12, 0x49, 0x24, 0x92, 0x58, 0x82, 0x08, 0x20, 0x8A, 0x69, 0x28,
  0xE2, 0x49, 0xA2, 0x84, 0xFF, 0xF8, 0xB9, 0xD8, 0xCE, 0x10, 0xC2, 0x18,
  0x43, 0x08, 0x61, 0x0C, 0x21, 0x84, 0x20, 0xBB, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x84, 0x7B, 0x18, 0x61, 0x86, 0x18, 0x71, 0x78, 0xBB, 0x18, 0x61,
  0x86, 0x18, 0x71, 0xBA, 0x08, 0x20, 0x7E, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x7C, 0x10, 0x41, 0xBC, 0x88, 0x88, 0x88, 0x80, 0x7A, 0x28, 0x50, 0x30,
  0x28, 0x63, 0x78, 0x22, 0xF2, 0x22, 0x22, 0x22, 0x30, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x73, 0x74, 0x42, 0x89, 0x12, 0x22, 0x85, 0x0A, 0x08, 0x10,
  0x88, 0xC4, 0x65, 0x32, 0x95, 0x52, 0xA9, 0x8C, 0xC6, 0x22, 0x00, 0x44,
  0x88, 0xA0, 0xC1, 0x05, 0x0A, 0x22, 0x46, 0x42, 0x89, 0x11, 0x22, 0x85,
  0x0A, 0x08, 0x10, 0x20, 0x83, 0x00, 0xF8, 0x21, 0x04, 0x21, 0x84, 0x20,
  0xFC, 0x12, 0x44, 0x44, 0x48, 0x44, 0x44, 0x44, 0x21, 0xFF, 0xFC, 0xC4,
  0x22, 0x22, 0x21, 0x22, 0x22, 0x22, 0x48, 0x71, 0x99, 0x8E,
};

const GFXglyph RobotoCondensed_Light17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 12, 4, 1, -12 },
  { 3, 3, 4, 5, 1, -13 },
  { 5, 8, 12, 9, 1, -12 },
  { 17, 6, 16, 8, 1, -14 },
  { 29, 9, 12, 11, 1, -12 },
  { 43, 8, 12, 9, 1, -12 },
  { 55, 1, 4, 3, 1, -13 },
  { 56, 4, 18, 5, 1, -14 },
  { 65, 4, 18, 5, 0, -14 },
  { 74, 7, 7, 7, 0, -12 },
  { 81, 7, 9, 8, 1, -10 },
  { 89, 2, 4, 3, 0, -2 },
  { 90, 4, 1, 4, 0, -6 },
  { 91, 2, 1, 4, 1, -1 },
  { 92, 5, 13, 6, 0, -12 },
  { 101, 6, 12, 8, 1, -12 },
  { 110, 4, 12, 8, 1, -12 },
  { 116, 7, 12, 8, 1, -12 },
  { 127, 6, 12, 8, 1, -12 },
  { 136, 7, 12, 8, 1, -12 },
  { 147, 7, 12, 8, 1, -12 },
  { 158, 6, 12, 8, 1, -12 },
  { 167, 6, 12, 8, 1, -12 },
  { 176, 6, 12, 8, 1, -12 },
  { 185, 6, 12, 8, 1, -12 },
  { 194, 2, 9, 3, 1, -9 },
  { 197, 1, 11, 3, 1, -9 },
  { 199, 5, 7, 8, 1, -9 },
  { 204, 6, 5, 8, 1, -8 },
  { 208, 6, 7, 8, 1, -9 },
  { 214, 5, 12, 7, 1, -12 },
  { 222, 11, 16, 13, 1, -12 },
  { 244, 9, 12, 9, 0, -12 },
  { 258, 7, 12, 9, 1, -12 },
  { 269, 8, 12, 10, 1, -12 },
  { 281, 8, 12, 10, 1, -12 },
  { 293, 7, 12, 8, 1, -12 },
  { 304, 7, 12, 8, 1, -12 },
  { 315, 8, 12, 10, 1, -12 },
  { 327, 8, 12, 10, 1, -12 },
  { 339, 1, 12, 4, 2, -12 },
  { 341, 6, 12, 8, 1, -12 },
  { 350, 8, 12, 9, 1, -12 },
  { 362, 6, 12, 8, 1, -12 },
  { 371, 10, 12, 13, 1, -12 },
  { 386, 8, 12, 10, 1, -12 },
  { 398, 8, 12, 10, 1, -12 },
  { 410, 7, 12, 9, 1, -12 },
  { 421, 8, 14, 10, 1, -12 },
  { 435, 8, 12, 9, 1, -12 },
  { 447, 7, 12, 9, 1, -12 },
  { 458, 7, 12, 9, 1, -12 },
  { 469, 7, 12, 10, 1, -12 },
  { 480, 9, 12, 9, 0, -12 },
  { 494, 12, 12, 13, 1, -12 },
  { 512, 8, 12, 9, 1, -12 },
  { 524, 9, 12, 9, 0, -12 },
  { 538, 7, 12, 9, 1, -12 },
  { 549, 3, 17, 4, 1, -14 },
  { 556, 6, 13, 6, 0, -12 },
  { 566, 3, 17, 4, 0, -14 },
  { 573, 5, 6, 6, 1, -12 },
  { 577, 6, 1, 7, 0, 0 },
  { 578, 3, 2, 5, 1, -12 },
  { 579, 6, 9, 8, 1, -9 },
  { 586, 6, 13, 8, 1, -13 },
  { 596, 6, 9, 8, 1, -9 },
  { 603, 6, 13, 8, 1, -13 },
  { 613, 6, 9, 8, 1, -9 },
  { 620, 4, 13, 5, 1, -13 },
  { 627, 6, 12, 8, 1, -9 },
  { 636, 6, 13, 8, 1, -13 },
  { 646, 1, 12, 4, 1, -12 },
  { 648, 3, 15, 4, -1, -12 },
  { 654, 6, 13, 7, 1, -13 },
  { 664, 1, 13, 4, 1, -13 },
  { 666, 11, 9, 13, 1, -9 },
  { 679, 6, 9, 8, 1, -9 },
  { 686, 6, 9, 8, 1, -9 },
  { 693, 6, 12, 8, 1, -9 },
  { 702, 6, 12, 8, 1, -9 },
  { 711, 4, 9, 5, 1, -9 },
  { 716, 6, 9, 8, 1, -9 },
  { 723, 4, 11, 5, 0, -11 },
  { 729, 6, 9, 8, 1, -9 },
  { 736, 7, 9, 7, 0, -9 },
  { 744, 9, 9, 11, 1, -9 },
  { 755, 7, 9, 7, 0, -9 },
  { 763, 7, 12, 7, 0, -9 },
  { 774, 6, 9, 7, 1, -9 },
  { 781, 4, 16, 5, 1, -13 },
  { 789, 1, 14, 4, 1, -12 },
  { 791, 4, 16, 5, 0, -13 },
  { 799, 8, 3, 10, 1, -7 },
};

const GFXfont RobotoCondensed_Light17pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light17pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOCONDENSED_LIGHT17PT7B_H_
