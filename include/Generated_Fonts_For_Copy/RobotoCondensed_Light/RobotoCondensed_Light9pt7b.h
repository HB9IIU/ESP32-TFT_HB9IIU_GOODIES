#ifndef _ROBOTOCONDENSED_LIGHT9PT7B_H_
#define _ROBOTOCONDENSED_LIGHT9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF2, 0x00, 0x01, 0x94, 0xA5, 0x39, 0x00, 0x1A, 0xC4, 0x4E, 0x00,
  0xE5, 0xBC, 0x43, 0x8C, 0x60, 0x62, 0x98, 0x8A, 0x49, 0xA0, 0x00, 0x7F,
  0x00, 0x95, 0x55, 0x80, 0x0F, 0x46, 0x02, 0xF2, 0x00, 0xC0, 0x00, 0x00,
  0x25, 0x24, 0xA4, 0xD6, 0xDB, 0x70, 0xD5, 0x54, 0x61, 0x12, 0x24, 0xE0,
  0x69, 0x12, 0x19, 0x60, 0x02, 0x55, 0xF1, 0x00, 0xF3, 0x12, 0x78, 0x53,
  0x5B, 0x70, 0x71, 0x22, 0x24, 0x40, 0x69, 0x96, 0x99, 0x60, 0x69, 0x99,
  0x71, 0x20, 0x00, 0x0C, 0x29, 0x10, 0x48, 0x89, 0x40, 0x74, 0x94, 0x10,
  0x72, 0x2B, 0x75, 0xD7, 0xE8, 0x1C, 0x21, 0x14, 0xA7, 0x46, 0x20, 0xF6,
  0xFB, 0x78, 0xE9, 0x88, 0x89, 0xE0, 0xE9, 0x99, 0x99, 0xE0, 0xD2, 0x69,
  0x30, 0xD2, 0x69, 0x20, 0xE9, 0x88, 0x99, 0xE0, 0x99, 0x9D, 0x99, 0x90,
  0xFE, 0x11, 0x11, 0x19, 0x60, 0xAA, 0xCC, 0xCA, 0x90, 0x92, 0x49, 0x30,
  0x8C, 0x63, 0xBD, 0xF6, 0xA0, 0x99, 0xDD, 0xB9, 0x90, 0xE9, 0x99, 0x99,
  0xE0, 0xF6, 0xF9, 0x20, 0xE9, 0x99, 0x99, 0xE1, 0xE9, 0x9E, 0xAA, 0x90,
  0x79, 0x42, 0x19, 0x70, 0x62, 0x22, 0x22, 0x20, 0xB6, 0xDB, 0x78, 0x8C,
  0x94, 0xA5, 0x10, 0x80, 0x93, 0x25, 0xB3, 0x66, 0xC9, 0x80, 0x00, 0x92,
  0x98, 0x46, 0x2A, 0x40, 0x8A, 0x94, 0x42, 0x10, 0x80, 0x71, 0x22, 0x44,
  0xA0, 0x7E, 0x91, 0x24, 0x49, 0x7F, 0x48, 0x80, 0x40, 0x90, 0x61, 0x59,
  0x70, 0x13, 0xDB, 0x78, 0x69, 0x89, 0x60, 0x11, 0x79, 0x99, 0x70, 0x69,
  0xB8, 0x70, 0x69, 0x24, 0x90, 0x79, 0x99, 0x71, 0x60, 0x13, 0x5B, 0x48,
  0x3E, 0x3F, 0x80, 0x13, 0x49, 0x88, 0xFE, 0xDD, 0x6B, 0x52, 0x00, 0xD6,
  0xD2, 0x69, 0x99, 0x60, 0xD6, 0xDD, 0x00, 0x79, 0x99, 0x71, 0x10, 0xEA,
  0x00, 0x68, 0x61, 0x60, 0x55, 0x50, 0x36, 0xDE, 0x9A, 0x66, 0x00, 0x82,
  0xE7, 0x92, 0x40, 0xA6, 0x46, 0x90, 0x9A, 0x66, 0x24, 0x40, 0x52, 0x44,
  0xA0, 0x49, 0x20, 0x92, 0x40, 0x7E, 0x95, 0x55, 0x80, 0xD2,
};

const GFXglyph RobotoCondensed_Light9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 0, -7 },
  { 2, 1, 2, 3, 1, -7 },
  { 3, 5, 7, 5, 0, -7 },
  { 8, 3, 9, 4, 1, -8 },
  { 12, 5, 7, 6, 0, -7 },
  { 17, 5, 7, 5, 0, -7 },
  { 22, 1, 2, 2, 0, -7 },
  { 23, 1, 9, 3, 1, -7 },
  { 25, 2, 9, 3, 0, -7 },
  { 28, 4, 4, 4, 0, -7 },
  { 30, 4, 5, 4, 0, -6 },
  { 33, 1, 2, 2, 0, -1 },
  { 34, 2, 1, 2, 0, -4 },
  { 35, 1, 1, 2, 1, -1 },
  { 36, 3, 8, 3, 0, -7 },
  { 39, 3, 7, 4, 1, -7 },
  { 42, 2, 7, 4, 1, -7 },
  { 44, 4, 7, 4, 0, -7 },
  { 48, 4, 7, 4, 0, -7 },
  { 52, 4, 7, 4, 0, -7 },
  { 56, 3, 7, 4, 1, -7 },
  { 59, 3, 7, 4, 1, -7 },
  { 62, 4, 7, 4, 0, -7 },
  { 66, 4, 7, 4, 0, -7 },
  { 70, 4, 7, 4, 0, -7 },
  { 74, 1, 5, 2, 0, -5 },
  { 75, 1, 6, 2, 0, -5 },
  { 76, 3, 4, 4, 0, -5 },
  { 78, 3, 2, 4, 1, -4 },
  { 79, 3, 4, 4, 1, -5 },
  { 81, 3, 7, 4, 0, -7 },
  { 84, 6, 8, 7, 1, -6 },
  { 90, 5, 7, 5, 0, -7 },
  { 95, 3, 7, 5, 1, -7 },
  { 98, 4, 7, 5, 1, -7 },
  { 102, 4, 7, 5, 1, -7 },
  { 106, 3, 7, 4, 1, -7 },
  { 109, 3, 7, 4, 1, -7 },
  { 112, 4, 7, 5, 1, -7 },
  { 116, 4, 7, 6, 1, -7 },
  { 120, 1, 7, 2, 1, -7 },
  { 121, 4, 7, 4, 0, -7 },
  { 125, 4, 7, 5, 1, -7 },
  { 129, 3, 7, 4, 1, -7 },
  { 132, 5, 7, 7, 1, -7 },
  { 137, 4, 7, 6, 1, -7 },
  { 141, 4, 7, 5, 1, -7 },
  { 145, 3, 7, 5, 1, -7 },
  { 148, 4, 8, 5, 1, -7 },
  { 152, 4, 7, 5, 1, -7 },
  { 156, 4, 7, 5, 0, -7 },
  { 160, 4, 7, 5, 0, -7 },
  { 164, 3, 7, 5, 1, -7 },
  { 167, 5, 7, 5, 0, -7 },
  { 172, 7, 7, 7, 0, -7 },
  { 179, 5, 7, 5, 0, -7 },
  { 184, 5, 7, 5, 0, -7 },
  { 189, 4, 7, 5, 0, -7 },
  { 193, 1, 8, 2, 1, -7 },
  { 194, 3, 8, 3, 0, -7 },
  { 197, 1, 8, 2, 0, -7 },
  { 198, 3, 3, 3, 0, -7 },
  { 200, 3, 1, 3, 0, 0 },
  { 201, 2, 2, 3, 0, -8 },
  { 202, 4, 5, 4, 0, -5 },
  { 205, 3, 7, 4, 1, -7 },
  { 208, 4, 5, 4, 0, -5 },
  { 211, 4, 7, 4, 0, -7 },
  { 215, 4, 5, 4, 0, -5 },
  { 218, 3, 7, 3, 0, -7 },
  { 221, 4, 7, 4, 0, -5 },
  { 225, 3, 7, 4, 1, -7 },
  { 228, 1, 7, 2, 0, -7 },
  { 229, 1, 9, 2, 0, -7 },
  { 231, 3, 7, 4, 1, -7 },
  { 234, 1, 7, 2, 0, -7 },
  { 235, 5, 5, 7, 1, -5 },
  { 239, 3, 5, 4, 1, -5 },
  { 241, 4, 5, 4, 0, -5 },
  { 244, 3, 7, 4, 1, -5 },
  { 247, 4, 7, 4, 0, -5 },
  { 251, 2, 5, 3, 1, -5 },
  { 253, 4, 5, 4, 0, -5 },
  { 256, 2, 6, 3, 0, -6 },
  { 258, 3, 5, 4, 1, -5 },
  { 260, 4, 5, 4, 0, -5 },
  { 263, 6, 5, 6, 0, -5 },
  { 267, 4, 5, 4, 0, -5 },
  { 270, 4, 7, 4, 0, -5 },
  { 274, 4, 5, 4, 0, -5 },
  { 277, 3, 9, 3, 0, -7 },
  { 281, 1, 8, 2, 1, -7 },
  { 282, 2, 9, 3, 0, -7 },
  { 285, 4, 2, 5, 1, -4 },
};

const GFXfont RobotoCondensed_Light9pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light9pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOCONDENSED_LIGHT9PT7B_H_
