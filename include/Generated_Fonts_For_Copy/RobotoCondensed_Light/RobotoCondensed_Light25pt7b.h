#ifndef _ROBOTOCONDENSED_LIGHT25PT7B_H_
#define _ROBOTOCONDENSED_LIGHT25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light25pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0x80, 0xF0, 0x99, 0x99, 0x99, 0x04, 0x40, 0x44,
  0x0C, 0x40, 0x8C, 0x08, 0x87, 0xFF, 0x08, 0x80, 0x88, 0x18, 0x81, 0x08,
  0x11, 0x81, 0x10, 0xFF, 0xE1, 0x10, 0x11, 0x02, 0x10, 0x23, 0x02, 0x20,
  0x04, 0x01, 0x01, 0xE0, 0xEE, 0x60, 0x90, 0x34, 0x0D, 0x00, 0x60, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x20, 0x0F, 0x03, 0x40, 0xD8, 0x23, 0x38,
  0x7C, 0x04, 0x01, 0x00, 0x38, 0x01, 0x30, 0x0C, 0x42, 0x21, 0x18, 0x84,
  0x43, 0x13, 0x04, 0xC8, 0x0E, 0x40, 0x01, 0x00, 0x08, 0x00, 0x27, 0x01,
  0x32, 0x04, 0x8C, 0x22, 0x10, 0x88, 0x44, 0x23, 0x00, 0xC8, 0x01, 0xC0,
  0x1E, 0x03, 0x30, 0x21, 0x02, 0x10, 0x21, 0x02, 0x30, 0x36, 0x01, 0xC0,
  0x18, 0x03, 0xC0, 0x66, 0x24, 0x22, 0xC3, 0x2C, 0x1E, 0xC0, 0xC4, 0x0C,
  0x73, 0xE1, 0xE3, 0x57, 0xC0, 0x08, 0x8C, 0x46, 0x21, 0x18, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x30, 0x84, 0x30, 0x86, 0x10, 0x40, 0x84, 0x10,
  0xC2, 0x10, 0xC2, 0x10, 0x84, 0x31, 0x8C, 0x63, 0x10, 0x84, 0x62, 0x11,
  0x88, 0x84, 0x00, 0x04, 0x01, 0x00, 0x41, 0x11, 0x7F, 0xC3, 0x80, 0xE0,
  0x4C, 0x31, 0x08, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F,
  0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x55, 0xE0, 0xF8,
  0xF0, 0x02, 0x0C, 0x10, 0x20, 0xC1, 0x02, 0x0C, 0x10, 0x20, 0xC1, 0x02,
  0x04, 0x10, 0x20, 0x41, 0x82, 0x04, 0x00, 0x1E, 0x0C, 0xC6, 0x19, 0x02,
  0x40, 0x90, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x40, 0xD0,
  0x24, 0x09, 0x86, 0x33, 0x07, 0x80, 0x09, 0xFB, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x40, 0x1E, 0x1C, 0xC4, 0x1B, 0x02, 0xC0,
  0x80, 0x20, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x08, 0x06, 0x03,
  0x00, 0x80, 0x40, 0x1F, 0xF0, 0x1E, 0x0C, 0xC6, 0x19, 0x02, 0xC0, 0x80,
  0x20, 0x18, 0x0C, 0x1E, 0x00, 0x60, 0x08, 0x02, 0x00, 0xF0, 0x3C, 0x09,
  0x02, 0x73, 0x07, 0x80, 0x03, 0x00, 0x60, 0x1C, 0x02, 0x80, 0xD0, 0x12,
  0x04, 0x40, 0x88, 0x21, 0x0C, 0x21, 0x04, 0x60, 0x8F, 0xFE, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x7F, 0xA0, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x78, 0xEE, 0x41, 0x00, 0xC0, 0x20, 0x10, 0x0C, 0x07, 0x06, 0x82, 0x77,
  0x1F, 0x00, 0x0E, 0x1C, 0x18, 0x08, 0x0C, 0x04, 0x02, 0x79, 0xCE, 0xC1,
  0x40, 0xE0, 0x70, 0x18, 0x1C, 0x0F, 0x07, 0x82, 0x77, 0x1E, 0x00, 0xFF,
  0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x02, 0x01, 0x80,
  0x40, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x00, 0x1E, 0x0C,
  0xC6, 0x19, 0x02, 0x40, 0x90, 0x26, 0x08, 0xCC, 0x1E, 0x08, 0x64, 0x09,
  0x03, 0xC0, 0xF0, 0x34, 0x0D, 0x02, 0x33, 0x87, 0x80, 0x1E, 0x0C, 0xC6,
  0x19, 0x02, 0xC0, 0xB0, 0x2C, 0x0F, 0x03, 0x40, 0xD8, 0x73, 0x38, 0x72,
  0x00, 0x80, 0x20, 0x18, 0x0C, 0x0E, 0x0E, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x48, 0x00, 0x00, 0x00, 0x24, 0x96, 0x80, 0x00, 0x81, 0xC3, 0x87, 0x0E,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x40, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x03, 0x0C, 0x30, 0xC0, 0x80, 0x3C,
  0x66, 0xC3, 0x81, 0x01, 0x01, 0x03, 0x02, 0x04, 0x0C, 0x18, 0x18, 0x10,
  0x00, 0x00, 0x00, 0x18, 0x18, 0x01, 0xF0, 0x03, 0x8E, 0x02, 0x00, 0x82,
  0x00, 0x63, 0x00, 0x11, 0x07, 0x05, 0x84, 0x42, 0x84, 0x21, 0x42, 0x10,
  0xA3, 0x08, 0x51, 0x04, 0x38, 0x82, 0x1C, 0x41, 0x0E, 0x21, 0x85, 0x10,
  0xC4, 0x84, 0xA6, 0x43, 0x8E, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x80, 0x0F, 0x80, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xB0,
  0x09, 0x01, 0x90, 0x11, 0x81, 0x08, 0x10, 0x83, 0x08, 0x20, 0xC2, 0x04,
  0x7F, 0xC4, 0x06, 0x40, 0x2C, 0x02, 0x80, 0x38, 0x01, 0xFE, 0x30, 0xEC,
  0x0B, 0x02, 0xC0, 0xB0, 0x2C, 0x1B, 0x0C, 0xFF, 0x30, 0x6C, 0x0F, 0x03,
  0xC0, 0x70, 0x1C, 0x0F, 0x02, 0xC3, 0xBF, 0xC0, 0x1F, 0x06, 0x71, 0x03,
  0x60, 0x28, 0x07, 0x00, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x07, 0x00, 0xF0, 0x12, 0x06, 0x33, 0x83, 0xE0, 0xFE, 0x18, 0xE3,
  0x02, 0x60, 0x6C, 0x05, 0x80, 0xB0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x05, 0x80, 0xB0, 0x36, 0x04, 0xC3, 0x9F, 0xC0, 0xFF, 0xE0,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x7F, 0xC0, 0xFF, 0xE0, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x7F, 0xB0, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x00, 0x1F, 0x06, 0x79, 0x01, 0x60, 0x38, 0x07, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x0F, 0xC0, 0x18, 0x03, 0x80, 0x70,
  0x0B, 0x03, 0x39, 0xC3, 0xF0, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xFF, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x0C, 0x07, 0x07, 0x82, 0x77, 0x1E, 0x00, 0xC0, 0x58, 0x1B, 0x06,
  0x61, 0x8C, 0x61, 0x88, 0x33, 0x06, 0xC0, 0xF8, 0x1D, 0x83, 0x30, 0x63,
  0x0C, 0x31, 0x86, 0x30, 0x66, 0x06, 0xC0, 0xD8, 0x0C, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x7F, 0xC0, 0xC0, 0x07, 0x80, 0x1F, 0x80, 0x3D,
  0x00, 0x7A, 0x01, 0xF6, 0x02, 0xE4, 0x05, 0xCC, 0x1B, 0x98, 0x27, 0x90,
  0xCF, 0x31, 0x1E, 0x22, 0x3C, 0x4C, 0x78, 0xD0, 0xF0, 0xA1, 0xE1, 0xC3,
  0xC3, 0x07, 0x82, 0x0C, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1D, 0x03, 0xB0,
  0x72, 0x0E, 0x61, 0xC4, 0x38, 0xC7, 0x08, 0xE1, 0x9C, 0x13, 0x83, 0x70,
  0x2E, 0x03, 0xC0, 0x78, 0x04, 0x1F, 0x0F, 0x71, 0x03, 0x60, 0x38, 0x07,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xF0, 0x1A, 0x06, 0x7B, 0x83, 0xE0, 0xFF, 0x30, 0xEC, 0x0F, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x6F, 0xF3, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x00, 0x1F, 0x0F, 0x71, 0x03, 0x60, 0x28, 0x07,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xF0, 0x12, 0x06, 0x7B, 0x83, 0xF0, 0x03, 0x00, 0x30, 0x02, 0xFE, 0x10,
  0x72, 0x02, 0x40, 0x68, 0x05, 0x00, 0xA0, 0x14, 0x06, 0x80, 0x90, 0x73,
  0xF8, 0x41, 0x08, 0x31, 0x02, 0x20, 0x64, 0x06, 0x80, 0xD0, 0x0C, 0x1F,
  0x07, 0x71, 0x81, 0x20, 0x34, 0x06, 0x80, 0x18, 0x01, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0x00, 0x30, 0x07, 0x80, 0xF0, 0x1A, 0x02, 0x31, 0xC3, 0xE0,
  0xFF, 0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x03, 0x73, 0x87, 0xC0,
  0x80, 0x3C, 0x03, 0xC0, 0x24, 0x06, 0x40, 0x66, 0x04, 0x20, 0x42, 0x0C,
  0x30, 0x83, 0x08, 0x11, 0x81, 0x10, 0x19, 0x00, 0xB0, 0x0B, 0x00, 0xE0,
  0x06, 0x00, 0x60, 0x80, 0x80, 0xB0, 0x30, 0x2C, 0x1C, 0x09, 0x05, 0x06,
  0x41, 0x41, 0x90, 0x58, 0x46, 0x12, 0x11, 0x8C, 0x84, 0x22, 0x23, 0x08,
  0x8C, 0xC2, 0x21, 0x20, 0xD8, 0x48, 0x34, 0x12, 0x05, 0x07, 0x81, 0x40,
  0xC0, 0x70, 0x30, 0x18, 0x0C, 0x02, 0x03, 0x00, 0xC0, 0x24, 0x06, 0x60,
  0xC3, 0x0C, 0x31, 0x81, 0x90, 0x0B, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x0E,
  0x01, 0xB0, 0x11, 0x83, 0x08, 0x20, 0xC6, 0x04, 0x40, 0x6C, 0x02, 0x40,
  0x13, 0x01, 0x88, 0x08, 0x60, 0xC1, 0x04, 0x0C, 0x60, 0x22, 0x01, 0x90,
  0x05, 0x80, 0x28, 0x01, 0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0xFF, 0xE0, 0x08, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60,
  0x18, 0x02, 0x00, 0xC0, 0x1F, 0xFC, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x49, 0x27, 0x81, 0x81, 0x02, 0x04, 0x0C, 0x08, 0x10, 0x30, 0x20,
  0x40, 0xC0, 0x81, 0x03, 0x02, 0x04, 0x0C, 0x18, 0x10, 0xF3, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x10, 0x30, 0xA1,
  0x42, 0xC8, 0x91, 0x23, 0x82, 0xFF, 0x80, 0x42, 0x10, 0x1E, 0x39, 0x90,
  0x68, 0x10, 0x08, 0xFD, 0xC2, 0x81, 0xC0, 0xE0, 0xF0, 0x6C, 0xD3, 0xC8,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x79, 0xCE, 0xC1, 0x40, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC1, 0x73, 0xA7, 0x80, 0x1E, 0x39,
  0x90, 0x78, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x50, 0x2E, 0x61,
  0xE0, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x7A, 0xE7, 0x41, 0xA0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x02, 0x81, 0x40, 0xB9, 0xC7, 0xA0, 0x1E,
  0x39, 0x90, 0x78, 0x1C, 0x0E, 0x07, 0xFF, 0x80, 0xC0, 0x60, 0x10, 0x2E,
  0x71, 0xF0, 0x1C, 0xE2, 0x08, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x00, 0x1E, 0xB9, 0xD0, 0x68, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xA0, 0x50, 0x6E, 0x71, 0xE8, 0x04, 0x02, 0x83, 0x73,
  0x0F, 0x00, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x9E, 0xB7, 0xC1, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xA0, 0x2A, 0xAA,
  0xAA, 0xA0, 0x10, 0x80, 0x00, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x1B, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x0D, 0x0C, 0x8C, 0x4C, 0x24, 0x14, 0x0F, 0x06, 0xC2, 0x21, 0x08, 0x86,
  0x41, 0xA0, 0x40, 0xFF, 0xFF, 0xE0, 0x9E, 0x3D, 0x6E, 0xDF, 0x0E, 0x0C,
  0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x81, 0x81, 0x03, 0x02,
  0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x20, 0x9E, 0xB7, 0xC1, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x1E, 0x0C, 0xE6, 0x09,
  0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x50, 0x36, 0x08, 0xCE, 0x1E,
  0x00, 0x9E, 0x73, 0xB0, 0x50, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xF0, 0x5C, 0xE9, 0xE4, 0x02, 0x01, 0x00, 0x80, 0x40, 0x00, 0x1E, 0xB9,
  0xD0, 0x68, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xA0, 0x50, 0x2E, 0x71,
  0xE8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0xBD, 0xB1, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x00, 0x3E, 0x31, 0x90, 0x68, 0x36, 0x01, 0x80, 0x70,
  0x06, 0x01, 0xE0, 0xD0, 0x6C, 0x63, 0xE0, 0x30, 0xC3, 0x0C, 0xFC, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0x06, 0x1C, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0xE7, 0x3D, 0x81, 0xC0, 0xF0,
  0x48, 0x24, 0x33, 0x10, 0x88, 0x4C, 0x34, 0x0A, 0x07, 0x03, 0x00, 0x80,
  0x83, 0x07, 0x0C, 0x1C, 0x30, 0xD0, 0xE3, 0x46, 0x89, 0x92, 0x26, 0x49,
  0x8B, 0x36, 0x28, 0x50, 0xA1, 0x43, 0x85, 0x06, 0x0C, 0x10, 0x20, 0xC1,
  0xA1, 0x98, 0x84, 0xC1, 0x40, 0xE0, 0x20, 0x38, 0x34, 0x13, 0x18, 0xC8,
  0x2C, 0x18, 0x81, 0xE0, 0xB0, 0x48, 0x64, 0x33, 0x10, 0x88, 0x4C, 0x34,
  0x0A, 0x07, 0x03, 0x00, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x70, 0x00, 0xFF,
  0x00, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x30, 0x10, 0x18, 0x18,
  0x0F, 0xF8, 0x04, 0x21, 0x04, 0x30, 0xC3, 0x0C, 0x30, 0xC2, 0x18, 0xC1,
  0x82, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x41, 0x02, 0x04, 0xFF, 0xFF, 0xF8,
  0x40, 0xC0, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x60, 0x60, 0x61,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x30, 0x40, 0x70, 0x2B,
  0x06, 0x10, 0xC3, 0xE8, 0x38,
};

const GFXglyph RobotoCondensed_Light25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 18, 5, 2, -18 },
  { 6, 4, 6, 7, 2, -19 },
  { 9, 12, 18, 13, 1, -18 },
  { 36, 10, 22, 12, 1, -20 },
  { 64, 14, 18, 16, 1, -18 },
  { 96, 12, 18, 13, 1, -18 },
  { 123, 2, 5, 4, 1, -19 },
  { 125, 5, 26, 7, 2, -20 },
  { 142, 5, 26, 7, 1, -20 },
  { 159, 10, 10, 11, 0, -18 },
  { 172, 10, 13, 12, 1, -15 },
  { 189, 2, 6, 5, 1, -2 },
  { 191, 5, 1, 6, 1, -8 },
  { 192, 2, 2, 6, 2, -2 },
  { 193, 7, 20, 9, 1, -18 },
  { 211, 10, 18, 12, 1, -18 },
  { 234, 5, 18, 12, 2, -18 },
  { 246, 10, 18, 12, 1, -18 },
  { 269, 10, 18, 12, 1, -18 },
  { 292, 11, 18, 12, 1, -18 },
  { 317, 9, 18, 12, 2, -18 },
  { 338, 9, 18, 12, 2, -18 },
  { 359, 10, 18, 12, 1, -18 },
  { 382, 10, 18, 12, 1, -18 },
  { 405, 10, 18, 12, 1, -18 },
  { 428, 2, 13, 5, 2, -13 },
  { 432, 3, 17, 5, 1, -13 },
  { 439, 9, 10, 11, 1, -13 },
  { 451, 8, 6, 12, 2, -11 },
  { 457, 8, 10, 11, 2, -13 },
  { 467, 8, 18, 10, 1, -18 },
  { 485, 17, 23, 20, 1, -17 },
  { 534, 12, 18, 14, 1, -18 },
  { 561, 10, 18, 13, 2, -18 },
  { 584, 11, 18, 14, 2, -18 },
  { 609, 11, 18, 14, 2, -18 },
  { 634, 9, 18, 12, 2, -18 },
  { 655, 9, 18, 12, 2, -18 },
  { 676, 11, 18, 15, 2, -18 },
  { 701, 11, 18, 15, 2, -18 },
  { 726, 2, 18, 6, 2, -18 },
  { 731, 9, 18, 12, 1, -18 },
  { 752, 11, 18, 14, 2, -18 },
  { 777, 9, 18, 12, 2, -18 },
  { 798, 15, 18, 19, 2, -18 },
  { 832, 11, 18, 15, 2, -18 },
  { 857, 11, 18, 15, 2, -18 },
  { 882, 10, 18, 13, 2, -18 },
  { 905, 11, 21, 15, 2, -18 },
  { 934, 11, 18, 14, 2, -18 },
  { 959, 11, 18, 13, 1, -18 },
  { 984, 11, 18, 13, 1, -18 },
  { 1009, 10, 18, 14, 2, -18 },
  { 1032, 12, 18, 14, 1, -18 },
  { 1059, 18, 18, 19, 1, -18 },
  { 1100, 12, 18, 13, 1, -18 },
  { 1127, 13, 18, 13, 0, -18 },
  { 1157, 11, 18, 13, 1, -18 },
  { 1182, 3, 24, 6, 2, -20 },
  { 1191, 7, 20, 9, 1, -18 },
  { 1209, 4, 24, 6, 0, -20 },
  { 1221, 7, 9, 9, 1, -18 },
  { 1229, 9, 1, 10, 0, 0 },
  { 1231, 4, 3, 7, 1, -18 },
  { 1233, 9, 13, 12, 1, -13 },
  { 1248, 9, 19, 12, 2, -19 },
  { 1270, 9, 13, 11, 1, -13 },
  { 1285, 9, 19, 12, 1, -19 },
  { 1307, 9, 13, 11, 1, -13 },
  { 1322, 6, 19, 8, 1, -19 },
  { 1337, 9, 18, 12, 1, -13 },
  { 1358, 8, 19, 12, 2, -19 },
  { 1377, 2, 18, 5, 2, -18 },
  { 1382, 5, 23, 5, -1, -18 },
  { 1397, 9, 19, 11, 2, -19 },
  { 1419, 1, 19, 5, 2, -19 },
  { 1422, 15, 13, 19, 2, -13 },
  { 1447, 8, 13, 12, 2, -13 },
  { 1460, 10, 13, 12, 1, -13 },
  { 1477, 9, 18, 12, 2, -13 },
  { 1498, 9, 18, 12, 1, -13 },
  { 1519, 5, 13, 8, 2, -13 },
  { 1528, 9, 13, 11, 1, -13 },
  { 1543, 6, 17, 7, 0, -17 },
  { 1556, 8, 13, 12, 2, -13 },
  { 1569, 9, 13, 11, 1, -13 },
  { 1584, 14, 13, 16, 1, -13 },
  { 1607, 9, 13, 11, 1, -13 },
  { 1622, 9, 18, 10, 1, -13 },
  { 1643, 9, 13, 11, 1, -13 },
  { 1658, 6, 25, 7, 1, -20 },
  { 1677, 1, 21, 6, 2, -18 },
  { 1680, 7, 25, 7, 0, -20 },
  { 1702, 11, 5, 15, 2, -10 },
};

const GFXfont RobotoCondensed_Light25pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light25pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light25pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOCONDENSED_LIGHT25PT7B_H_
