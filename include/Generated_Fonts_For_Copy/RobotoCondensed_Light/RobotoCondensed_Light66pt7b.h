#ifndef _ROBOTOCONDENSED_LIGHT66PT7B_H_
#define _ROBOTOCONDENSED_LIGHT66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light66pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xEF, 0x7F, 0xCC, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x07,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x38, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x1C, 0x00, 0x07, 0x00,
  0x60, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x03,
  0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0x80, 0x38, 0x00, 0x0E, 0x00, 0xC0,
  0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x1E,
  0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x07, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78,
  0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0xFC, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x03, 0x80, 0x18, 0x07,
  0x00, 0x70, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x18, 0x01, 0xC0, 0x1C,
  0x03, 0x00, 0x38, 0x07, 0x00, 0x60, 0x07, 0x01, 0xE0, 0x0C, 0x00, 0xE0,
  0x38, 0x01, 0x80, 0x1C, 0x0E, 0x00, 0x38, 0x03, 0x81, 0xC0, 0x07, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0x1E, 0x0E, 0x00, 0x0E, 0x03, 0x83, 0x80, 0x01,
  0xE0, 0xF0, 0x70, 0x00, 0x1F, 0xFC, 0x1C, 0x00, 0x01, 0xFF, 0x03, 0x80,
  0x00, 0x1F, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x7E, 0x00, 0x00, 0x38, 0x3F, 0xF0,
  0x00, 0x0E, 0x0F, 0xFF, 0x00, 0x01, 0xC1, 0xC0, 0xE0, 0x00, 0x70, 0x70,
  0x0E, 0x00, 0x0E, 0x0E, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x1C, 0x00, 0xF0,
  0x70, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x07, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x38, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x38, 0x07, 0x00, 0xE0, 0x07,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x1C, 0x0E, 0x00, 0x38,
  0x07, 0x00, 0x40, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x1E,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x78, 0xF8, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0x87, 0xC0,
  0x1C, 0x3C, 0x0F, 0x00, 0x71, 0xE0, 0x1E, 0x01, 0xC7, 0x80, 0x7C, 0x07,
  0x3C, 0x00, 0xF0, 0x3C, 0xF0, 0x01, 0xE0, 0xF3, 0xC0, 0x03, 0xC3, 0xCE,
  0x00, 0x0F, 0x8E, 0x38, 0x00, 0x1E, 0x78, 0xE0, 0x00, 0x3D, 0xE3, 0x80,
  0x00, 0xFF, 0x0E, 0x00, 0x01, 0xFC, 0x3C, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x07, 0x83, 0xE0, 0x00, 0x3F, 0x07, 0x80, 0x01, 0xFC, 0x1F, 0x00, 0x0F,
  0xF8, 0x3F, 0x00, 0xFD, 0xF0, 0x7F, 0xFF, 0xE3, 0xC0, 0xFF, 0xFE, 0x07,
  0x80, 0xFF, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x08, 0x00, 0x60, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0x80,
  0x02, 0x80, 0x06, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x30, 0x01, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x60, 0x0E, 0x01, 0xBF, 0x03, 0x83,
  0xFF, 0xF8, 0xE3, 0xFD, 0xFF, 0xBF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3C, 0xF0, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC0, 0xF0,
  0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x0E, 0x00,
  0x1C, 0x00, 0x80, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8E, 0x3C,
  0x78, 0xE3, 0xCF, 0x1E, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x77,
  0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F,
  0x80, 0xF8, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x38,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x38,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x0F,
  0x81, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0xE7,
  0xFB, 0xFF, 0xC7, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0x80, 0xFC, 0x07,
  0x80, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x0F,
  0x1E, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1C, 0xF0, 0x00,
  0x07, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0xF0,
  0x01, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x0F, 0x3C,
  0x00, 0x07, 0x9E, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0x78, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC3, 0xC0, 0x03,
  0xC1, 0xF8, 0x07, 0xC0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x0E, 0x1C, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00,
  0x0E, 0x01, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0xC0,
  0x1C, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x01, 0xC0,
  0x0F, 0x00, 0x1C, 0x01, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0xC0,
  0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x7F, 0x00, 0x39, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x18,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1F,
  0x00, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x3F, 0x80, 0x38, 0x7F, 0xF0, 0x1C, 0xFF,
  0xFC, 0x0E, 0xFE, 0x7F, 0x0F, 0xF8, 0x07, 0xC7, 0xF0, 0x01, 0xE3, 0xF0,
  0x00, 0x79, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x73, 0xC0, 0x00,
  0x79, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x1E, 0x0F, 0x00,
  0x1F, 0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x1F, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x03, 0xE0,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x07,
  0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x79, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0x78, 0x00, 0x0E, 0x3C, 0x00,
  0x0F, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x07, 0x81, 0xE0, 0x07, 0xC0, 0xF8,
  0x07, 0xC0, 0x3F, 0x9F, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x03, 0xC3,
  0xC0, 0x00, 0xF1, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07,
  0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x1E, 0xF0, 0x00,
  0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xF0,
  0x0F, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x78, 0x00,
  0xF0, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x9E, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3D,
  0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x9E, 0x00, 0x0F,
  0xC7, 0x80, 0x0F, 0xE3, 0xE0, 0x1E, 0xF0, 0xFE, 0x7E, 0x78, 0x3F, 0xFE,
  0x3C, 0x0F, 0xFE, 0x1C, 0x00, 0xFC, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x31, 0xEF, 0xFF,
  0x78, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x1E, 0xFF, 0xF7, 0x8C,
  0x0C, 0x7C, 0xF9, 0xF3, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x8F, 0x1E, 0x78,
  0xE3, 0xC1, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xE0, 0x3E, 0x3E, 0x00, 0xF1, 0xE0,
  0x03, 0xCE, 0x00, 0x1E, 0xF0, 0x00, 0x77, 0x80, 0x03, 0xBC, 0x00, 0x1F,
  0xC0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x07,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x07,
  0xE0, 0x01, 0xC1, 0xC0, 0x01, 0xFF, 0x80, 0x0E, 0x3C, 0x00, 0x3F, 0xFC,
  0x00, 0xE3, 0x80, 0x07, 0xC3, 0xE0, 0x0E, 0x38, 0x00, 0xF0, 0x0E, 0x00,
  0x63, 0x80, 0x1E, 0x00, 0xE0, 0x06, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x77,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x77, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0xE0, 0x0E, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xE0,
  0x0E, 0x00, 0x1C, 0x00, 0x6E, 0x00, 0xE0, 0x01, 0xC0, 0x06, 0xE0, 0x0E,
  0x00, 0x3C, 0x00, 0xEE, 0x00, 0xE0, 0x03, 0xC0, 0x0E, 0xE0, 0x0E, 0x00,
  0x3C, 0x00, 0xCE, 0x00, 0xE0, 0x07, 0xC0, 0x1C, 0xE0, 0x0F, 0x00, 0x7C,
  0x01, 0xC7, 0x00, 0x70, 0x0D, 0xC0, 0x38, 0x70, 0x07, 0x81, 0xDE, 0x07,
  0x87, 0x00, 0x3F, 0xF8, 0xF0, 0xF0, 0x70, 0x03, 0xFF, 0x0F, 0xFE, 0x03,
  0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x38, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0xE0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x00, 0x3C,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0x80, 0x3F,
  0xE0, 0xE0, 0x00, 0x7C, 0x38, 0x00, 0x0F, 0x8E, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x07, 0x8E, 0x00,
  0x03, 0xC3, 0x80, 0x01, 0xF0, 0xE0, 0x07, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0xFC, 0x38, 0x00, 0x0F,
  0x8E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0xB8, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0xE0, 0x00,
  0x0F, 0x38, 0x00, 0x07, 0xCE, 0x00, 0x07, 0xE3, 0x80, 0x1F, 0xF0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x70,
  0x0F, 0xFC, 0x0E, 0x00, 0x0F, 0xC1, 0xC0, 0x00, 0x7C, 0x38, 0x00, 0x07,
  0xC7, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x0F, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x1F, 0x1C, 0x00, 0x07, 0xC3, 0x80,
  0x03, 0xF0, 0x70, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0xFC, 0x01, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x79, 0xF0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x3E, 0x1F, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x7C,
  0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0xF8, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xF1, 0xC0, 0x00,
  0x1F, 0x0E, 0x00, 0x01, 0xF0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0,
  0x1C, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0xF8, 0x07, 0x00, 0x0F, 0x80, 0x38,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0xC0, 0x0E, 0x00, 0x7C, 0x00, 0x70, 0x07,
  0xC0, 0x03, 0x80, 0x3C, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0xE0, 0x3E, 0x00,
  0x07, 0x03, 0xE0, 0x00, 0x38, 0x3E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x71, 0xF8, 0x00, 0x03, 0x9F, 0xC0, 0x00, 0x1D, 0xFF,
  0x00, 0x00, 0xEF, 0x7C, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0x3F, 0x07, 0x80,
  0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x03,
  0x80, 0x1F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x00,
  0x0F, 0x80, 0x38, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x07,
  0xC0, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xE0,
  0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xF1, 0xC0,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0xFB, 0x80, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xEE, 0x00, 0x00, 0x03,
  0xFF, 0xBC, 0x00, 0x00, 0x0E, 0xFE, 0xF0, 0x00, 0x00, 0x7B, 0xF9, 0xC0,
  0x00, 0x01, 0xEF, 0xE7, 0x80, 0x00, 0x07, 0x3F, 0x9E, 0x00, 0x00, 0x3C,
  0xFE, 0x38, 0x00, 0x00, 0xF3, 0xF8, 0xF0, 0x00, 0x03, 0x8F, 0xE1, 0xC0,
  0x00, 0x1E, 0x3F, 0x87, 0x00, 0x00, 0x70, 0xFE, 0x1E, 0x00, 0x01, 0xC3,
  0xF8, 0x38, 0x00, 0x0F, 0x0F, 0xE0, 0xE0, 0x00, 0x38, 0x3F, 0x83, 0xC0,
  0x01, 0xE0, 0xFE, 0x07, 0x00, 0x07, 0x83, 0xF8, 0x1E, 0x00, 0x1C, 0x0F,
  0xE0, 0x78, 0x00, 0xF0, 0x3F, 0x80, 0xE0, 0x03, 0xC0, 0xFE, 0x03, 0xC0,
  0x0E, 0x03, 0xF8, 0x0F, 0x00, 0x78, 0x0F, 0xE0, 0x1C, 0x01, 0xE0, 0x3F,
  0x80, 0x78, 0x07, 0x00, 0xFE, 0x01, 0xE0, 0x3C, 0x03, 0xF8, 0x03, 0x80,
  0xF0, 0x0F, 0xE0, 0x0F, 0x03, 0x80, 0x3F, 0x80, 0x3C, 0x1E, 0x00, 0xFE,
  0x00, 0x70, 0x70, 0x03, 0xF8, 0x01, 0xE1, 0xC0, 0x0F, 0xE0, 0x03, 0x8F,
  0x00, 0x3F, 0x80, 0x0E, 0x38, 0x00, 0xFE, 0x00, 0x3C, 0xE0, 0x03, 0xF8,
  0x00, 0x77, 0x80, 0x0F, 0xE0, 0x01, 0xDC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFD, 0xC0, 0x00, 0x0F, 0xEF, 0x00, 0x00, 0x7F, 0x3C,
  0x00, 0x03, 0xF9, 0xE0, 0x00, 0x1F, 0xC7, 0x80, 0x00, 0xFE, 0x3C, 0x00,
  0x07, 0xF0, 0xF0, 0x00, 0x3F, 0x87, 0x80, 0x01, 0xFC, 0x1E, 0x00, 0x0F,
  0xE0, 0x70, 0x00, 0x7F, 0x03, 0xC0, 0x03, 0xF8, 0x0F, 0x00, 0x1F, 0xC0,
  0x78, 0x00, 0xFE, 0x01, 0xE0, 0x07, 0xF0, 0x0F, 0x00, 0x3F, 0x80, 0x3C,
  0x01, 0xFC, 0x01, 0xE0, 0x0F, 0xE0, 0x07, 0x80, 0x7F, 0x00, 0x1C, 0x03,
  0xF8, 0x00, 0xF0, 0x1F, 0xC0, 0x03, 0x80, 0xFE, 0x00, 0x1E, 0x07, 0xF0,
  0x00, 0x78, 0x3F, 0x80, 0x03, 0xC1, 0xFC, 0x00, 0x0F, 0x0F, 0xE0, 0x00,
  0x78, 0x7F, 0x00, 0x01, 0xE3, 0xF8, 0x00, 0x0F, 0x1F, 0xC0, 0x00, 0x3C,
  0xFE, 0x00, 0x00, 0xE7, 0xF0, 0x00, 0x07, 0xBF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x07, 0x9C,
  0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x0E,
  0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x70, 0x01, 0xFF, 0x0E, 0x00, 0x03, 0xF1, 0xC0, 0x00, 0x3E, 0x38,
  0x00, 0x03, 0xE7, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xE7, 0x00, 0x01, 0xF8,
  0xE0, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1D,
  0xE0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x1D, 0xE0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0E, 0x00, 0x7F, 0xC0, 0xE0, 0x00, 0x7E,
  0x0E, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xF0,
  0xE0, 0x00, 0x3E, 0x0E, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xE0,
  0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x78, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x07, 0xCE, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x00,
  0x78, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x1E, 0x78, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x81,
  0xF8, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x01, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1C,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3D, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0x8E, 0x00, 0x03, 0xF8, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x70, 0x00, 0x1C,
  0x3C, 0x00, 0x0E, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1D, 0xE0, 0x00, 0xF0,
  0x70, 0x00, 0x79, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0x81,
  0xE0, 0x01, 0xC7, 0x00, 0x07, 0x03, 0xC0, 0x03, 0x8F, 0x00, 0x1E, 0x07,
  0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x0E,
  0x00, 0x38, 0x38, 0x00, 0xE0, 0x1E, 0x00, 0x70, 0x78, 0x01, 0xC0, 0x3C,
  0x00, 0xE0, 0x70, 0x07, 0x80, 0x78, 0x03, 0xC0, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x01, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x03, 0xC0, 0x78, 0x07, 0x01, 0xE0, 0x03, 0x80,
  0xE0, 0x0E, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x0F, 0x03,
  0x80, 0x3C, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x1C,
  0x00, 0x70, 0x78, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x70,
  0x01, 0xE1, 0xC0, 0x00, 0xF1, 0xE0, 0x01, 0xC3, 0x80, 0x01, 0xE3, 0x80,
  0x03, 0x87, 0x00, 0x03, 0xC7, 0x00, 0x07, 0x1E, 0x00, 0x03, 0x8E, 0x00,
  0x0F, 0x3C, 0x00, 0x07, 0x3C, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x1C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x3D, 0xC0, 0x00,
  0x77, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x7B, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x1F,
  0x0F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0,
  0x3E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07,
  0xBE, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x01,
  0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x03,
  0xC0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x1E, 0x38,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7B, 0x80, 0x1C, 0xE0,
  0x07, 0x38, 0x03, 0xC7, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x1E, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xE7, 0x80,
  0x39, 0xC0, 0x0E, 0x70, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x07, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xC0, 0x0E, 0x3F, 0x00, 0x0E, 0x3C,
  0x00, 0x0E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x70,
  0x00, 0x3E, 0x78, 0x00, 0x7E, 0x7C, 0x00, 0xEE, 0x3E, 0x03, 0xEE, 0x3F,
  0xFF, 0xCF, 0x1F, 0xFF, 0x8F, 0x07, 0xFE, 0x0F, 0x01, 0xF8, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x3E, 0x00, 0xE1, 0xFF, 0xC0, 0xE3,
  0xFF, 0xE0, 0xE7, 0xFF, 0xF0, 0xEF, 0x01, 0xF8, 0xEC, 0x00, 0x7C, 0xF8,
  0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xE0,
  0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF8,
  0x00, 0x3C, 0xFC, 0x00, 0x78, 0xEF, 0x01, 0xF8, 0xE7, 0xFF, 0xF0, 0xE3,
  0xFF, 0xE0, 0xE1, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0x80, 0x7C, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x38,
  0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x1F, 0x80, 0x7C, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x3E, 0x03, 0x81, 0xFF, 0x87, 0x0F, 0xFF, 0x8E,
  0x3F, 0xFF, 0x9C, 0xFC, 0x07, 0xB9, 0xE0, 0x03, 0xF7, 0x80, 0x03, 0xEF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1D,
  0xC0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xE7, 0x80, 0x0F, 0xCF,
  0xC0, 0x7B, 0x8F, 0xFF, 0xE7, 0x0F, 0xFF, 0x8E, 0x07, 0xFE, 0x1C, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x0F, 0x80, 0xFC, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x04, 0x1F,
  0x00, 0x0E, 0x1F, 0x80, 0x3E, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0,
  0x3F, 0xF0, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x1C,
  0x3F, 0xFE, 0x38, 0xFF, 0xFE, 0x73, 0xF0, 0x1E, 0xE7, 0x80, 0x0F, 0xDE,
  0x00, 0x0F, 0xBC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x77, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0x9E,
  0x00, 0x3F, 0x3F, 0x00, 0xEE, 0x3F, 0xFF, 0x9C, 0x3F, 0xFE, 0x38, 0x1F,
  0xF8, 0x70, 0x0F, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x40, 0x00, 0xF1, 0xC0, 0x01,
  0xE3, 0xE0, 0x0F, 0x83, 0xF8, 0xFF, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x03, 0xE0, 0x38, 0x3F, 0xF0, 0xE3,
  0xFF, 0xE3, 0x9F, 0xFF, 0xCE, 0x70, 0x1F, 0x3B, 0x80, 0x1E, 0xFC, 0x00,
  0x7B, 0xE0, 0x00, 0xEF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0xFF, 0xFF, 0x70,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x3C,
  0x0F, 0x80, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0xF0, 0x3E, 0xDF, 0x9F, 0xF3, 0xFC, 0x7E, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0xF1, 0xC0, 0x03, 0xE3,
  0x80, 0x0F, 0x87, 0x00, 0x3E, 0x0E, 0x00, 0x78, 0x1C, 0x01, 0xE0, 0x38,
  0x07, 0x80, 0x70, 0x1F, 0x00, 0xE0, 0x7C, 0x01, 0xC1, 0xF0, 0x03, 0x83,
  0xC0, 0x07, 0x0F, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0xF8, 0x00, 0x3B, 0xF0,
  0x00, 0x77, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF9, 0xE0, 0x03, 0xE3, 0xE0,
  0x07, 0x83, 0xC0, 0x0E, 0x03, 0xC0, 0x1C, 0x07, 0xC0, 0x38, 0x07, 0x80,
  0x70, 0x07, 0x80, 0xE0, 0x0F, 0x81, 0xC0, 0x0F, 0x03, 0x80, 0x0F, 0x07,
  0x00, 0x1F, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x70,
  0x00, 0x3C, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x70, 0x7F, 0xC0, 0x1F, 0xF8, 0x38, 0xFF, 0xF8, 0x1F, 0xFF,
  0x1C, 0xFF, 0xFE, 0x3F, 0xFF, 0x8E, 0xF0, 0x1F, 0x1E, 0x03, 0xE7, 0x60,
  0x07, 0xDC, 0x00, 0xFB, 0xF0, 0x01, 0xFC, 0x00, 0x3D, 0xF0, 0x00, 0x7E,
  0x00, 0x1E, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x03, 0x83, 0xFF, 0x0E, 0x3F, 0xFE, 0x39, 0xFF,
  0xFC, 0xE7, 0x01, 0xF3, 0xB8, 0x01, 0xEF, 0xC0, 0x07, 0xBE, 0x00, 0x0E,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x0F,
  0x81, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x9E, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x39, 0xE0, 0x00, 0x1E,
  0x3C, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x7C, 0x00,
  0x78, 0x0F, 0x80, 0x7C, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xE1, 0xFF, 0xC0,
  0xE3, 0xFF, 0xE0, 0xE7, 0xFF, 0xF0, 0xEF, 0x01, 0xF8, 0xFC, 0x00, 0x78,
  0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C,
  0xF8, 0x00, 0x3C, 0xFC, 0x00, 0x78, 0xEE, 0x01, 0xF8, 0xE7, 0xFF, 0xF0,
  0xE3, 0xFF, 0xE0, 0xE1, 0xFF, 0xC0, 0xE0, 0x3E, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xFE, 0x1C, 0x3F, 0xFE, 0x38, 0xFF, 0xFE, 0x73, 0xF0, 0x0E, 0xE7,
  0x80, 0x0F, 0xDF, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEF, 0x00, 0x03, 0xDE,
  0x00, 0x0F, 0x9E, 0x00, 0x3F, 0x3F, 0x00, 0xEE, 0x3F, 0xFF, 0xDC, 0x3F,
  0xFF, 0x38, 0x1F, 0xF8, 0x70, 0x0F, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x7B, 0x87, 0xFE, 0x3F, 0xF9,
  0xFE, 0xEF, 0x83, 0xB8, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xF0, 0x0F, 0x87,
  0x80, 0x0F, 0x8F, 0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0xF0,
  0x00, 0x3D, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xDE,
  0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3F, 0x00, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x3C, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7D, 0xE0, 0x03,
  0xF7, 0x80, 0x1F, 0xCF, 0x80, 0xFF, 0x3F, 0xFF, 0x9C, 0x7F, 0xFC, 0x70,
  0xFF, 0xE1, 0xC0, 0x7C, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x38,
  0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x1E, 0x00, 0x78, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x07, 0x81, 0xE0, 0x07,
  0x81, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0xC3, 0xC0, 0x01,
  0xC3, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0xE0, 0x00, 0x70, 0x00, 0x39,
  0xC0, 0x01, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xE0, 0x01, 0xE7, 0x80, 0x07,
  0xC0, 0x03, 0xC7, 0x00, 0x1F, 0x80, 0x07, 0x0E, 0x00, 0x3F, 0x80, 0x1E,
  0x1E, 0x00, 0x77, 0x00, 0x3C, 0x3C, 0x00, 0xEE, 0x00, 0x78, 0x38, 0x03,
  0xDC, 0x00, 0xE0, 0x70, 0x07, 0x3C, 0x01, 0xC0, 0xF0, 0x0E, 0x38, 0x07,
  0x81, 0xE0, 0x1C, 0x70, 0x0F, 0x01, 0xC0, 0x78, 0xF0, 0x1C, 0x03, 0x80,
  0xE1, 0xE0, 0x38, 0x07, 0x81, 0xC1, 0xC0, 0xF0, 0x0F, 0x03, 0x83, 0x81,
  0xE0, 0x0E, 0x0E, 0x07, 0x83, 0x80, 0x1C, 0x1C, 0x07, 0x07, 0x00, 0x38,
  0x38, 0x0E, 0x0E, 0x00, 0x78, 0xF0, 0x1C, 0x3C, 0x00, 0xF1, 0xC0, 0x3C,
  0x70, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x03,
  0xDE, 0x00, 0xE7, 0x80, 0x07, 0xB8, 0x01, 0xEE, 0x00, 0x07, 0x70, 0x01,
  0xDC, 0x00, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0x1F, 0xC0, 0x07, 0x70, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x3C,
  0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x03,
  0xC3, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xE7, 0x80, 0x01,
  0xE7, 0x80, 0x01, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0x81, 0xE0, 0x07,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x3E,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xC7,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x07, 0x00, 0x0E, 0x03, 0xC0, 0x0F,
  0x01, 0xE0, 0x07, 0x80, 0x70, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xE0, 0x78, 0x00, 0xF0,
  0x38, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x03,
  0x87, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x39, 0xC0, 0x00,
  0x1E, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0x00, 0x03, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x78, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1C, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x40, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x73, 0xFF, 0x80, 0x03, 0xDF, 0xFF, 0x80,
  0x0E, 0x78, 0x3F, 0x00, 0x3B, 0xC0, 0x3C, 0x00, 0xEE, 0x00, 0x78, 0x07,
  0xB8, 0x00, 0xF8, 0x3C, 0xE0, 0x01, 0xFF, 0xF3, 0x80, 0x03, 0xFF, 0x8E,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_Light66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 48, 14, 5, -47 },
  { 31, 10, 15, 19, 5, -50 },
  { 50, 30, 47, 34, 3, -47 },
  { 227, 24, 62, 32, 4, -55 },
  { 413, 35, 49, 42, 4, -48 },
  { 628, 30, 49, 35, 4, -48 },
  { 812, 3, 14, 11, 4, -50 },
  { 818, 14, 68, 19, 4, -53 },
  { 937, 13, 68, 20, 2, -53 },
  { 1048, 26, 26, 28, 1, -47 },
  { 1133, 27, 35, 33, 3, -39 },
  { 1252, 7, 15, 13, 2, -6 },
  { 1266, 13, 3, 17, 2, -22 },
  { 1271, 5, 6, 16, 5, -5 },
  { 1275, 20, 51, 23, 1, -47 },
  { 1403, 24, 49, 32, 4, -48 },
  { 1550, 15, 47, 32, 5, -47 },
  { 1639, 26, 48, 32, 3, -48 },
  { 1795, 25, 49, 32, 3, -48 },
  { 1949, 28, 47, 32, 2, -47 },
  { 2114, 24, 48, 32, 5, -47 },
  { 2258, 25, 48, 32, 4, -47 },
  { 2408, 26, 47, 32, 3, -47 },
  { 2561, 25, 49, 32, 4, -48 },
  { 2715, 25, 48, 32, 3, -48 },
  { 2865, 6, 36, 13, 4, -35 },
  { 2892, 7, 44, 12, 2, -35 },
  { 2931, 22, 28, 30, 3, -35 },
  { 3008, 22, 18, 32, 5, -31 },
  { 3058, 23, 28, 30, 4, -35 },
  { 3139, 21, 49, 27, 3, -48 },
  { 3268, 44, 61, 52, 4, -46 },
  { 3604, 34, 47, 36, 1, -47 },
  { 3804, 26, 47, 35, 6, -47 },
  { 3957, 30, 49, 37, 4, -48 },
  { 4141, 27, 47, 38, 6, -47 },
  { 4300, 24, 47, 33, 6, -47 },
  { 4441, 24, 47, 32, 6, -47 },
  { 4582, 29, 49, 39, 5, -48 },
  { 4760, 29, 47, 41, 6, -47 },
  { 4931, 4, 47, 16, 6, -47 },
  { 4955, 24, 48, 32, 2, -47 },
  { 5099, 29, 47, 36, 6, -47 },
  { 5270, 23, 47, 31, 6, -47 },
  { 5406, 38, 47, 49, 6, -47 },
  { 5630, 29, 47, 41, 6, -47 },
  { 5801, 31, 49, 39, 4, -48 },
  { 5991, 27, 47, 36, 6, -47 },
  { 6150, 31, 56, 39, 4, -48 },
  { 6367, 28, 47, 36, 6, -47 },
  { 6532, 28, 49, 34, 3, -48 },
  { 6704, 30, 47, 34, 2, -47 },
  { 6881, 28, 48, 38, 5, -47 },
  { 7049, 32, 47, 36, 2, -47 },
  { 7237, 47, 47, 51, 2, -47 },
  { 7514, 31, 47, 35, 2, -47 },
  { 7697, 32, 47, 35, 1, -47 },
  { 7885, 28, 47, 34, 3, -47 },
  { 8050, 9, 64, 15, 5, -54 },
  { 8122, 20, 51, 23, 2, -47 },
  { 8250, 9, 64, 15, 1, -54 },
  { 8322, 18, 23, 24, 3, -47 },
  { 8374, 24, 3, 25, 1, 0 },
  { 8383, 11, 9, 19, 3, -49 },
  { 8396, 24, 37, 31, 3, -36 },
  { 8507, 24, 51, 32, 5, -50 },
  { 8660, 24, 37, 30, 3, -36 },
  { 8771, 23, 51, 32, 4, -50 },
  { 8918, 24, 37, 30, 3, -36 },
  { 9029, 17, 51, 20, 2, -51 },
  { 9138, 23, 49, 32, 4, -36 },
  { 9279, 22, 50, 32, 5, -50 },
  { 9417, 4, 47, 14, 5, -47 },
  { 9441, 11, 60, 14, -2, -47 },
  { 9524, 23, 50, 29, 5, -50 },
  { 9668, 4, 50, 14, 5, -50 },
  { 9693, 41, 36, 50, 5, -36 },
  { 9878, 22, 36, 32, 5, -36 },
  { 9977, 26, 37, 32, 3, -36 },
  { 10098, 24, 49, 32, 5, -36 },
  { 10245, 23, 49, 32, 4, -36 },
  { 10386, 14, 36, 20, 5, -36 },
  { 10449, 23, 37, 29, 3, -36 },
  { 10556, 16, 45, 19, 1, -44 },
  { 10646, 22, 36, 32, 5, -35 },
  { 10745, 24, 35, 28, 2, -35 },
  { 10850, 39, 35, 43, 2, -35 },
  { 11021, 24, 35, 28, 2, -35 },
  { 11126, 25, 48, 28, 1, -35 },
  { 11276, 23, 35, 28, 3, -35 },
  { 11377, 17, 64, 20, 2, -51 },
  { 11513, 3, 56, 15, 6, -47 },
  { 11534, 16, 64, 20, 1, -51 },
  { 11662, 30, 12, 39, 5, -26 },
};

const GFXfont RobotoCondensed_Light66pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light66pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light66pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _ROBOTOCONDENSED_LIGHT66PT7B_H_
