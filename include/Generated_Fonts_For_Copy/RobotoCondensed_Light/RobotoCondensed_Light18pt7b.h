#ifndef _ROBOTOCONDENSED_LIGHT18PT7B_H_
#define _ROBOTOCONDENSED_LIGHT18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light18pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xA0, 0xC0, 0xB6, 0xD0, 0x12, 0x12, 0x12, 0x12, 0xFF,
  0x24, 0x24, 0x24, 0xFF, 0x24, 0x48, 0x48, 0x48, 0x10, 0x20, 0xE2, 0x28,
  0x70, 0x50, 0x30, 0x38, 0x18, 0x0C, 0x18, 0x28, 0x8E, 0x08, 0x10, 0x60,
  0x24, 0x09, 0x22, 0x48, 0x94, 0x19, 0x00, 0x80, 0x2E, 0x14, 0x85, 0x12,
  0x44, 0x92, 0x03, 0x80, 0x38, 0x44, 0x44, 0x44, 0x48, 0x30, 0x30, 0x51,
  0x89, 0x86, 0x86, 0xC6, 0x79, 0xF0, 0x12, 0x24, 0x44, 0x88, 0x88, 0x88,
  0x44, 0x42, 0x21, 0x84, 0x22, 0x21, 0x11, 0x11, 0x11, 0x12, 0x22, 0x48,
  0x10, 0x23, 0x49, 0xE1, 0x84, 0x91, 0x00, 0x10, 0x20, 0x40, 0x8F, 0xE2,
  0x04, 0x08, 0x10, 0xF0, 0xE0, 0xC0, 0x04, 0x20, 0x82, 0x10, 0x41, 0x08,
  0x20, 0x84, 0x10, 0x42, 0x00, 0x38, 0x8A, 0x14, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x12, 0x23, 0x80, 0x17, 0x91, 0x11, 0x11, 0x11, 0x11, 0x10,
  0x38, 0x8A, 0x14, 0x20, 0x40, 0x82, 0x04, 0x10, 0x41, 0x82, 0x0F, 0xE0,
  0x38, 0x8A, 0x14, 0x20, 0x40, 0x8E, 0x02, 0x03, 0x06, 0x0A, 0x23, 0x80,
  0x0C, 0x18, 0x50, 0xA2, 0x44, 0x91, 0x22, 0x85, 0xFC, 0x10, 0x20, 0x40,
  0x7E, 0x81, 0x02, 0x04, 0x0F, 0x11, 0x01, 0x03, 0x05, 0x0A, 0x23, 0x80,
  0x18, 0x41, 0x02, 0x0B, 0x98, 0xA0, 0xC1, 0x83, 0x07, 0x0A, 0x23, 0x80,
  0xFE, 0x04, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x20, 0x81, 0x04, 0x00,
  0x38, 0x8A, 0x14, 0x18, 0x48, 0x8E, 0x22, 0x83, 0x06, 0x0E, 0x27, 0x80,
  0x38, 0x8A, 0x14, 0x28, 0x30, 0x61, 0xA3, 0x7C, 0x08, 0x10, 0x47, 0x00,
  0xC0, 0x00, 0xC0, 0xC0, 0x02, 0xA8, 0x04, 0x63, 0x30, 0xC0, 0x81, 0x81,
  0xFC, 0x00, 0x3F, 0x81, 0x81, 0x83, 0x0C, 0x66, 0x20, 0x74, 0x62, 0x10,
  0x84, 0x44, 0x20, 0x00, 0x02, 0x00, 0x0F, 0x81, 0x04, 0x20, 0x24, 0x01,
  0x47, 0x18, 0x89, 0x88, 0x99, 0x11, 0x91, 0x19, 0x11, 0x91, 0x18, 0x92,
  0x8E, 0xE4, 0x00, 0x40, 0x02, 0x00, 0x1F, 0x00, 0x0C, 0x06, 0x03, 0x02,
  0x41, 0x20, 0x90, 0x88, 0x42, 0x3F, 0x20, 0x90, 0x28, 0x14, 0x08, 0xF9,
  0x0A, 0x14, 0x28, 0x50, 0xBE, 0x42, 0x87, 0x06, 0x1C, 0x2F, 0x80, 0x3C,
  0x62, 0x41, 0x81, 0x80, 0x80, 0x80, 0x80, 0x80, 0x81, 0x41, 0x62, 0x3C,
  0xF9, 0x0A, 0x1C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x1C, 0x2F, 0x80,
  0xFE, 0x08, 0x20, 0x82, 0x0F, 0xA0, 0x82, 0x08, 0x20, 0xFC, 0xFE, 0x08,
  0x20, 0x82, 0x0F, 0xA0, 0x82, 0x08, 0x20, 0x80, 0x3E, 0x63, 0x41, 0x81,
  0x80, 0x80, 0x80, 0x8F, 0x81, 0x81, 0x41, 0x61, 0x3E, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0xF8,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x06, 0x18, 0x63, 0x78, 0x82, 0x84,
  0x88, 0x90, 0xB0, 0xA0, 0xE0, 0x90, 0x98, 0x88, 0x84, 0x86, 0x82, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0x80, 0xE0, 0x3C,
  0x0F, 0x05, 0xC1, 0x68, 0x5A, 0x26, 0x89, 0x92, 0x65, 0x19, 0x46, 0x31,
  0x88, 0x40, 0x81, 0x81, 0xC1, 0xC1, 0xA1, 0xB1, 0x91, 0x89, 0x89, 0x85,
  0x85, 0x83, 0x83, 0x3C, 0x62, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x41, 0x62, 0x3C, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x61, 0x7C, 0x81,
  0x02, 0x04, 0x08, 0x00, 0x3C, 0x42, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x41, 0x62, 0x3E, 0x03, 0x01, 0xFC, 0xC2, 0xC2, 0xC1, 0xC1,
  0xC2, 0xC2, 0xFC, 0xC4, 0xC4, 0xC2, 0xC2, 0xC1, 0x3C, 0x46, 0x82, 0x82,
  0xC0, 0x60, 0x18, 0x06, 0x02, 0x81, 0x82, 0x42, 0x3C, 0xFF, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42, 0x3C, 0x40,
  0xA0, 0x50, 0x2C, 0x22, 0x11, 0x08, 0x88, 0x24, 0x12, 0x0A, 0x03, 0x01,
  0x80, 0x80, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x49, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x50, 0xA3, 0x0C, 0x30, 0xC3, 0x0C, 0x20, 0x40, 0x83, 0x42,
  0x46, 0x24, 0x28, 0x18, 0x10, 0x18, 0x2C, 0x24, 0x42, 0xC2, 0x81, 0x40,
  0xA0, 0x88, 0x44, 0x43, 0x20, 0xA0, 0x50, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0xFE, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x30, 0x20, 0x40,
  0x40, 0x80, 0xFF, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0x9C, 0x84, 0x20,
  0x84, 0x20, 0x84, 0x20, 0x84, 0x21, 0x04, 0xE4, 0x92, 0x49, 0x24, 0x92,
  0x49, 0x3C, 0x23, 0x14, 0xA9, 0x44, 0xFE, 0xC8, 0x7B, 0x18, 0x41, 0x7F,
  0x18, 0x61, 0x8D, 0xD0, 0x81, 0x02, 0x04, 0x0B, 0x98, 0xA0, 0xC1, 0x83,
  0x06, 0x0C, 0x1C, 0x57, 0x00, 0x7B, 0x18, 0x60, 0x82, 0x08, 0x21, 0x45,
  0xE0, 0x04, 0x10, 0x41, 0x7D, 0x18, 0x61, 0x86, 0x18, 0x61, 0x45, 0xF0,
  0x39, 0x18, 0x61, 0xFE, 0x08, 0x20, 0x44, 0xE0, 0x34, 0x44, 0xF4, 0x44,
  0x44, 0x44, 0x44, 0x7D, 0x18, 0x61, 0x86, 0x18, 0x61, 0x45, 0xF0, 0x41,
  0x45, 0xE0, 0x82, 0x08, 0x20, 0xBB, 0x1C, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x10, 0xC2, 0xAA, 0xAA, 0x80, 0x20, 0x02, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x22, 0xE0, 0x81, 0x02, 0x04, 0x08, 0x51, 0x24, 0x50, 0xA1, 0xA2, 0x44,
  0x48, 0xD0, 0x80, 0xFF, 0xFC, 0xB9, 0xD8, 0xC6, 0x18, 0xC2, 0x18, 0x43,
  0x08, 0x61, 0x0C, 0x21, 0x84, 0x30, 0x84, 0xBB, 0x1C, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x10, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x44, 0x70,
  0xB9, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC5, 0x72, 0x04, 0x08, 0x10,
  0x00, 0x7D, 0x18, 0x61, 0x86, 0x18, 0x61, 0x45, 0xF0, 0x41, 0x04, 0x10,
  0xBC, 0x88, 0x88, 0x88, 0x88, 0x7B, 0x18, 0x70, 0x60, 0x60, 0x61, 0x85,
  0xE0, 0x21, 0x3C, 0x42, 0x10, 0x84, 0x21, 0x08, 0x70, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x45, 0xF0, 0x42, 0x85, 0x12, 0x22, 0x44, 0x8A, 0x0C,
  0x18, 0x20, 0x88, 0x63, 0x18, 0xC6, 0x52, 0x54, 0x94, 0xA5, 0x29, 0x8C,
  0x21, 0x08, 0x40, 0x87, 0x24, 0x8C, 0x30, 0xC5, 0x12, 0x8A, 0x10, 0x42,
  0x85, 0x12, 0x22, 0x44, 0x8A, 0x0C, 0x18, 0x20, 0x40, 0x82, 0x0C, 0x00,
  0xFC, 0x20, 0x84, 0x10, 0x84, 0x10, 0x83, 0xF0, 0x12, 0x24, 0x44, 0x44,
  0x84, 0x44, 0x44, 0x42, 0x21, 0xFF, 0xFE, 0xC2, 0x08, 0x42, 0x10, 0x84,
  0x19, 0x88, 0x42, 0x10, 0x84, 0x44, 0x00, 0x71, 0x89, 0x87,
};

const GFXglyph RobotoCondensed_Light18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 13, 4, 1, -13 },
  { 5, 3, 4, 5, 1, -14 },
  { 7, 8, 13, 9, 1, -13 },
  { 20, 7, 17, 9, 1, -15 },
  { 35, 10, 13, 12, 1, -13 },
  { 52, 8, 13, 10, 1, -13 },
  { 65, 1, 4, 3, 1, -14 },
  { 66, 4, 18, 5, 1, -14 },
  { 75, 4, 18, 5, 0, -14 },
  { 84, 7, 7, 8, 0, -13 },
  { 91, 7, 9, 9, 1, -11 },
  { 99, 1, 4, 3, 1, -2 },
  { 100, 3, 1, 5, 1, -6 },
  { 101, 2, 1, 4, 1, -1 },
  { 102, 6, 14, 6, 0, -13 },
  { 113, 7, 13, 9, 1, -13 },
  { 125, 4, 13, 9, 1, -13 },
  { 132, 7, 13, 9, 1, -13 },
  { 144, 7, 13, 9, 1, -13 },
  { 156, 7, 13, 9, 1, -13 },
  { 168, 7, 13, 9, 1, -13 },
  { 180, 7, 13, 9, 1, -13 },
  { 192, 7, 13, 9, 1, -13 },
  { 204, 7, 13, 9, 1, -13 },
  { 216, 7, 13, 9, 1, -13 },
  { 228, 2, 9, 4, 1, -9 },
  { 231, 2, 11, 3, 1, -9 },
  { 234, 6, 8, 8, 1, -10 },
  { 240, 6, 4, 9, 1, -8 },
  { 243, 6, 8, 8, 1, -10 },
  { 249, 5, 13, 7, 1, -13 },
  { 258, 12, 17, 14, 1, -13 },
  { 284, 9, 13, 10, 0, -13 },
  { 299, 7, 13, 10, 2, -13 },
  { 311, 8, 13, 10, 1, -13 },
  { 324, 7, 13, 10, 2, -13 },
  { 336, 6, 13, 9, 2, -13 },
  { 346, 6, 13, 9, 2, -13 },
  { 356, 8, 13, 11, 1, -13 },
  { 369, 8, 13, 11, 2, -13 },
  { 382, 1, 13, 4, 2, -13 },
  { 384, 6, 13, 9, 1, -13 },
  { 394, 8, 13, 10, 2, -13 },
  { 407, 6, 13, 8, 2, -13 },
  { 417, 10, 13, 13, 2, -13 },
  { 434, 8, 13, 11, 2, -13 },
  { 447, 8, 13, 11, 1, -13 },
  { 460, 7, 13, 10, 2, -13 },
  { 472, 8, 15, 11, 1, -13 },
  { 487, 8, 13, 10, 1, -13 },
  { 500, 8, 13, 9, 1, -13 },
  { 513, 8, 13, 9, 1, -13 },
  { 526, 8, 13, 10, 1, -13 },
  { 539, 9, 13, 10, 0, -13 },
  { 554, 12, 13, 14, 1, -13 },
  { 574, 8, 13, 10, 1, -13 },
  { 587, 9, 13, 9, 0, -13 },
  { 602, 8, 13, 9, 1, -13 },
  { 615, 3, 18, 4, 1, -15 },
  { 622, 5, 14, 6, 1, -13 },
  { 631, 3, 18, 4, 0, -15 },
  { 638, 5, 6, 7, 1, -13 },
  { 642, 7, 1, 7, 0, 0 },
  { 643, 3, 2, 5, 1, -13 },
  { 644, 6, 10, 8, 1, -10 },
  { 652, 7, 14, 9, 1, -14 },
  { 665, 6, 10, 8, 1, -10 },
  { 673, 6, 14, 9, 1, -14 },
  { 684, 6, 10, 8, 1, -10 },
  { 692, 4, 14, 5, 1, -14 },
  { 699, 6, 14, 9, 1, -10 },
  { 710, 6, 14, 9, 1, -14 },
  { 721, 2, 13, 4, 1, -13 },
  { 725, 4, 17, 4, -1, -13 },
  { 734, 7, 14, 8, 1, -14 },
  { 747, 1, 14, 4, 1, -14 },
  { 749, 11, 10, 14, 1, -10 },
  { 763, 6, 10, 9, 1, -10 },
  { 771, 7, 10, 9, 1, -10 },
  { 780, 7, 14, 9, 1, -10 },
  { 793, 6, 14, 9, 1, -10 },
  { 804, 4, 10, 5, 1, -10 },
  { 809, 6, 10, 8, 1, -10 },
  { 817, 5, 12, 5, 0, -12 },
  { 825, 6, 10, 9, 1, -10 },
  { 833, 7, 10, 8, 0, -10 },
  { 842, 10, 10, 12, 1, -10 },
  { 855, 6, 10, 8, 1, -10 },
  { 863, 7, 14, 8, 0, -10 },
  { 876, 6, 10, 8, 1, -10 },
  { 884, 4, 18, 5, 1, -14 },
  { 893, 1, 15, 4, 2, -13 },
  { 895, 5, 18, 5, 0, -14 },
  { 907, 8, 3, 11, 1, -7 },
};

const GFXfont RobotoCondensed_Light18pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light18pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light18pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOCONDENSED_LIGHT18PT7B_H_
