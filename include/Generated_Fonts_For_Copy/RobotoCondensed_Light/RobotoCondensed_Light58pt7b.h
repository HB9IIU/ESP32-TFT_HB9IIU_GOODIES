#ifndef _ROBOTOCONDENSED_LIGHT58PT7B_H_
#define _ROBOTOCONDENSED_LIGHT58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light58pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x70, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x70, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1B, 0x86, 0xE1, 0xB8, 0x6E, 0x1B,
  0x06, 0xC1, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80,
  0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x07, 0x00, 0x07,
  0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x06, 0x00,
  0x06, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF0, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30,
  0x1C, 0x00, 0x0C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00,
  0x70, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x80, 0x01, 0x80, 0xE0,
  0x00, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x30, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07,
  0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x18, 0x00, 0x18, 0x06, 0x00,
  0x06, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0E,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xF0, 0x1F, 0x07,
  0x80, 0x3C, 0x3C, 0x00, 0x78, 0xE0, 0x01, 0xE3, 0x80, 0x03, 0x8E, 0x00,
  0x0E, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0xF3, 0x80, 0x01, 0xCE, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x3D, 0xE0, 0x00,
  0xE7, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x1F, 0x01, 0xF0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x38, 0x07, 0x00,
  0xE0, 0x70, 0x0E, 0x01, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0C,
  0x03, 0x80, 0x70, 0x38, 0x07, 0x00, 0xE0, 0x60, 0x0E, 0x01, 0xC1, 0xC0,
  0x1C, 0x03, 0x83, 0x00, 0x18, 0x06, 0x0E, 0x00, 0x38, 0x1C, 0x18, 0x00,
  0x38, 0x70, 0x70, 0x00, 0x7F, 0xE1, 0xC0, 0x00, 0x3F, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x40, 0x00, 0x06, 0x07, 0xF0, 0x00,
  0x1C, 0x1F, 0xF0, 0x00, 0x30, 0x70, 0xF0, 0x00, 0xE1, 0xC0, 0xE0, 0x01,
  0x83, 0x80, 0xE0, 0x07, 0x06, 0x01, 0xC0, 0x0C, 0x0C, 0x01, 0x80, 0x38,
  0x38, 0x03, 0x00, 0xE0, 0x70, 0x06, 0x01, 0xC0, 0xE0, 0x0C, 0x07, 0x01,
  0xC0, 0x18, 0x0E, 0x01, 0x80, 0x30, 0x38, 0x03, 0x00, 0xE0, 0x20, 0x07,
  0x01, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xF0,
  0x3C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x78, 0x00, 0xF0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x38, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0xF1, 0xE0, 0x1C, 0x3C, 0x1C, 0x03, 0x87, 0x03, 0xC0,
  0x71, 0xE0, 0x3C, 0x0E, 0x38, 0x03, 0xC1, 0xCF, 0x00, 0x38, 0x39, 0xE0,
  0x07, 0x8F, 0x38, 0x00, 0x79, 0xC7, 0x00, 0x07, 0x38, 0xE0, 0x00, 0xFF,
  0x1C, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0xF8, 0x38, 0x00, 0x1E, 0x07, 0x80,
  0x03, 0xE0, 0x78, 0x01, 0xFE, 0x0F, 0x80, 0x7D, 0xE0, 0xFF, 0xFF, 0x3C,
  0x0F, 0xFF, 0x83, 0xC0, 0x7F, 0xC0, 0x3C, 0x00, 0x80, 0x00, 0x00, 0x6D,
  0xB6, 0xDF, 0xFF, 0xFE, 0x00, 0x20, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x20, 0x40, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x06, 0x00,
  0x40, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x1C,
  0x06, 0xF8, 0x38, 0x3D, 0xFE, 0x73, 0xFC, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xF7, 0x00,
  0x01, 0xC7, 0x00, 0x07, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x78, 0x0F, 0x00,
  0xE0, 0x0E, 0x01, 0x80, 0x1C, 0x01, 0x00, 0x10, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0x8E, 0x79, 0xCF, 0x38,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x77, 0xFE, 0xF2, 0x00, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF8,
  0x03, 0xFB, 0xF0, 0x1F, 0x01, 0xE0, 0x78, 0x03, 0x83, 0xC0, 0x0F, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0x79, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00,
  0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x70, 0x00, 0x1D,
  0xC0, 0x00, 0xF7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xE0,
  0x00, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0x78, 0x03,
  0x81, 0xF0, 0x1E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x10, 0x0F, 0x03, 0xF0, 0xFF, 0x7F, 0xFF, 0xC7,
  0xF0, 0x7C, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xE0, 0x1E, 0x07, 0x80, 0x1E, 0x1E, 0x00,
  0x3C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x79, 0xE0, 0x00, 0x73, 0x80, 0x00,
  0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF8, 0x03, 0xF7, 0xF0, 0x1E, 0x01, 0xE0, 0xF0, 0x03, 0xC7, 0x80,
  0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x79, 0xC0, 0x00, 0xEF, 0x00, 0x03,
  0xBC, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xEF, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x78, 0x00, 0x78,
  0xF0, 0x03, 0xC3, 0xE0, 0x1E, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87,
  0x00, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xE0,
  0x70, 0x00, 0xE0, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x1C,
  0x00, 0x70, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x3F, 0x80, 0x3B, 0xFF,
  0x80, 0xFF, 0xFF, 0x03, 0xF0, 0x7E, 0x0F, 0x00, 0x78, 0x38, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7,
  0x80, 0x07, 0x8E, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0x78, 0x07, 0x80, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x83,
  0xF0, 0x1C, 0x7F, 0xE0, 0xE7, 0xFF, 0xC7, 0x78, 0x3E, 0x3F, 0x00, 0x79,
  0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x3B, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x7B, 0x80, 0x03, 0x9E, 0x00, 0x1C, 0x70, 0x01, 0xE3, 0xC0, 0x1E, 0x0F,
  0x01, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x01, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFB, 0xF8, 0x1E, 0x01,
  0xE0, 0xF0, 0x03, 0xC3, 0x80, 0x07, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x39,
  0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0,
  0x00, 0xE7, 0x80, 0x03, 0x8E, 0x00, 0x1E, 0x3C, 0x00, 0x70, 0x78, 0x03,
  0x80, 0xF0, 0x3E, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0xF0, 0x3E, 0x07, 0x00, 0x3C, 0x38, 0x00, 0x71, 0xE0, 0x00, 0xE7, 0x00,
  0x03, 0x9C, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x77, 0x00, 0x03, 0xDC,
  0x00, 0x0E, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xE0, 0x1F, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xF7, 0xF0, 0x1E, 0x03, 0xC0,
  0xF0, 0x07, 0x83, 0x80, 0x0F, 0x1E, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0,
  0x01, 0xEF, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xDC, 0x00, 0x0F, 0x70, 0x00, 0x7D, 0xE0, 0x01, 0xF3, 0x80,
  0x0F, 0x8F, 0x00, 0x7E, 0x1F, 0x07, 0xB8, 0x3F, 0xFC, 0xE0, 0x7F, 0xE3,
  0x80, 0x7E, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF7, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xEF,
  0xF8, 0x00, 0x3C, 0xF7, 0xCF, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x38, 0xE7, 0x3C, 0xE1, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x0F, 0x1E, 0x01, 0xEF, 0x00,
  0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0xC1, 0xC0, 0x01, 0xF0,
  0x01, 0xC3, 0x80, 0x0F, 0xF8, 0x01, 0x86, 0x00, 0x3F, 0xF8, 0x03, 0x1C,
  0x00, 0xF0, 0x78, 0x06, 0x38, 0x03, 0xC0, 0x70, 0x0E, 0x60, 0x07, 0x00,
  0xE0, 0x1D, 0xC0, 0x1C, 0x01, 0xC0, 0x1B, 0x80, 0x38, 0x03, 0x00, 0x37,
  0x00, 0xE0, 0x06, 0x00, 0x6E, 0x01, 0xC0, 0x0C, 0x00, 0xD8, 0x03, 0x80,
  0x18, 0x01, 0xB0, 0x06, 0x00, 0x70, 0x03, 0x60, 0x1C, 0x00, 0xE0, 0x07,
  0xC0, 0x38, 0x01, 0xC0, 0x0F, 0x80, 0x70, 0x03, 0x80, 0x1F, 0x00, 0xE0,
  0x07, 0x00, 0x3E, 0x01, 0xC0, 0x0E, 0x00, 0x7C, 0x03, 0x80, 0x1C, 0x01,
  0xF8, 0x07, 0x00, 0x38, 0x03, 0xB0, 0x0E, 0x00, 0x70, 0x06, 0x60, 0x1C,
  0x01, 0xC0, 0x0C, 0xC0, 0x38, 0x03, 0x80, 0x39, 0x80, 0x70, 0x0F, 0x80,
  0x63, 0x80, 0xF0, 0x1F, 0x01, 0xC7, 0x00, 0xE0, 0x6E, 0x07, 0x0E, 0x01,
  0xF7, 0xCE, 0x1E, 0x0C, 0x01, 0xFF, 0x0F, 0xF8, 0x1C, 0x01, 0xFC, 0x0F,
  0xE0, 0x38, 0x00, 0x40, 0x04, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x20, 0x00, 0x01, 0xF8, 0x01,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xE0, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x71,
  0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x38, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87,
  0x00, 0x1F, 0x8E, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0x70,
  0x00, 0x1C, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xF7, 0x00,
  0x01, 0xEE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00,
  0x38, 0xE0, 0x00, 0xF1, 0xC0, 0x07, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x1C, 0x00, 0x3E, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xEE, 0x00,
  0x07, 0x9C, 0x00, 0x3E, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x0F, 0x80, 0x3E, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x00, 0xF0,
  0xE0, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x1C, 0x3C, 0x00,
  0x0F, 0x07, 0x80, 0x07, 0x80, 0xF8, 0x03, 0xE0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xE0, 0x07, 0xE0, 0xE0, 0x00, 0xF0,
  0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0,
  0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF3, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0x80, 0x3E, 0x07, 0x80, 0x03,
  0xC3, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x07, 0x70, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xF0,
  0x00, 0x07, 0x1E, 0x00, 0x03, 0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x01, 0xF8,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x40,
  0x00, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3B, 0x80, 0x03, 0xDC, 0x00, 0x1C, 0xF0, 0x01, 0xE3, 0xC0,
  0x1E, 0x1F, 0x01, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x01, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x03,
  0xE3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x0E, 0x00,
  0x1E, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0x38, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x03, 0x80, 0x78, 0x00, 0xE0, 0x1E, 0x00, 0x38, 0x0F, 0x00,
  0x0E, 0x07, 0x80, 0x03, 0x83, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0x78,
  0x00, 0x0E, 0x3C, 0x00, 0x03, 0x9F, 0x80, 0x00, 0xEF, 0xF0, 0x00, 0x3F,
  0xBC, 0x00, 0x0F, 0xC7, 0x80, 0x03, 0xF0, 0xF0, 0x00, 0xF8, 0x3C, 0x00,
  0x3C, 0x07, 0x80, 0x0E, 0x00, 0xF0, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x80, 0xE0,
  0x00, 0xF0, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF0,
  0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x1E, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xDC, 0x00, 0x00, 0x3F, 0xEE, 0x00, 0x00,
  0x3B, 0xF7, 0x00, 0x00, 0x1D, 0xF9, 0xC0, 0x00, 0x0E, 0xFC, 0xE0, 0x00,
  0x0E, 0x7E, 0x70, 0x00, 0x07, 0x3F, 0x1C, 0x00, 0x07, 0x9F, 0x8E, 0x00,
  0x03, 0x8F, 0xC7, 0x80, 0x01, 0xC7, 0xE1, 0xC0, 0x01, 0xE3, 0xF0, 0xE0,
  0x00, 0xE1, 0xF8, 0x78, 0x00, 0x70, 0xFC, 0x1C, 0x00, 0x78, 0x7E, 0x0E,
  0x00, 0x38, 0x3F, 0x03, 0x80, 0x1C, 0x1F, 0x81, 0xC0, 0x1C, 0x0F, 0xC0,
  0xE0, 0x0E, 0x07, 0xE0, 0x38, 0x07, 0x03, 0xF0, 0x1C, 0x07, 0x01, 0xF8,
  0x0E, 0x03, 0x80, 0xFC, 0x03, 0x81, 0xC0, 0x7E, 0x01, 0xC1, 0xC0, 0x3F,
  0x00, 0xE0, 0xE0, 0x1F, 0x80, 0x38, 0x70, 0x0F, 0xC0, 0x1C, 0x70, 0x07,
  0xE0, 0x0E, 0x38, 0x03, 0xF0, 0x03, 0x9C, 0x01, 0xF8, 0x01, 0xDC, 0x00,
  0xFC, 0x00, 0xEE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x07, 0x80, 0x0F, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xB8, 0x00, 0x07, 0xE7, 0x00, 0x01, 0xF9, 0xC0, 0x00, 0x7E, 0x38,
  0x00, 0x1F, 0x8F, 0x00, 0x07, 0xE1, 0xC0, 0x01, 0xF8, 0x78, 0x00, 0x7E,
  0x0E, 0x00, 0x1F, 0x83, 0xC0, 0x07, 0xE0, 0x70, 0x01, 0xF8, 0x0E, 0x00,
  0x7E, 0x03, 0x80, 0x1F, 0x80, 0x70, 0x07, 0xE0, 0x1E, 0x01, 0xF8, 0x03,
  0x80, 0x7E, 0x00, 0xF0, 0x1F, 0x80, 0x1C, 0x07, 0xE0, 0x07, 0x81, 0xF8,
  0x00, 0xE0, 0x7E, 0x00, 0x1C, 0x1F, 0x80, 0x07, 0x07, 0xE0, 0x00, 0xE1,
  0xF8, 0x00, 0x3C, 0x7E, 0x00, 0x07, 0x1F, 0x80, 0x01, 0xE7, 0xE0, 0x00,
  0x39, 0xF8, 0x00, 0x0F, 0x7E, 0x00, 0x01, 0xDF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0x80, 0x3E, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x38, 0xE0, 0x00,
  0x1E, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x80, 0xF8, 0x07, 0xE0, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xE0, 0x01, 0xF8,
  0xE0, 0x00, 0x7C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x7C,
  0xE0, 0x01, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0x80, 0x07, 0x83, 0xC0,
  0x00, 0xF1, 0xE0, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x1C,
  0x3C, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x81, 0xF8, 0x07, 0xE0, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x87, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0xE0, 0x03, 0xF0, 0xE0, 0x00, 0xF8, 0xE0, 0x00,
  0x3C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF8, 0xE0, 0x01, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03,
  0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01,
  0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x78, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xF0,
  0x07, 0x81, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1C, 0x70,
  0x00, 0x0F, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xCE,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0x7C, 0x01, 0xF0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x38, 0x00,
  0x03, 0x9E, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xE3, 0xC0, 0x01, 0xE0, 0xF8,
  0x03, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00,
  0x04, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x1C, 0xF0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x38, 0x03, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0xE0, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0xDC, 0x00, 0x07, 0x80, 0x01, 0xCE,
  0x00, 0x07, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0xE0, 0x00, 0x73, 0x80, 0x01,
  0xF0, 0x00, 0x39, 0xE0, 0x00, 0xDC, 0x00, 0x3C, 0x70, 0x00, 0xEE, 0x00,
  0x1C, 0x38, 0x00, 0x77, 0x00, 0x0E, 0x1C, 0x00, 0x39, 0x80, 0x07, 0x0F,
  0x00, 0x18, 0xE0, 0x07, 0x87, 0x80, 0x1C, 0x70, 0x03, 0x81, 0xC0, 0x0E,
  0x38, 0x01, 0xC0, 0xE0, 0x07, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x06, 0x00,
  0x70, 0x3C, 0x03, 0x83, 0x80, 0x78, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x30, 0x0E, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x00, 0xF0, 0x38, 0x0E, 0x07, 0x80, 0x38, 0x1C, 0x07, 0x03,
  0x80, 0x1C, 0x0C, 0x01, 0x81, 0xC0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x07,
  0x07, 0x00, 0x70, 0x70, 0x03, 0xC3, 0x80, 0x38, 0x78, 0x00, 0xE1, 0x80,
  0x0C, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0x8E,
  0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x07, 0x30, 0x00, 0x67, 0x00, 0x03,
  0xB8, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00,
  0x0E, 0xE0, 0x00, 0x76, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x00, 0x01, 0xB0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x0E, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x03,
  0xC0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x70, 0x07,
  0x80, 0x0F, 0x01, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x0E, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x01, 0xE0, 0x03, 0xC0, 0x38, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1C,
  0x3C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0x70, 0x00, 0xF0, 0x07, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0xC0, 0x01,
  0xE0, 0x38, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1B, 0x80,
  0x1D, 0xC0, 0x0E, 0x60, 0x06, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0x83,
  0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x60, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x1C,
  0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1C,
  0x07, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xBF, 0x83,
  0xC0, 0x1E, 0x1C, 0x00, 0x71, 0xE0, 0x03, 0xCE, 0x00, 0x0E, 0x70, 0x00,
  0x73, 0x80, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xF0, 0x03,
  0x9F, 0x00, 0x1C, 0xF0, 0x00, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80,
  0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x07, 0xBC, 0x00, 0x7C,
  0xE0, 0x07, 0xE7, 0x80, 0x77, 0x1F, 0xFF, 0x38, 0xFF, 0xF1, 0xC1, 0xFF,
  0x0F, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x01, 0x00, 0x70, 0xFF, 0x83, 0x8F, 0xFE, 0x1C, 0xFF, 0xF8, 0xEE, 0x03,
  0xE7, 0xE0, 0x07, 0xBE, 0x00, 0x3D, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0x78, 0x00, 0x3B, 0xE0, 0x03, 0xDF, 0x00,
  0x1C, 0xEE, 0x03, 0xE7, 0x7F, 0xFE, 0x39, 0xFF, 0xE1, 0xC3, 0xFE, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F,
  0xBF, 0x83, 0xE0, 0x1E, 0x1C, 0x00, 0x79, 0xE0, 0x01, 0xCE, 0x00, 0x0E,
  0x70, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x70, 0x00, 0x7B, 0x80, 0x03, 0x9E,
  0x00, 0x1C, 0x70, 0x01, 0xC3, 0xE0, 0x1E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x81, 0xFE, 0x1C, 0x3F, 0xFC, 0xE3, 0xFF, 0xF7,
  0x3E, 0x01, 0xB9, 0xE0, 0x07, 0xDE, 0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x00,
  0x03, 0xB8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x3D, 0xE0, 0x01,
  0xE7, 0x80, 0x1F, 0x3E, 0x01, 0xF8, 0xFF, 0xFD, 0xC3, 0xFF, 0xCE, 0x07,
  0xF8, 0x70, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xE0, 0x3F, 0xBF, 0x81, 0xE0, 0x1E, 0x1E, 0x00, 0x71, 0xE0, 0x03, 0xCE,
  0x00, 0x0E, 0x70, 0x00, 0x77, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x63, 0xE0, 0x0F, 0x0F, 0xF7, 0xF0,
  0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x07, 0xF8, 0x1F, 0xF0, 0x7C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x3F, 0xFE,
  0x7F, 0xFC, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE1, 0xC3, 0xFF, 0xCE, 0x3F, 0xFF, 0x73, 0xE0, 0x1B, 0x9E, 0x00,
  0x7D, 0xE0, 0x01, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xEE, 0x00, 0x07,
  0x70, 0x00, 0x3B, 0x80, 0x03, 0xDE, 0x00, 0x1E, 0x78, 0x01, 0xF3, 0xE0,
  0x1F, 0x8F, 0xFF, 0xDC, 0x3F, 0xFC, 0xE0, 0x7F, 0x87, 0x00, 0x60, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x40, 0x03, 0xC7, 0x00, 0x1E, 0x3E, 0x03, 0xE0, 0xFF, 0xFE, 0x01,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x0F, 0xF0, 0xE3, 0xFF, 0x8E, 0x7F, 0xFC, 0xEE, 0x03, 0xCE,
  0xC0, 0x1E, 0xF8, 0x00, 0xEF, 0x80, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x2F, 0xFF, 0x70, 0x00, 0x00,
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x70, 0x00, 0x00, 0xF0, 0x3C, 0x0F, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x3E, 0xFF, 0x3F,
  0x8F, 0xC0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x1E, 0xE0, 0x03, 0xCE, 0x00, 0x78, 0xE0, 0x07, 0x8E, 0x00, 0xF0, 0xE0,
  0x1E, 0x0E, 0x03, 0xC0, 0xE0, 0x78, 0x0E, 0x07, 0x00, 0xE0, 0xF0, 0x0E,
  0x1E, 0x00, 0xE3, 0xC0, 0x0E, 0x78, 0x00, 0xEF, 0x80, 0x0E, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xDE, 0x00, 0xF8, 0xF0, 0x0F, 0x07, 0x00, 0xE0, 0x78,
  0x0E, 0x03, 0xC0, 0xE0, 0x1C, 0x0E, 0x01, 0xE0, 0xE0, 0x0E, 0x0E, 0x00,
  0xF0, 0xE0, 0x07, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0xCE, 0x00, 0x1E, 0xE0,
  0x00, 0xEE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x10, 0x00,
  0x00, 0x0E, 0x1F, 0xF0, 0x1F, 0xF0, 0xE3, 0xFF, 0x83, 0xFF, 0x8E, 0x7F,
  0xFC, 0x7F, 0xFC, 0xEE, 0x03, 0xCE, 0x01, 0xEF, 0xC0, 0x1F, 0xC0, 0x0E,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x00, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x7E, 0x00,
  0x07, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x07,
  0xE0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0x70,
  0x00, 0x7E, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x7E, 0x00,
  0x07, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x07,
  0xE0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0x70,
  0x00, 0x7E, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x7E, 0x00,
  0x07, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x07,
  0xE0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x0F, 0xF0, 0xE3, 0xFF, 0x8E, 0x7F, 0xFC, 0xEE, 0x03, 0xCE, 0xC0, 0x1E,
  0xF8, 0x00, 0xEF, 0x80, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x10, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xFC, 0x03, 0xFB, 0xF8, 0x1E, 0x01, 0xF0, 0xF0, 0x03, 0xC3, 0x80, 0x07,
  0x9E, 0x00, 0x0E, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70,
  0x00, 0x3D, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x8F, 0x00, 0x3C, 0x1E, 0x01,
  0xF0, 0x3F, 0xBF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x07, 0x0F, 0xF8, 0x39, 0xFF, 0xE1, 0xDF, 0xFF, 0x8E, 0xE0,
  0x3E, 0x7C, 0x00, 0xF3, 0xE0, 0x03, 0xDE, 0x00, 0x0E, 0xE0, 0x00, 0x77,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x77, 0x80, 0x03, 0xBC, 0x00, 0x3D, 0xF0,
  0x01, 0xCE, 0xC0, 0x3E, 0x77, 0xEF, 0xE3, 0x9F, 0xFE, 0x1C, 0x3F, 0xE0,
  0xE0, 0x30, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE1, 0xC3, 0xFF, 0xCE, 0x3F, 0xBF, 0x73, 0xE0, 0x1F, 0x9E, 0x00, 0x7D,
  0xE0, 0x01, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70,
  0x00, 0x3B, 0x80, 0x01, 0xDE, 0x00, 0x1E, 0x78, 0x01, 0xF3, 0xE0, 0x1F,
  0x8F, 0xEF, 0xDC, 0x3F, 0xFC, 0xE0, 0x7F, 0x87, 0x00, 0x60, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x2E, 0x1F, 0xE7, 0xFE, 0x7F, 0xEE, 0x0F,
  0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01,
  0xF9, 0xF8, 0x3C, 0x03, 0xC7, 0x80, 0x1E, 0x70, 0x00, 0xE7, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xE7,
  0x80, 0x1E, 0x7C, 0x03, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x02, 0x00,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F,
  0x70, 0x00, 0xF7, 0x00, 0x1F, 0x78, 0x03, 0xF3, 0xC0, 0x77, 0x3F, 0xFF,
  0x71, 0xFF, 0xE7, 0x0F, 0xF8, 0x70, 0x08, 0x00, 0x70, 0x00, 0x1D, 0xC0,
  0x00, 0xF7, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x01,
  0xC3, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0xF0, 0x78, 0x03, 0x80,
  0xE0, 0x0E, 0x03, 0x80, 0x38, 0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70,
  0x1C, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x30,
  0x00, 0xE1, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xFC, 0x00, 0x78, 0x00, 0xE7, 0x00, 0x1E, 0x00, 0x39, 0xC0,
  0x07, 0x80, 0x0E, 0x70, 0x03, 0xE0, 0x07, 0x9C, 0x00, 0xFC, 0x01, 0xC3,
  0x80, 0x3F, 0x00, 0x70, 0xE0, 0x0D, 0xC0, 0x1C, 0x38, 0x07, 0x70, 0x07,
  0x0E, 0x01, 0xCE, 0x03, 0x81, 0xC0, 0x73, 0x80, 0xE0, 0x70, 0x38, 0xE0,
  0x38, 0x1C, 0x0E, 0x18, 0x0E, 0x07, 0x03, 0x87, 0x07, 0x01, 0xE0, 0xE1,
  0xC1, 0xC0, 0x38, 0x70, 0x70, 0x70, 0x0E, 0x1C, 0x0C, 0x1C, 0x03, 0x87,
  0x03, 0x86, 0x00, 0xE1, 0x80, 0xE3, 0x80, 0x1C, 0xE0, 0x38, 0xE0, 0x07,
  0x38, 0x07, 0x38, 0x01, 0xCE, 0x01, 0xCE, 0x00, 0x73, 0x00, 0x77, 0x00,
  0x0F, 0xC0, 0x0D, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x7B, 0xC0, 0x07, 0x9E, 0x00, 0x38, 0x78, 0x03, 0xC1, 0xC0, 0x1C, 0x0F,
  0x01, 0xE0, 0x38, 0x0E, 0x01, 0xE0, 0xF0, 0x07, 0x07, 0x00, 0x3C, 0x70,
  0x00, 0xE7, 0x80, 0x03, 0xB8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x77, 0x00,
  0x07, 0xBC, 0x00, 0x38, 0xE0, 0x03, 0xC7, 0x80, 0x1C, 0x1C, 0x01, 0xC0,
  0xF0, 0x1E, 0x03, 0x80, 0xE0, 0x0E, 0x0F, 0x00, 0x78, 0x70, 0x01, 0xC7,
  0x80, 0x0F, 0x38, 0x00, 0x3B, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3D, 0xC0,
  0x00, 0xF7, 0x80, 0x03, 0x9E, 0x00, 0x0E, 0x38, 0x00, 0x78, 0xE0, 0x01,
  0xC3, 0xC0, 0x07, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xE0, 0x78, 0x03, 0x80,
  0xE0, 0x0E, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70,
  0x3C, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x70,
  0x00, 0xF1, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x3C, 0x00, 0x1E, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0C, 0x00, 0x70, 0x07, 0xC0, 0x3C, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0,
  0x3F, 0x00, 0xF0, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x03,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x3C, 0x01, 0xF0, 0x1F, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x0F, 0x00, 0x30, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x33, 0xFF, 0x80, 0x0D, 0xE1, 0xF0,
  0x07, 0x70, 0x3E, 0x01, 0xF8, 0x03, 0xC0, 0xFE, 0x00, 0x78, 0x7B, 0x80,
  0x0F, 0xFC, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_Light58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 42, 12, 4, -41 },
  { 22, 10, 13, 17, 4, -44 },
  { 39, 26, 41, 30, 3, -41 },
  { 173, 22, 54, 28, 3, -48 },
  { 322, 31, 43, 37, 3, -42 },
  { 489, 27, 43, 31, 3, -42 },
  { 635, 3, 13, 10, 3, -44 },
  { 640, 12, 59, 17, 4, -46 },
  { 729, 12, 59, 17, 1, -46 },
  { 818, 23, 23, 25, 1, -41 },
  { 885, 24, 30, 29, 2, -34 },
  { 975, 6, 13, 11, 2, -5 },
  { 985, 11, 3, 15, 2, -20 },
  { 990, 5, 5, 14, 4, -4 },
  { 994, 18, 45, 21, 1, -41 },
  { 1096, 22, 43, 28, 3, -42 },
  { 1215, 12, 41, 28, 5, -41 },
  { 1277, 23, 42, 28, 3, -42 },
  { 1398, 22, 43, 28, 3, -42 },
  { 1517, 25, 41, 28, 2, -41 },
  { 1646, 22, 42, 28, 4, -41 },
  { 1762, 21, 42, 28, 4, -41 },
  { 1873, 23, 41, 28, 2, -41 },
  { 1991, 22, 43, 28, 3, -42 },
  { 2110, 22, 42, 28, 3, -42 },
  { 2226, 5, 31, 12, 4, -30 },
  { 2246, 6, 38, 11, 2, -30 },
  { 2275, 20, 25, 26, 2, -31 },
  { 2338, 20, 14, 28, 4, -26 },
  { 2373, 20, 24, 26, 4, -31 },
  { 2433, 18, 43, 23, 3, -42 },
  { 2530, 39, 53, 45, 3, -40 },
  { 2789, 30, 41, 32, 1, -41 },
  { 2943, 23, 41, 31, 5, -41 },
  { 3061, 26, 43, 33, 4, -42 },
  { 3201, 24, 41, 33, 5, -41 },
  { 3324, 22, 41, 29, 5, -41 },
  { 3437, 21, 41, 28, 5, -41 },
  { 3545, 26, 43, 34, 4, -42 },
  { 3685, 26, 41, 36, 5, -41 },
  { 3819, 4, 41, 14, 5, -41 },
  { 3840, 21, 42, 28, 2, -41 },
  { 3951, 26, 41, 32, 5, -41 },
  { 4085, 20, 41, 27, 5, -41 },
  { 4188, 33, 41, 43, 5, -41 },
  { 4358, 26, 41, 36, 5, -41 },
  { 4492, 26, 43, 34, 4, -42 },
  { 4632, 24, 41, 31, 5, -41 },
  { 4755, 26, 49, 34, 4, -42 },
  { 4915, 24, 41, 32, 5, -41 },
  { 5038, 25, 43, 30, 3, -42 },
  { 5173, 26, 41, 30, 2, -41 },
  { 5307, 25, 42, 33, 4, -41 },
  { 5439, 29, 41, 31, 1, -41 },
  { 5588, 41, 41, 45, 2, -41 },
  { 5799, 27, 41, 31, 2, -41 },
  { 5938, 28, 41, 30, 1, -41 },
  { 6082, 25, 41, 30, 3, -41 },
  { 6211, 8, 56, 13, 4, -47 },
  { 6267, 17, 45, 20, 2, -41 },
  { 6363, 8, 56, 13, 1, -47 },
  { 6419, 17, 21, 21, 2, -41 },
  { 6464, 21, 3, 22, 1, 0 },
  { 6472, 9, 8, 17, 3, -44 },
  { 6481, 21, 33, 27, 3, -32 },
  { 6568, 21, 45, 28, 4, -44 },
  { 6687, 21, 33, 26, 3, -32 },
  { 6774, 21, 45, 28, 3, -44 },
  { 6893, 21, 33, 27, 3, -32 },
  { 6980, 15, 45, 17, 2, -45 },
  { 7065, 21, 44, 28, 3, -32 },
  { 7181, 20, 44, 28, 4, -44 },
  { 7291, 4, 43, 12, 4, -43 },
  { 7313, 10, 55, 12, -2, -43 },
  { 7382, 20, 44, 25, 4, -44 },
  { 7492, 3, 44, 12, 5, -44 },
  { 7509, 36, 32, 44, 4, -32 },
  { 7653, 20, 32, 28, 4, -32 },
  { 7733, 22, 33, 28, 3, -32 },
  { 7824, 21, 44, 28, 4, -32 },
  { 7940, 21, 44, 28, 3, -32 },
  { 8056, 12, 32, 18, 4, -32 },
  { 8104, 20, 33, 26, 3, -32 },
  { 8187, 14, 39, 17, 1, -38 },
  { 8256, 20, 32, 28, 4, -31 },
  { 8336, 22, 31, 25, 1, -31 },
  { 8422, 34, 31, 38, 2, -31 },
  { 8554, 21, 31, 25, 2, -31 },
  { 8636, 22, 43, 24, 1, -31 },
  { 8755, 20, 31, 25, 3, -31 },
  { 8833, 14, 56, 17, 2, -45 },
  { 8931, 3, 49, 13, 5, -41 },
  { 8950, 14, 56, 17, 1, -45 },
  { 9048, 26, 10, 34, 4, -22 },
};

const GFXfont RobotoCondensed_Light58pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light58pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light58pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _ROBOTOCONDENSED_LIGHT58PT7B_H_
