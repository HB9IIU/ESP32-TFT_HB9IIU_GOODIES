#ifndef _ROBOTOCONDENSED_LIGHT54PT7B_H_
#define _ROBOTOCONDENSED_LIGHT54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light54pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0D, 0x86, 0xC3, 0x61, 0xB0, 0xD8, 0x60, 0x00,
  0x70, 0x18, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x60, 0x38, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x70, 0x00,
  0xE0, 0x70, 0x00, 0xC0, 0x70, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0x80, 0xE0, 0x01,
  0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x80, 0xC0, 0x03,
  0x81, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03,
  0x01, 0x80, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x06,
  0x03, 0x80, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x0E,
  0x07, 0x00, 0x0E, 0x07, 0x00, 0x0C, 0x07, 0x00, 0x0C, 0x06, 0x00, 0x0C,
  0x06, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xF8, 0x0F, 0x8F, 0xC1, 0xE0, 0x3C, 0x3C, 0x01, 0xE3, 0x80, 0x0E, 0x38,
  0x00, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x77,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0xF7, 0x80, 0x0E, 0x3C, 0x03, 0xE1,
  0xFC, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x06, 0x07, 0x00, 0x00, 0x70, 0x18, 0x02, 0x03, 0x00, 0xC0, 0x38, 0x18,
  0x07, 0x01, 0x80, 0xC0, 0x38, 0x1C, 0x06, 0x01, 0xC0, 0xC0, 0x30, 0x0E,
  0x0E, 0x01, 0x80, 0x70, 0x60, 0x0C, 0x03, 0x07, 0x00, 0x70, 0x18, 0x30,
  0x01, 0x81, 0xC3, 0x80, 0x0E, 0x1C, 0x18, 0x00, 0x3F, 0xE1, 0x80, 0x00,
  0xFE, 0x1C, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x07, 0x01, 0x00, 0x00, 0x30, 0x7F, 0x00, 0x03, 0x87,
  0xFC, 0x00, 0x18, 0x70, 0x70, 0x01, 0xC3, 0x03, 0x80, 0x0C, 0x38, 0x0C,
  0x00, 0xE1, 0xC0, 0x70, 0x06, 0x0C, 0x03, 0x80, 0x70, 0x60, 0x1C, 0x03,
  0x03, 0x00, 0xE0, 0x30, 0x18, 0x07, 0x03, 0x80, 0xC0, 0x38, 0x18, 0x07,
  0x01, 0xC1, 0xC0, 0x38, 0x0C, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xF1, 0xE0, 0x00,
  0xE0, 0x78, 0x00, 0xF0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x03, 0x00,
  0x1C, 0x01, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70,
  0x01, 0xC0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x78,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xF3, 0x80, 0x00, 0xF1, 0xE0, 0x18, 0x70,
  0x78, 0x0C, 0x70, 0x1C, 0x0E, 0x38, 0x07, 0x07, 0x38, 0x03, 0xC3, 0x9C,
  0x00, 0xF1, 0xCE, 0x00, 0x38, 0xC7, 0x00, 0x0E, 0xE3, 0x80, 0x07, 0xF1,
  0xC0, 0x01, 0xF0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x3F,
  0x07, 0x80, 0x7F, 0x83, 0xF0, 0xFC, 0xE0, 0x7F, 0xF8, 0x78, 0x1F, 0xF8,
  0x1E, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x30,
  0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0,
  0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x70,
  0x0C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x30, 0x0E, 0x01, 0xC0, 0x30, 0x04, 0x40, 0x1C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38,
  0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x70,
  0x0C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x10, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x1C, 0x0E, 0x07, 0xFC, 0x71, 0xFF, 0xFB, 0xBF,
  0xC7, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0x70, 0x00, 0x71, 0xC0, 0x07, 0x8F, 0x00, 0x38, 0x38, 0x03, 0x80, 0xE0,
  0x3C, 0x07, 0x81, 0xC0, 0x1C, 0x04, 0x00, 0x40, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x39, 0xCE, 0x73, 0x9C, 0xEE, 0x77, 0xB8, 0x80, 0xFF, 0xFF, 0xFF,
  0xFC, 0x6F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x00, 0xF0, 0xF8,
  0x1E, 0x03, 0x83, 0xC0, 0x1C, 0x38, 0x01, 0xE7, 0x00, 0x0E, 0x70, 0x00,
  0xE7, 0x00, 0x0E, 0x70, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0x60, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00,
  0xE3, 0x80, 0x1C, 0x3C, 0x01, 0xC1, 0xE0, 0x38, 0x0F, 0x8F, 0x80, 0x7F,
  0xF0, 0x03, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x30, 0x0F, 0x03, 0xF1, 0xFF,
  0x7F, 0x7F, 0xC7, 0xE0, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x3E,
  0x1F, 0x03, 0xC0, 0x3C, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x9E, 0x00, 0x1C,
  0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0xF0, 0xF8, 0x3C, 0x03, 0xC7, 0x80,
  0x1C, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xFF, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xE7, 0x00, 0x0E, 0x78,
  0x01, 0xE3, 0xC0, 0x3C, 0x3F, 0x0F, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0C,
  0xE0, 0x00, 0x39, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x0E,
  0x00, 0x0E, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x01, 0xC0, 0xE0,
  0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x70,
  0x01, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x31, 0xF8, 0x03, 0x7F, 0xE0, 0x3F, 0xFF, 0x87, 0xC0,
  0xF8, 0x78, 0x03, 0xC1, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0xE7, 0x00, 0x0E,
  0x70, 0x00, 0xE3, 0x80, 0x1C, 0x3C, 0x03, 0xC1, 0xF0, 0xF8, 0x0F, 0xFF,
  0x00, 0x3F, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0xC0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x7E, 0x01, 0xCF, 0xFC, 0x0E, 0xFF, 0xF0,
  0x7F, 0x03, 0xC3, 0xE0, 0x0F, 0x3E, 0x00, 0x39, 0xE0, 0x01, 0xEF, 0x00,
  0x07, 0x78, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x37,
  0x00, 0x01, 0xF8, 0x00, 0x0C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00,
  0x39, 0xC0, 0x01, 0xC7, 0x00, 0x1E, 0x38, 0x00, 0xE0, 0xE0, 0x0F, 0x07,
  0x80, 0xF0, 0x1F, 0x1F, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xF0, 0xF8, 0x3C, 0x03, 0xC3, 0x80,
  0x1E, 0x78, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x07, 0x70,
  0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x0E, 0x70, 0x00, 0xE3,
  0x80, 0x1E, 0x3C, 0x01, 0xC1, 0xE0, 0x78, 0x0F, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xFF, 0x01, 0xE0, 0x78, 0x3C, 0x01, 0xC7, 0x80, 0x0E, 0x70, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x77, 0x00, 0x0F, 0x78,
  0x00, 0xE3, 0xC0, 0x3E, 0x1F, 0x0F, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xF1, 0xF0,
  0x3C, 0x07, 0x83, 0x80, 0x3C, 0x70, 0x01, 0xC7, 0x00, 0x1E, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0xF7, 0x00, 0x0F, 0x78, 0x01, 0xF3, 0x80, 0x3F, 0x3E, 0x0F, 0x71,
  0xFF, 0xE7, 0x0F, 0xFC, 0x60, 0x3F, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0x80, 0x00, 0x73, 0xDE, 0xF2, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x73, 0xFE, 0xF2, 0x00, 0x39,
  0xF7, 0xCE, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x38, 0xE3, 0x8E, 0x38, 0xE7, 0x9C, 0xF3,
  0x84, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x87, 0xE7, 0xC3, 0xC0, 0xF3, 0xC0,
  0x3D, 0xC0, 0x0E, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x0C, 0x0C, 0x00,
  0x00, 0x00, 0xC1, 0xC0, 0x07, 0xC0, 0x0E, 0x18, 0x00, 0xFF, 0x00, 0x63,
  0x80, 0x3E, 0xF8, 0x06, 0x38, 0x03, 0x81, 0xC0, 0x73, 0x00, 0x70, 0x1C,
  0x07, 0x70, 0x0E, 0x01, 0x80, 0x37, 0x00, 0xE0, 0x18, 0x03, 0x60, 0x0C,
  0x01, 0x80, 0x36, 0x01, 0xC0, 0x18, 0x03, 0x60, 0x1C, 0x01, 0x80, 0x3E,
  0x01, 0x80, 0x18, 0x03, 0xE0, 0x38, 0x01, 0x80, 0x3E, 0x03, 0x80, 0x38,
  0x03, 0xE0, 0x38, 0x03, 0x80, 0x3E, 0x03, 0x80, 0x38, 0x03, 0xE0, 0x38,
  0x03, 0x80, 0x3E, 0x03, 0x00, 0x38, 0x03, 0xE0, 0x30, 0x03, 0x80, 0x3E,
  0x03, 0x00, 0x38, 0x07, 0xE0, 0x38, 0x03, 0x00, 0x6E, 0x03, 0x80, 0x70,
  0x06, 0x60, 0x38, 0x07, 0x80, 0xE6, 0x03, 0x80, 0xF8, 0x0C, 0x60, 0x1C,
  0x1D, 0x81, 0xC7, 0x01, 0xE3, 0x9C, 0x38, 0x70, 0x0F, 0xF0, 0xFF, 0x03,
  0x00, 0x7E, 0x0F, 0xE0, 0x38, 0x01, 0x00, 0x10, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x01, 0x80, 0x00, 0x07, 0xF1, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x37, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x31, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x38, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C,
  0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x0E,
  0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x03, 0x00, 0x38, 0x00, 0x70, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70,
  0x38, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xC0, 0x0F, 0x8E, 0x00, 0x1E, 0x70, 0x00, 0x73, 0x80,
  0x03, 0x9C, 0x00, 0x1E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D,
  0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00,
  0x38, 0xE0, 0x07, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0E,
  0x00, 0x3C, 0x70, 0x00, 0xF3, 0x80, 0x03, 0xDC, 0x00, 0x0E, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0E, 0xE0, 0x00, 0xF7, 0x00, 0x0F,
  0x38, 0x00, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xC7, 0xF0, 0x1E,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x0F,
  0xC3, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x38, 0x01, 0xF0, 0xE0, 0x01,
  0xE3, 0x80, 0x03, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1E, 0xE0, 0x00, 0x3B,
  0x80, 0x00, 0xEE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x07,
  0xB8, 0x00, 0x1C, 0xE0, 0x00, 0xF3, 0x80, 0x07, 0x8E, 0x00, 0x7C, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x0F, 0xC3, 0xF8, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x3C,
  0x38, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x78, 0x00, 0x07, 0x3C, 0x00, 0x07,
  0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x3E, 0x0F, 0xE1, 0xFC, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0E, 0xE0, 0x00, 0xE7, 0x00, 0x0E, 0x70,
  0x01, 0xE7, 0x80, 0x1C, 0x3C, 0x07, 0xC1, 0xF9, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x40, 0x00, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0xF3, 0x80,
  0x01, 0xC7, 0x00, 0x07, 0x8E, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x38, 0x01,
  0xE0, 0x70, 0x03, 0x80, 0xE0, 0x0F, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0xF0,
  0x07, 0x01, 0xC0, 0x0E, 0x07, 0x80, 0x1C, 0x1E, 0x00, 0x38, 0x78, 0x00,
  0x71, 0xE0, 0x00, 0xE3, 0x80, 0x01, 0xCF, 0x80, 0x03, 0xBF, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xCF, 0x00, 0x1F, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x70,
  0x1E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x3C, 0x07, 0x00,
  0x38, 0x0E, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x38, 0x00, 0x70, 0x70, 0x00,
  0xF0, 0xE0, 0x00, 0xF1, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xE7, 0x00, 0x01,
  0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0x00, 0x00, 0x1F,
  0xEE, 0x00, 0x00, 0x77, 0xCC, 0x00, 0x00, 0xEF, 0x9C, 0x00, 0x03, 0x9F,
  0x38, 0x00, 0x07, 0x3E, 0x38, 0x00, 0x0E, 0x7C, 0x70, 0x00, 0x38, 0xF8,
  0xE0, 0x00, 0x71, 0xF0, 0xE0, 0x00, 0xE3, 0xE1, 0xC0, 0x03, 0x87, 0xE3,
  0x80, 0x07, 0x0F, 0xC3, 0x80, 0x0E, 0x1F, 0x87, 0x00, 0x38, 0x3F, 0x0E,
  0x00, 0x70, 0x7E, 0x0E, 0x00, 0xE0, 0xFC, 0x1C, 0x03, 0x81, 0xF8, 0x18,
  0x07, 0x03, 0xF0, 0x38, 0x0E, 0x07, 0xE0, 0x70, 0x38, 0x0F, 0xC0, 0x60,
  0x70, 0x1F, 0x80, 0xE0, 0xC0, 0x3F, 0x01, 0xC3, 0x80, 0x7E, 0x01, 0x87,
  0x00, 0xFC, 0x03, 0x8C, 0x01, 0xF8, 0x07, 0x38, 0x03, 0xF0, 0x07, 0x70,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x70, 0x01,
  0xC0, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xEE, 0x00,
  0x07, 0xEE, 0x00, 0x07, 0xE7, 0x00, 0x07, 0xE7, 0x00, 0x07, 0xE3, 0x80,
  0x07, 0xE3, 0xC0, 0x07, 0xE1, 0xC0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xE0,
  0x07, 0xE0, 0x70, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x3C,
  0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1E, 0x07, 0xE0, 0x0E, 0x07, 0xE0, 0x07,
  0x07, 0xE0, 0x07, 0x07, 0xE0, 0x03, 0x87, 0xE0, 0x03, 0x87, 0xE0, 0x01,
  0xC7, 0xE0, 0x01, 0xE7, 0xE0, 0x00, 0xE7, 0xE0, 0x00, 0x77, 0xE0, 0x00,
  0x77, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0xF0, 0x03, 0xC0, 0xF0,
  0x00, 0xF0, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x38,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x07, 0x80,
  0x7F, 0x3F, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x10, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x38, 0x00, 0xF8, 0xE0,
  0x00, 0xF3, 0x80, 0x01, 0xCE, 0x00, 0x07, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80,
  0x01, 0xEE, 0x00, 0x0F, 0x38, 0x00, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0xF0, 0x07,
  0xC0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x78, 0x00,
  0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x1C, 0xF0, 0x00,
  0x0E, 0x38, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x07, 0x81, 0xE0,
  0x0F, 0x80, 0x7F, 0x3F, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x10, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x08, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x38, 0x00, 0xF8, 0xE0, 0x01, 0xE3, 0x80,
  0x03, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1E, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE,
  0x00, 0x07, 0xB8, 0x00, 0x1C, 0xE0, 0x00, 0xF3, 0x80, 0x07, 0x8E, 0x00,
  0x3C, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0E, 0x00, 0xE0,
  0x38, 0x03, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x38, 0x00,
  0x38, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x03, 0xB8, 0x00, 0x0E,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x70, 0x00, 0x08, 0x00, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x0F, 0xE3, 0xF0, 0x1F, 0x00, 0x78, 0x1C, 0x00, 0x3C,
  0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x78, 0x00, 0x0E,
  0x78, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x1E,
  0x3C, 0x00, 0x1C, 0x1F, 0x00, 0x7C, 0x0F, 0xE3, 0xF8, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x38, 0x00,
  0x0E, 0x70, 0x00, 0x3C, 0xF0, 0x00, 0x70, 0xF8, 0x03, 0xE0, 0xFC, 0x3F,
  0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x3C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x1C, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x07, 0x80, 0x0E,
  0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0xE0,
  0x00, 0x70, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C,
  0x1C, 0x00, 0x01, 0x83, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1F,
  0x80, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x03, 0x9C, 0x00, 0x1E,
  0x00, 0x0E, 0x70, 0x00, 0x78, 0x00, 0x39, 0xC0, 0x03, 0xF0, 0x00, 0xE7,
  0x00, 0x0F, 0xC0, 0x03, 0x8E, 0x00, 0x33, 0x00, 0x1C, 0x38, 0x00, 0xCC,
  0x00, 0x70, 0xE0, 0x07, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0xE0, 0x07, 0x0E,
  0x00, 0x71, 0x80, 0x1C, 0x1C, 0x01, 0x86, 0x00, 0xE0, 0x70, 0x0E, 0x1C,
  0x03, 0x81, 0xC0, 0x38, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0xC0, 0x38, 0x1C,
  0x03, 0x03, 0x00, 0xC0, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x38,
  0x1C, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x0E, 0x06, 0x01, 0x81, 0xC0, 0x18,
  0x38, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x70,
  0xE0, 0x07, 0x0C, 0x00, 0xC3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x31,
  0xC0, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x03, 0x98, 0x00, 0x67,
  0x00, 0x0E, 0xE0, 0x01, 0x9C, 0x00, 0x3B, 0x80, 0x07, 0x60, 0x00, 0x6E,
  0x00, 0x1D, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x07, 0xBC,
  0x00, 0x07, 0x8E, 0x00, 0x03, 0x87, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC0,
  0xF0, 0x01, 0xE0, 0x38, 0x00, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x70,
  0x03, 0xC0, 0x78, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x38, 0x00, 0x1E, 0x3C,
  0x00, 0x07, 0x1C, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xC7, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x70, 0x1C, 0x00,
  0x78, 0x0F, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x3C, 0x00, 0x78,
  0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0x8F, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x77, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C,
  0x01, 0xC0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x01, 0xE0, 0x03, 0x80,
  0x70, 0x00, 0x70, 0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x87, 0x80, 0x00,
  0xE1, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x38, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xE0, 0x06, 0xE0, 0x06, 0x60, 0x0E, 0x70, 0x0C, 0x70, 0x1C,
  0x30, 0x1C, 0x38, 0x1C, 0x38, 0x38, 0x18, 0x38, 0x1C, 0x38, 0x1C, 0x70,
  0x0C, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0x87, 0xC3, 0x80, 0x38, 0xE0,
  0x03, 0x9C, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xFF,
  0xFE, 0x3C, 0x01, 0xCF, 0x00, 0x39, 0xC0, 0x07, 0x70, 0x00, 0xEE, 0x00,
  0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x03, 0xDC, 0x00,
  0xF9, 0xC0, 0x3F, 0x3F, 0x3E, 0x73, 0xFF, 0x8E, 0x3F, 0xE1, 0xC0, 0x40,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x3F, 0xE1, 0xCF, 0xFE, 0x3B, 0xC7,
  0xE7, 0xE0, 0x1E, 0xF8, 0x01, 0xDE, 0x00, 0x3B, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0xEF, 0x00, 0x3D, 0xF8, 0x07, 0x3B, 0xC7, 0xE7, 0x3F, 0xF8,
  0xE3, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFC,
  0x0F, 0x87, 0xC3, 0xC0, 0x3C, 0xF0, 0x03, 0x9C, 0x00, 0x77, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0x70, 0x00, 0xEF, 0x00, 0x38, 0xF0, 0x0F, 0x0F, 0x87, 0xC0,
  0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x7F, 0x8E, 0x3F, 0xFD, 0xC7, 0xC3, 0xF9, 0xE0, 0x1F, 0x78, 0x01, 0xEE,
  0x00, 0x1D, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x80, 0x1E, 0x78,
  0x06, 0xC7, 0xC7, 0xD8, 0x7F, 0xF3, 0x07, 0xF8, 0x60, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0x87, 0xC3, 0xC0, 0x38, 0xF0,
  0x03, 0x9C, 0x00, 0x77, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x08, 0xF0, 0x07, 0x8F, 0x83, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xC1, 0xF1, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x03,
  0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x0C, 0x7F, 0xF9, 0x9F, 0x87,
  0xB3, 0xC0, 0x36, 0xF0, 0x03, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3B, 0x80, 0x07,
  0x70, 0x00, 0xEF, 0x00, 0x3C, 0xF0, 0x0F, 0x8F, 0x8F, 0xF0, 0xFF, 0xEE,
  0x0F, 0xF1, 0xC0, 0x30, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x90, 0x00, 0xF3, 0x00, 0x1C, 0x78, 0x0F, 0x87, 0xFF, 0xE0,
  0x7F, 0xF8, 0x01, 0xF8, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x80, 0xE1, 0xFC, 0x39, 0xFF,
  0xCE, 0xF1, 0xF3, 0xF0, 0x1E, 0xF8, 0x03, 0xBC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xC0, 0xEF, 0xFE, 0x00, 0x00, 0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x03, 0x80,
  0xF0, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x73, 0xFC, 0xFE, 0x3E,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x03,
  0xC7, 0x00, 0xF0, 0xE0, 0x3C, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x78,
  0x0E, 0x1E, 0x01, 0xC7, 0x80, 0x38, 0xE0, 0x07, 0x38, 0x00, 0xEF, 0x00,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7C, 0xE0, 0x0F, 0x1E, 0x01, 0xC1, 0xC0,
  0x38, 0x3C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x83, 0x80, 0x78,
  0x70, 0x07, 0x0E, 0x00, 0xF1, 0xC0, 0x0E, 0x38, 0x00, 0xE7, 0x00, 0x1E,
  0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x71,
  0xFE, 0x03, 0xFE, 0x39, 0xFF, 0xC3, 0xFF, 0x9D, 0xE3, 0xE3, 0xC7, 0xEF,
  0xC0, 0x7B, 0x80, 0x77, 0xC0, 0x1D, 0x80, 0x3F, 0xC0, 0x0F, 0x80, 0x0F,
  0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x01, 0xE0, 0x03, 0xF0, 0x00, 0xE0, 0x01,
  0xF8, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x1C, 0x00,
  0x3F, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x0F, 0xC0, 0x03, 0x80,
  0x07, 0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x70,
  0x00, 0xFC, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x0E,
  0x00, 0x1F, 0x80, 0x07, 0x00, 0x0F, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x01,
  0xC0, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0xFC, 0x00,
  0x38, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x20, 0x38, 0x7F, 0x0E, 0x7F, 0xF3, 0xBC, 0x7C, 0xFC, 0x07, 0xBE, 0x00,
  0xEF, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x20, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0xC0, 0x3E, 0x1F, 0x03, 0xC0, 0x3C, 0x1C, 0x00, 0xF1, 0xE0,
  0x03, 0x8E, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0x70, 0x00, 0x3B, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x78, 0x00,
  0xE1, 0xC0, 0x0F, 0x0F, 0x00, 0xF0, 0x3E, 0x1F, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x7F, 0xC3, 0x9F, 0xFC,
  0x77, 0x8F, 0xCF, 0x80, 0x7D, 0xE0, 0x07, 0xBC, 0x00, 0x77, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xDE, 0x00, 0x7B, 0xE0, 0x1E, 0x77, 0x8F, 0xCE,
  0x7F, 0xF1, 0xC7, 0xF8, 0x38, 0x18, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x0C,
  0x7F, 0xF9, 0x9F, 0x87, 0xB3, 0xC0, 0x3E, 0xF0, 0x03, 0xDC, 0x00, 0x3B,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEF, 0x00, 0x3C, 0xF0, 0x0F, 0x8F,
  0x87, 0xF0, 0xFF, 0xEE, 0x0F, 0xF1, 0xC0, 0x30, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x5C, 0x7F,
  0x9F, 0xF7, 0xFF, 0xC1, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x7C,
  0x78, 0x07, 0x9C, 0x00, 0xE7, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x01, 0xDC,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0xF7, 0x80, 0x78, 0xFC, 0x7E, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x1F, 0xFE, 0xFF, 0xF7, 0xFF, 0x83, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF0,
  0x04, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0x70, 0x07, 0xDE, 0x03,
  0xF3, 0xE7, 0xFC, 0xFF, 0xF7, 0x0F, 0xF1, 0xC0, 0x40, 0x00, 0x70, 0x00,
  0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x1C,
  0x00, 0x70, 0xE0, 0x03, 0x83, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x0E,
  0x03, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x01, 0x80, 0x1C,
  0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x06, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80,
  0x07, 0x1C, 0x00, 0x18, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x1B,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80,
  0x0E, 0x00, 0x3B, 0x80, 0x3E, 0x00, 0xE7, 0x00, 0x7C, 0x01, 0xCE, 0x00,
  0xD8, 0x03, 0x9C, 0x01, 0xB0, 0x07, 0x1C, 0x07, 0x70, 0x0C, 0x38, 0x0E,
  0xE0, 0x38, 0x70, 0x18, 0xC0, 0x70, 0xE0, 0x31, 0xC0, 0xE0, 0xC0, 0xE3,
  0x81, 0x81, 0xC1, 0xC7, 0x07, 0x03, 0x83, 0x06, 0x0E, 0x07, 0x0E, 0x0E,
  0x1C, 0x06, 0x1C, 0x1C, 0x38, 0x0E, 0x38, 0x38, 0x60, 0x1C, 0x60, 0x31,
  0xC0, 0x39, 0xC0, 0x73, 0x80, 0x33, 0x80, 0xE7, 0x00, 0x77, 0x00, 0xCC,
  0x00, 0xEC, 0x01, 0xB8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xE7, 0x00,
  0x1C, 0x78, 0x03, 0xC3, 0x80, 0x38, 0x3C, 0x07, 0x81, 0xC0, 0x70, 0x0E,
  0x0F, 0x00, 0xE0, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x03, 0xB8, 0x00,
  0x3B, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x3B, 0x80, 0x03, 0xBC, 0x00, 0x71, 0xC0, 0x0F, 0x0E,
  0x00, 0xE0, 0xE0, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x03, 0x83, 0x80,
  0x3C, 0x70, 0x01, 0xCF, 0x00, 0x1E, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x77,
  0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E,
  0x38, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x07, 0x07, 0x00, 0x70,
  0x70, 0x07, 0x06, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x01,
  0xDC, 0x00, 0x1D, 0xC0, 0x01, 0xDC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x18,
  0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x1C, 0x07, 0xE0, 0x3C, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x0C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x03, 0x3F, 0xF0,
  0x03, 0x70, 0xF8, 0x03, 0xE0, 0x38, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1F,
  0x0E, 0xC0, 0x0F, 0xFC, 0xC0, 0x03, 0xFC, 0x00, 0x01, 0xF0,
};

const GFXglyph RobotoCondensed_Light54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 39, 12, 4, -38 },
  { 21, 9, 12, 16, 4, -41 },
  { 35, 24, 38, 28, 3, -38 },
  { 149, 20, 50, 26, 3, -44 },
  { 274, 29, 40, 35, 3, -39 },
  { 419, 25, 40, 29, 3, -39 },
  { 544, 3, 12, 9, 3, -41 },
  { 549, 10, 55, 16, 4, -43 },
  { 618, 11, 55, 16, 1, -43 },
  { 694, 21, 22, 23, 1, -38 },
  { 752, 22, 28, 27, 2, -32 },
  { 829, 5, 12, 10, 2, -5 },
  { 837, 10, 3, 14, 2, -19 },
  { 841, 4, 5, 13, 4, -4 },
  { 844, 16, 41, 19, 1, -38 },
  { 926, 20, 40, 26, 3, -39 },
  { 1026, 12, 38, 26, 4, -38 },
  { 1083, 21, 39, 26, 3, -39 },
  { 1186, 20, 40, 26, 3, -39 },
  { 1286, 23, 38, 26, 2, -38 },
  { 1396, 20, 39, 26, 4, -38 },
  { 1494, 21, 39, 26, 3, -38 },
  { 1597, 22, 38, 26, 2, -38 },
  { 1702, 20, 40, 26, 3, -39 },
  { 1802, 20, 39, 26, 3, -39 },
  { 1900, 5, 29, 11, 3, -28 },
  { 1919, 6, 35, 10, 2, -28 },
  { 1946, 19, 23, 24, 2, -29 },
  { 2001, 18, 14, 26, 4, -25 },
  { 2033, 19, 23, 25, 3, -29 },
  { 2088, 17, 40, 22, 2, -39 },
  { 2173, 36, 50, 42, 3, -38 },
  { 2398, 27, 38, 30, 1, -38 },
  { 2527, 21, 38, 29, 5, -38 },
  { 2627, 24, 40, 31, 4, -39 },
  { 2747, 22, 38, 31, 5, -38 },
  { 2852, 20, 38, 27, 5, -38 },
  { 2947, 20, 38, 27, 5, -38 },
  { 3042, 24, 40, 32, 4, -39 },
  { 3162, 24, 38, 33, 5, -38 },
  { 3276, 3, 38, 13, 5, -38 },
  { 3291, 20, 39, 26, 2, -38 },
  { 3389, 23, 38, 30, 5, -38 },
  { 3499, 18, 38, 25, 5, -38 },
  { 3585, 31, 38, 40, 5, -38 },
  { 3733, 24, 38, 33, 5, -38 },
  { 3847, 25, 40, 32, 3, -39 },
  { 3972, 22, 38, 29, 5, -38 },
  { 4077, 25, 46, 32, 3, -39 },
  { 4221, 22, 38, 30, 5, -38 },
  { 4326, 24, 40, 28, 2, -39 },
  { 4446, 25, 38, 28, 2, -38 },
  { 4565, 23, 39, 31, 4, -38 },
  { 4678, 27, 38, 29, 1, -38 },
  { 4807, 38, 38, 42, 2, -38 },
  { 4988, 25, 38, 29, 2, -38 },
  { 5107, 26, 38, 28, 1, -38 },
  { 5231, 24, 38, 28, 2, -38 },
  { 5345, 8, 52, 12, 4, -44 },
  { 5397, 16, 41, 19, 2, -38 },
  { 5479, 7, 52, 12, 1, -44 },
  { 5525, 16, 19, 20, 2, -38 },
  { 5563, 19, 3, 21, 1, 0 },
  { 5571, 9, 7, 15, 3, -40 },
  { 5579, 19, 31, 25, 3, -30 },
  { 5653, 19, 42, 26, 4, -41 },
  { 5753, 19, 31, 25, 3, -30 },
  { 5827, 19, 42, 26, 3, -41 },
  { 5927, 19, 31, 25, 3, -30 },
  { 6001, 14, 42, 16, 2, -42 },
  { 6075, 19, 41, 26, 3, -30 },
  { 6173, 18, 41, 26, 4, -41 },
  { 6266, 4, 39, 11, 4, -39 },
  { 6286, 10, 50, 12, -2, -39 },
  { 6349, 19, 41, 23, 4, -41 },
  { 6447, 3, 41, 11, 4, -41 },
  { 6463, 33, 30, 41, 4, -30 },
  { 6587, 18, 30, 26, 4, -30 },
  { 6655, 21, 31, 27, 3, -30 },
  { 6737, 19, 41, 26, 4, -30 },
  { 6835, 19, 41, 26, 3, -30 },
  { 6933, 11, 30, 16, 4, -30 },
  { 6975, 18, 31, 24, 3, -30 },
  { 7045, 13, 37, 16, 1, -36 },
  { 7106, 18, 30, 26, 4, -29 },
  { 7174, 21, 29, 23, 1, -29 },
  { 7251, 31, 29, 35, 2, -29 },
  { 7364, 20, 29, 23, 2, -29 },
  { 7437, 20, 40, 23, 1, -29 },
  { 7537, 19, 29, 23, 2, -29 },
  { 7606, 13, 53, 16, 2, -42 },
  { 7693, 2, 45, 12, 5, -38 },
  { 7705, 13, 53, 16, 1, -42 },
  { 7792, 24, 10, 32, 4, -21 },
};

const GFXfont RobotoCondensed_Light54pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light54pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light54pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOCONDENSED_LIGHT54PT7B_H_
