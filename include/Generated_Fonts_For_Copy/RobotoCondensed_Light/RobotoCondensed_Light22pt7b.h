#ifndef _ROBOTOCONDENSED_LIGHT22PT7B_H_
#define _ROBOTOCONDENSED_LIGHT22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE3, 0xB6, 0xDA, 0x08, 0x82, 0x20, 0x90, 0x24, 0x11, 0x1F,
  0xF1, 0x10, 0x44, 0x12, 0x04, 0x8F, 0xF8, 0x88, 0x22, 0x08, 0x82, 0x20,
  0x90, 0x08, 0x08, 0x1C, 0x62, 0x41, 0x41, 0x41, 0x40, 0x60, 0x38, 0x0E,
  0x03, 0x01, 0x81, 0xC1, 0x41, 0x63, 0x3E, 0x08, 0x08, 0x70, 0x04, 0x80,
  0x88, 0x88, 0x88, 0x89, 0x04, 0x90, 0x72, 0x00, 0x20, 0x04, 0x00, 0x4E,
  0x09, 0x10, 0x91, 0x11, 0x11, 0x11, 0x01, 0x10, 0x0E, 0x1C, 0x08, 0x86,
  0x21, 0x88, 0x62, 0x09, 0x03, 0x80, 0x40, 0x28, 0x13, 0x1C, 0x6E, 0x0A,
  0x81, 0xB0, 0x66, 0x38, 0xF1, 0xF8, 0x08, 0x84, 0x42, 0x21, 0x08, 0x42,
  0x31, 0x8C, 0x21, 0x08, 0x42, 0x08, 0x41, 0x08, 0x20, 0x88, 0x44, 0x22,
  0x23, 0x11, 0x11, 0x11, 0x13, 0x22, 0x24, 0x48, 0x80, 0x08, 0x04, 0x02,
  0x1D, 0x33, 0xE0, 0x60, 0x58, 0x44, 0x21, 0x00, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x87, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x56, 0x80, 0xF0,
  0xC0, 0x02, 0x0C, 0x10, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20, 0x41, 0x02,
  0x04, 0x10, 0x20, 0x40, 0x3C, 0x62, 0x41, 0x41, 0xC1, 0xC1, 0x81, 0x81,
  0x81, 0x81, 0xC1, 0xC1, 0x41, 0x43, 0x62, 0x1C, 0x1B, 0xF6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x3C, 0x31, 0x10, 0xD8, 0x28, 0x10,
  0x08, 0x0C, 0x04, 0x06, 0x06, 0x02, 0x02, 0x03, 0x01, 0x01, 0x01, 0xFF,
  0x3C, 0x62, 0x41, 0xC1, 0x01, 0x01, 0x02, 0x1C, 0x03, 0x01, 0x01, 0x01,
  0x81, 0xC1, 0x62, 0x3C, 0x02, 0x03, 0x03, 0x81, 0x41, 0xA0, 0x90, 0xC8,
  0x44, 0x42, 0x21, 0x20, 0x9F, 0xF0, 0x20, 0x10, 0x08, 0x04, 0x7E, 0x40,
  0x40, 0x40, 0xC0, 0x80, 0xBC, 0xC6, 0x02, 0x03, 0x03, 0x03, 0x83, 0x82,
  0x46, 0x3C, 0x0E, 0x0C, 0x08, 0x0C, 0x04, 0x02, 0xF1, 0x8D, 0x82, 0xC1,
  0x60, 0xF0, 0x78, 0x34, 0x12, 0x08, 0x88, 0x38, 0xFF, 0x80, 0x80, 0x40,
  0x60, 0x20, 0x10, 0x10, 0x08, 0x04, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80,
  0xC0, 0x40, 0x3C, 0x31, 0x10, 0x48, 0x24, 0x12, 0x09, 0x88, 0x38, 0x62,
  0x20, 0xA0, 0x50, 0x38, 0x12, 0x09, 0x8C, 0x78, 0x3C, 0x66, 0x43, 0xC1,
  0x81, 0x81, 0x81, 0xC1, 0x43, 0x67, 0x3D, 0x01, 0x03, 0x02, 0x0C, 0x38,
  0x50, 0x00, 0x07, 0x70, 0x00, 0x05, 0x78, 0x02, 0x0C, 0x73, 0x8C, 0x18,
  0x1C, 0x0E, 0x06, 0x04, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0xE0, 0x38,
  0x0C, 0x03, 0x03, 0x0C, 0x38, 0xE0, 0x80, 0x38, 0x8A, 0x1C, 0x10, 0x20,
  0x41, 0x06, 0x08, 0x20, 0x40, 0x80, 0x00, 0x04, 0x08, 0x07, 0xE0, 0x18,
  0x20, 0x40, 0x21, 0x00, 0x22, 0x00, 0x48, 0x38, 0x50, 0x88, 0xA2, 0x11,
  0x84, 0x43, 0x10, 0x86, 0x21, 0x0C, 0x42, 0x18, 0x84, 0x48, 0x9C, 0x91,
  0xCE, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x60, 0x00, 0x3E, 0x00, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xD0, 0x09, 0x00, 0x90, 0x19, 0x81, 0x08, 0x10,
  0x81, 0x0C, 0x20, 0x43, 0xFC, 0x20, 0x66, 0x02, 0x40, 0x24, 0x02, 0xFC,
  0x41, 0x20, 0x50, 0x28, 0x14, 0x0A, 0x09, 0xF8, 0x83, 0x40, 0xA0, 0x70,
  0x38, 0x14, 0x0A, 0x0D, 0xF8, 0x1F, 0x0C, 0x66, 0x0D, 0x01, 0x40, 0x70,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x01, 0x40, 0x58, 0x33, 0x18,
  0x7C, 0xFC, 0x43, 0x20, 0x50, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x1C, 0x0A, 0x19, 0xF8, 0xFF, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x3E, 0x31, 0xB0, 0x70, 0x18, 0x0C, 0x02, 0x01, 0x00,
  0x87, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x05, 0x86, 0x7C, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x81, 0x83, 0xC2, 0x46, 0x3C, 0x81,
  0xA0, 0xC8, 0x22, 0x10, 0x8C, 0x26, 0x09, 0x02, 0xC0, 0xF8, 0x32, 0x08,
  0xC2, 0x18, 0x82, 0x20, 0xC8, 0x1A, 0x02, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xC0,
  0x1E, 0x01, 0xF0, 0x0F, 0xC0, 0x7A, 0x07, 0xD0, 0x2E, 0xC1, 0x72, 0x1B,
  0x90, 0x9C, 0x44, 0xE2, 0x67, 0x12, 0x38, 0x51, 0xC3, 0x8E, 0x18, 0x70,
  0x43, 0x80, 0xF0, 0x3C, 0x0E, 0x83, 0xB0, 0xE4, 0x39, 0x8E, 0x23, 0x8C,
  0xE1, 0x38, 0x2E, 0x0B, 0x81, 0xE0, 0x78, 0x0E, 0x03, 0x1F, 0x06, 0x31,
  0x83, 0x20, 0x24, 0x05, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xA0, 0x24, 0x04, 0xC1, 0x8C, 0x60, 0xF8, 0xFE, 0x41, 0xA0, 0x70, 0x18,
  0x0C, 0x06, 0x07, 0x06, 0xFE, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x1F, 0x06, 0x31, 0x83, 0x20, 0x24, 0x05, 0x80, 0xB0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0x20, 0x24, 0x04, 0xC1, 0x8C, 0x60, 0xF8, 0x01,
  0x80, 0x18, 0x01, 0x00, 0xFC, 0x41, 0xA0, 0x50, 0x38, 0x1C, 0x0E, 0x05,
  0x06, 0xFC, 0x42, 0x21, 0x90, 0x48, 0x34, 0x0A, 0x07, 0x01, 0x1E, 0x31,
  0x90, 0x78, 0x1C, 0x0A, 0x01, 0x80, 0x78, 0x07, 0x00, 0xC0, 0x30, 0x18,
  0x0A, 0x05, 0x86, 0x3C, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x0D, 0x8C, 0x7C, 0x40, 0x28, 0x05, 0x81, 0x90, 0x22,
  0x04, 0x41, 0x8C, 0x20, 0x84, 0x10, 0x83, 0x30, 0x24, 0x04, 0x80, 0xB0,
  0x0C, 0x01, 0x80, 0x30, 0x81, 0x03, 0x02, 0x07, 0x0A, 0x0A, 0x14, 0x34,
  0x28, 0x48, 0x50, 0x91, 0x91, 0x32, 0x22, 0x24, 0x4C, 0x48, 0x90, 0x90,
  0xA1, 0x41, 0x42, 0x82, 0x83, 0x06, 0x06, 0x0C, 0x08, 0x08, 0xC0, 0xD0,
  0x26, 0x18, 0x84, 0x32, 0x04, 0x81, 0xC0, 0x30, 0x0C, 0x07, 0x81, 0x20,
  0xCC, 0x21, 0x18, 0x64, 0x0A, 0x03, 0x40, 0x6C, 0x08, 0x81, 0x10, 0x41,
  0x08, 0x22, 0x06, 0x40, 0x58, 0x0E, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0xFF, 0x80, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x80,
  0x40, 0x30, 0x08, 0x04, 0x01, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x03, 0xFF,
  0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x4E, 0x82, 0x0C, 0x10, 0x41,
  0x82, 0x08, 0x30, 0x41, 0x06, 0x08, 0x20, 0x81, 0x04, 0xE4, 0x92, 0x49,
  0x24, 0x92, 0x49, 0x24, 0x9E, 0x30, 0xC3, 0x12, 0x49, 0x2C, 0x61, 0xFF,
  0x46, 0x20, 0x3C, 0x62, 0x43, 0x01, 0x01, 0x3F, 0x61, 0xC1, 0x81, 0x83,
  0x45, 0x79, 0x80, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC6, 0x82, 0x82, 0x83,
  0x83, 0x83, 0x83, 0x82, 0x82, 0xC6, 0xBC, 0x3C, 0x62, 0xC1, 0x81, 0x80,
  0x80, 0x80, 0x80, 0x81, 0x41, 0x62, 0x3C, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x3D, 0x63, 0x41, 0xC1, 0x81, 0x81, 0x81, 0x81, 0xC1, 0x41, 0x63, 0x3D,
  0x3C, 0x62, 0x41, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x80, 0x40, 0x63, 0x3E,
  0x19, 0x18, 0xC6, 0x7D, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x60, 0x3D,
  0x63, 0x41, 0xC1, 0x81, 0x81, 0x81, 0x81, 0xC1, 0x41, 0x63, 0x3D, 0x01,
  0x01, 0x62, 0x3C, 0x81, 0x02, 0x04, 0x08, 0x17, 0xB1, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0xC7, 0xFF, 0x80, 0x11, 0x00, 0x01,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x13, 0xE0, 0x81, 0x02, 0x04, 0x08,
  0x10, 0xA3, 0x4C, 0x91, 0x43, 0x87, 0x89, 0x11, 0x23, 0x42, 0x82, 0xFF,
  0xFF, 0x80, 0xBC, 0xF6, 0x28, 0xE0, 0xC3, 0x04, 0x18, 0x20, 0xC1, 0x06,
  0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x10, 0xBD, 0x8E,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x3C, 0x31, 0x90,
  0x58, 0x28, 0x1C, 0x0E, 0x07, 0x03, 0xC1, 0x20, 0x98, 0xC7, 0x80, 0xBC,
  0xC6, 0x82, 0x82, 0x83, 0x83, 0x83, 0x82, 0x82, 0x82, 0xC6, 0xBC, 0x80,
  0x80, 0x80, 0x80, 0x3D, 0x63, 0x41, 0xC1, 0x81, 0x81, 0x81, 0x81, 0xC1,
  0x41, 0x63, 0x3D, 0x01, 0x01, 0x01, 0x01, 0xBC, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x3C, 0x46, 0xC2, 0xC0, 0x60, 0x30, 0x0C, 0x02, 0x03, 0x83, 0x42,
  0x3C, 0x20, 0x82, 0x3E, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xC1,
  0xC0, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0F, 0x3B, 0xD0,
  0x83, 0x82, 0xC2, 0x42, 0x44, 0x44, 0x24, 0x2C, 0x28, 0x38, 0x18, 0x10,
  0x82, 0x14, 0x30, 0xB1, 0x84, 0x8E, 0x24, 0xD2, 0x24, 0x91, 0x24, 0x85,
  0x14, 0x38, 0xE1, 0x86, 0x0C, 0x30, 0x60, 0x80, 0x82, 0x46, 0x44, 0x2C,
  0x38, 0x18, 0x18, 0x28, 0x24, 0x44, 0xC2, 0x83, 0x41, 0xA0, 0x98, 0x44,
  0x62, 0x21, 0x10, 0x48, 0x28, 0x14, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x40, 0xC0, 0xFE, 0x02, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x20, 0x20, 0x40,
  0xC0, 0xFF, 0x08, 0x8C, 0x42, 0x10, 0x84, 0x22, 0x30, 0xC2, 0x10, 0x84,
  0x21, 0x0C, 0x20, 0x80, 0xFF, 0xFF, 0xE0, 0xC1, 0x82, 0x0C, 0x30, 0xC3,
  0x0C, 0x10, 0x60, 0xC4, 0x10, 0xC3, 0x0C, 0x30, 0xC2, 0x18, 0xC0, 0x38,
  0x29, 0x89, 0x19, 0x21, 0xC0,
};

const GFXglyph RobotoCondensed_Light22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 16, 5, 2, -16 },
  { 3, 3, 5, 6, 2, -17 },
  { 5, 10, 16, 11, 1, -16 },
  { 25, 8, 20, 11, 1, -18 },
  { 45, 12, 16, 14, 1, -16 },
  { 69, 10, 16, 12, 1, -16 },
  { 89, 1, 5, 4, 1, -17 },
  { 90, 5, 23, 6, 1, -18 },
  { 105, 4, 23, 7, 1, -18 },
  { 117, 9, 9, 9, 0, -16 },
  { 128, 9, 11, 11, 1, -13 },
  { 141, 2, 5, 4, 1, -2 },
  { 143, 4, 1, 6, 1, -7 },
  { 144, 1, 2, 5, 2, -2 },
  { 145, 7, 17, 8, 0, -16 },
  { 160, 8, 16, 11, 1, -16 },
  { 176, 5, 16, 11, 2, -16 },
  { 186, 9, 16, 11, 1, -16 },
  { 204, 8, 16, 11, 1, -16 },
  { 220, 9, 16, 11, 1, -16 },
  { 238, 8, 16, 11, 2, -16 },
  { 254, 9, 16, 11, 1, -16 },
  { 272, 9, 16, 11, 1, -16 },
  { 290, 9, 16, 11, 1, -16 },
  { 308, 8, 16, 11, 1, -16 },
  { 324, 2, 12, 4, 1, -12 },
  { 327, 2, 15, 4, 1, -12 },
  { 331, 7, 10, 10, 1, -12 },
  { 340, 7, 5, 11, 2, -10 },
  { 345, 8, 10, 10, 1, -12 },
  { 355, 7, 16, 9, 1, -16 },
  { 369, 15, 20, 17, 1, -15 },
  { 407, 12, 16, 12, 0, -16 },
  { 431, 9, 16, 12, 2, -16 },
  { 449, 10, 16, 12, 1, -16 },
  { 469, 9, 16, 13, 2, -16 },
  { 487, 8, 16, 11, 2, -16 },
  { 503, 8, 16, 11, 2, -16 },
  { 519, 9, 16, 13, 2, -16 },
  { 537, 10, 16, 14, 2, -16 },
  { 557, 1, 16, 5, 2, -16 },
  { 559, 8, 16, 11, 1, -16 },
  { 575, 10, 16, 12, 2, -16 },
  { 595, 8, 16, 10, 2, -16 },
  { 611, 13, 16, 16, 2, -16 },
  { 637, 10, 16, 14, 2, -16 },
  { 657, 11, 16, 13, 1, -16 },
  { 679, 9, 16, 12, 2, -16 },
  { 697, 11, 19, 13, 1, -16 },
  { 724, 9, 16, 12, 2, -16 },
  { 742, 9, 16, 11, 1, -16 },
  { 760, 10, 16, 11, 1, -16 },
  { 780, 9, 16, 13, 2, -16 },
  { 798, 11, 16, 12, 0, -16 },
  { 820, 15, 16, 17, 1, -16 },
  { 850, 10, 16, 12, 1, -16 },
  { 870, 11, 16, 12, 0, -16 },
  { 892, 10, 16, 12, 1, -16 },
  { 912, 3, 21, 5, 2, -18 },
  { 920, 6, 17, 8, 1, -16 },
  { 933, 3, 21, 5, 0, -18 },
  { 941, 6, 8, 8, 1, -16 },
  { 947, 8, 1, 8, 0, 0 },
  { 948, 4, 3, 6, 1, -17 },
  { 950, 8, 12, 10, 1, -12 },
  { 962, 8, 17, 11, 2, -17 },
  { 979, 8, 12, 10, 1, -12 },
  { 991, 8, 17, 11, 1, -17 },
  { 1008, 8, 12, 10, 1, -12 },
  { 1020, 5, 17, 7, 1, -17 },
  { 1031, 8, 16, 11, 1, -12 },
  { 1047, 7, 17, 11, 2, -17 },
  { 1062, 1, 17, 5, 2, -17 },
  { 1065, 4, 21, 5, -1, -17 },
  { 1076, 7, 17, 10, 2, -17 },
  { 1091, 1, 17, 5, 2, -17 },
  { 1094, 13, 12, 17, 2, -12 },
  { 1114, 7, 12, 11, 2, -12 },
  { 1125, 9, 12, 11, 1, -12 },
  { 1139, 8, 16, 11, 2, -12 },
  { 1155, 8, 16, 11, 1, -12 },
  { 1171, 4, 12, 7, 2, -12 },
  { 1177, 8, 12, 10, 1, -12 },
  { 1189, 6, 15, 6, 0, -15 },
  { 1201, 7, 12, 11, 2, -12 },
  { 1212, 8, 12, 9, 1, -12 },
  { 1224, 13, 12, 14, 1, -12 },
  { 1244, 8, 12, 9, 1, -12 },
  { 1256, 9, 16, 9, 0, -12 },
  { 1274, 8, 12, 9, 1, -12 },
  { 1286, 5, 21, 7, 1, -17 },
  { 1300, 1, 19, 5, 2, -16 },
  { 1303, 6, 21, 7, 0, -17 },
  { 1319, 11, 4, 13, 1, -9 },
};

const GFXfont RobotoCondensed_Light22pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light22pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOCONDENSED_LIGHT22PT7B_H_
