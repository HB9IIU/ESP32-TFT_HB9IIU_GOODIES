#ifndef _ROBOTOCONDENSED_LIGHT34PT7B_H_
#define _ROBOTOCONDENSED_LIGHT34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light34pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x00, 0xFB, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0x02, 0x08, 0x04, 0x30, 0x18, 0x60, 0x30, 0xC0,
  0x61, 0x00, 0xC2, 0x1F, 0xFF, 0xBF, 0xFF, 0x04, 0x30, 0x18, 0x60, 0x30,
  0x80, 0x61, 0x00, 0x82, 0x01, 0x0C, 0x02, 0x18, 0x0C, 0x30, 0xFF, 0xFD,
  0xFF, 0xF8, 0x41, 0x00, 0x82, 0x01, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x18,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x1F, 0x03, 0xFE, 0x18, 0x31, 0x80,
  0xCC, 0x06, 0x60, 0x13, 0x00, 0x98, 0x00, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xCC, 0x06, 0x70, 0x71, 0xFF, 0x03, 0xE0, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0C, 0x20, 0x03, 0x0C, 0x10, 0x83,
  0x0C, 0x20, 0xC2, 0x08, 0x31, 0x83, 0x0C, 0x40, 0xC2, 0x30, 0x1F, 0x88,
  0x03, 0xC6, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x63, 0xC0, 0x11, 0xF8,
  0x0C, 0xC3, 0x02, 0x30, 0xC1, 0x88, 0x30, 0x42, 0x04, 0x30, 0x83, 0x18,
  0x30, 0xC2, 0x0C, 0x30, 0x01, 0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x1F, 0xC0,
  0x30, 0xC0, 0x30, 0x60, 0x30, 0x60, 0x20, 0x60, 0x30, 0x40, 0x30, 0xC0,
  0x31, 0x80, 0x1B, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x73, 0x06,
  0x61, 0x84, 0xC1, 0x84, 0xC0, 0xCC, 0xC0, 0x6C, 0xC0, 0x7C, 0xC0, 0x38,
  0xC0, 0x38, 0x60, 0x7C, 0x3F, 0xCE, 0x1F, 0x86, 0xFF, 0xFC, 0x02, 0x0C,
  0x30, 0x41, 0x82, 0x0C, 0x18, 0x20, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x10, 0x30, 0x60, 0xC0, 0x81, 0x83, 0x02,
  0x06, 0x04, 0x0C, 0x0C, 0x08, 0x81, 0x81, 0x83, 0x03, 0x06, 0x06, 0x0C,
  0x08, 0x18, 0x30, 0x60, 0xC0, 0x81, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0x83, 0x06, 0x0C, 0x18, 0x20, 0xC1, 0x82, 0x0C, 0x10, 0x61, 0x82, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x41, 0x05, 0xE4, 0xF3, 0xFF,
  0x01, 0xF0, 0x07, 0x80, 0x1B, 0x00, 0xCC, 0x06, 0x18, 0x18, 0x30, 0x40,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x33, 0x36, 0x66,
  0xC4, 0xFF, 0xFC, 0x7D, 0x80, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x00,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x80,
  0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0xC0,
  0x30, 0x00, 0x0F, 0x81, 0xFE, 0x0C, 0x18, 0xC0, 0xC6, 0x03, 0x60, 0x1B,
  0x00, 0xD8, 0x02, 0xC0, 0x16, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x02, 0xC0, 0x16, 0x01, 0xB0, 0x0C, 0xC0, 0x66, 0x06,
  0x18, 0x30, 0xFF, 0x01, 0xF0, 0x02, 0x3D, 0xFF, 0x38, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x0F, 0x81, 0xFE, 0x1C, 0x38, 0xC0, 0xEC, 0x03, 0x60, 0x1B,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x30, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0x83, 0xFC, 0x70, 0x66, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0xFC, 0x0F,
  0xC0, 0x0E, 0x00, 0x30, 0x03, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xE0,
  0x37, 0x06, 0x3F, 0xC0, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x05,
  0x80, 0x1B, 0x00, 0x26, 0x00, 0xCC, 0x03, 0x18, 0x06, 0x30, 0x18, 0x60,
  0x30, 0xC0, 0xC1, 0x81, 0x83, 0x06, 0x06, 0x08, 0x0C, 0x30, 0x18, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x7F, 0xF7, 0xFF, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x04, 0x00, 0x4F, 0x0F, 0xFC, 0xE0, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x66, 0x0E, 0x3F,
  0xC1, 0xF0, 0x01, 0xC0, 0x3E, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x47, 0x86, 0xFF, 0x3C, 0x19, 0xC0, 0x6C, 0x03, 0x60,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xD0, 0x06, 0xC0, 0x66, 0x03,
  0x18, 0x30, 0x7F, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x0F,
  0x81, 0xFE, 0x1C, 0x18, 0xC0, 0x66, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06,
  0x40, 0x33, 0x01, 0x8C, 0x18, 0x3F, 0x81, 0xFC, 0x38, 0x71, 0x80, 0xD8,
  0x06, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0x38, 0x38, 0xFF,
  0x83, 0xF0, 0x0F, 0x03, 0xFC, 0x70, 0xE6, 0x06, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x60, 0x77, 0x0F, 0x3F,
  0xB1, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x1C, 0x1F,
  0x01, 0xC0, 0x7D, 0x80, 0x00, 0x00, 0x00, 0x02, 0xFC, 0x27, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x33, 0x26, 0x6C, 0x40, 0x00, 0x10, 0x07,
  0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x07, 0x01, 0xE0, 0x78, 0x1E,
  0x07, 0x80, 0xE0, 0x08, 0x00, 0x0F, 0x07, 0xF9, 0xC3, 0x30, 0x36, 0x07,
  0x80, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x03,
  0x80, 0x30, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x1C, 0x03, 0x80, 0x70,
  0x01, 0x81, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x18, 0x1E,
  0x06, 0x60, 0x7F, 0x04, 0xC1, 0x86, 0x09, 0x02, 0x0C, 0x1A, 0x0C, 0x18,
  0x3C, 0x18, 0x30, 0x78, 0x20, 0x60, 0xF0, 0xC0, 0xC1, 0xE1, 0x81, 0x83,
  0xC3, 0x02, 0x07, 0x86, 0x04, 0x0B, 0x0C, 0x08, 0x16, 0x18, 0x30, 0x2C,
  0x30, 0x60, 0xD8, 0x31, 0xE1, 0x10, 0x7E, 0x6C, 0x20, 0x78, 0xF0, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x20, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x68, 0x00, 0x36, 0x00, 0x13, 0x00, 0x18,
  0x80, 0x0C, 0x60, 0x06, 0x30, 0x06, 0x18, 0x03, 0x06, 0x01, 0x83, 0x01,
  0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x7F, 0xF8, 0x3F, 0xFC, 0x18, 0x03,
  0x08, 0x01, 0x8C, 0x00, 0x46, 0x00, 0x33, 0x00, 0x1B, 0x00, 0x0D, 0x80,
  0x03, 0xFF, 0x87, 0xFF, 0x30, 0x1D, 0x80, 0x6C, 0x01, 0x60, 0x0F, 0x00,
  0x78, 0x06, 0xC0, 0x36, 0x03, 0x3F, 0xF1, 0xFF, 0xCC, 0x07, 0x60, 0x1B,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x3B, 0xFF, 0x9F, 0xF8, 0x07, 0xE0, 0x3F, 0xF0, 0xE0, 0x71, 0x80, 0x66,
  0x00, 0x6C, 0x00, 0xD0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x06,
  0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x33, 0x00, 0xC7, 0x03, 0x87, 0xFE, 0x03,
  0xF0, 0xFF, 0x83, 0xFF, 0x8C, 0x07, 0x30, 0x0E, 0xC0, 0x1B, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x06,
  0xC0, 0x3B, 0x01, 0xCF, 0xFE, 0x3F, 0xE0, 0xFF, 0xF7, 0xFF, 0xB0, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0xFF, 0xCF, 0xFE, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0F, 0xFE, 0xFF, 0xEC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0xE0,
  0x1F, 0xF8, 0x38, 0x1C, 0x30, 0x0E, 0x60, 0x06, 0x60, 0x06, 0x60, 0x03,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x03, 0x60, 0x03,
  0x60, 0x03, 0x30, 0x07, 0x18, 0x0E, 0x0F, 0xFC, 0x03, 0xF0, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x1E, 0x00, 0xF0, 0x04, 0xC0, 0x66, 0x03, 0x38,
  0x30, 0xFF, 0x01, 0xF0, 0xC0, 0x0D, 0x80, 0x33, 0x00, 0xC6, 0x03, 0x8C,
  0x0E, 0x18, 0x18, 0x30, 0x60, 0x61, 0x80, 0xC7, 0x01, 0x9C, 0x03, 0x30,
  0x06, 0xE0, 0x0F, 0x60, 0x1C, 0xE0, 0x38, 0xC0, 0x60, 0xC0, 0xC0, 0xC1,
  0x81, 0xC3, 0x01, 0x86, 0x01, 0x8C, 0x03, 0x98, 0x03, 0x30, 0x03, 0x60,
  0x07, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x01, 0xBF, 0x00, 0x1B, 0xD8, 0x01, 0xBD, 0x80, 0x33, 0xD8, 0x03, 0x3C,
  0xC0, 0x33, 0xCC, 0x06, 0x3C, 0x40, 0x63, 0xC6, 0x06, 0x3C, 0x60, 0xC3,
  0xC2, 0x0C, 0x3C, 0x30, 0x83, 0xC3, 0x18, 0x3C, 0x11, 0x83, 0xC1, 0x90,
  0x3C, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0xC0, 0xE0, 0x3C, 0x06,
  0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7B, 0x00,
  0xF6, 0x01, 0xE6, 0x03, 0xC6, 0x07, 0x8C, 0x0F, 0x0C, 0x1E, 0x18, 0x3C,
  0x18, 0x78, 0x30, 0xF0, 0x31, 0xE0, 0x63, 0xC0, 0x67, 0x80, 0x6F, 0x00,
  0xDE, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0x07, 0xE0,
  0x1F, 0xF8, 0x38, 0x1C, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x06,
  0x60, 0x06, 0x30, 0x0E, 0x38, 0x1C, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xC3,
  0xFF, 0xCC, 0x03, 0x30, 0x06, 0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x6C, 0x01, 0xB0, 0x0E, 0xFF, 0xF3, 0xFF, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x38, 0x1C, 0x70, 0x0C,
  0x60, 0x06, 0x60, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x70, 0x0C, 0x38, 0x1C,
  0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x02,
  0xFF, 0x83, 0xFF, 0x8C, 0x07, 0x30, 0x0E, 0xC0, 0x1B, 0x00, 0x6C, 0x01,
  0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x03, 0xB0, 0x1C, 0xFF, 0xE3, 0xFE,
  0x0C, 0x0C, 0x30, 0x30, 0xC0, 0x63, 0x01, 0x8C, 0x03, 0x30, 0x0C, 0xC0,
  0x1B, 0x00, 0x6C, 0x00, 0xF0, 0x03, 0x0F, 0xC0, 0xFF, 0xC7, 0x03, 0x98,
  0x06, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x1D, 0xC0, 0xE3, 0xFF, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0,
  0x19, 0xC0, 0xE3, 0xFF, 0x03, 0xF0, 0xC0, 0x03, 0x60, 0x01, 0x98, 0x00,
  0xCC, 0x00, 0x66, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x18, 0x30,
  0x0C, 0x0C, 0x06, 0x06, 0x06, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x60, 0x80,
  0x30, 0xC0, 0x08, 0x60, 0x06, 0x20, 0x03, 0x30, 0x00, 0x98, 0x00, 0x6C,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0xC0, 0x18, 0x03,
  0x40, 0x18, 0x03, 0x60, 0x1C, 0x03, 0x60, 0x1C, 0x02, 0x60, 0x34, 0x06,
  0x60, 0x34, 0x06, 0x20, 0x26, 0x06, 0x30, 0x26, 0x06, 0x30, 0x66, 0x0C,
  0x30, 0x62, 0x0C, 0x30, 0x43, 0x0C, 0x18, 0x43, 0x0C, 0x18, 0xC3, 0x0C,
  0x18, 0xC1, 0x18, 0x18, 0xC1, 0x98, 0x08, 0x81, 0x98, 0x0D, 0x81, 0x98,
  0x0D, 0x80, 0x90, 0x0D, 0x80, 0xF0, 0x0D, 0x00, 0xF0, 0x07, 0x00, 0xF0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x60, 0x07, 0x60,
  0x06, 0x30, 0x0E, 0x30, 0x0C, 0x18, 0x18, 0x1C, 0x18, 0x0C, 0x30, 0x06,
  0x30, 0x06, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x03,
  0xC0, 0x07, 0x60, 0x06, 0x60, 0x0E, 0x30, 0x0C, 0x30, 0x18, 0x18, 0x18,
  0x1C, 0x30, 0x0C, 0x30, 0x0E, 0x60, 0x06, 0xE0, 0x03, 0xC0, 0x03, 0xE0,
  0x06, 0x60, 0x06, 0x60, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x18, 0x18, 0x18,
  0x30, 0x0C, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x06, 0x60, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xF0, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C,
  0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60,
  0x18, 0x02, 0x00, 0xC0, 0x30, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x7F, 0xF8, 0x0C, 0x03, 0x00, 0xE0, 0x78, 0x1A, 0x04, 0xC3, 0x30, 0xC6,
  0x21, 0x98, 0x66, 0x0D, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xC3, 0x0C, 0x61,
  0x80, 0x1F, 0x83, 0xFC, 0x60, 0x6C, 0x06, 0xC0, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x1F, 0xE7, 0xFE, 0x60, 0x2C, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x6E,
  0x0F, 0x7F, 0xB3, 0xE3, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC7, 0x86, 0xFF, 0x3C, 0x1D, 0xC0, 0x6C,
  0x03, 0x60, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1B, 0x80, 0xDE, 0x0E, 0xDF, 0xE6, 0x3C, 0x00, 0x1F,
  0x83, 0xFC, 0x60, 0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x3C, 0x03, 0xC0, 0x26, 0x06, 0x3F,
  0xC1, 0xF8, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x1F, 0x33, 0xFB, 0x70, 0x76, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x60,
  0x37, 0x07, 0x3F, 0xB1, 0xF3, 0x0F, 0x83, 0xFC, 0x70, 0x6E, 0x06, 0xC0,
  0x3C, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xE0, 0x07, 0x07, 0x3F, 0xE0, 0xF8, 0x07, 0x87, 0xC7, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0xFF, 0x7F, 0x86, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x00, 0x1F, 0x33, 0xFB, 0x70, 0x7E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x60,
  0x37, 0x07, 0x3F, 0xB1, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x34, 0x03, 0x60,
  0x63, 0xFC, 0x0F, 0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC7, 0x8C, 0xFE, 0xD0, 0x6E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x5D, 0x80, 0x03, 0x6D, 0xB6,
  0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x08, 0x70, 0xC0, 0x00, 0x00, 0x02, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x18, 0x6F, 0xBC, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x6C, 0x0C, 0xC1, 0xCC, 0x18, 0xC3,
  0x0C, 0x60, 0xCC, 0x0D, 0x80, 0xFC, 0x0F, 0x60, 0xE6, 0x0C, 0x30, 0xC1,
  0x8C, 0x18, 0xC0, 0xCC, 0x0E, 0xC0, 0x6C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xC7, 0x83, 0xE3, 0x7F, 0x9F, 0xCD, 0x06, 0xC3, 0xB8,
  0x0E, 0x06, 0xE0, 0x30, 0x0B, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C,
  0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03,
  0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0,
  0x30, 0x0F, 0x00, 0xC0, 0x30, 0xC7, 0x8C, 0xFE, 0xD0, 0x6E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x0F, 0x81, 0xFF, 0x1C,
  0x18, 0xC0, 0x6C, 0x03, 0x60, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x19, 0x80, 0xCE, 0x0C, 0x3F, 0xE0,
  0x7C, 0x00, 0xC7, 0x86, 0xFF, 0x3C, 0x1D, 0xC0, 0x6C, 0x03, 0x60, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1B, 0x80, 0xDE, 0x0E, 0xDF, 0xE6, 0x7C, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x1F, 0x33, 0xFB, 0x70, 0x7E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x60, 0x36, 0x07, 0x3F, 0xF1, 0xF3, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0xCF, 0xDF, 0xD0,
  0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x1F, 0x07, 0xF9, 0x83, 0xE0, 0x3C, 0x07, 0x80, 0x18,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x30, 0x07, 0x80, 0xF0, 0x1B,
  0x07, 0x7F, 0xC3, 0xF0, 0x30, 0x30, 0x30, 0x30, 0x30, 0xFE, 0xFE, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x18, 0x1E, 0x0F, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x34, 0x03,
  0x60, 0x77, 0x0F, 0x3F, 0xB1, 0xF3, 0xC0, 0x36, 0x01, 0x90, 0x0C, 0xC0,
  0x46, 0x06, 0x10, 0x30, 0xC1, 0x86, 0x18, 0x10, 0xC0, 0xC6, 0x06, 0x20,
  0x33, 0x00, 0x98, 0x06, 0x80, 0x3C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x60, 0x34, 0x06, 0x03, 0x60, 0x60, 0x66, 0x0F, 0x06, 0x60, 0xF0,
  0x66, 0x09, 0x06, 0x30, 0x98, 0x43, 0x19, 0x8C, 0x31, 0x98, 0xC3, 0x10,
  0x8C, 0x13, 0x0C, 0x81, 0xB0, 0xD8, 0x1B, 0x0D, 0x81, 0xA0, 0x58, 0x0E,
  0x07, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0xE0, 0x33, 0x03,
  0x8C, 0x18, 0x61, 0x81, 0x8C, 0x0C, 0xC0, 0x36, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1B, 0x01, 0x98, 0x0C, 0x60, 0xC1, 0x8E, 0x0C, 0x60,
  0x36, 0x01, 0x80, 0xC0, 0x36, 0x01, 0x98, 0x0C, 0xC0, 0xC6, 0x06, 0x10,
  0x30, 0xC1, 0x86, 0x18, 0x30, 0xC0, 0xC6, 0x06, 0x60, 0x33, 0x00, 0xD8,
  0x06, 0x80, 0x3C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x60, 0x0F, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0x01, 0x81,
  0x81, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x60, 0xF0, 0x70, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x01, 0x00, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x30, 0x0C, 0x03, 0x01,
  0x80, 0x40, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x0C, 0x03, 0x81, 0xC1, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x60, 0x70, 0x20, 0x00, 0x1C, 0x03,
  0x3F, 0x03, 0x63, 0x82, 0x41, 0xC6, 0xC0, 0xFC, 0xC0, 0x38,
};

const GFXglyph RobotoCondensed_Light34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 24, 7, 2, -24 },
  { 10, 6, 8, 10, 2, -26 },
  { 16, 15, 24, 17, 2, -24 },
  { 61, 13, 30, 17, 2, -27 },
  { 110, 18, 24, 22, 2, -24 },
  { 164, 16, 24, 18, 2, -24 },
  { 212, 2, 7, 6, 2, -26 },
  { 214, 7, 35, 10, 2, -27 },
  { 245, 7, 35, 10, 1, -27 },
  { 276, 14, 14, 14, 0, -24 },
  { 301, 14, 18, 17, 1, -20 },
  { 333, 4, 8, 7, 1, -3 },
  { 337, 7, 2, 9, 1, -12 },
  { 339, 3, 3, 8, 2, -3 },
  { 341, 10, 26, 12, 1, -24 },
  { 374, 13, 24, 17, 2, -24 },
  { 413, 7, 24, 17, 3, -24 },
  { 434, 13, 24, 17, 2, -24 },
  { 473, 12, 24, 17, 2, -24 },
  { 509, 15, 24, 17, 1, -24 },
  { 554, 12, 24, 17, 3, -24 },
  { 590, 13, 24, 17, 2, -24 },
  { 629, 14, 24, 17, 1, -24 },
  { 671, 13, 24, 17, 2, -24 },
  { 710, 12, 24, 17, 2, -24 },
  { 746, 3, 18, 7, 2, -18 },
  { 753, 4, 23, 6, 1, -18 },
  { 765, 12, 14, 15, 1, -18 },
  { 786, 12, 9, 16, 2, -16 },
  { 800, 12, 14, 16, 2, -18 },
  { 821, 11, 24, 14, 1, -24 },
  { 854, 23, 32, 27, 2, -24 },
  { 946, 17, 24, 19, 1, -24 },
  { 997, 13, 24, 18, 3, -24 },
  { 1036, 15, 24, 19, 2, -24 },
  { 1081, 14, 24, 19, 3, -24 },
  { 1123, 13, 24, 17, 3, -24 },
  { 1162, 12, 24, 17, 3, -24 },
  { 1198, 16, 24, 20, 2, -24 },
  { 1246, 15, 24, 21, 3, -24 },
  { 1291, 2, 24, 8, 3, -24 },
  { 1297, 13, 24, 16, 1, -24 },
  { 1336, 15, 24, 19, 3, -24 },
  { 1381, 12, 24, 16, 3, -24 },
  { 1417, 20, 24, 25, 3, -24 },
  { 1477, 15, 24, 21, 3, -24 },
  { 1522, 16, 24, 20, 2, -24 },
  { 1570, 14, 24, 18, 3, -24 },
  { 1612, 16, 28, 20, 2, -24 },
  { 1668, 14, 24, 19, 3, -24 },
  { 1710, 14, 24, 18, 2, -24 },
  { 1752, 16, 24, 18, 1, -24 },
  { 1800, 14, 24, 19, 3, -24 },
  { 1842, 17, 24, 18, 1, -24 },
  { 1893, 24, 24, 26, 1, -24 },
  { 1965, 16, 24, 18, 1, -24 },
  { 2013, 16, 24, 18, 1, -24 },
  { 2061, 14, 24, 18, 2, -24 },
  { 2103, 4, 33, 8, 3, -28 },
  { 2120, 10, 26, 12, 1, -24 },
  { 2153, 5, 33, 8, 0, -28 },
  { 2174, 10, 12, 13, 1, -24 },
  { 2189, 13, 2, 13, 0, 0 },
  { 2193, 5, 5, 10, 2, -26 },
  { 2197, 12, 18, 16, 2, -18 },
  { 2224, 13, 26, 17, 2, -26 },
  { 2267, 12, 18, 15, 2, -18 },
  { 2294, 12, 26, 17, 2, -26 },
  { 2333, 12, 18, 16, 2, -18 },
  { 2360, 9, 26, 10, 1, -26 },
  { 2390, 12, 25, 17, 2, -18 },
  { 2428, 12, 26, 16, 2, -26 },
  { 2467, 3, 25, 7, 2, -25 },
  { 2477, 6, 32, 7, -1, -25 },
  { 2501, 12, 26, 15, 2, -26 },
  { 2540, 2, 26, 7, 3, -26 },
  { 2547, 22, 18, 26, 2, -18 },
  { 2597, 12, 18, 16, 2, -18 },
  { 2624, 13, 18, 17, 2, -18 },
  { 2654, 13, 25, 17, 2, -18 },
  { 2695, 12, 25, 17, 2, -18 },
  { 2733, 8, 18, 10, 2, -18 },
  { 2751, 11, 18, 15, 2, -18 },
  { 2776, 8, 23, 10, 1, -23 },
  { 2799, 12, 18, 16, 2, -18 },
  { 2826, 13, 18, 14, 1, -18 },
  { 2856, 20, 18, 22, 1, -18 },
  { 2901, 13, 18, 15, 1, -18 },
  { 2931, 13, 25, 14, 1, -18 },
  { 2972, 11, 18, 15, 2, -18 },
  { 2997, 9, 34, 10, 1, -27 },
  { 3036, 2, 28, 8, 3, -24 },
  { 3043, 9, 34, 10, 0, -27 },
  { 3082, 16, 6, 20, 2, -13 },
};

const GFXfont RobotoCondensed_Light34pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light34pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light34pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOCONDENSED_LIGHT34PT7B_H_
