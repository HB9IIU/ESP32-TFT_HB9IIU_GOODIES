#ifndef _ROBOTOCONDENSED_LIGHT51PT7B_H_
#define _ROBOTOCONDENSED_LIGHT51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0xC3, 0xC3, 0xC3, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7,
  0xC7, 0xC6, 0x00, 0x30, 0x38, 0x00, 0x30, 0x38, 0x00, 0x70, 0x30, 0x00,
  0x70, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x70, 0x00,
  0x60, 0x70, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0x60, 0x00, 0xC0, 0x60, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0xC0, 0x01,
  0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x81, 0xC0, 0x01,
  0x81, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x81, 0x80, 0x03, 0x01, 0x80, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x03, 0x03, 0x80, 0x03, 0x03, 0x00, 0x07,
  0x03, 0x00, 0x07, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06,
  0x07, 0x00, 0x06, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x1E, 0x07, 0x87,
  0x00, 0x70, 0xE0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x01, 0xDC,
  0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xB8, 0x00, 0xE7, 0x80, 0x3C, 0x78, 0x0F, 0x07, 0xFF, 0xC0, 0x7F,
  0xF0, 0x03, 0xF8, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x80, 0xE0, 0x30,
  0x30, 0x0C, 0x06, 0x06, 0x01, 0x81, 0x80, 0xC0, 0x30, 0x70, 0x18, 0x06,
  0x0C, 0x03, 0x01, 0xC3, 0x80, 0x60, 0x38, 0x60, 0x0E, 0x06, 0x1C, 0x00,
  0xC1, 0xC3, 0x00, 0x1C, 0x70, 0xE0, 0x01, 0xFE, 0x18, 0x00, 0x1F, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x0F, 0x00,
  0x01, 0x87, 0xF8, 0x00, 0x71, 0xE7, 0x80, 0x0C, 0x30, 0x30, 0x03, 0x8E,
  0x07, 0x00, 0x61, 0x80, 0x60, 0x18, 0x30, 0x0C, 0x03, 0x06, 0x01, 0x80,
  0xC0, 0xC0, 0x30, 0x38, 0x18, 0x06, 0x06, 0x03, 0x00, 0xC1, 0xC0, 0x60,
  0x18, 0x30, 0x0E, 0x07, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0xF0, 0x70, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x38, 0x00, 0xE0, 0x70, 0x01, 0xC1, 0xC0, 0x01, 0xC7, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0xE7, 0x00, 0x03, 0x87, 0x01, 0xCF, 0x0F, 0x03, 0x9C, 0x0F, 0x07,
  0x70, 0x0E, 0x0E, 0xE0, 0x0E, 0x19, 0xC0, 0x1E, 0x33, 0x80, 0x1C, 0xE7,
  0x00, 0x1D, 0xCE, 0x00, 0x1F, 0x1C, 0x00, 0x3E, 0x38, 0x00, 0x38, 0x38,
  0x00, 0xF8, 0x78, 0x03, 0xF8, 0x7C, 0x1F, 0x78, 0x7F, 0xF8, 0x70, 0x3F,
  0xE0, 0x70, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xF6, 0xDB, 0x00, 0x00, 0x40,
  0x18, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x04, 0x40,
  0x38, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80,
  0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38,
  0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38,
  0x0C, 0x06, 0x03, 0x80, 0x40, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x60, 0x2F,
  0x86, 0x1F, 0xFF, 0x6F, 0xF1, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0x00,
  0x01, 0xF8, 0x00, 0x3B, 0x80, 0x07, 0x1C, 0x00, 0x70, 0xE0, 0x0E, 0x07,
  0x01, 0xC0, 0x78, 0x1C, 0x03, 0x80, 0x80, 0x10, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x39, 0xCE, 0x73, 0x9D, 0xCE,
  0x77, 0x38, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xEF, 0xFE, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x0E, 0x07, 0x83, 0x80, 0x38,
  0xF0, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x0E, 0x60, 0x01, 0xDC, 0x00, 0x1B,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0x30, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x8E,
  0x00, 0xE1, 0xC0, 0x1C, 0x1C, 0x0F, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x01,
  0xF8, 0x00, 0x00, 0x20, 0x3C, 0x1F, 0x8F, 0xFF, 0xEF, 0xF1, 0xF0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x03,
  0xC0, 0xF0, 0x78, 0x03, 0x87, 0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00, 0x1C,
  0xE0, 0x01, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0,
  0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1E, 0x03, 0x87, 0x80, 0x38, 0xE0, 0x07,
  0x38, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x78,
  0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0D, 0xC0, 0x03, 0xBC, 0x00, 0x73,
  0x80, 0x1C, 0x3C, 0x07, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x6E, 0x00, 0x03, 0xB8, 0x00, 0x0C, 0xE0, 0x00, 0x73,
  0x80, 0x01, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80,
  0x0E, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x38,
  0x0E, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x0E,
  0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0xFC, 0x07, 0xFF,
  0xC1, 0xFF, 0xFC, 0x7C, 0x0F, 0x1C, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xD8, 0x00, 0x77, 0x00,
  0x39, 0xE0, 0x0E, 0x3C, 0x07, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xC0,
  0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x0F, 0x80, 0xC7, 0xFC, 0x1B, 0xFF, 0xC7,
  0x70, 0x3C, 0xF8, 0x03, 0xDF, 0x00, 0x3B, 0xC0, 0x07, 0x70, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1D, 0x80, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x03, 0x8E,
  0x00, 0x71, 0xE0, 0x1C, 0x1E, 0x07, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x00,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1E, 0x03, 0xC3, 0x80, 0x38, 0xE0, 0x03, 0x9C, 0x00,
  0x73, 0x80, 0x0E, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00,
  0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x00, 0xE0, 0xE0, 0x38, 0x0F, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0x07, 0x83, 0x80, 0x38, 0xE0, 0x03,
  0xB8, 0x00, 0x77, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x73, 0x80, 0x1E,
  0x3C, 0x07, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1E, 0x07, 0x87, 0x80, 0x78, 0xE0, 0x07,
  0x18, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x00, 0x03,
  0x60, 0x00, 0x6C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3D, 0xC0, 0x0F, 0xBC, 0x03, 0xE3, 0xC0, 0xEC,
  0x3F, 0xF9, 0x83, 0xFE, 0x30, 0x3F, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00,
  0x77, 0xFC, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0xF7, 0x9C, 0x3B, 0xDE, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x39, 0xCE, 0x73, 0xB9,
  0xDC, 0xE2, 0x00, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x38, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80,
  0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3C, 0x1E, 0x70, 0x0E, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x03, 0xE0, 0x06, 0x30, 0x03, 0xFE,
  0x01, 0x8C, 0x01, 0xE3, 0xC0, 0x67, 0x00, 0xE0, 0x30, 0x0D, 0x80, 0x38,
  0x0C, 0x03, 0x60, 0x1C, 0x03, 0x00, 0xD8, 0x06, 0x01, 0xC0, 0x3E, 0x03,
  0x80, 0x70, 0x0F, 0x80, 0xE0, 0x1C, 0x03, 0xC0, 0x30, 0x07, 0x00, 0xF0,
  0x0C, 0x01, 0x80, 0x3C, 0x07, 0x00, 0x60, 0x0F, 0x01, 0xC0, 0x18, 0x03,
  0xC0, 0x70, 0x06, 0x00, 0xF0, 0x1C, 0x01, 0x80, 0x3C, 0x07, 0x00, 0x60,
  0x1F, 0x01, 0xC0, 0x18, 0x06, 0xC0, 0x70, 0x0E, 0x01, 0xB8, 0x1C, 0x03,
  0x80, 0x6E, 0x03, 0x01, 0xE0, 0x31, 0x80, 0xE0, 0xD8, 0x1C, 0x60, 0x3C,
  0x77, 0x06, 0x18, 0x07, 0xF8, 0xFF, 0x07, 0x00, 0xFC, 0x1F, 0x80, 0xC0,
  0x08, 0x01, 0x00, 0x38, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x30, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x06,
  0x01, 0x80, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x01,
  0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0x38, 0x18, 0x00, 0x06, 0x0E, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8E, 0x00, 0x3C, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00,
  0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xCE, 0x00, 0x38, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8E, 0x00, 0x3C, 0xE0, 0x01, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0E, 0xE0, 0x03, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x78, 0x07,
  0x81, 0xE0, 0x03, 0x87, 0x80, 0x07, 0x8E, 0x00, 0x07, 0x3C, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x80, 0x01,
  0xC7, 0x00, 0x03, 0x8F, 0x00, 0x0F, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0xF0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x38, 0x01, 0xF0, 0xE0, 0x01, 0xE3, 0x80,
  0x03, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1E, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0xEE, 0x00, 0x01, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8,
  0x00, 0x0E, 0xE0, 0x00, 0x7B, 0x80, 0x01, 0xCE, 0x00, 0x0F, 0x38, 0x00,
  0x78, 0xE0, 0x07, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE,
  0x07, 0x80, 0x7C, 0x3C, 0x00, 0x71, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0x9C,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x70, 0x00, 0x0D,
  0xC0, 0x00, 0x33, 0x80, 0x01, 0xCF, 0x00, 0x0F, 0x1F, 0x00, 0xF8, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xC0, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x77, 0x00, 0x39, 0xE0, 0x1E, 0x3C, 0x0F, 0x07, 0xFF, 0xC0, 0xFF, 0xC0,
  0x0F, 0xC0, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0xF3, 0x80, 0x03, 0xC7, 0x00,
  0x07, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x78, 0x38, 0x01, 0xE0, 0x70, 0x07,
  0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0xF0, 0x07, 0x03, 0xC0,
  0x0E, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x70, 0x00, 0x71, 0xE0, 0x00,
  0xE7, 0xC0, 0x01, 0xDF, 0x80, 0x03, 0xBB, 0x80, 0x07, 0xE7, 0x80, 0x0F,
  0x87, 0x00, 0x1F, 0x07, 0x00, 0x3C, 0x0F, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x1C, 0x0E, 0x00,
  0x3C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x70, 0x00, 0x78, 0xE0, 0x00,
  0x79, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xF7, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFB, 0x80, 0x00,
  0x77, 0xEE, 0x00, 0x01, 0xDF, 0x98, 0x00, 0x07, 0x7E, 0x70, 0x00, 0x39,
  0xF9, 0xC0, 0x00, 0xE7, 0xE3, 0x00, 0x03, 0x1F, 0x8E, 0x00, 0x1C, 0x7E,
  0x38, 0x00, 0x71, 0xF8, 0x60, 0x01, 0x87, 0xE1, 0xC0, 0x0E, 0x1F, 0x87,
  0x00, 0x38, 0x7E, 0x0C, 0x00, 0xC1, 0xF8, 0x38, 0x07, 0x07, 0xE0, 0xE0,
  0x1C, 0x1F, 0x81, 0xC0, 0x60, 0x7E, 0x07, 0x03, 0x81, 0xF8, 0x0C, 0x0E,
  0x07, 0xE0, 0x38, 0x30, 0x1F, 0x80, 0xE1, 0xC0, 0x7E, 0x01, 0x87, 0x01,
  0xF8, 0x07, 0x38, 0x07, 0xE0, 0x1C, 0xE0, 0x1F, 0x80, 0x33, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0x80,
  0x1E, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xF8, 0x00, 0xC0, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFB, 0x80, 0x03, 0xF7, 0x00, 0x07, 0xE7, 0x00, 0x0F,
  0xC6, 0x00, 0x1F, 0x8E, 0x00, 0x3F, 0x0E, 0x00, 0x7E, 0x1C, 0x00, 0xFC,
  0x1C, 0x01, 0xF8, 0x38, 0x03, 0xF0, 0x38, 0x07, 0xE0, 0x70, 0x0F, 0xC0,
  0x70, 0x1F, 0x80, 0x70, 0x3F, 0x00, 0xE0, 0x7E, 0x00, 0xE0, 0xFC, 0x01,
  0xC1, 0xF8, 0x01, 0xC3, 0xF0, 0x03, 0x87, 0xE0, 0x03, 0x8F, 0xC0, 0x07,
  0x1F, 0x80, 0x07, 0x3F, 0x00, 0x07, 0x7E, 0x00, 0x0E, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x70, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0x00, 0xF8, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x0F, 0x00, 0xF8, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF1, 0xC0, 0x03, 0xCE, 0x00, 0x0F, 0x70, 0x00, 0x3B, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0E,
  0xE0, 0x00, 0xF7, 0x00, 0x0F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x1F, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x38,
  0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x3C,
  0x00, 0x3C, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x38, 0x00, 0xF0, 0xE0, 0x01,
  0xE3, 0x80, 0x03, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x33,
  0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x33, 0x80,
  0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x3C, 0xE0, 0x01, 0xE3, 0x80, 0x0F,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0x80, 0x38, 0x0E,
  0x00, 0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x0E, 0x0E, 0x00,
  0x38, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC0,
  0x78, 0x3C, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x07,
  0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00,
  0x73, 0x80, 0x03, 0xCF, 0x00, 0x1E, 0x1F, 0x00, 0xF0, 0x3F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1D, 0xC0, 0x01, 0xCF, 0x00,
  0x1E, 0x3C, 0x01, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xF8, 0x00,
  0xE0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x01, 0xC0,
  0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00,
  0x70, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x00,
  0x01, 0x83, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xE0,
  0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x0E,
  0x00, 0x06, 0xE0, 0x00, 0xF0, 0x00, 0xE6, 0x00, 0x0F, 0x00, 0x0E, 0x70,
  0x01, 0xF0, 0x00, 0xE7, 0x00, 0x1F, 0x00, 0x0E, 0x70, 0x01, 0xB8, 0x00,
  0xC7, 0x00, 0x1B, 0x80, 0x1C, 0x30, 0x03, 0x98, 0x01, 0xC3, 0x80, 0x39,
  0x80, 0x1C, 0x38, 0x03, 0x9C, 0x01, 0xC3, 0x80, 0x31, 0xC0, 0x18, 0x38,
  0x07, 0x0C, 0x03, 0x81, 0x80, 0x70, 0xC0, 0x38, 0x1C, 0x07, 0x0E, 0x03,
  0x81, 0xC0, 0x60, 0xE0, 0x30, 0x1C, 0x06, 0x06, 0x07, 0x00, 0xC0, 0xE0,
  0x60, 0x70, 0x0E, 0x0E, 0x07, 0x07, 0x00, 0xE0, 0xC0, 0x70, 0x70, 0x0E,
  0x0C, 0x03, 0x06, 0x00, 0xE1, 0xC0, 0x30, 0xE0, 0x06, 0x1C, 0x03, 0x8E,
  0x00, 0x71, 0x80, 0x38, 0xE0, 0x07, 0x18, 0x01, 0x8E, 0x00, 0x73, 0x80,
  0x18, 0xC0, 0x07, 0x38, 0x01, 0xDC, 0x00, 0x33, 0x00, 0x1D, 0xC0, 0x03,
  0x30, 0x00, 0xDC, 0x00, 0x3F, 0x00, 0x0D, 0x80, 0x03, 0xF0, 0x00, 0xD8,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x0E, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x07,
  0x01, 0xE0, 0x07, 0x81, 0xC0, 0x03, 0x83, 0xC0, 0x03, 0xC3, 0x80, 0x01,
  0xC7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xEF, 0x00, 0x01, 0xE7, 0x00, 0x01, 0xC7, 0x80, 0x03,
  0x83, 0x80, 0x03, 0x81, 0xC0, 0x07, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1E, 0x00, 0x70, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x38,
  0x00, 0x3C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xF0,
  0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x70,
  0x0E, 0x00, 0x78, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x1C,
  0x00, 0x38, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x73, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F,
  0xFF, 0xFE, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xD8, 0x03, 0xB8, 0x06, 0x70, 0x1C, 0x60, 0x38, 0xE0, 0x61, 0xC1,
  0xC1, 0x83, 0x83, 0x86, 0x07, 0x1C, 0x06, 0x38, 0x0E, 0x60, 0x1D, 0xC0,
  0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x70, 0x38, 0x3C,
  0x1C, 0x0E, 0x07, 0x03, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0xE0, 0x1C,
  0x70, 0x03, 0x98, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x0F, 0xFE, 0x1F, 0xFF, 0x8F, 0xE0, 0xE7, 0x80,
  0x39, 0xC0, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEC, 0x00, 0x3B, 0x00, 0x0E,
  0xC0, 0x03, 0xB8, 0x01, 0xEE, 0x00, 0xF9, 0xC0, 0x7E, 0x7F, 0xF9, 0x8F,
  0xFC, 0x70, 0xFC, 0x1C, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x0F, 0xE0, 0xC7, 0xFC, 0x33, 0xFF, 0xCD,
  0x80, 0xF3, 0xC0, 0x1E, 0xE0, 0x03, 0xB8, 0x00, 0x6C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x06, 0xE0, 0x03, 0xBC, 0x01, 0xED, 0x80, 0xF3, 0x7F,
  0xF8, 0xC7, 0xFC, 0x30, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0E, 0x03, 0xC3, 0x80, 0x1C, 0xF0, 0x03, 0x9C, 0x00, 0x33, 0x80,
  0x07, 0x70, 0x00, 0xEC, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0x70, 0x03, 0x8E, 0x00,
  0x70, 0xE0, 0x1C, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x1F, 0x87, 0x1F, 0xF9, 0xCF, 0xFF, 0x73, 0xC0, 0xFD, 0xC0, 0x0F, 0x70,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x70,
  0x01, 0xDC, 0x00, 0xF3, 0xC0, 0x7C, 0xFF, 0xF7, 0x0F, 0xF8, 0xC1, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0x03, 0xC3, 0x80,
  0x1C, 0x70, 0x03, 0x9C, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEC, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x30, 0xF0, 0x0F, 0x0F, 0xFF,
  0xC0, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x20, 0x0F, 0xC1, 0xFE, 0x0F,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x0F, 0xFF, 0x7F, 0xF8, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x07, 0xE0,
  0xC7, 0xFE, 0x73, 0xFF, 0xDC, 0xF0, 0x3F, 0x70, 0x03, 0xDC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xDC, 0x00, 0x77,
  0x00, 0x3C, 0xF0, 0x1F, 0x3F, 0xFD, 0xC3, 0xFE, 0x70, 0x7E, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x80, 0x07, 0x30, 0x03,
  0x9E, 0x01, 0xE3, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x3F, 0x0C,
  0x7F, 0xC6, 0x7F, 0xF3, 0x70, 0x3D, 0xB0, 0x0E, 0xF0, 0x03, 0x70, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1C, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x83, 0xC0,
  0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE7, 0xF7,
  0xF3, 0xE0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0xEC, 0x00, 0xE6, 0x00, 0xF3, 0x00, 0xF1, 0x80, 0xF0,
  0xC0, 0x70, 0x60, 0x70, 0x30, 0x70, 0x18, 0x78, 0x0C, 0x78, 0x06, 0x78,
  0x03, 0x38, 0x01, 0xBE, 0x00, 0xFF, 0x80, 0x79, 0xC0, 0x3C, 0x70, 0x1C,
  0x3C, 0x0C, 0x0E, 0x06, 0x03, 0x83, 0x01, 0xE1, 0x80, 0x70, 0xC0, 0x1C,
  0x60, 0x0F, 0x30, 0x03, 0x98, 0x00, 0xEC, 0x00, 0x76, 0x00, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xC1, 0xF0, 0x07, 0xE1, 0x8F, 0xF8, 0x3F, 0xF3, 0x3F, 0xF8,
  0xFF, 0xF6, 0xE0, 0x7B, 0x81, 0xEF, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0xF0, 0x03, 0xF0, 0x01, 0xC0, 0x07, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x18, 0xC1,
  0xF8, 0x63, 0xFE, 0x33, 0xFF, 0x9B, 0x81, 0xED, 0x80, 0x77, 0x80, 0x1B,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xE0, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1E, 0x03, 0xC7, 0x80, 0x3C, 0xE0, 0x03, 0xBC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x77, 0x00, 0x0E, 0xE0,
  0x03, 0x9E, 0x00, 0xF1, 0xE0, 0x3C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F,
  0xE0, 0x00, 0xC3, 0xF8, 0x31, 0xFF, 0x0D, 0xFF, 0xF3, 0x60, 0x3C, 0xF0,
  0x07, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xB8, 0x00, 0xEF, 0x00, 0x7B, 0x60, 0x3C, 0xDF, 0xFE, 0x33, 0xFF,
  0x0C, 0x3F, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0xC7, 0xFE, 0x73, 0xFF, 0xDC, 0xF0, 0x1F, 0x78,
  0x03, 0xDC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xDC, 0x00, 0x77, 0x00, 0x3C, 0xF0, 0x1F, 0x3F, 0xFF, 0xC7, 0xFE,
  0x70, 0x7F, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0xC3, 0xF1, 0xFC, 0xFF, 0x70, 0xF8, 0x3C, 0x0E, 0x03, 0x80,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00,
  0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x01, 0xE7, 0x00, 0x77, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0x60, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x1C, 0xF0, 0x1E, 0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xFE, 0xFF, 0xE0,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x7F, 0x03, 0xF0,
  0x1F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0xC0, 0x3E, 0xF0, 0x3F, 0x3F, 0xFB, 0x9F, 0xF9, 0xC3, 0xF0, 0x00, 0xE0,
  0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0xE3, 0x00, 0x1C, 0x70,
  0x03, 0x8E, 0x00, 0x60, 0xC0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x60, 0x30,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x60, 0x0C, 0x0C, 0x01, 0x83, 0x80, 0x38,
  0x70, 0x07, 0x0C, 0x00, 0x63, 0x80, 0x0E, 0x70, 0x01, 0xCC, 0x00, 0x1B,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8,
  0x01, 0xC0, 0x0E, 0xC0, 0x1F, 0x00, 0x77, 0x00, 0xF8, 0x03, 0x38, 0x06,
  0xC0, 0x39, 0xC0, 0x36, 0x01, 0xC6, 0x03, 0xB8, 0x0E, 0x38, 0x1D, 0xC0,
  0x61, 0xC0, 0xC6, 0x07, 0x0E, 0x06, 0x38, 0x38, 0x30, 0x71, 0xC1, 0xC1,
  0x83, 0x86, 0x0C, 0x0E, 0x18, 0x30, 0x60, 0x70, 0xC1, 0xC7, 0x01, 0x8E,
  0x0E, 0x38, 0x0C, 0x60, 0x31, 0x80, 0x73, 0x01, 0x8C, 0x03, 0xB8, 0x0E,
  0xE0, 0x1D, 0xC0, 0x77, 0x00, 0x6C, 0x01, 0xB0, 0x03, 0xE0, 0x0D, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x00, 0xE7, 0x00, 0x38, 0xE0,
  0x0F, 0x0E, 0x01, 0xC1, 0xC0, 0x78, 0x1C, 0x0E, 0x01, 0xC3, 0x80, 0x38,
  0x70, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x01, 0xB8, 0x00, 0x73,
  0x80, 0x1C, 0x38, 0x03, 0x87, 0x00, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x00,
  0xE1, 0xE0, 0x1C, 0x38, 0x01, 0xCF, 0x00, 0x3D, 0xC0, 0x03, 0x80, 0xE0,
  0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0x38, 0x00, 0xE3, 0x80, 0x1C, 0x70,
  0x03, 0x8E, 0x00, 0xE0, 0xC0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0xE0, 0x30,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x60, 0x0C, 0x1C, 0x01, 0xC3, 0x80, 0x38,
  0x60, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xCC, 0x00, 0x1B,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x10, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1C, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xC0, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1F,
  0x00, 0xF0, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x80,
  0xE0, 0x0C, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x07, 0x3F, 0xF0, 0x07,
  0x78, 0x78, 0x06, 0x70, 0x3C, 0x06, 0x60, 0x1E, 0x0E, 0x60, 0x0F, 0xFC,
  0xE0, 0x07, 0xF8, 0x00, 0x01, 0xF0,
};

const GFXglyph RobotoCondensed_Light51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 36, 11, 4, -36 },
  { 15, 8, 11, 15, 4, -38 },
  { 26, 24, 36, 26, 2, -36 },
  { 134, 19, 46, 25, 3, -41 },
  { 244, 27, 36, 33, 3, -36 },
  { 366, 23, 37, 27, 3, -36 },
  { 473, 3, 11, 9, 3, -38 },
  { 478, 11, 53, 15, 3, -41 },
  { 551, 10, 53, 15, 1, -41 },
  { 618, 20, 20, 22, 1, -36 },
  { 668, 21, 27, 25, 2, -31 },
  { 739, 5, 12, 10, 2, -5 },
  { 747, 11, 3, 13, 1, -18 },
  { 752, 4, 4, 12, 4, -4 },
  { 754, 15, 39, 18, 1, -36 },
  { 828, 19, 36, 25, 3, -36 },
  { 914, 11, 36, 25, 4, -36 },
  { 964, 20, 36, 25, 3, -36 },
  { 1054, 19, 36, 25, 3, -36 },
  { 1140, 22, 36, 25, 2, -36 },
  { 1239, 18, 36, 25, 4, -36 },
  { 1320, 19, 36, 25, 3, -36 },
  { 1406, 20, 36, 25, 2, -36 },
  { 1496, 19, 36, 25, 3, -36 },
  { 1582, 19, 36, 25, 3, -36 },
  { 1668, 5, 27, 10, 3, -27 },
  { 1685, 5, 34, 9, 2, -27 },
  { 1707, 17, 21, 23, 2, -27 },
  { 1752, 17, 14, 25, 4, -24 },
  { 1782, 18, 21, 23, 3, -27 },
  { 1830, 16, 36, 21, 2, -36 },
  { 1902, 34, 46, 40, 3, -35 },
  { 2098, 26, 36, 28, 1, -36 },
  { 2215, 20, 36, 27, 4, -36 },
  { 2305, 23, 36, 29, 3, -36 },
  { 2409, 22, 36, 29, 4, -36 },
  { 2508, 19, 36, 25, 4, -36 },
  { 2594, 19, 36, 25, 4, -36 },
  { 2680, 22, 36, 30, 4, -36 },
  { 2779, 23, 36, 31, 4, -36 },
  { 2883, 3, 36, 12, 5, -36 },
  { 2897, 18, 36, 25, 2, -36 },
  { 2978, 23, 36, 28, 4, -36 },
  { 3082, 18, 36, 24, 4, -36 },
  { 3163, 30, 36, 38, 4, -36 },
  { 3298, 23, 36, 31, 4, -36 },
  { 3402, 24, 36, 30, 3, -36 },
  { 3510, 21, 36, 28, 4, -36 },
  { 3605, 24, 42, 30, 3, -36 },
  { 3731, 22, 36, 28, 4, -36 },
  { 3830, 22, 36, 26, 2, -36 },
  { 3929, 23, 36, 27, 2, -36 },
  { 4033, 21, 36, 29, 4, -36 },
  { 4128, 25, 36, 28, 1, -36 },
  { 4241, 36, 36, 39, 2, -36 },
  { 4403, 24, 36, 27, 2, -36 },
  { 4511, 25, 36, 27, 1, -36 },
  { 4624, 22, 36, 27, 2, -36 },
  { 4723, 7, 49, 12, 4, -41 },
  { 4766, 16, 39, 18, 1, -36 },
  { 4844, 7, 49, 12, 1, -41 },
  { 4887, 15, 18, 19, 2, -36 },
  { 4921, 18, 3, 20, 1, 0 },
  { 4928, 8, 7, 15, 3, -38 },
  { 4935, 18, 27, 24, 3, -27 },
  { 4996, 18, 38, 25, 4, -38 },
  { 5082, 19, 27, 23, 2, -27 },
  { 5147, 18, 38, 25, 3, -38 },
  { 5233, 19, 27, 23, 2, -27 },
  { 5298, 13, 39, 15, 2, -39 },
  { 5362, 18, 37, 25, 3, -27 },
  { 5446, 17, 38, 25, 4, -38 },
  { 5527, 3, 37, 11, 4, -37 },
  { 5541, 9, 47, 11, -2, -37 },
  { 5594, 17, 38, 22, 4, -38 },
  { 5675, 3, 38, 11, 4, -38 },
  { 5690, 31, 27, 39, 4, -27 },
  { 5795, 17, 27, 25, 4, -27 },
  { 5853, 19, 27, 25, 3, -27 },
  { 5918, 18, 37, 25, 4, -27 },
  { 6002, 18, 37, 25, 3, -27 },
  { 6086, 10, 27, 15, 4, -27 },
  { 6120, 17, 27, 23, 3, -27 },
  { 6178, 12, 34, 15, 1, -34 },
  { 6229, 17, 27, 25, 4, -27 },
  { 6287, 19, 27, 22, 1, -27 },
  { 6352, 29, 27, 33, 2, -27 },
  { 6450, 19, 27, 22, 1, -27 },
  { 6515, 19, 37, 21, 1, -27 },
  { 6603, 18, 27, 22, 2, -27 },
  { 6664, 12, 50, 15, 2, -40 },
  { 6739, 3, 43, 11, 4, -36 },
  { 6756, 12, 50, 15, 1, -40 },
  { 6831, 24, 9, 30, 3, -20 },
};

const GFXfont RobotoCondensed_Light51pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light51pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light51pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _ROBOTOCONDENSED_LIGHT51PT7B_H_
