#ifndef _ROBOTOCONDENSED_LIGHT28PT7B_H_
#define _ROBOTOCONDENSED_LIGHT28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x9C, 0xE7, 0x29, 0x48, 0x06, 0x20,
  0x31, 0x01, 0x08, 0x08, 0x40, 0x42, 0x02, 0x31, 0xFF, 0xE1, 0x88, 0x08,
  0x40, 0x42, 0x02, 0x10, 0x11, 0x80, 0x8C, 0x7F, 0xF8, 0x42, 0x02, 0x10,
  0x10, 0x80, 0x8C, 0x04, 0x60, 0x62, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x78,
  0x7F, 0x98, 0x6C, 0x0F, 0x03, 0xC0, 0xF0, 0x04, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x38, 0x03, 0x00, 0xE0, 0x18, 0x0F, 0x03, 0xC0, 0x9F, 0xE1, 0xE0,
  0x30, 0x0C, 0x03, 0x00, 0x78, 0x03, 0x20, 0x08, 0x42, 0x21, 0x08, 0x84,
  0x62, 0x11, 0x08, 0x4C, 0x32, 0x20, 0x79, 0x00, 0x04, 0x00, 0x20, 0x00,
  0x8E, 0x04, 0x4C, 0x32, 0x10, 0x88, 0x46, 0x21, 0x10, 0x84, 0xC2, 0x10,
  0x04, 0xC0, 0x1E, 0x0F, 0x00, 0x7E, 0x03, 0x08, 0x0C, 0x30, 0x30, 0x80,
  0xC2, 0x03, 0x18, 0x06, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0x60, 0x08, 0x86,
  0x63, 0x19, 0x06, 0x4C, 0x0D, 0x10, 0x3C, 0x40, 0x61, 0x81, 0xC3, 0xBD,
  0x07, 0xC6, 0xFC, 0x08, 0x21, 0x0C, 0x21, 0x84, 0x10, 0xC3, 0x0C, 0x30,
  0x82, 0x08, 0x20, 0x83, 0x0C, 0x30, 0x41, 0x06, 0x08, 0x30, 0x40, 0x82,
  0x86, 0x10, 0xC2, 0x18, 0x42, 0x18, 0xC2, 0x10, 0x84, 0x21, 0x08, 0x46,
  0x31, 0x08, 0xC4, 0x62, 0x31, 0x00, 0x06, 0x00, 0x60, 0x06, 0x04, 0x62,
  0xF6, 0xE1, 0xF8, 0x06, 0x00, 0xF0, 0x19, 0x83, 0x0C, 0x20, 0x80, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x6D, 0xAD,
  0x00, 0xF8, 0xF0, 0x03, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x08,
  0x08, 0x18, 0x10, 0x10, 0x30, 0x20, 0x20, 0x60, 0x40, 0x40, 0xC0, 0x80,
  0x80, 0x1E, 0x1F, 0xC6, 0x1B, 0x02, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x98, 0x67,
  0xF0, 0x78, 0x04, 0x7F, 0x71, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x1F, 0x07, 0x71, 0x83, 0x20, 0x24, 0x07,
  0x80, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x60, 0x08,
  0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x3F, 0xF0, 0x1F, 0x07, 0x71,
  0x83, 0x20, 0x24, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x70, 0x3E,
  0x00, 0x60, 0x04, 0x00, 0xF0, 0x1A, 0x03, 0x40, 0x6C, 0x18, 0xEF, 0x07,
  0x80, 0x01, 0x80, 0x18, 0x03, 0x80, 0x28, 0x06, 0x80, 0x48, 0x0C, 0x80,
  0x88, 0x18, 0x83, 0x08, 0x30, 0x86, 0x08, 0x40, 0x8C, 0x08, 0xFF, 0xF0,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x3F, 0xDF, 0xF6, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x01, 0x7C, 0x7F, 0x90, 0x70, 0x0C, 0x01, 0x00, 0x40,
  0x1C, 0x07, 0x01, 0x40, 0xD8, 0x33, 0xB8, 0x7C, 0x07, 0x07, 0x83, 0x01,
  0x80, 0x60, 0x10, 0x0C, 0x03, 0x78, 0xBF, 0xB8, 0x6C, 0x0E, 0x03, 0x80,
  0x60, 0x18, 0x07, 0x03, 0xC0, 0xD8, 0x63, 0xF8, 0x78, 0xFF, 0xE0, 0x04,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x0C,
  0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08,
  0x00, 0x1E, 0x1F, 0xCC, 0x1B, 0x03, 0x80, 0xE0, 0x3C, 0x0D, 0x06, 0x7F,
  0x0F, 0x86, 0x1B, 0x02, 0x80, 0xE0, 0x18, 0x06, 0x03, 0x80, 0xF0, 0x67,
  0x78, 0xF8, 0x1F, 0x07, 0x71, 0x83, 0x30, 0x64, 0x05, 0x80, 0xF0, 0x1E,
  0x03, 0x40, 0x6C, 0x0D, 0x83, 0x9D, 0xF1, 0xE6, 0x00, 0x80, 0x10, 0x06,
  0x00, 0x80, 0x30, 0x7C, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x6C, 0x00,
  0x00, 0x00, 0x06, 0xDA, 0xD0, 0x00, 0x40, 0x70, 0x70, 0x78, 0x38, 0x38,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x06,
  0x0E, 0x1C, 0x38, 0x30, 0x10, 0x00, 0x1E, 0x3F, 0x98, 0x78, 0x3C, 0x08,
  0x0C, 0x06, 0x02, 0x03, 0x03, 0x03, 0x01, 0x80, 0x80, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x01, 0x00, 0x01, 0xF8, 0x01, 0xC7, 0x81, 0xC0, 0x30,
  0x40, 0x06, 0x20, 0x00, 0x98, 0x00, 0x24, 0x0F, 0x07, 0x06, 0x61, 0xC3,
  0x18, 0x60, 0x86, 0x18, 0x61, 0x86, 0x10, 0x61, 0x84, 0x10, 0x61, 0x04,
  0x18, 0x41, 0x06, 0x10, 0x41, 0x84, 0x30, 0xA1, 0xD6, 0x6C, 0x38, 0xF1,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x38, 0xE0, 0x07,
  0xE0, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x60, 0x05, 0x80, 0x32,
  0x00, 0x88, 0x02, 0x30, 0x18, 0x40, 0x41, 0x01, 0x06, 0x0C, 0x08, 0x30,
  0x20, 0xFF, 0xC6, 0x03, 0x18, 0x04, 0x40, 0x1B, 0x00, 0x6C, 0x00, 0xA0,
  0x03, 0xFF, 0x18, 0x7B, 0x03, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x06,
  0xC3, 0x9F, 0xF3, 0x03, 0x60, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x78, 0x0F, 0x0F, 0x7F, 0x80, 0x0F, 0x83, 0xDC, 0x60, 0x64, 0x03, 0xC0,
  0x3C, 0x01, 0xC0, 0x18, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0C, 0x01, 0xC0, 0x1C, 0x03, 0x40, 0x36, 0x06, 0x3D, 0xC0, 0xF8, 0xFF,
  0x0C, 0x7C, 0xC0, 0xEC, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x6C, 0x0E, 0xC7, 0xCF, 0xF0, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFB, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0xF0, 0xFF, 0xF8, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFB, 0xFF,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x00, 0x0F, 0x83, 0xDE, 0x60, 0x66, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x1F, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0x60, 0x17, 0x03, 0x3D, 0xE0, 0xFC, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFF, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x30, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x1C, 0x07, 0x03, 0xC0, 0xD8, 0x67, 0xF8, 0x78, 0xC0, 0x36, 0x03, 0x30,
  0x31, 0x81, 0x0C, 0x18, 0x61, 0x83, 0x18, 0x19, 0x80, 0xCC, 0x06, 0xE0,
  0x3F, 0x01, 0xCC, 0x0C, 0x30, 0x60, 0x83, 0x06, 0x18, 0x18, 0xC0, 0xC6,
  0x03, 0x30, 0x0D, 0x80, 0x20, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7E, 0x80, 0x2F, 0x60, 0x37, 0xB0, 0x13, 0xC8,
  0x09, 0xE6, 0x0C, 0xF1, 0x04, 0x78, 0x82, 0x3C, 0x63, 0x1E, 0x11, 0x0F,
  0x08, 0x87, 0x86, 0xC3, 0xC1, 0x41, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x10,
  0x30, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3D, 0x01, 0xEC, 0x0F, 0x30,
  0x79, 0x83, 0xC6, 0x1E, 0x10, 0xF0, 0xC7, 0x82, 0x3C, 0x19, 0xE0, 0x4F,
  0x03, 0x78, 0x0B, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x30, 0x0F, 0x81,
  0xFE, 0x18, 0x18, 0x80, 0x6C, 0x01, 0x60, 0x0A, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x58, 0x02,
  0x40, 0x33, 0x03, 0x0F, 0xF0, 0x1F, 0x00, 0xFF, 0x8C, 0x3C, 0xC0, 0x6C,
  0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x2C, 0x06, 0xC3, 0xCF,
  0xF8, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x0F, 0x81, 0xFE, 0x18, 0x18, 0x80, 0x6C, 0x01, 0x60, 0x0A, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0x00, 0x58, 0x02, 0x40, 0x33, 0x03, 0x0F, 0xF0, 0x1F, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x40, 0xFF, 0x0C, 0x3C, 0xC0, 0x6C, 0x06, 0xC0, 0x2C, 0x02,
  0xC0, 0x2C, 0x02, 0xC0, 0x6C, 0x06, 0xC3, 0xCF, 0xF0, 0xC1, 0x8C, 0x18,
  0xC0, 0xCC, 0x0C, 0xC0, 0x6C, 0x06, 0xC0, 0x3C, 0x03, 0x0F, 0x83, 0xDC,
  0x60, 0x66, 0x03, 0x40, 0x34, 0x01, 0x60, 0x06, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x1C, 0x01, 0x40, 0x36, 0x03,
  0x3D, 0xE0, 0xF8, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x36, 0x06, 0x3F, 0xC1, 0xF8, 0xC0, 0x0B, 0x00, 0x6C, 0x01, 0x90,
  0x04, 0x60, 0x31, 0x80, 0xC2, 0x03, 0x0C, 0x08, 0x30, 0x60, 0x41, 0x81,
  0x04, 0x06, 0x30, 0x08, 0xC0, 0x22, 0x00, 0xC8, 0x03, 0x60, 0x05, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x80, 0xC0, 0x60, 0x3C, 0x06, 0x02, 0x40, 0x60,
  0x24, 0x0E, 0x06, 0x60, 0xB0, 0x66, 0x09, 0x06, 0x60, 0x90, 0x42, 0x19,
  0x04, 0x21, 0x98, 0xC3, 0x10, 0x8C, 0x31, 0x08, 0xC3, 0x30, 0x88, 0x13,
  0x0C, 0x81, 0x20, 0xD8, 0x1A, 0x05, 0x81, 0xE0, 0x50, 0x1E, 0x05, 0x00,
  0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xC0, 0x1B, 0x01, 0x98, 0x0C,
  0x60, 0xC1, 0x04, 0x0C, 0x60, 0x22, 0x01, 0xB0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0A, 0x00, 0xD8, 0x04, 0x60, 0x63, 0x06, 0x0C, 0x30, 0x63, 0x01,
  0x98, 0x0D, 0x80, 0x30, 0xC0, 0x1E, 0x00, 0x98, 0x0C, 0xC0, 0x42, 0x06,
  0x18, 0x20, 0x43, 0x03, 0x10, 0x09, 0x80, 0x6C, 0x01, 0xC0, 0x0E, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x7F, 0xF0, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x06, 0x00, 0xC0, 0x0F, 0xFF, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xF0, 0x80, 0xC0, 0x40,
  0x40, 0x60, 0x20, 0x20, 0x30, 0x10, 0x10, 0x18, 0x18, 0x08, 0x0C, 0x0C,
  0x04, 0x06, 0x06, 0x02, 0x02, 0x03, 0x01, 0xF1, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x18, 0x18, 0x1C,
  0x34, 0x24, 0x26, 0x62, 0x42, 0x43, 0xC3, 0xFF, 0xE0, 0x61, 0x0C, 0x30,
  0x1F, 0x0E, 0xE6, 0x0D, 0x03, 0x00, 0x40, 0x11, 0xFC, 0xE1, 0x60, 0x50,
  0x1C, 0x05, 0x03, 0x41, 0xDF, 0xD3, 0xE4, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0D, 0xF3, 0xFE, 0xC0, 0xB0, 0x3C, 0x0F, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0B, 0xFE, 0x9F, 0x00, 0x1F, 0x07,
  0x71, 0x83, 0x20, 0x24, 0x05, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01,
  0x01, 0x20, 0x26, 0x0C, 0x77, 0x07, 0xC0, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC7, 0x99, 0xDF, 0x60, 0xEC, 0x0D, 0x01, 0xA0, 0x3C,
  0x07, 0x80, 0xF0, 0x1A, 0x03, 0x40, 0x6C, 0x0D, 0x83, 0x9D, 0xF1, 0xE6,
  0x1F, 0x07, 0x71, 0x83, 0x20, 0x24, 0x05, 0x80, 0xF0, 0x1F, 0xFF, 0xC0,
  0x18, 0x03, 0x00, 0x20, 0x06, 0x04, 0x7F, 0x87, 0xC0, 0x0E, 0x3C, 0xC1,
  0x83, 0x06, 0x3F, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x00, 0x1E, 0x67, 0x7D, 0x83, 0xB0, 0x34, 0x06, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x68, 0x0D, 0x01, 0xB0, 0x36, 0x0E, 0x77, 0xC7,
  0x98, 0x03, 0x00, 0x60, 0x08, 0x83, 0x1D, 0xC1, 0xF0, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x3D, 0xFF, 0xE1, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x08, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x18, 0xC0, 0x00, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x62, 0xF7, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x1B, 0x0C, 0xC6, 0x31, 0x0C, 0xC3, 0x60, 0xF0, 0x3E,
  0x0C, 0xC3, 0x30, 0xC6, 0x30, 0xCC, 0x33, 0x06, 0xC0, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x9E, 0x1E, 0x5B, 0xDF, 0xF8, 0x78, 0x78, 0x18,
  0x1C, 0x0C, 0x0E, 0x04, 0x07, 0x02, 0x03, 0x81, 0x01, 0xC0, 0x80, 0xE0,
  0x40, 0x70, 0x20, 0x38, 0x10, 0x1C, 0x08, 0x0E, 0x04, 0x07, 0x02, 0x02,
  0xCF, 0x7F, 0xF8, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x02, 0x0F, 0x07, 0xF9, 0x83, 0x30, 0x34, 0x06,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x28, 0x05, 0x00, 0xB0, 0x36, 0x0C, 0x7F,
  0x83, 0xC0, 0x9F, 0x3F, 0xEC, 0x1B, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xBF, 0xED, 0xF3, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x00, 0x1E, 0x67, 0x7D, 0x83, 0xB0, 0x34, 0x06,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x68, 0x0D, 0x01, 0xB0, 0x36, 0x0E, 0x77,
  0xC7, 0x98, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0xDF, 0xFE,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x00, 0x1F, 0x0E,
  0xE6, 0x0D, 0x03, 0x40, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x0F,
  0x03, 0x60, 0xDE, 0xE1, 0xF0, 0x20, 0x82, 0x08, 0xFC, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xF1, 0xC0, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1B, 0xFC,
  0xF2, 0x80, 0xF0, 0x3C, 0x09, 0x02, 0x61, 0x98, 0x42, 0x10, 0x8C, 0x33,
  0x04, 0x81, 0x20, 0x78, 0x0C, 0x03, 0x00, 0xC0, 0xC1, 0x81, 0xC1, 0x83,
  0x41, 0x83, 0x41, 0xC2, 0x63, 0x42, 0x62, 0x46, 0x22, 0x46, 0x26, 0x64,
  0x26, 0x24, 0x34, 0x24, 0x34, 0x2C, 0x1C, 0x38, 0x1C, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xC0, 0xD8, 0x66, 0x18, 0xCC, 0x12, 0x07, 0x80, 0xC0, 0x30,
  0x0C, 0x07, 0x83, 0x30, 0x84, 0x61, 0x90, 0x2C, 0x0C, 0x80, 0xF0, 0x3C,
  0x09, 0x06, 0x61, 0x98, 0x42, 0x10, 0xCC, 0x33, 0x04, 0x81, 0x20, 0x78,
  0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x03, 0xC0, 0xE0, 0x00,
  0xFF, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x06,
  0x03, 0x00, 0x80, 0x60, 0x30, 0x0F, 0xFC, 0x02, 0x18, 0x20, 0xC1, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x41, 0x83, 0x1C, 0x30, 0x10, 0x30, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x18, 0x30, 0x30, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x40, 0xC0, 0xC0, 0x81, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC0, 0x81, 0xC1, 0x86, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x10,
  0x61, 0x82, 0x00, 0x38, 0x1B, 0xE0, 0xF1, 0x85, 0x07, 0xE8, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_Light28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 20, 6, 2, -20 },
  { 6, 5, 6, 8, 2, -21 },
  { 10, 13, 20, 14, 1, -20 },
  { 43, 10, 26, 14, 2, -23 },
  { 76, 14, 20, 18, 2, -20 },
  { 111, 14, 20, 15, 1, -20 },
  { 146, 1, 6, 5, 2, -21 },
  { 147, 6, 28, 8, 2, -22 },
  { 168, 5, 28, 8, 1, -22 },
  { 186, 12, 11, 12, 0, -20 },
  { 203, 12, 15, 14, 1, -17 },
  { 226, 3, 6, 5, 1, -3 },
  { 229, 5, 1, 7, 1, -9 },
  { 230, 2, 2, 7, 2, -2 },
  { 231, 8, 22, 10, 1, -20 },
  { 253, 10, 20, 14, 2, -20 },
  { 278, 6, 20, 14, 2, -20 },
  { 293, 11, 20, 14, 1, -20 },
  { 321, 11, 20, 14, 1, -20 },
  { 349, 12, 20, 14, 1, -20 },
  { 379, 10, 20, 14, 2, -20 },
  { 404, 10, 20, 14, 2, -20 },
  { 429, 11, 20, 14, 1, -20 },
  { 457, 10, 20, 14, 2, -20 },
  { 482, 11, 20, 14, 1, -20 },
  { 510, 2, 15, 6, 2, -15 },
  { 514, 3, 18, 5, 1, -15 },
  { 521, 10, 12, 13, 1, -15 },
  { 536, 10, 6, 14, 2, -12 },
  { 544, 9, 12, 13, 2, -15 },
  { 558, 9, 20, 11, 1, -20 },
  { 581, 18, 25, 22, 2, -19 },
  { 638, 14, 20, 15, 1, -20 },
  { 673, 11, 20, 15, 2, -20 },
  { 701, 12, 20, 16, 2, -20 },
  { 731, 12, 20, 16, 2, -20 },
  { 761, 11, 20, 14, 2, -20 },
  { 789, 11, 20, 14, 2, -20 },
  { 817, 12, 20, 17, 2, -20 },
  { 847, 13, 20, 17, 2, -20 },
  { 880, 1, 20, 7, 3, -20 },
  { 883, 10, 20, 14, 1, -20 },
  { 908, 13, 20, 15, 2, -20 },
  { 941, 10, 20, 13, 2, -20 },
  { 966, 17, 20, 21, 2, -20 },
  { 1009, 13, 20, 17, 2, -20 },
  { 1042, 13, 20, 17, 2, -20 },
  { 1075, 12, 20, 15, 2, -20 },
  { 1105, 13, 23, 17, 2, -20 },
  { 1143, 12, 20, 15, 2, -20 },
  { 1173, 12, 20, 14, 1, -20 },
  { 1203, 13, 20, 15, 1, -20 },
  { 1236, 12, 20, 16, 2, -20 },
  { 1266, 14, 20, 15, 1, -20 },
  { 1301, 20, 20, 22, 1, -20 },
  { 1351, 13, 20, 15, 1, -20 },
  { 1384, 13, 20, 15, 1, -20 },
  { 1417, 12, 20, 15, 1, -20 },
  { 1447, 4, 27, 6, 2, -23 },
  { 1461, 8, 22, 10, 1, -20 },
  { 1483, 4, 27, 6, 0, -23 },
  { 1497, 8, 10, 10, 1, -20 },
  { 1507, 11, 1, 11, 0, 0 },
  { 1509, 5, 4, 8, 1, -21 },
  { 1512, 10, 15, 13, 1, -15 },
  { 1531, 10, 21, 14, 2, -21 },
  { 1558, 11, 15, 13, 1, -15 },
  { 1579, 11, 21, 14, 1, -21 },
  { 1608, 11, 15, 13, 1, -15 },
  { 1629, 7, 21, 8, 1, -21 },
  { 1648, 11, 21, 14, 1, -15 },
  { 1677, 9, 21, 13, 2, -21 },
  { 1701, 2, 20, 6, 2, -20 },
  { 1706, 5, 26, 6, -1, -20 },
  { 1723, 10, 21, 12, 2, -21 },
  { 1750, 2, 21, 6, 2, -21 },
  { 1756, 17, 15, 21, 2, -15 },
  { 1788, 9, 15, 14, 2, -15 },
  { 1805, 11, 15, 14, 1, -15 },
  { 1826, 10, 21, 14, 2, -15 },
  { 1853, 11, 21, 14, 1, -15 },
  { 1882, 6, 15, 8, 2, -15 },
  { 1894, 10, 15, 13, 1, -15 },
  { 1913, 6, 19, 8, 1, -19 },
  { 1928, 9, 15, 13, 2, -15 },
  { 1945, 10, 15, 12, 1, -15 },
  { 1964, 16, 15, 18, 1, -15 },
  { 1994, 10, 15, 12, 1, -15 },
  { 2013, 10, 21, 12, 1, -15 },
  { 2040, 10, 15, 12, 1, -15 },
  { 2059, 7, 28, 8, 1, -22 },
  { 2084, 2, 24, 6, 2, -20 },
  { 2090, 7, 28, 8, 0, -22 },
  { 2115, 13, 5, 17, 2, -11 },
};

const GFXfont RobotoCondensed_Light28pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light28pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light28pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOCONDENSED_LIGHT28PT7B_H_
