#ifndef _ROBOTOCONDENSED_LIGHT46PT7B_H_
#define _ROBOTOCONDENSED_LIGHT46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light46pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x60, 0x00, 0x00, 0x06, 0xFF, 0x60, 0xE3, 0xE3, 0xE3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC2, 0xC2, 0x00, 0x60, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30,
  0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x38,
  0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0,
  0x18, 0x38, 0x00, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x03,
  0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0x60, 0x03,
  0x03, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x06, 0x06, 0x00, 0x30, 0x60,
  0x01, 0x83, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30,
  0x30, 0x01, 0x83, 0x80, 0x0C, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x3E, 0xF8,
  0x38, 0x0E, 0x38, 0x03, 0x9C, 0x01, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00,
  0x1D, 0x80, 0x0E, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0x38, 0x03, 0x9E, 0x03, 0xC7, 0xEF, 0xC1,
  0xFF, 0xC0, 0x3F, 0x80, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x0C,
  0x00, 0x06, 0x06, 0x03, 0x03, 0x03, 0x01, 0x83, 0x01, 0x81, 0x81, 0x80,
  0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x30, 0x30, 0x60, 0x18, 0x18, 0x60, 0x0C,
  0x0C, 0x70, 0x03, 0x0C, 0x30, 0x01, 0xFC, 0x30, 0x00, 0x3C, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x1F,
  0x00, 0x06, 0x1F, 0xC0, 0x03, 0x1C, 0x70, 0x03, 0x0C, 0x18, 0x01, 0x8E,
  0x06, 0x01, 0x86, 0x03, 0x01, 0xC3, 0x01, 0x80, 0xC1, 0x80, 0xC0, 0xC0,
  0xC0, 0x60, 0x60, 0x60, 0x30, 0x60, 0x38, 0x18, 0x10, 0x0C, 0x1C, 0x00,
  0x07, 0x1C, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0x83, 0x80, 0x1C, 0x06, 0x00, 0x70,
  0x18, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x70, 0x38,
  0x01, 0xC1, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x70, 0x00, 0x1F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3B, 0x80, 0x01, 0xC7,
  0x03, 0x0E, 0x1C, 0x0C, 0x70, 0x38, 0x31, 0xC0, 0x70, 0xC6, 0x01, 0xC3,
  0x38, 0x03, 0x9C, 0xE0, 0x07, 0x61, 0x80, 0x1F, 0x86, 0x00, 0x3C, 0x1C,
  0x00, 0x70, 0x70, 0x03, 0xE0, 0xE0, 0x1F, 0x81, 0xF3, 0xE7, 0x03, 0xFF,
  0x0E, 0x03, 0xF0, 0x38, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0xC0, 0xE0, 0x60,
  0x60, 0x70, 0x30, 0x38, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0x80,
  0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03,
  0x01, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x0C, 0x03,
  0x01, 0x80, 0xE0, 0x70, 0x18, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E,
  0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0C, 0x0E,
  0x06, 0x06, 0x03, 0x03, 0x03, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x20, 0x30, 0x0F, 0x0C, 0x3F, 0xF3,
  0x3F, 0x3F, 0xFE, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07, 0x30,
  0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x70, 0x38, 0x38, 0x0E, 0x00, 0x01, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x39, 0xCE, 0x73,
  0x9C, 0xCE, 0x62, 0x00, 0xFF, 0xFF, 0xC0, 0x6F, 0xF7, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00,
  0x07, 0xE0, 0x07, 0xFC, 0x07, 0x9F, 0x07, 0x03, 0xC7, 0x00, 0xE3, 0x80,
  0x31, 0x80, 0x1D, 0xC0, 0x06, 0xE0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x06, 0xE0, 0x03, 0x70, 0x01, 0x98, 0x01, 0xCE, 0x00, 0xC7,
  0x00, 0xE1, 0xC0, 0xF0, 0x7D, 0xF0, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0x00,
  0xC0, 0xF0, 0xFD, 0xFF, 0xF9, 0xF8, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xF3, 0xE0,
  0xF0, 0x3C, 0x38, 0x07, 0x1C, 0x00, 0xE6, 0x00, 0x39, 0x80, 0x0E, 0xE0,
  0x03, 0xB8, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0x03, 0xF0, 0x03, 0xFF,
  0x01, 0xF3, 0xE0, 0xF0, 0x1C, 0x30, 0x07, 0x1C, 0x00, 0xE7, 0x00, 0x39,
  0x80, 0x06, 0x60, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x66, 0x00, 0x19, 0xC0, 0x0E, 0x70,
  0x03, 0x8E, 0x01, 0xC1, 0xF3, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0x60, 0x00,
  0xEC, 0x00, 0x19, 0x80, 0x07, 0x30, 0x00, 0xC6, 0x00, 0x38, 0xC0, 0x06,
  0x18, 0x01, 0xC3, 0x00, 0x30, 0x60, 0x0E, 0x0C, 0x03, 0x81, 0x80, 0x60,
  0x30, 0x1C, 0x06, 0x03, 0x00, 0xC0, 0xE0, 0x18, 0x18, 0x03, 0x07, 0x00,
  0x60, 0xC0, 0x0C, 0x38, 0x01, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x67, 0xE0, 0x7F, 0xF8, 0x7F, 0xFC,
  0x70, 0x1E, 0x60, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x07, 0x60, 0x0E, 0x70, 0x1E, 0x3E, 0x7C, 0x1F, 0xF8, 0x07, 0xE0,
  0x00, 0x78, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x7E, 0x0E, 0x7F, 0xC7, 0xF9, 0xF3, 0xE0, 0x39, 0xE0, 0x0E, 0xE0, 0x07,
  0x70, 0x01, 0xB0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xD8, 0x00, 0xCE, 0x00, 0xE3,
  0x80, 0x71, 0xE0, 0x70, 0x7C, 0xF0, 0x1F, 0xF0, 0x03, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xF3, 0xE0, 0xF0, 0x3C, 0x38,
  0x07, 0x0C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x06, 0x70, 0x01, 0x9C, 0x00,
  0x67, 0x00, 0x18, 0xC0, 0x0E, 0x38, 0x03, 0x07, 0x01, 0xC0, 0xF3, 0xE0,
  0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0x83, 0x83, 0x80, 0x70, 0xC0, 0x0E, 0x70,
  0x01, 0x98, 0x00, 0x76, 0x00, 0x1F, 0x80, 0x07, 0x60, 0x01, 0xD8, 0x00,
  0x76, 0x00, 0x1D, 0xC0, 0x06, 0x70, 0x03, 0x8E, 0x01, 0xC1, 0xF1, 0xF0,
  0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0xCF, 0x07,
  0x81, 0xC3, 0x80, 0x73, 0x80, 0x39, 0xC0, 0x0E, 0xC0, 0x07, 0x60, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0D, 0x80,
  0x06, 0xE0, 0x07, 0x70, 0x03, 0x9C, 0x03, 0xCE, 0x03, 0x63, 0xC7, 0xB0,
  0xFF, 0x98, 0x1F, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x0F, 0x80, 0x00, 0x6F, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0xFF, 0x60, 0x18, 0xE3, 0xCE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x61, 0x86, 0x38,
  0xE3, 0x8C, 0x71, 0x86, 0x00, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x78, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x01, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0C, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x00,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFB, 0xE3, 0x81,
  0xC6, 0x01, 0xDC, 0x01, 0xB8, 0x03, 0x70, 0x06, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x30, 0xC0, 0x0F,
  0x80, 0x23, 0x80, 0x7F, 0x80, 0x66, 0x01, 0xE3, 0x80, 0xCC, 0x03, 0x03,
  0x01, 0x98, 0x0C, 0x06, 0x03, 0x60, 0x18, 0x0C, 0x06, 0xC0, 0x60, 0x18,
  0x05, 0x80, 0xC0, 0x30, 0x0B, 0x01, 0x80, 0x60, 0x16, 0x07, 0x00, 0xC0,
  0x2C, 0x0C, 0x01, 0x80, 0x58, 0x18, 0x03, 0x01, 0xB0, 0x30, 0x06, 0x03,
  0x60, 0x60, 0x1C, 0x06, 0xC0, 0xC0, 0x30, 0x0D, 0x81, 0x80, 0x60, 0x1B,
  0x03, 0x00, 0xC0, 0x66, 0x07, 0x03, 0xC0, 0xCC, 0x06, 0x0D, 0x83, 0x1C,
  0x0E, 0x33, 0x8E, 0x18, 0x0F, 0xE3, 0xF8, 0x30, 0x0F, 0x03, 0xC0, 0x70,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x02, 0x00, 0x01, 0xF0, 0x1C, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x63,
  0x00, 0x00, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x38, 0x38, 0x00, 0x70, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xE0,
  0x07, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x06, 0x01, 0x80, 0x0E, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x18,
  0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0x61, 0x80, 0x00, 0xE7, 0x00,
  0x01, 0xCE, 0x00, 0x03, 0x98, 0x00, 0x03, 0x70, 0x00, 0x07, 0xE0, 0x00,
  0x0E, 0xFF, 0xF0, 0x3F, 0xFF, 0x0C, 0x07, 0xE3, 0x00, 0x3C, 0xC0, 0x07,
  0x30, 0x00, 0xEC, 0x00, 0x3B, 0x00, 0x0E, 0xC0, 0x01, 0xB0, 0x00, 0xEC,
  0x00, 0x3B, 0x00, 0x0E, 0xC0, 0x07, 0x30, 0x03, 0xCC, 0x03, 0xE3, 0xFF,
  0xE0, 0xFF, 0xFE, 0x30, 0x03, 0xCC, 0x00, 0x3B, 0x00, 0x0E, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xB0, 0x01, 0xCC, 0x03, 0xF3, 0xFF,
  0xF8, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xDF, 0x81,
  0xE0, 0x1C, 0x38, 0x00, 0xE3, 0x80, 0x06, 0x70, 0x00, 0x76, 0x00, 0x07,
  0x60, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0x60, 0x00, 0x37, 0x00, 0x07, 0x70, 0x00, 0x73,
  0x80, 0x06, 0x38, 0x00, 0xE1, 0xC0, 0x1C, 0x0F, 0x9F, 0x80, 0x7F, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0x01, 0xF8, 0x60, 0x07,
  0x8C, 0x00, 0x39, 0x80, 0x03, 0x30, 0x00, 0x76, 0x00, 0x06, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x07, 0x60, 0x01, 0xCC, 0x00, 0x39,
  0x80, 0x1E, 0x30, 0x3F, 0x87, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F,
  0xFC, 0x03, 0xF3, 0xF0, 0x3C, 0x03, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x39,
  0xC0, 0x01, 0xCE, 0x00, 0x06, 0x60, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xEC, 0x00, 0x07, 0x60,
  0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0x70, 0x00, 0x73, 0xC0, 0x03,
  0x8F, 0x00, 0x78, 0x3F, 0x1F, 0x80, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0E, 0x70, 0x1E, 0x3E,
  0x7C, 0x1F, 0xF8, 0x07, 0xE0, 0xC0, 0x00, 0xEC, 0x00, 0x1C, 0xC0, 0x03,
  0x8C, 0x00, 0x78, 0xC0, 0x07, 0x0C, 0x00, 0xE0, 0xC0, 0x1C, 0x0C, 0x03,
  0xC0, 0xC0, 0x38, 0x0C, 0x07, 0x00, 0xC0, 0xE0, 0x0C, 0x1C, 0x00, 0xC3,
  0xC0, 0x0C, 0x38, 0x00, 0xC7, 0x00, 0x0C, 0xF8, 0x00, 0xDF, 0x80, 0x0F,
  0xDC, 0x00, 0xF9, 0xE0, 0x0F, 0x0E, 0x00, 0xE0, 0x70, 0x0C, 0x07, 0x80,
  0xC0, 0x38, 0x0C, 0x01, 0xC0, 0xC0, 0x1E, 0x0C, 0x00, 0xE0, 0xC0, 0x07,
  0x0C, 0x00, 0x78, 0xC0, 0x03, 0x8C, 0x00, 0x1C, 0xC0, 0x01, 0xEC, 0x00,
  0x0E, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xB0, 0x00, 0x0F, 0xF6, 0x00, 0x01, 0xBE, 0xE0, 0x00,
  0x37, 0xCC, 0x00, 0x0E, 0xF9, 0xC0, 0x01, 0x9F, 0x38, 0x00, 0x73, 0xE3,
  0x00, 0x0E, 0x7C, 0x70, 0x01, 0x8F, 0x8E, 0x00, 0x71, 0xF0, 0xC0, 0x0E,
  0x3E, 0x1C, 0x01, 0x87, 0xC3, 0x80, 0x70, 0xF8, 0x30, 0x0E, 0x1F, 0x07,
  0x01, 0x83, 0xE0, 0xE0, 0x70, 0x7C, 0x0C, 0x0E, 0x0F, 0x81, 0xC1, 0x81,
  0xF0, 0x18, 0x70, 0x3E, 0x03, 0x0E, 0x07, 0xC0, 0x71, 0x80, 0xF8, 0x06,
  0x70, 0x1F, 0x00, 0xCC, 0x03, 0xE0, 0x1D, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x70, 0x07, 0xC0, 0x0C,
  0x00, 0xE0, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x3D, 0xC0, 0x03, 0xDC, 0x00, 0x3C, 0xE0, 0x03, 0xCE, 0x00,
  0x3C, 0x70, 0x03, 0xC3, 0x00, 0x3C, 0x38, 0x03, 0xC1, 0x80, 0x3C, 0x1C,
  0x03, 0xC0, 0xC0, 0x3C, 0x0E, 0x03, 0xC0, 0x70, 0x3C, 0x07, 0x03, 0xC0,
  0x38, 0x3C, 0x03, 0x83, 0xC0, 0x1C, 0x3C, 0x00, 0xC3, 0xC0, 0x0E, 0x3C,
  0x00, 0x63, 0xC0, 0x07, 0x3C, 0x00, 0x33, 0xC0, 0x03, 0xBC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x30, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xF7, 0xE0, 0x38, 0x03, 0x83,
  0x80, 0x0E, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xCC, 0x00, 0x06, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3B, 0x00, 0x01, 0x9C, 0x00, 0x1C,
  0xE0, 0x00, 0xE3, 0x80, 0x0E, 0x0F, 0x00, 0xE0, 0x3F, 0x7F, 0x00, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0x00, 0xFC, 0x60,
  0x03, 0xCC, 0x00, 0x39, 0x80, 0x03, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xB0, 0x00, 0x76, 0x00, 0x1E, 0xC0, 0x07, 0x98, 0x07, 0xE3, 0xFF,
  0xF8, 0x7F, 0xFC, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xF7, 0xE0, 0x38, 0x03, 0x83, 0x80, 0x0E,
  0x38, 0x00, 0x39, 0xC0, 0x01, 0xCC, 0x00, 0x06, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3B, 0x00, 0x01, 0x9C, 0x00, 0x1C, 0xE0, 0x00,
  0xE3, 0x80, 0x0E, 0x0E, 0x00, 0xE0, 0x3F, 0x7E, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x40, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0x00,
  0xFC, 0x60, 0x03, 0xCC, 0x00, 0x39, 0x80, 0x03, 0xB0, 0x00, 0x76, 0x00,
  0x0E, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0xEC, 0x00,
  0x1D, 0x80, 0x03, 0x30, 0x00, 0xE6, 0x00, 0x38, 0xC0, 0x3F, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x60, 0x1C, 0x0C, 0x01, 0xC1, 0x80, 0x38, 0x30, 0x03,
  0x06, 0x00, 0x70, 0xC0, 0x06, 0x18, 0x00, 0xE3, 0x00, 0x0C, 0x60, 0x01,
  0xCC, 0x00, 0x19, 0x80, 0x03, 0xB0, 0x00, 0x76, 0x00, 0x07, 0xC0, 0x00,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0x9F, 0x83, 0xC0, 0x3C, 0x38,
  0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x06, 0x70, 0x00, 0x77,
  0x00, 0x07, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x06, 0x38,
  0x00, 0xE3, 0xC0, 0x1C, 0x1F, 0xDF, 0xC0, 0x7F, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07,
  0x70, 0x00, 0x67, 0x00, 0x0E, 0x38, 0x00, 0xE3, 0xC0, 0x3C, 0x1F, 0x9F,
  0x80, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x19,
  0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0x86, 0x00, 0x07, 0x0E,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x30, 0x38, 0x00, 0xE0, 0x70,
  0x01, 0xC0, 0x60, 0x03, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x30, 0x03, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x00, 0x0C, 0x06,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x30, 0x60, 0x00, 0x61, 0xC0,
  0x00, 0xE3, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0xB8, 0x00,
  0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x01, 0x80, 0x07, 0xE0, 0x03, 0x80,
  0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x06, 0x60, 0x03, 0xC0,
  0x06, 0x60, 0x07, 0xC0, 0x0E, 0x70, 0x06, 0xE0, 0x0E, 0x70, 0x06, 0x60,
  0x0C, 0x70, 0x06, 0x60, 0x0C, 0x30, 0x0E, 0x60, 0x0C, 0x30, 0x0C, 0x70,
  0x1C, 0x38, 0x0C, 0x30, 0x1C, 0x38, 0x0C, 0x30, 0x18, 0x38, 0x1C, 0x30,
  0x18, 0x18, 0x1C, 0x30, 0x18, 0x18, 0x18, 0x38, 0x38, 0x1C, 0x18, 0x18,
  0x38, 0x1C, 0x38, 0x18, 0x30, 0x0C, 0x38, 0x18, 0x30, 0x0C, 0x30, 0x1C,
  0x70, 0x0C, 0x30, 0x0C, 0x70, 0x0E, 0x30, 0x0C, 0x70, 0x0E, 0x70, 0x0C,
  0x60, 0x06, 0x60, 0x0E, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06,
  0xE0, 0x07, 0xE0, 0x06, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x80,
  0x07, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x1C,
  0x01, 0xC0, 0x70, 0x07, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x70, 0x00,
  0x71, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0xB0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3B, 0x80,
  0x01, 0xCE, 0x00, 0x07, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE0, 0xE0, 0x07,
  0x01, 0x80, 0x1C, 0x07, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x00,
  0x70, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x8C, 0x00, 0x0C, 0x38,
  0x00, 0x70, 0xE0, 0x01, 0xC1, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x87, 0x00,
  0x0E, 0x1C, 0x00, 0x18, 0x60, 0x00, 0x73, 0x80, 0x00, 0xCC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xFF, 0xF0, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1F, 0xFF, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1F, 0x00, 0xD8, 0x06,
  0xC0, 0x67, 0x03, 0x18, 0x38, 0xC1, 0x87, 0x0C, 0x18, 0xE0, 0xC6, 0x07,
  0x30, 0x1B, 0x80, 0xD8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x70, 0x38, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x8F, 0x87, 0x01, 0xE7,
  0x00, 0x73, 0x80, 0x19, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0xFF, 0xC1, 0xFF, 0xE3, 0xE0, 0x33, 0xC0, 0x19, 0xC0, 0x0C, 0xC0,
  0x06, 0xE0, 0x03, 0x70, 0x01, 0xB8, 0x01, 0xCC, 0x01, 0xE7, 0x01, 0xF3,
  0xF7, 0xD8, 0xFF, 0xCE, 0x1F, 0x87, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x7E, 0x0E, 0x7F, 0xC7, 0x71, 0xF3,
  0xE0, 0x3D, 0xE0, 0x0E, 0xE0, 0x03, 0x70, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1B, 0xC0, 0x1D,
  0xF0, 0x1C, 0xFF, 0x3E, 0x77, 0xFE, 0x38, 0xFC, 0x00, 0x03, 0xF0, 0x07,
  0xFE, 0x07, 0x8F, 0x87, 0x01, 0xE7, 0x00, 0x73, 0x80, 0x19, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0xB0, 0x01, 0xDC,
  0x00, 0xEE, 0x00, 0x63, 0x80, 0x70, 0xF1, 0xF0, 0x3F, 0xF0, 0x07, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0xFC, 0x30, 0xFF, 0x98, 0xF9, 0xEC, 0xE0, 0x3E, 0xE0, 0x07, 0x70, 0x03,
  0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36,
  0x00, 0x1B, 0x80, 0x1C, 0xC0, 0x0E, 0x70, 0x0F, 0x1F, 0x3D, 0x87, 0xFC,
  0xC1, 0xF8, 0x60, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xCF, 0x87, 0x00, 0xE7,
  0x00, 0x73, 0x80, 0x1D, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x23, 0xC0, 0x30,
  0xF8, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x01, 0xF0, 0x7E, 0x0F, 0x80, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x0F, 0xFC,
  0xFF, 0xC1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x07,
  0xE1, 0x87, 0xFC, 0xC7, 0xCF, 0x67, 0x01, 0xF7, 0x00, 0x7B, 0x80, 0x1D,
  0xC0, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0,
  0x00, 0xDC, 0x00, 0xEE, 0x00, 0x73, 0x80, 0x78, 0xF9, 0xEC, 0x3F, 0xE6,
  0x0F, 0xC3, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x71, 0x00,
  0x31, 0xC0, 0x38, 0x78, 0x78, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE1, 0xF0, 0xE7, 0xFC,
  0xEF, 0x3E, 0xFC, 0x0E, 0xF8, 0x06, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x6E, 0xF6, 0x00, 0x00,
  0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x60, 0x04, 0x1C, 0x38, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xDE,
  0xF9, 0xE0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x78, 0xE0, 0x70, 0xE0, 0xE0,
  0xE1, 0xC0, 0xE3, 0x80, 0xE7, 0x00, 0xEF, 0x00, 0xEE, 0x00, 0xFF, 0x00,
  0xFB, 0x80, 0xF3, 0x80, 0xE1, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70,
  0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE1, 0xF0, 0x1F,
  0x87, 0x3F, 0xE1, 0xFF, 0x3B, 0x8F, 0x1C, 0x79, 0xF0, 0x1D, 0x80, 0xEF,
  0x00, 0x78, 0x03, 0x78, 0x03, 0xC0, 0x1F, 0x80, 0x1C, 0x00, 0xFC, 0x00,
  0xE0, 0x07, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0,
  0x0F, 0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x03, 0xF0, 0x03, 0x80, 0x1F,
  0x80, 0x1C, 0x00, 0xFC, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x3F, 0x00,
  0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x70,
  0x03, 0xF0, 0x03, 0x80, 0x1F, 0x80, 0x1C, 0x00, 0xFC, 0x00, 0xE0, 0x07,
  0xE1, 0xF0, 0xE7, 0xFC, 0xEF, 0x3E, 0xFC, 0x0E, 0xF8, 0x06, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0x03, 0xF0, 0x03, 0xFF, 0x01, 0xF1, 0xE0, 0xF0, 0x1C, 0x38, 0x03, 0x9C,
  0x00, 0x67, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0D, 0x80, 0x03,
  0x60, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x18, 0xE0, 0x0E, 0x3C, 0x07, 0x07,
  0xC7, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0xE3, 0xF0, 0x77, 0xFE, 0x3F, 0x8F,
  0x9F, 0x01, 0xCF, 0x00, 0x77, 0x00, 0x1B, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xDE, 0x00,
  0xEF, 0x80, 0xE7, 0xF1, 0xF3, 0xBF, 0xF1, 0xC7, 0xE0, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xE1, 0x87, 0xFC, 0xC7, 0x8F, 0x67,
  0x00, 0xF7, 0x00, 0x3B, 0x80, 0x1D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xDC, 0x00, 0xEE, 0x00, 0x73,
  0x80, 0x78, 0xF1, 0xEC, 0x3F, 0xE6, 0x0F, 0xC3, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0xE3, 0xF9, 0xFE, 0xFF, 0xE0, 0xF0, 0x3C, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x07, 0xE0,
  0x1F, 0xF8, 0x3E, 0x3C, 0x38, 0x0E, 0x70, 0x06, 0x70, 0x07, 0x70, 0x07,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x07, 0x60, 0x07,
  0x70, 0x07, 0x70, 0x0E, 0x3E, 0x3E, 0x1F, 0xFC, 0x07, 0xF0, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x07, 0xFE, 0xFF, 0xC1, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07,
  0x00, 0xF0, 0x0F, 0x80, 0xF8, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x0F, 0x70, 0x1F, 0x3E,
  0xFF, 0x1F, 0xF7, 0x0F, 0xC7, 0xE0, 0x01, 0xB0, 0x01, 0xDC, 0x00, 0xEE,
  0x00, 0x63, 0x00, 0x71, 0x80, 0x38, 0xE0, 0x18, 0x30, 0x0C, 0x18, 0x0E,
  0x0E, 0x06, 0x07, 0x03, 0x01, 0x83, 0x80, 0xE1, 0x80, 0x70, 0xC0, 0x18,
  0xE0, 0x0C, 0x60, 0x07, 0x30, 0x01, 0x98, 0x00, 0xDC, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x01, 0x80, 0xC0, 0x0C, 0x00, 0xF0,
  0x07, 0x00, 0x7E, 0x01, 0xE0, 0x1F, 0x80, 0x78, 0x06, 0x60, 0x1E, 0x01,
  0x98, 0x0F, 0x80, 0xE7, 0x03, 0x70, 0x39, 0xC0, 0xCC, 0x0C, 0x30, 0x33,
  0x03, 0x0C, 0x1C, 0xE0, 0xC3, 0x86, 0x18, 0x70, 0xE1, 0x86, 0x18, 0x18,
  0x61, 0x86, 0x06, 0x30, 0x71, 0x81, 0xCC, 0x0C, 0xE0, 0x73, 0x03, 0x30,
  0x0D, 0xC0, 0xCC, 0x03, 0x60, 0x3B, 0x00, 0xD8, 0x06, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0x80, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x70, 0x03, 0x98, 0x03, 0x8E, 0x01, 0xC3, 0x01, 0xC1, 0xC0,
  0xC0, 0x70, 0xE0, 0x38, 0x60, 0x0E, 0x70, 0x03, 0x70, 0x01, 0xF8, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0E, 0x60,
  0x06, 0x38, 0x07, 0x0E, 0x03, 0x07, 0x03, 0x81, 0xC3, 0x80, 0x61, 0xC0,
  0x39, 0xC0, 0x0E, 0xE0, 0x07, 0xE0, 0x03, 0xB0, 0x01, 0xDC, 0x00, 0xCE,
  0x00, 0x67, 0x00, 0x71, 0x80, 0x38, 0xE0, 0x18, 0x70, 0x1C, 0x18, 0x0E,
  0x0E, 0x06, 0x07, 0x07, 0x01, 0x83, 0x80, 0xE1, 0x80, 0x70, 0xC0, 0x18,
  0xE0, 0x0E, 0x60, 0x07, 0x30, 0x01, 0xB8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x01, 0x78, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x81, 0xF0, 0x3C, 0x07,
  0x80, 0x38, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0x70, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x07, 0x80, 0x78,
  0x0F, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x08, 0x00, 0x0F, 0x00, 0x01, 0xFE, 0x00, 0xDF,
  0xF8, 0x06, 0xC1, 0xE0, 0x3E, 0x07, 0x83, 0x70, 0x1F, 0x7B, 0x00, 0x3F,
  0x80, 0x00, 0xF8,
};

const GFXglyph RobotoCondensed_Light46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 33, 10, 3, -33 },
  { 18, 8, 10, 13, 3, -35 },
  { 28, 21, 33, 24, 2, -33 },
  { 115, 17, 42, 22, 3, -38 },
  { 205, 25, 33, 29, 2, -33 },
  { 309, 22, 33, 25, 2, -33 },
  { 400, 2, 10, 8, 3, -35 },
  { 403, 9, 48, 13, 3, -37 },
  { 457, 9, 48, 14, 1, -37 },
  { 511, 18, 18, 20, 1, -33 },
  { 552, 19, 24, 23, 2, -27 },
  { 609, 5, 10, 9, 1, -4 },
  { 616, 9, 2, 12, 1, -15 },
  { 619, 4, 4, 11, 3, -4 },
  { 621, 14, 36, 16, 1, -33 },
  { 684, 17, 33, 22, 3, -33 },
  { 755, 10, 33, 22, 4, -33 },
  { 797, 18, 33, 22, 2, -33 },
  { 872, 18, 33, 22, 2, -33 },
  { 947, 19, 33, 22, 2, -33 },
  { 1026, 16, 33, 22, 4, -33 },
  { 1092, 17, 33, 22, 3, -33 },
  { 1163, 18, 33, 22, 2, -33 },
  { 1238, 18, 33, 22, 2, -33 },
  { 1313, 17, 33, 22, 2, -33 },
  { 1384, 4, 25, 9, 3, -25 },
  { 1397, 6, 31, 9, 1, -25 },
  { 1421, 15, 19, 21, 2, -24 },
  { 1457, 16, 11, 22, 3, -21 },
  { 1479, 16, 19, 21, 3, -24 },
  { 1517, 15, 33, 19, 2, -33 },
  { 1579, 31, 42, 36, 3, -32 },
  { 1742, 23, 33, 25, 1, -33 },
  { 1837, 18, 33, 25, 4, -33 },
  { 1912, 20, 33, 26, 3, -33 },
  { 1995, 19, 33, 26, 4, -33 },
  { 2074, 17, 33, 23, 4, -33 },
  { 2145, 17, 33, 23, 4, -33 },
  { 2216, 21, 33, 27, 3, -33 },
  { 2303, 20, 33, 28, 4, -33 },
  { 2386, 3, 33, 11, 4, -33 },
  { 2399, 16, 33, 22, 2, -33 },
  { 2465, 20, 33, 25, 4, -33 },
  { 2548, 16, 33, 21, 4, -33 },
  { 2614, 27, 33, 34, 4, -33 },
  { 2726, 20, 33, 28, 4, -33 },
  { 2809, 21, 33, 27, 3, -33 },
  { 2896, 19, 33, 25, 4, -33 },
  { 2975, 21, 39, 27, 3, -33 },
  { 3078, 19, 33, 25, 4, -33 },
  { 3157, 20, 33, 24, 2, -33 },
  { 3240, 22, 33, 24, 1, -33 },
  { 3331, 20, 33, 26, 3, -33 },
  { 3414, 23, 33, 25, 1, -33 },
  { 3509, 32, 33, 35, 2, -33 },
  { 3641, 22, 33, 25, 1, -33 },
  { 3732, 22, 33, 24, 1, -33 },
  { 3823, 20, 33, 24, 2, -33 },
  { 3906, 7, 44, 10, 3, -37 },
  { 3945, 14, 36, 16, 1, -33 },
  { 4008, 7, 44, 10, 0, -37 },
  { 4047, 13, 16, 17, 2, -33 },
  { 4073, 16, 2, 18, 1, 0 },
  { 4077, 8, 6, 13, 2, -34 },
  { 4083, 17, 24, 22, 2, -24 },
  { 4134, 17, 35, 22, 3, -35 },
  { 4209, 17, 24, 21, 2, -24 },
  { 4260, 17, 35, 22, 2, -35 },
  { 4335, 17, 24, 21, 2, -24 },
  { 4386, 12, 35, 14, 2, -35 },
  { 4439, 17, 33, 22, 2, -24 },
  { 4510, 16, 35, 22, 3, -35 },
  { 4580, 4, 33, 10, 3, -33 },
  { 4597, 7, 42, 10, -1, -33 },
  { 4634, 16, 35, 20, 3, -35 },
  { 4704, 2, 35, 10, 4, -35 },
  { 4713, 29, 24, 35, 3, -24 },
  { 4800, 16, 24, 22, 3, -24 },
  { 4848, 18, 24, 23, 2, -24 },
  { 4902, 17, 33, 22, 3, -24 },
  { 4973, 17, 33, 23, 2, -24 },
  { 5044, 10, 24, 14, 3, -24 },
  { 5074, 16, 24, 21, 2, -24 },
  { 5122, 11, 31, 13, 1, -31 },
  { 5165, 16, 24, 22, 3, -24 },
  { 5213, 17, 24, 20, 1, -24 },
  { 5264, 26, 24, 30, 2, -24 },
  { 5342, 17, 24, 20, 1, -24 },
  { 5393, 17, 33, 19, 1, -24 },
  { 5464, 16, 24, 20, 2, -24 },
  { 5512, 11, 45, 14, 2, -36 },
  { 5574, 2, 39, 10, 4, -33 },
  { 5584, 11, 45, 14, 1, -36 },
  { 5646, 21, 8, 27, 3, -17 },
};

const GFXfont RobotoCondensed_Light46pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light46pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light46pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOCONDENSED_LIGHT46PT7B_H_
