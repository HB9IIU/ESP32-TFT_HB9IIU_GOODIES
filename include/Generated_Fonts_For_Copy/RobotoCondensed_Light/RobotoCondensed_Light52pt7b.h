#ifndef _ROBOTOCONDENSED_LIGHT52PT7B_H_
#define _ROBOTOCONDENSED_LIGHT52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light52pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xE0, 0x00, 0x00, 0x00, 0xEF, 0xE4, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x00, 0x30, 0x18, 0x00,
  0x30, 0x18, 0x00, 0x30, 0x38, 0x00, 0x30, 0x38, 0x00, 0x70, 0x30, 0x00,
  0x70, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00,
  0x60, 0x70, 0x00, 0xE0, 0x70, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01,
  0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01,
  0x81, 0xC0, 0x01, 0x81, 0xC0, 0x03, 0x81, 0x80, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x03, 0x01, 0x80, 0x03, 0x03, 0x80, 0x03, 0x03, 0x80, 0x07,
  0x03, 0x80, 0x07, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06,
  0x03, 0x00, 0x06, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0x0F, 0x87, 0x80, 0x70, 0xE0,
  0x07, 0x1C, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80,
  0x07, 0x70, 0x00, 0xEE, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x0E, 0xE0, 0x01, 0xDE, 0x00, 0x71, 0xE0, 0x1E, 0x1F, 0x0F,
  0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE0, 0x60,
  0x00, 0x0C, 0x07, 0x00, 0x80, 0xC0, 0x30, 0x1C, 0x0C, 0x03, 0x01, 0x80,
  0xC0, 0x30, 0x38, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x30, 0x70, 0x0C, 0x03,
  0x06, 0x00, 0xC0, 0x70, 0xE0, 0x0E, 0x06, 0x0C, 0x00, 0x70, 0xE1, 0xC0,
  0x03, 0xFC, 0x18, 0x00, 0x1F, 0x83, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x40, 0x00, 0x18, 0x3F, 0x80, 0x03, 0x87, 0xFC, 0x00, 0x30, 0xE0, 0xC0,
  0x07, 0x0C, 0x0E, 0x00, 0x60, 0xC0, 0x60, 0x0E, 0x1C, 0x07, 0x00, 0xC1,
  0xC0, 0x70, 0x1C, 0x1C, 0x07, 0x01, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x07,
  0x03, 0x01, 0xC0, 0x70, 0x70, 0x0C, 0x06, 0x02, 0x00, 0xC0, 0xE0, 0x00,
  0x0E, 0x0C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x0E,
  0x00, 0x1E, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x03, 0x00, 0x18, 0x03,
  0x80, 0x18, 0x03, 0x80, 0x18, 0x03, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07,
  0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x70,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x1E, 0xE0, 0x00, 0x3C, 0x70, 0x0C, 0x38, 0x78, 0x0C, 0x70, 0x3C,
  0x0C, 0x70, 0x1C, 0x1C, 0xE0, 0x0E, 0x1C, 0xE0, 0x0F, 0x1C, 0xE0, 0x07,
  0x1C, 0xE0, 0x03, 0xB8, 0xE0, 0x03, 0xF8, 0xE0, 0x01, 0xF0, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0x70, 0x01, 0xF8, 0x78, 0x03, 0xF8, 0x3E, 0x0F,
  0x9C, 0x1F, 0xFF, 0x1E, 0x07, 0xFC, 0x0F, 0x00, 0x40, 0x00, 0xFF, 0xFF,
  0xFF, 0xDB, 0x00, 0x00, 0x20, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01,
  0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x02, 0x40, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x06,
  0x01, 0x80, 0x70, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x80, 0x60, 0x1F, 0x06,
  0x0F, 0xFE, 0x63, 0xF7, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x80, 0x03, 0x9C, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00,
  0xE0, 0x70, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x08, 0x01, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x39, 0xCE, 0x73,
  0x9C, 0xEE, 0x77, 0x38, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x6F, 0xFF, 0x00,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0xF8, 0x0F, 0x87, 0x81, 0xC0, 0x78, 0x70, 0x07, 0x0E, 0x00,
  0x73, 0x80, 0x0E, 0x70, 0x00, 0xCC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x33, 0x80, 0x0E,
  0x38, 0x01, 0xC7, 0x00, 0x70, 0x70, 0x1E, 0x0F, 0x87, 0x80, 0xFF, 0xE0,
  0x07, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x20, 0x1C, 0x1F, 0x8F, 0xF7, 0xE7,
  0xF0, 0xF8, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x00, 0x7F,
  0xC0, 0x0F, 0xFE, 0x01, 0xE0, 0xF0, 0x38, 0x07, 0x87, 0x00, 0x3C, 0x70,
  0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x0C, 0xE0, 0x00, 0xCE,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x00, 0xFF, 0x80,
  0x3F, 0xF8, 0x0F, 0x07, 0x83, 0x80, 0x38, 0xF0, 0x07, 0x9C, 0x00, 0x77,
  0x00, 0x0E, 0xE0, 0x00, 0xDC, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x01, 0xCE, 0x00, 0x39, 0xE0, 0x0E, 0x1F, 0x07, 0xC1, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0x10, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xB8, 0x00,
  0x0E, 0xE0, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0x38,
  0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0,
  0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x03,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE3, 0xF0, 0x1D, 0xFF, 0x83, 0xFF, 0xF8,
  0x7C, 0x0F, 0x8E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0x9C, 0x00, 0x73,
  0x80, 0x0E, 0x78, 0x03, 0xC7, 0x80, 0xF0, 0x78, 0x3C, 0x07, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x0F, 0xC0, 0x63, 0xFE, 0x06, 0x7F, 0xF8, 0xEE, 0x07, 0x8F,
  0xC0, 0x3C, 0xF8, 0x01, 0xCF, 0x00, 0x0E, 0xF0, 0x00, 0xEE, 0x00, 0x0E,
  0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x76, 0x00, 0x06, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80,
  0x1C, 0x3C, 0x01, 0xC1, 0xE0, 0x38, 0x0F, 0x0F, 0x80, 0x7F, 0xF0, 0x03,
  0xFC, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0x01, 0xF0, 0xF8, 0x3C, 0x07, 0x87, 0x80, 0x3C, 0x70, 0x01, 0xC7,
  0x00, 0x1C, 0x70, 0x00, 0xE6, 0x00, 0x0E, 0x60, 0x00, 0xE6, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x00, 0x1C, 0x70, 0x01, 0xC3, 0x80, 0x38, 0x1C, 0x07,
  0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1E, 0x0F, 0x03, 0x80,
  0x38, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x1C, 0x38, 0x03, 0xC3, 0xE0, 0xF8,
  0x1F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xF8, 0x0F, 0x0F, 0x83, 0xC0, 0x70, 0xF0, 0x07, 0x1C, 0x00,
  0xF3, 0x80, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x1B, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xB8, 0x00, 0xF7, 0x00, 0x3E, 0xF0, 0x0F,
  0xCF, 0x03, 0xB8, 0xFF, 0xE7, 0x0F, 0xF8, 0xE0, 0x7C, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00,
  0x1F, 0x00, 0x00, 0x73, 0xFE, 0xE2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xF7, 0xDC, 0x40, 0x33, 0xDE, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE7,
  0x39, 0xCE, 0x73, 0xB9, 0xDC, 0xE2, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x07,
  0xFF, 0x07, 0xC7, 0xC3, 0x80, 0xE3, 0x80, 0x39, 0xC0, 0x1D, 0xC0, 0x06,
  0xE0, 0x03, 0xF0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x00, 0x06, 0x0C, 0x00, 0x7E, 0x00, 0xE3, 0x80,
  0x1F, 0xE0, 0x0C, 0x60, 0x07, 0x9E, 0x01, 0x8C, 0x01, 0xC0, 0xE0, 0x33,
  0x80, 0x70, 0x18, 0x06, 0x60, 0x0C, 0x03, 0x00, 0xEC, 0x03, 0x80, 0x60,
  0x0D, 0x80, 0x60, 0x0C, 0x01, 0xF0, 0x1C, 0x01, 0x80, 0x3E, 0x03, 0x80,
  0x30, 0x07, 0xC0, 0x60, 0x06, 0x00, 0xF8, 0x0C, 0x00, 0xC0, 0x1E, 0x01,
  0x80, 0x38, 0x03, 0xC0, 0x30, 0x07, 0x00, 0x78, 0x0E, 0x00, 0xE0, 0x1F,
  0x01, 0xC0, 0x1C, 0x03, 0x60, 0x38, 0x03, 0x80, 0x6C, 0x07, 0x00, 0x60,
  0x0D, 0xC0, 0x60, 0x0C, 0x01, 0xB8, 0x0C, 0x03, 0x80, 0x67, 0x01, 0xC0,
  0x78, 0x0C, 0x60, 0x38, 0x1F, 0x03, 0x8C, 0x03, 0x8E, 0x70, 0xE1, 0x80,
  0x7F, 0x8F, 0xF8, 0x38, 0x07, 0xE0, 0xFE, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x30, 0x00, 0x01,
  0xFC, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x71, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x06, 0x1C, 0x00,
  0x03, 0x83, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x1C, 0x0E,
  0x00, 0x07, 0x01, 0xC0, 0x01, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38,
  0x03, 0x00, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00,
  0x70, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x06, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xC0, 0x07, 0x8E,
  0x00, 0x1E, 0x70, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00,
  0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x0E, 0x70,
  0x00, 0x73, 0x80, 0x07, 0x9C, 0x00, 0x78, 0xFF, 0xFF, 0x87, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE1, 0xC0, 0x07, 0x8E, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0x80,
  0x01, 0xDC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xDC, 0x00,
  0x0E, 0xE0, 0x00, 0xF7, 0x00, 0x1F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x0F, 0xC1, 0xF0, 0x0F, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x06, 0x70, 0x00, 0x07, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x38, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x78,
  0x0F, 0xC1, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x38, 0x01, 0xF0, 0xE0,
  0x01, 0xE3, 0x80, 0x03, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x0E, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00,
  0x07, 0x38, 0x00, 0x3C, 0xE0, 0x01, 0xE3, 0x80, 0x1F, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7C, 0x1F, 0x81,
  0xE0, 0x07, 0x87, 0x80, 0x07, 0x1E, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0x70,
  0x00, 0x1D, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0xF0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x73,
  0x80, 0x0E, 0x70, 0x03, 0xCF, 0x00, 0xF0, 0xF8, 0x7C, 0x0F, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x73, 0x80,
  0x01, 0xC7, 0x00, 0x07, 0x8E, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x38, 0x00,
  0xE0, 0x70, 0x03, 0xC0, 0xE0, 0x0F, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70,
  0x07, 0x01, 0xC0, 0x0E, 0x07, 0x80, 0x1C, 0x1E, 0x00, 0x38, 0x78, 0x00,
  0x70, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xCF, 0x80, 0x03, 0xBF, 0x80, 0x07,
  0xF7, 0x80, 0x0F, 0xC7, 0x00, 0x1F, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1E, 0x03, 0x80, 0x1C, 0x07, 0x00,
  0x3C, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x70, 0x00,
  0x78, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xF7, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFE, 0xC0, 0x00, 0x0E, 0xFB, 0x80,
  0x00, 0x3B, 0xEE, 0x00, 0x00, 0xEF, 0x98, 0x00, 0x07, 0x3E, 0x70, 0x00,
  0x1C, 0xF9, 0xC0, 0x00, 0x73, 0xE3, 0x80, 0x03, 0x8F, 0x8E, 0x00, 0x0E,
  0x3E, 0x38, 0x00, 0x30, 0xF8, 0x70, 0x01, 0xC3, 0xE1, 0xC0, 0x07, 0x0F,
  0x87, 0x00, 0x18, 0x3E, 0x0E, 0x00, 0xE0, 0xF8, 0x38, 0x03, 0x83, 0xE0,
  0xE0, 0x0C, 0x0F, 0x81, 0xC0, 0x70, 0x3E, 0x07, 0x01, 0xC0, 0xF8, 0x0C,
  0x06, 0x03, 0xE0, 0x38, 0x38, 0x0F, 0x80, 0xE0, 0xE0, 0x3E, 0x01, 0x87,
  0x00, 0xF8, 0x07, 0x1C, 0x03, 0xE0, 0x1C, 0x70, 0x0F, 0x80, 0x33, 0x80,
  0x3E, 0x00, 0xEE, 0x00, 0xF8, 0x03, 0xB0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xE0, 0x03, 0xE0,
  0x03, 0x80, 0x0C, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xEE, 0x00, 0x07,
  0xEE, 0x00, 0x07, 0xE7, 0x00, 0x07, 0xE3, 0x80, 0x07, 0xE3, 0x80, 0x07,
  0xE1, 0xC0, 0x07, 0xE1, 0xC0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xE0, 0x07,
  0xE0, 0x70, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x1C, 0x07,
  0xE0, 0x1C, 0x07, 0xE0, 0x0E, 0x07, 0xE0, 0x0E, 0x07, 0xE0, 0x07, 0x07,
  0xE0, 0x07, 0x07, 0xE0, 0x03, 0x87, 0xE0, 0x03, 0x87, 0xE0, 0x01, 0xC7,
  0xE0, 0x01, 0xE7, 0xE0, 0x00, 0xE7, 0xE0, 0x00, 0x77, 0xE0, 0x00, 0x77,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x08, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0x00, 0x78, 0x1C, 0x00, 0x3C,
  0x3C, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0x60, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x3C,
  0x0F, 0x00, 0x78, 0x0F, 0xC3, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x38,
  0x00, 0x78, 0xE0, 0x00, 0xF3, 0x80, 0x01, 0xEE, 0x00, 0x03, 0xB8, 0x00,
  0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0,
  0x00, 0x7B, 0x80, 0x03, 0xCE, 0x00, 0x1E, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x83, 0xFF, 0xF8, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0x00, 0x78,
  0x1C, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x3C, 0x1F, 0x00, 0x78, 0x0F, 0xC3, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x18, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x02, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x38, 0x00, 0xF8, 0xE0, 0x00, 0xE3, 0x80,
  0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE,
  0x00, 0x03, 0xB8, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x03, 0x8E, 0x00,
  0x3E, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0E, 0x00, 0xE0,
  0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x07,
  0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x7C, 0x1F, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x0F, 0x0E, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x33, 0x80,
  0x00, 0x63, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x77, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0x38,
  0x00, 0x1C, 0x78, 0x00, 0x78, 0x78, 0x01, 0xE0, 0x7E, 0x1F, 0x80, 0x7F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x03,
  0x9C, 0x00, 0x0E, 0x78, 0x00, 0x70, 0xF0, 0x03, 0xC1, 0xF0, 0x7E, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0xF0, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x0E,
  0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01,
  0xC0, 0x01, 0x80, 0x70, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x03,
  0x03, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xC6, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x77, 0x00, 0x03, 0x80, 0x03, 0xB8, 0x00, 0x3C, 0x00, 0x1C, 0xE0,
  0x01, 0xE0, 0x00, 0xE7, 0x00, 0x0F, 0x80, 0x07, 0x38, 0x00, 0x7C, 0x00,
  0x71, 0xC0, 0x07, 0x60, 0x03, 0x8E, 0x00, 0x3B, 0x00, 0x1C, 0x38, 0x01,
  0x9C, 0x00, 0xE1, 0xC0, 0x0C, 0xE0, 0x06, 0x0E, 0x00, 0xE3, 0x00, 0x70,
  0x70, 0x07, 0x18, 0x03, 0x83, 0x80, 0x30, 0xE0, 0x1C, 0x0E, 0x01, 0x87,
  0x00, 0xE0, 0x70, 0x1C, 0x38, 0x06, 0x03, 0x80, 0xE0, 0xC0, 0x70, 0x1C,
  0x06, 0x06, 0x03, 0x80, 0x60, 0x30, 0x38, 0x1C, 0x03, 0x83, 0x81, 0xC0,
  0xE0, 0x1C, 0x1C, 0x06, 0x06, 0x00, 0xE0, 0xE0, 0x30, 0x70, 0x07, 0x06,
  0x01, 0xC3, 0x80, 0x18, 0x70, 0x0E, 0x1C, 0x00, 0xE3, 0x80, 0x30, 0xE0,
  0x07, 0x1C, 0x01, 0x86, 0x00, 0x38, 0xC0, 0x0E, 0x70, 0x01, 0xCE, 0x00,
  0x73, 0x80, 0x06, 0x70, 0x01, 0x9C, 0x00, 0x3B, 0x80, 0x0C, 0xC0, 0x01,
  0xD8, 0x00, 0x76, 0x00, 0x0E, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0x70, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0xC3,
  0x80, 0x01, 0xC3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xE7,
  0x80, 0x01, 0xC3, 0x80, 0x03, 0x83, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x00,
  0xE0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x1E, 0x00, 0x78, 0x1C, 0x00,
  0x38, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x9E, 0x00,
  0x01, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x70, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x1C, 0x00, 0x70, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x1E, 0x07, 0x00,
  0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0,
  0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xFC, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0xFF, 0xFF,
  0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x3E, 0x00, 0x6C, 0x00, 0xDC, 0x03, 0xB8, 0x06, 0x30, 0x1C, 0x70, 0x38,
  0xE0, 0x60, 0xC1, 0xC1, 0xC3, 0x83, 0x86, 0x03, 0x1C, 0x07, 0x38, 0x0E,
  0x60, 0x0D, 0xC0, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x00, 0x00, 0x01, 0xFF, 0x01,
  0xFF, 0xE0, 0xF8, 0x7C, 0x78, 0x07, 0x9C, 0x00, 0xE6, 0x00, 0x3B, 0x80,
  0x07, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x03, 0xFF,
  0xC3, 0xFF, 0xF3, 0xFC, 0x1D, 0xE0, 0x07, 0x70, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x1F, 0xF0, 0x0F, 0xDF, 0x1F, 0x73, 0xFF, 0x9C, 0x7F, 0x87, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x3F, 0xC1, 0xDF, 0xFC, 0x3F, 0x87,
  0xC7, 0xC0, 0x3C, 0xF0, 0x03, 0x9C, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00,
  0xEE, 0x00, 0x1D, 0xC0, 0x01, 0xB8, 0x00, 0x37, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0xC0, 0x0E,
  0x7C, 0x03, 0xCD, 0xE1, 0xF1, 0x9F, 0xFC, 0x30, 0xFF, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x3C, 0x78, 0x07, 0x9C,
  0x00, 0xEE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1D, 0xC0, 0x0E, 0x78, 0x07, 0x8F, 0x87, 0xC1, 0xFF,
  0xE0, 0x1F, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0xFF,
  0x8E, 0x3F, 0xF9, 0xCF, 0x87, 0xBB, 0xC0, 0x3F, 0x70, 0x03, 0xEE, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xEE, 0x00, 0x3D, 0xC0, 0x0F, 0x9C, 0x03, 0xF3, 0xE1, 0xEE, 0x3F, 0xF9,
  0xC1, 0xFE, 0x38, 0x04, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xE0, 0x0F, 0xFF,
  0x01, 0xF0, 0x78, 0x1C, 0x03, 0xC3, 0x80, 0x1C, 0x38, 0x00, 0xE7, 0x00,
  0x0E, 0x70, 0x00, 0xE7, 0x00, 0x06, 0x60, 0x00, 0x6E, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x04, 0x1E, 0x00, 0xE1, 0xF8, 0x3C, 0x0F, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x0F,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x1C, 0x7F, 0xF3, 0x9F, 0x0F, 0x77, 0x80, 0x7E, 0xE0,
  0x07, 0xDC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xDC, 0x00, 0x7B, 0x80, 0x1F, 0x38, 0x07, 0xE7, 0xC3,
  0xDC, 0x7F, 0xF3, 0x83, 0xFC, 0x70, 0x08, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0xC4, 0x00, 0x38, 0xC0, 0x0E, 0x3E, 0x03,
  0xC3, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x3F, 0xC7,
  0x3F, 0xF3, 0xB8, 0x7D, 0xF8, 0x0E, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x06, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x77,
  0xFB, 0xF9, 0xF0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x07, 0xB8, 0x03, 0xCE, 0x01,
  0xE3, 0x80, 0xF0, 0xE0, 0x38, 0x38, 0x1C, 0x0E, 0x0E, 0x03, 0x87, 0x80,
  0xE3, 0xC0, 0x39, 0xE0, 0x0E, 0x70, 0x03, 0xB8, 0x00, 0xFF, 0x00, 0x3E,
  0xE0, 0x0F, 0xB8, 0x03, 0xC7, 0x00, 0xE0, 0xE0, 0x38, 0x3C, 0x0E, 0x07,
  0x03, 0x80, 0xE0, 0xE0, 0x3C, 0x38, 0x07, 0x0E, 0x00, 0xE3, 0x80, 0x3C,
  0xE0, 0x07, 0x38, 0x00, 0xEE, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x80, 0xC3, 0xFC, 0x0F, 0xF8, 0xCF, 0xFE, 0x1F, 0xFC, 0xDE, 0x1F,
  0x3C, 0x3E, 0xD8, 0x07, 0x70, 0x0E, 0xF0, 0x07, 0xE0, 0x0E, 0xF0, 0x03,
  0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03,
  0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03,
  0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03,
  0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03,
  0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03,
  0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03,
  0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x00, 0x71, 0xFE, 0x39, 0xFF, 0x9D, 0xC3, 0xEF, 0xC0,
  0x77, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xF0, 0xF8,
  0x3C, 0x03, 0xC7, 0x80, 0x1C, 0x70, 0x00, 0xEF, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7,
  0x80, 0x1C, 0x3C, 0x03, 0xC1, 0xF0, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x18, 0x7F, 0x83, 0x3F, 0xF8, 0x6F, 0x0F,
  0x8F, 0x80, 0x79, 0xE0, 0x07, 0x38, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01,
  0xDC, 0x00, 0x3B, 0x80, 0x03, 0x70, 0x00, 0x6E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1B, 0x80, 0x03,
  0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x80, 0x1C,
  0xF8, 0x07, 0x9F, 0xC3, 0xE3, 0xBF, 0xF8, 0x73, 0xFE, 0x0E, 0x04, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x1C, 0x7F, 0xF3, 0x9F, 0x07, 0x77, 0x80, 0x7E,
  0xE0, 0x07, 0xDC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xDC, 0x00, 0x7B, 0x80, 0x0F, 0x38, 0x03, 0xE7,
  0xC1, 0xDC, 0x7F, 0xF3, 0x87, 0xFC, 0x70, 0x08, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x1C, 0xFF,
  0xBF, 0xFF, 0xFF, 0xC1, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0x87, 0x83, 0xE7, 0x80, 0x73, 0x80,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xB8, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0x70, 0x07, 0xBF, 0x0F, 0x8F, 0xFF, 0x81, 0xFF, 0x80,
  0x08, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x7F, 0x03, 0xF0, 0x04, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1E, 0xE0, 0x1F, 0x7C,
  0x3D, 0x9F, 0xFC, 0xC7, 0xFC, 0x60, 0x20, 0x00, 0xE0, 0x00, 0x77, 0x00,
  0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38,
  0x01, 0xC1, 0xC0, 0x18, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x0C, 0x03, 0x00,
  0xE0, 0x70, 0x0E, 0x07, 0x00, 0x60, 0x60, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x03, 0x0E, 0x00, 0x38, 0xC0, 0x03, 0x9C, 0x00, 0x19, 0xC0, 0x01, 0x98,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x60, 0x00, 0xE0, 0x03, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0x7E,
  0x00, 0x78, 0x01, 0x98, 0x01, 0xE0, 0x0E, 0x70, 0x0F, 0x80, 0x39, 0xC0,
  0x3F, 0x00, 0xE7, 0x00, 0xDC, 0x03, 0x0C, 0x03, 0x70, 0x1C, 0x38, 0x1C,
  0xC0, 0x70, 0xE0, 0x73, 0x81, 0xC3, 0x81, 0x8E, 0x06, 0x06, 0x06, 0x18,
  0x38, 0x1C, 0x38, 0x60, 0xE0, 0x70, 0xE1, 0xC3, 0x81, 0xC3, 0x07, 0x0C,
  0x03, 0x1C, 0x0C, 0x30, 0x0E, 0x70, 0x39, 0xC0, 0x39, 0x80, 0xE7, 0x00,
  0xE6, 0x01, 0x98, 0x01, 0xB8, 0x06, 0x60, 0x07, 0xE0, 0x1F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0,
  0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0x70, 0x00,
  0xE3, 0x80, 0x1E, 0x3C, 0x01, 0xC1, 0xC0, 0x38, 0x1E, 0x03, 0x80, 0xE0,
  0x70, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x03, 0x9E, 0x00, 0x39, 0xC0, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xDC, 0x00, 0x39, 0xC0, 0x07, 0x8E, 0x00, 0x70, 0xE0,
  0x0E, 0x07, 0x00, 0xE0, 0x78, 0x1C, 0x03, 0x81, 0xC0, 0x1C, 0x38, 0x01,
  0xC7, 0x80, 0x0E, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0xE7, 0x00, 0x0E, 0x70,
  0x00, 0xE7, 0x00, 0x0E, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC1,
  0xC0, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x0C, 0x03, 0x00, 0xE0, 0x70,
  0x0E, 0x07, 0x00, 0x60, 0x60, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0x38, 0xC0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x01, 0xD8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x10,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0x80, 0xF8, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xF8, 0x03, 0xC0, 0x3E, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x78, 0x07, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x80,
  0x0D, 0xFF, 0x80, 0x1B, 0x87, 0x80, 0x7E, 0x07, 0x80, 0xF8, 0x07, 0xC3,
  0xB0, 0x03, 0xFF, 0x60, 0x03, 0xFC, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_Light52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 38, 11, 4, -37 },
  { 20, 8, 12, 15, 4, -39 },
  { 32, 24, 37, 27, 2, -37 },
  { 143, 19, 49, 25, 3, -43 },
  { 260, 28, 39, 33, 3, -38 },
  { 397, 24, 39, 28, 3, -38 },
  { 514, 3, 11, 9, 3, -39 },
  { 519, 11, 53, 15, 3, -41 },
  { 592, 11, 53, 15, 1, -41 },
  { 665, 20, 21, 22, 1, -37 },
  { 718, 21, 27, 26, 2, -31 },
  { 789, 5, 12, 10, 2, -5 },
  { 797, 10, 3, 13, 2, -18 },
  { 801, 4, 5, 12, 4, -4 },
  { 804, 16, 40, 18, 1, -37 },
  { 884, 19, 39, 25, 3, -38 },
  { 977, 11, 37, 25, 4, -37 },
  { 1028, 20, 38, 25, 3, -38 },
  { 1123, 19, 39, 25, 3, -38 },
  { 1216, 22, 37, 25, 2, -37 },
  { 1318, 19, 38, 25, 4, -37 },
  { 1409, 20, 38, 25, 3, -37 },
  { 1504, 21, 37, 25, 2, -37 },
  { 1602, 20, 39, 25, 3, -38 },
  { 1700, 19, 38, 25, 3, -38 },
  { 1791, 5, 28, 10, 3, -27 },
  { 1809, 5, 34, 10, 2, -27 },
  { 1831, 18, 22, 23, 2, -28 },
  { 1881, 18, 14, 25, 4, -24 },
  { 1913, 18, 22, 24, 3, -28 },
  { 1963, 17, 39, 21, 2, -38 },
  { 2046, 35, 48, 41, 3, -36 },
  { 2256, 26, 37, 29, 1, -37 },
  { 2377, 21, 37, 28, 4, -37 },
  { 2475, 24, 39, 29, 3, -38 },
  { 2592, 22, 37, 30, 4, -37 },
  { 2694, 20, 37, 26, 4, -37 },
  { 2787, 20, 37, 26, 4, -37 },
  { 2880, 23, 39, 31, 4, -38 },
  { 2993, 24, 37, 32, 4, -37 },
  { 3104, 3, 37, 13, 5, -37 },
  { 3118, 19, 38, 25, 2, -37 },
  { 3209, 23, 37, 29, 4, -37 },
  { 3316, 19, 37, 24, 4, -37 },
  { 3404, 30, 37, 39, 4, -37 },
  { 3543, 24, 37, 32, 4, -37 },
  { 3654, 24, 39, 31, 3, -38 },
  { 3771, 22, 37, 28, 4, -37 },
  { 3873, 24, 44, 31, 3, -38 },
  { 4005, 22, 37, 29, 4, -37 },
  { 4107, 23, 39, 27, 2, -38 },
  { 4220, 24, 37, 27, 2, -37 },
  { 4331, 22, 38, 30, 4, -37 },
  { 4436, 26, 37, 28, 1, -37 },
  { 4557, 37, 37, 40, 2, -37 },
  { 4729, 24, 37, 28, 2, -37 },
  { 4840, 25, 37, 27, 1, -37 },
  { 4956, 23, 37, 27, 2, -37 },
  { 5063, 7, 50, 12, 4, -42 },
  { 5107, 15, 40, 18, 2, -37 },
  { 5182, 7, 50, 12, 1, -42 },
  { 5226, 15, 18, 19, 2, -37 },
  { 5260, 19, 3, 20, 1, 0 },
  { 5268, 8, 7, 15, 3, -39 },
  { 5275, 18, 29, 25, 3, -28 },
  { 5341, 19, 40, 25, 4, -39 },
  { 5436, 18, 29, 24, 3, -28 },
  { 5502, 19, 40, 25, 3, -39 },
  { 5597, 20, 29, 24, 2, -28 },
  { 5670, 13, 40, 16, 2, -40 },
  { 5735, 19, 39, 25, 3, -28 },
  { 5828, 17, 39, 25, 4, -39 },
  { 5911, 3, 37, 11, 4, -37 },
  { 5925, 9, 48, 11, -2, -37 },
  { 5979, 18, 39, 23, 4, -39 },
  { 6067, 3, 39, 11, 4, -39 },
  { 6082, 32, 28, 40, 4, -28 },
  { 6194, 17, 28, 25, 4, -28 },
  { 6254, 20, 29, 26, 3, -28 },
  { 6327, 19, 39, 25, 4, -28 },
  { 6420, 19, 39, 25, 3, -28 },
  { 6513, 11, 28, 16, 4, -28 },
  { 6552, 17, 29, 23, 3, -28 },
  { 6614, 12, 36, 15, 1, -35 },
  { 6668, 17, 28, 25, 4, -27 },
  { 6728, 20, 27, 22, 1, -27 },
  { 6796, 30, 27, 34, 2, -27 },
  { 6898, 20, 27, 22, 1, -27 },
  { 6966, 20, 38, 22, 1, -27 },
  { 7061, 19, 27, 22, 2, -27 },
  { 7126, 13, 51, 16, 2, -41 },
  { 7209, 2, 44, 12, 5, -37 },
  { 7220, 13, 51, 16, 1, -41 },
  { 7303, 23, 9, 31, 4, -20 },
};

const GFXfont RobotoCondensed_Light52pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light52pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light52pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOCONDENSED_LIGHT52PT7B_H_
