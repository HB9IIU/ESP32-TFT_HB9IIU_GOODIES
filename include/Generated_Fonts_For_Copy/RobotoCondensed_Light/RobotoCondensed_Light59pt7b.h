#ifndef _ROBOTOCONDENSED_LIGHT59PT7B_H_
#define _ROBOTOCONDENSED_LIGHT59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light59pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x11, 0xDF, 0xFB, 0x88, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x6E, 0x1B, 0x86, 0xE1, 0x80, 0x00, 0x18, 0x06,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x30,
  0x0C, 0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8,
  0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x60, 0x18, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C,
  0x00, 0x06, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70,
  0x1C, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x70, 0x1C, 0x00,
  0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xF0,
  0x1F, 0x07, 0x80, 0x3E, 0x3C, 0x00, 0x78, 0xF0, 0x00, 0xE3, 0x80, 0x03,
  0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x70, 0x00, 0x1D,
  0xC0, 0x00, 0x77, 0x80, 0x03, 0xCE, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0x7C,
  0x07, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x70,
  0x18, 0x01, 0x00, 0x60, 0x1C, 0x01, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0,
  0x0C, 0x03, 0x00, 0xE0, 0x0C, 0x07, 0x00, 0xE0, 0x0C, 0x06, 0x00, 0xE0,
  0x0C, 0x0E, 0x00, 0xE0, 0x0C, 0x0C, 0x00, 0xE0, 0x1C, 0x1C, 0x00, 0x60,
  0x1C, 0x18, 0x00, 0x70, 0x18, 0x38, 0x00, 0x70, 0x38, 0x30, 0x00, 0x38,
  0x78, 0x70, 0x00, 0x1F, 0xF0, 0xE0, 0x00, 0x0F, 0xE0, 0xE0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x07, 0xF0, 0x00, 0x07, 0x0F, 0xF8, 0x00,
  0x0E, 0x1E, 0x1C, 0x00, 0x0C, 0x1C, 0x0E, 0x00, 0x1C, 0x38, 0x0E, 0x00,
  0x18, 0x38, 0x06, 0x00, 0x38, 0x38, 0x07, 0x00, 0x30, 0x30, 0x07, 0x00,
  0x70, 0x30, 0x07, 0x00, 0x60, 0x30, 0x07, 0x00, 0xE0, 0x30, 0x07, 0x00,
  0xC0, 0x30, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x03, 0x80, 0x38, 0x06, 0x01,
  0x80, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1E, 0x1C, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x0E, 0x00, 0xE0, 0x01,
  0xE0, 0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x00,
  0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xE0, 0x3C, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x70, 0xF8, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x3B,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E,
  0x3C, 0x01, 0xC3, 0xC1, 0xE0, 0x1C, 0x38, 0x0F, 0x01, 0xC7, 0x80, 0x70,
  0x1C, 0x70, 0x07, 0x83, 0x8F, 0x00, 0x3C, 0x38, 0xF0, 0x01, 0xE3, 0x8E,
  0x00, 0x1E, 0x38, 0xE0, 0x00, 0xF7, 0x0E, 0x00, 0x07, 0xF0, 0xF0, 0x00,
  0x3F, 0x07, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xF0,
  0x3C, 0x00, 0x7F, 0x03, 0xE0, 0x1F, 0x78, 0x1F, 0xFF, 0xE3, 0xC0, 0xFF,
  0xFC, 0x1C, 0x03, 0xFF, 0x01, 0xE0, 0x03, 0x00, 0x00, 0x77, 0x77, 0x76,
  0x66, 0x66, 0xEE, 0xE0, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x20,
  0x40, 0x06, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x06, 0x00, 0x40, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x20, 0x1C, 0x00, 0xF0, 0x38, 0x1F, 0xFC, 0x71,
  0xFD, 0xFF, 0xEF, 0xF8, 0x7F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x77, 0x00, 0x01, 0xEF, 0x00, 0x07, 0x8F, 0x00,
  0x0E, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x1E, 0x03,
  0x80, 0x1C, 0x02, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCE, 0x39, 0xCF, 0x38,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0xF2, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0x01, 0xE0, 0x78, 0x03, 0xC3, 0xC0,
  0x07, 0x0E, 0x00, 0x1E, 0x38, 0x00, 0x39, 0xE0, 0x00, 0xE7, 0x00, 0x03,
  0xDC, 0x00, 0x0F, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x70,
  0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00,
  0x3D, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x3C, 0x00, 0x78,
  0x70, 0x01, 0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x18, 0x03, 0xC0, 0xFE,
  0x1F, 0xF3, 0xFF, 0xFF, 0x3F, 0xE1, 0xF8, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFF, 0x01, 0xE0, 0x1E, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x1C,
  0x3C, 0x00, 0x3C, 0x70, 0x00, 0x39, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0xE7,
  0x00, 0x01, 0xCE, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1E, 0x01, 0xE0, 0xF0, 0x03,
  0xC3, 0x80, 0x07, 0x1E, 0x00, 0x1E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xEF,
  0x00, 0x03, 0xBC, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0x70,
  0x00, 0x39, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x0F, 0x80, 0x7C, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x87, 0x00, 0x03, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x01,
  0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0xF0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x3C, 0x00, 0xE0,
  0x1C, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x0E,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x3F, 0x80, 0x77, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0xF0,
  0x07, 0xC7, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1D, 0xE0, 0x00, 0xE7, 0x00, 0x0F, 0x3C, 0x00,
  0xF0, 0xF8, 0x0F, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0x08, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFE,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x3F, 0x80, 0xE3, 0xFF,
  0x83, 0x9F, 0xFF, 0x0E, 0xF8, 0x3E, 0x3F, 0x80, 0x78, 0xF8, 0x00, 0xF3,
  0xE0, 0x01, 0xCF, 0x00, 0x07, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0xEE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x39, 0xC0, 0x00, 0xE7,
  0x00, 0x07, 0x9E, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0x81, 0xF0,
  0x3E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xF0, 0x1F, 0x07, 0x80, 0x1E,
  0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x78, 0x00, 0x38, 0xE0, 0x00, 0x79,
  0xC0, 0x00, 0xF3, 0x80, 0x01, 0xE7, 0x00, 0x03, 0xCE, 0x00, 0x07, 0x9E,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x78, 0x00, 0xE0, 0x78,
  0x03, 0xC0, 0x7C, 0x1F, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xF0, 0x07, 0xC1, 0xF0, 0x1E, 0x00, 0xF0, 0x78, 0x00, 0xF1, 0xE0, 0x00,
  0xE3, 0x80, 0x01, 0xE7, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xB8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x73,
  0x80, 0x00, 0xE7, 0x00, 0x03, 0xCF, 0x00, 0x07, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xF0, 0x1E, 0x03, 0xE0, 0xF0, 0x07, 0x83, 0x80, 0x0F, 0x1E, 0x00, 0x1C,
  0x70, 0x00, 0x79, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0x70, 0x00, 0x3D,
  0xE0, 0x00, 0xF7, 0x80, 0x07, 0xCF, 0x00, 0x3F, 0x3E, 0x01, 0xDC, 0x7C,
  0x1E, 0x70, 0xFF, 0xF1, 0xC1, 0xFF, 0x8E, 0x01, 0xF8, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00,
  0x00, 0xF7, 0xFF, 0xE2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xC4, 0x3C, 0xF3, 0xCF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x71, 0xC7, 0x1C, 0xF3, 0xCF, 0x38, 0xE7, 0x9C,
  0xE1, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x00, 0x18, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x1F, 0x80, 0x0C,
  0x1C, 0x00, 0x7F, 0xC0, 0x0E, 0x1C, 0x00, 0xFF, 0xF0, 0x0E, 0x38, 0x01,
  0xE0, 0x70, 0x06, 0x38, 0x01, 0xC0, 0x70, 0x06, 0x38, 0x03, 0x80, 0x70,
  0x06, 0x30, 0x03, 0x80, 0x70, 0x07, 0x70, 0x07, 0x00, 0x70, 0x07, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x70, 0x0E, 0x00,
  0x70, 0x07, 0x60, 0x0E, 0x00, 0x70, 0x07, 0x60, 0x0C, 0x00, 0x70, 0x07,
  0x60, 0x1C, 0x00, 0x70, 0x07, 0x60, 0x1C, 0x00, 0x60, 0x07, 0xE0, 0x1C,
  0x00, 0x60, 0x07, 0xE0, 0x1C, 0x00, 0x60, 0x07, 0xE0, 0x1C, 0x00, 0x60,
  0x07, 0xE0, 0x1C, 0x00, 0xE0, 0x06, 0x60, 0x1C, 0x00, 0xE0, 0x06, 0x60,
  0x1C, 0x00, 0xE0, 0x06, 0x60, 0x1C, 0x00, 0xE0, 0x0E, 0x60, 0x1C, 0x01,
  0xE0, 0x0C, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x70, 0x0E, 0x03, 0x60, 0x1C,
  0x70, 0x0F, 0x07, 0x70, 0x38, 0x70, 0x07, 0xDE, 0x78, 0x70, 0x38, 0x07,
  0xFC, 0x3F, 0xE0, 0x38, 0x03, 0xF8, 0x1F, 0xC0, 0x38, 0x00, 0x40, 0x02,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x78, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0E,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xF0, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87,
  0x00, 0x1F, 0x8E, 0x00, 0x0F, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0x70,
  0x00, 0x1E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00,
  0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0x70, 0x00,
  0x1C, 0xE0, 0x00, 0x79, 0xC0, 0x01, 0xE3, 0x80, 0x0F, 0x87, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x38, 0x00, 0x7C, 0x70, 0x00, 0x3C,
  0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xEE, 0x00,
  0x03, 0xDC, 0x00, 0x0F, 0x38, 0x00, 0x7E, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x07, 0xC3,
  0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x38, 0xE0, 0x00,
  0x0E, 0x3C, 0x00, 0x07, 0x87, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3E,
  0x00, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x30, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x1C, 0x00, 0xFE, 0x0E, 0x00, 0x0F, 0x87, 0x00, 0x03, 0xE3, 0x80, 0x00,
  0xF1, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0xB8, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x70, 0x00,
  0x07, 0x38, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x8E, 0x00, 0x07, 0xC7, 0x00,
  0x07, 0xC3, 0x80, 0x1F, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xF8, 0x03, 0xF0,
  0x3E, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E,
  0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9E, 0x00, 0x1E,
  0x78, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xE0, 0x3E, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xB8,
  0x00, 0x03, 0xCE, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x78,
  0x38, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x03,
  0xC0, 0x38, 0x01, 0xF0, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x00, 0xE0,
  0x1E, 0x00, 0x38, 0x0F, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0x81, 0xE0, 0x00,
  0xE0, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0x8F, 0x80,
  0x00, 0xE7, 0xF0, 0x00, 0x3B, 0xFC, 0x00, 0x0F, 0xE7, 0x80, 0x03, 0xF0,
  0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x03,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x3C,
  0x03, 0x80, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x0E, 0x00,
  0x07, 0x83, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xB8, 0x00,
  0x00, 0x77, 0xEE, 0x00, 0x00, 0x1D, 0xFB, 0xC0, 0x00, 0x0F, 0x7E, 0x70,
  0x00, 0x03, 0x9F, 0x9C, 0x00, 0x00, 0xE7, 0xE7, 0x80, 0x00, 0x79, 0xF8,
  0xE0, 0x00, 0x1C, 0x7E, 0x38, 0x00, 0x07, 0x1F, 0x8F, 0x00, 0x03, 0xC7,
  0xE1, 0xC0, 0x00, 0xE1, 0xF8, 0x70, 0x00, 0x38, 0x7E, 0x1E, 0x00, 0x1E,
  0x1F, 0x83, 0x80, 0x07, 0x07, 0xE0, 0xE0, 0x01, 0xC1, 0xF8, 0x1C, 0x00,
  0xF0, 0x7E, 0x07, 0x00, 0x38, 0x1F, 0x81, 0xC0, 0x0E, 0x07, 0xE0, 0x38,
  0x07, 0x01, 0xF8, 0x0E, 0x01, 0xC0, 0x7E, 0x03, 0x80, 0x70, 0x1F, 0x80,
  0x70, 0x38, 0x07, 0xE0, 0x1C, 0x0E, 0x01, 0xF8, 0x07, 0x03, 0x80, 0x7E,
  0x00, 0xE1, 0xC0, 0x1F, 0x80, 0x38, 0x70, 0x07, 0xE0, 0x0F, 0x1C, 0x01,
  0xF8, 0x01, 0xCE, 0x00, 0x7E, 0x00, 0x73, 0x80, 0x1F, 0x80, 0x1E, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x07, 0x80, 0x07, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x00,
  0x38, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xB8, 0x00, 0x07, 0xE7, 0x00, 0x01, 0xF9, 0xE0, 0x00, 0x7E,
  0x38, 0x00, 0x1F, 0x8F, 0x00, 0x07, 0xE1, 0xC0, 0x01, 0xF8, 0x78, 0x00,
  0x7E, 0x0E, 0x00, 0x1F, 0x83, 0xC0, 0x07, 0xE0, 0x70, 0x01, 0xF8, 0x0E,
  0x00, 0x7E, 0x03, 0xC0, 0x1F, 0x80, 0x70, 0x07, 0xE0, 0x1E, 0x01, 0xF8,
  0x03, 0x80, 0x7E, 0x00, 0xF0, 0x1F, 0x80, 0x1C, 0x07, 0xE0, 0x07, 0x81,
  0xF8, 0x00, 0xE0, 0x7E, 0x00, 0x1C, 0x1F, 0x80, 0x07, 0x87, 0xE0, 0x00,
  0xE1, 0xF8, 0x00, 0x3C, 0x7E, 0x00, 0x07, 0x1F, 0x80, 0x01, 0xE7, 0xE0,
  0x00, 0x39, 0xF8, 0x00, 0x0F, 0x7E, 0x00, 0x01, 0xDF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x04, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xF8, 0x03,
  0xE0, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x3C, 0x78,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x78, 0x78, 0x00, 0x0E, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xE0, 0x01,
  0xF8, 0xE0, 0x00, 0x7C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0x7C, 0xE0, 0x01, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xE0,
  0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x78, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78,
  0x78, 0x00, 0x1E, 0x07, 0x80, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x02, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x10, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1C, 0x00, 0x7E, 0x0E, 0x00, 0x07, 0x87,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x0E,
  0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00,
  0x1E, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x8E, 0x00,
  0x07, 0x87, 0x00, 0x0F, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0x70, 0x03, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x78, 0x0E,
  0x00, 0x1C, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xE0,
  0xE0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07,
  0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x39, 0xC0, 0x00,
  0x1E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF0, 0x07, 0xC1,
  0xF0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07,
  0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x3E, 0x00,
  0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0xF0, 0x7C,
  0x01, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x02, 0x00, 0x00, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70,
  0x0F, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01,
  0xE0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x70, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x70, 0x00, 0x3E, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0xC0, 0x01,
  0xE7, 0x80, 0x03, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0xFC, 0x00, 0x1C, 0x38,
  0x00, 0x73, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0xE0, 0x03, 0xC3, 0xC0, 0x07,
  0x38, 0x00, 0xE0, 0x70, 0x01, 0xCE, 0x00, 0x38, 0x1C, 0x00, 0xE1, 0x80,
  0x0E, 0x07, 0x00, 0x38, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x1C, 0x01, 0xE0,
  0x78, 0x03, 0x87, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0xC0, 0x1C, 0x03, 0x80,
  0x70, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x03,
  0x80, 0xF0, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x1C, 0x0E,
  0x00, 0x70, 0x38, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0x07,
  0x07, 0x00, 0x70, 0x70, 0x01, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0x38, 0x70,
  0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x03, 0x86, 0x00, 0x38,
  0x70, 0x00, 0xE3, 0x80, 0x06, 0x38, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00,
  0x07, 0x38, 0x00, 0x73, 0x80, 0x01, 0xCC, 0x00, 0x1C, 0xE0, 0x00, 0x77,
  0x00, 0x03, 0x38, 0x00, 0x1D, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38,
  0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x03, 0xC0, 0x03, 0xC0, 0x3C,
  0x00, 0x1C, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x0F, 0x0F, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x3C,
  0x03, 0xC0, 0x07, 0x80, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x38,
  0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xFF,
  0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1D, 0xC0, 0x0E,
  0x70, 0x07, 0x38, 0x07, 0x1C, 0x03, 0x87, 0x01, 0xC3, 0x81, 0xC1, 0xC0,
  0xE0, 0x70, 0x70, 0x38, 0x70, 0x1C, 0x38, 0x07, 0x1C, 0x03, 0x9C, 0x01,
  0xCE, 0x00, 0x77, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xE0, 0x1E,
  0x1E, 0x00, 0x79, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xF8, 0x03, 0x8F, 0x00,
  0x1C, 0xF0, 0x00, 0xE7, 0x00, 0x07, 0x78, 0x00, 0x3B, 0x80, 0x01, 0xDC,
  0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x07, 0xBC, 0x00, 0x3C, 0xE0, 0x03,
  0xE7, 0x80, 0x7F, 0x9F, 0xFF, 0xBC, 0x7F, 0xF9, 0xE1, 0xFF, 0x07, 0x00,
  0x80, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x10, 0x03, 0x87, 0xFC, 0x0E, 0x3F, 0xFC, 0x39, 0xFF, 0xF8, 0xEE, 0x01,
  0xE3, 0xF0, 0x03, 0xCF, 0x80, 0x07, 0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x3B,
  0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE,
  0x00, 0x03, 0xB8, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x01, 0xEF, 0x80,
  0x07, 0x3F, 0x00, 0x3C, 0xEE, 0x01, 0xE3, 0x9F, 0xFF, 0x8E, 0x3F, 0xFC,
  0x38, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xE0, 0x1E, 0x1E, 0x00, 0x79, 0xE0, 0x01,
  0xCE, 0x00, 0x0F, 0x70, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0xFE, 0x00, 0x07, 0x70, 0x00, 0x3B,
  0x80, 0x01, 0xDE, 0x00, 0x1C, 0x78, 0x01, 0xE3, 0xE0, 0x1E, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x02, 0x03, 0x81, 0xFF, 0x1C, 0x3F, 0xFC,
  0xE3, 0xFF, 0xF7, 0x3E, 0x01, 0xF9, 0xE0, 0x07, 0xDE, 0x00, 0x1E, 0xF0,
  0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xBC, 0x00,
  0x1C, 0xE0, 0x01, 0xE7, 0x80, 0x1F, 0x1E, 0x01, 0xF8, 0xFF, 0xFD, 0xC3,
  0xFF, 0xCE, 0x07, 0xFC, 0x70, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xE0, 0x1E, 0x1E, 0x00, 0x79,
  0xE0, 0x01, 0xCE, 0x00, 0x0F, 0x70, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x61, 0xF0, 0x0F,
  0x8F, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x10, 0x00, 0x00,
  0x08, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3C, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x00, 0x20, 0x00, 0x1F, 0xF1, 0xC3, 0xFF, 0xCE, 0x3F, 0xFF, 0x73, 0xE0,
  0x1F, 0x9E, 0x00, 0x7D, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0x70, 0x00, 0x3B,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0xC0, 0x01, 0xDE, 0x00, 0x1E, 0x78,
  0x01, 0xF1, 0xE0, 0x1F, 0x8F, 0xFF, 0xDC, 0x3F, 0xFC, 0xE0, 0x7F, 0xC7,
  0x00, 0x60, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x40, 0x01, 0xC7, 0x80, 0x1E, 0x3F, 0x03, 0xE0,
  0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x0F, 0xF0, 0xE3, 0xFF, 0x8E, 0x7F, 0xFC,
  0xEF, 0x03, 0xEE, 0xC0, 0x0E, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x6F, 0xFF,
  0x70, 0x00, 0x00, 0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x01, 0x80, 0xF0, 0x3C,
  0x0F, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78,
  0x3E, 0xFF, 0x3F, 0x8F, 0xC0, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0xF3, 0x80, 0x07, 0x9C, 0x00, 0x78, 0xE0,
  0x07, 0x87, 0x00, 0x78, 0x38, 0x07, 0x81, 0xC0, 0x78, 0x0E, 0x03, 0xC0,
  0x70, 0x3C, 0x03, 0x83, 0xC0, 0x1C, 0x3C, 0x00, 0xE3, 0xC0, 0x07, 0x3C,
  0x00, 0x39, 0xE0, 0x01, 0xDF, 0x80, 0x0F, 0xFE, 0x00, 0x7E, 0xF0, 0x03,
  0xE3, 0xC0, 0x1E, 0x0F, 0x00, 0xE0, 0x78, 0x07, 0x01, 0xE0, 0x38, 0x07,
  0x81, 0xC0, 0x3C, 0x0E, 0x00, 0xF0, 0x70, 0x03, 0xC3, 0x80, 0x1E, 0x1C,
  0x00, 0x78, 0xE0, 0x01, 0xE7, 0x00, 0x0F, 0x38, 0x00, 0x3D, 0xC0, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x08, 0x07, 0x0F,
  0xF8, 0x07, 0xFC, 0x38, 0xFF, 0xE0, 0xFF, 0xF1, 0xCF, 0xFF, 0x8F, 0xFF,
  0xCE, 0xE0, 0x3E, 0xF0, 0x1E, 0x7E, 0x00, 0xF7, 0x00, 0x7B, 0xE0, 0x03,
  0xF0, 0x01, 0xDF, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x7F,
  0x80, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x00, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0x80,
  0x01, 0xC0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00,
  0x3F, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x00,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x1F,
  0x80, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x00, 0x70,
  0x00, 0x3F, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x0F, 0xC0,
  0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0x38, 0x00,
  0x1F, 0x80, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x0F, 0xF0, 0xE3, 0xFF, 0x8E, 0x7F, 0xFC, 0xEF, 0x03, 0xEE, 0xC0,
  0x0E, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xF0, 0x1F, 0x07, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x3B, 0xC0,
  0x00, 0x77, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xE1,
  0xE0, 0x03, 0xC1, 0xF0, 0x1F, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x10, 0x03, 0x87, 0xFC, 0x0E, 0x3F,
  0xFC, 0x39, 0xFF, 0xF8, 0xEE, 0x01, 0xE3, 0xF0, 0x03, 0xCF, 0x80, 0x07,
  0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8,
  0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0,
  0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0x3E, 0x00, 0x3C, 0xEE, 0x01,
  0xE3, 0xBF, 0xFF, 0x0E, 0x7F, 0xFC, 0x38, 0x7F, 0xC0, 0xE0, 0x10, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF1, 0xC3,
  0xFF, 0xCE, 0x3F, 0xFF, 0x73, 0xE0, 0x1F, 0x9E, 0x00, 0x7D, 0xE0, 0x01,
  0xEF, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B,
  0xC0, 0x01, 0xDE, 0x00, 0x1E, 0x78, 0x01, 0xF1, 0xE0, 0x1F, 0x8F, 0xFF,
  0xDC, 0x3F, 0xFC, 0xE0, 0x7F, 0xC7, 0x00, 0x60, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x0F, 0xF8, 0xFF, 0xCF, 0xFE, 0xF0, 0x76, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0x81, 0xFF, 0xFC, 0x3C, 0x03, 0xE3, 0x80, 0x1E, 0x78, 0x00, 0xE7,
  0x00, 0x0F, 0x70, 0x00, 0x77, 0x00, 0x07, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0x70,
  0x00, 0xF7, 0x80, 0x0E, 0x3C, 0x03, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x20, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0x81, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xFC, 0x0F, 0xF0,
  0x1F, 0xC0, 0x08, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0x78, 0x01, 0xF3, 0xC0,
  0x7F, 0x3F, 0xFF, 0x71, 0xFF, 0xE7, 0x07, 0xF8, 0x70, 0x08, 0x00, 0x70,
  0x00, 0x1C, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xC3, 0x80,
  0x03, 0x87, 0x00, 0x07, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00,
  0x70, 0x3C, 0x01, 0xE0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x03, 0x83, 0x80,
  0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00,
  0x38, 0xE0, 0x00, 0x39, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0xDC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x78,
  0x00, 0x77, 0x00, 0x1E, 0x00, 0x3D, 0xC0, 0x07, 0x80, 0x0E, 0x70, 0x01,
  0xF0, 0x03, 0x9E, 0x00, 0xFC, 0x00, 0xE3, 0x80, 0x3F, 0x00, 0x38, 0xE0,
  0x0E, 0xE0, 0x1C, 0x38, 0x03, 0x38, 0x07, 0x0F, 0x01, 0xCE, 0x01, 0xC1,
  0xC0, 0x73, 0x80, 0x70, 0x70, 0x1C, 0x70, 0x3C, 0x1C, 0x0E, 0x1C, 0x0E,
  0x07, 0x03, 0x87, 0x03, 0x80, 0xE0, 0xE1, 0xC0, 0xE0, 0x38, 0x38, 0x38,
  0x38, 0x0E, 0x1C, 0x0E, 0x1C, 0x03, 0x87, 0x03, 0x87, 0x00, 0x71, 0xC0,
  0x61, 0xC0, 0x1C, 0x60, 0x1C, 0x70, 0x07, 0x38, 0x07, 0x38, 0x01, 0xCE,
  0x01, 0xCE, 0x00, 0x3B, 0x80, 0x3B, 0x80, 0x0E, 0xC0, 0x0E, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xC3, 0x80,
  0x0F, 0x0F, 0x00, 0x38, 0x1C, 0x01, 0xE0, 0x78, 0x0F, 0x00, 0xE0, 0x38,
  0x03, 0xC1, 0xE0, 0x07, 0x07, 0x00, 0x0E, 0x3C, 0x00, 0x3C, 0xE0, 0x00,
  0x77, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0xF7, 0x80,
  0x03, 0x8E, 0x00, 0x1E, 0x1C, 0x00, 0x70, 0x78, 0x03, 0xC0, 0xE0, 0x1E,
  0x03, 0xC0, 0x78, 0x07, 0x03, 0xC0, 0x1E, 0x0E, 0x00, 0x3C, 0x78, 0x00,
  0xF1, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x1D, 0xC0, 0x00,
  0x77, 0x80, 0x03, 0xDE, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xF0, 0x01, 0xE3,
  0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x78, 0x03, 0xC0, 0xE0,
  0x0E, 0x03, 0x80, 0x38, 0x0F, 0x01, 0xE0, 0x1C, 0x07, 0x00, 0x70, 0x1C,
  0x01, 0xE0, 0xF0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00,
  0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0xE0, 0x00, 0x3B,
  0x80, 0x00, 0xEE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x04, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x03, 0xC0, 0x0F,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0xF0, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x03,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x1C, 0xFF, 0xE0, 0x03,
  0x9E, 0x3E, 0x00, 0x77, 0x03, 0xE0, 0x0E, 0xE0, 0x3E, 0x03, 0xB8, 0x03,
  0xE0, 0x77, 0x00, 0x3E, 0x3C, 0xE0, 0x03, 0xFF, 0x9C, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph RobotoCondensed_Light59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 43, 13, 4, -42 },
  { 28, 10, 13, 17, 4, -44 },
  { 45, 27, 42, 30, 3, -42 },
  { 187, 22, 55, 29, 3, -49 },
  { 339, 32, 44, 38, 3, -43 },
  { 515, 28, 44, 32, 3, -43 },
  { 669, 4, 13, 10, 3, -44 },
  { 676, 12, 61, 17, 4, -47 },
  { 768, 12, 61, 18, 1, -47 },
  { 860, 23, 24, 25, 1, -42 },
  { 929, 25, 30, 29, 2, -34 },
  { 1023, 6, 13, 11, 2, -6 },
  { 1033, 11, 3, 15, 2, -20 },
  { 1038, 5, 5, 14, 4, -4 },
  { 1042, 18, 46, 21, 1, -42 },
  { 1146, 22, 44, 29, 3, -43 },
  { 1267, 13, 42, 29, 5, -42 },
  { 1336, 23, 43, 29, 3, -43 },
  { 1460, 22, 44, 29, 3, -43 },
  { 1581, 25, 42, 29, 2, -42 },
  { 1713, 21, 43, 29, 5, -42 },
  { 1826, 22, 43, 29, 4, -42 },
  { 1945, 24, 42, 29, 2, -42 },
  { 2071, 23, 44, 29, 3, -43 },
  { 2198, 22, 43, 29, 3, -43 },
  { 2317, 5, 32, 12, 4, -31 },
  { 2337, 6, 38, 11, 2, -31 },
  { 2366, 20, 24, 26, 2, -31 },
  { 2426, 20, 15, 29, 4, -27 },
  { 2464, 20, 24, 27, 4, -31 },
  { 2524, 18, 44, 24, 3, -43 },
  { 2623, 40, 54, 46, 3, -41 },
  { 2893, 30, 42, 32, 1, -42 },
  { 3051, 23, 42, 32, 5, -42 },
  { 3172, 26, 44, 33, 4, -43 },
  { 3315, 25, 42, 34, 5, -42 },
  { 3447, 22, 42, 29, 5, -42 },
  { 3563, 22, 42, 29, 5, -42 },
  { 3679, 27, 44, 35, 4, -43 },
  { 3828, 26, 42, 36, 5, -42 },
  { 3965, 3, 42, 14, 6, -42 },
  { 3981, 22, 43, 28, 2, -42 },
  { 4100, 26, 42, 32, 5, -42 },
  { 4237, 21, 42, 27, 5, -42 },
  { 4348, 34, 42, 44, 5, -42 },
  { 4527, 26, 42, 36, 5, -42 },
  { 4664, 27, 44, 35, 4, -43 },
  { 4813, 24, 42, 32, 5, -42 },
  { 4939, 27, 50, 35, 4, -43 },
  { 5108, 25, 42, 32, 5, -42 },
  { 5240, 25, 44, 31, 3, -43 },
  { 5378, 27, 42, 31, 2, -42 },
  { 5520, 25, 43, 34, 4, -42 },
  { 5655, 30, 42, 32, 1, -42 },
  { 5813, 42, 42, 45, 2, -42 },
  { 6034, 28, 42, 32, 2, -42 },
  { 6181, 29, 42, 31, 1, -42 },
  { 6334, 25, 42, 31, 3, -42 },
  { 6466, 9, 57, 13, 4, -48 },
  { 6531, 18, 46, 21, 2, -42 },
  { 6635, 8, 57, 13, 1, -48 },
  { 6692, 17, 21, 22, 2, -42 },
  { 6737, 21, 3, 23, 1, 0 },
  { 6745, 10, 8, 17, 3, -44 },
  { 6755, 21, 33, 28, 3, -32 },
  { 6842, 22, 45, 29, 4, -44 },
  { 6966, 21, 33, 27, 3, -32 },
  { 7053, 21, 45, 29, 3, -44 },
  { 7172, 21, 33, 27, 3, -32 },
  { 7259, 15, 45, 18, 2, -45 },
  { 7344, 21, 44, 29, 3, -32 },
  { 7460, 20, 44, 28, 4, -44 },
  { 7570, 4, 43, 12, 4, -43 },
  { 7592, 10, 55, 13, -2, -43 },
  { 7661, 21, 44, 26, 4, -44 },
  { 7777, 3, 44, 12, 5, -44 },
  { 7794, 37, 32, 45, 4, -32 },
  { 7942, 20, 32, 28, 4, -32 },
  { 8022, 23, 33, 29, 3, -32 },
  { 8117, 22, 44, 29, 4, -32 },
  { 8238, 21, 44, 29, 3, -32 },
  { 8354, 13, 32, 18, 4, -32 },
  { 8406, 20, 33, 26, 3, -32 },
  { 8489, 14, 40, 17, 1, -39 },
  { 8559, 20, 32, 28, 4, -31 },
  { 8639, 23, 31, 25, 1, -31 },
  { 8729, 34, 31, 39, 2, -31 },
  { 8861, 22, 31, 25, 2, -31 },
  { 8947, 22, 43, 25, 1, -31 },
  { 9066, 20, 31, 25, 3, -31 },
  { 9144, 15, 58, 18, 2, -46 },
  { 9253, 3, 50, 13, 5, -42 },
  { 9272, 14, 58, 18, 1, -46 },
  { 9374, 27, 11, 35, 4, -23 },
};

const GFXfont RobotoCondensed_Light59pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light59pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light59pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOCONDENSED_LIGHT59PT7B_H_
