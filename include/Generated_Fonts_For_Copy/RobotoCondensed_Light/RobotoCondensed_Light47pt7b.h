#ifndef _ROBOTOCONDENSED_LIGHT47PT7B_H_
#define _ROBOTOCONDENSED_LIGHT47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Light.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Light47pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x60, 0x00, 0x00, 0x06, 0x77, 0x60, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x0E,
  0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0xC1, 0xC0, 0x06, 0x06, 0x03, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0xE0, 0xC0,
  0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03,
  0x03, 0x00, 0x1C, 0x18, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x06, 0x06,
  0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x03, 0x83, 0x80, 0x0C, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x1F, 0x80,
  0x3F, 0xF0, 0x3F, 0xFC, 0x38, 0x0E, 0x38, 0x03, 0x9C, 0x00, 0xCC, 0x00,
  0x76, 0x00, 0x3B, 0x00, 0x1D, 0x80, 0x0E, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xB8, 0x03, 0x9E,
  0x03, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x18,
  0x60, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x0C, 0x02, 0x06, 0x06, 0x03, 0x03,
  0x01, 0x81, 0x81, 0x80, 0xC1, 0x80, 0xC0, 0x61, 0xC0, 0x60, 0x30, 0xC0,
  0x30, 0x38, 0xE0, 0x18, 0x18, 0x60, 0x0E, 0x0C, 0x60, 0x03, 0x8C, 0x30,
  0x00, 0xFE, 0x30, 0x00, 0x3C, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x3C, 0x00, 0x0C, 0x3F, 0x80, 0x0E, 0x30, 0xC0, 0x06, 0x38, 0x30, 0x06,
  0x18, 0x18, 0x03, 0x0C, 0x0E, 0x03, 0x06, 0x03, 0x01, 0x83, 0x01, 0x81,
  0x81, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x60, 0x70, 0xE0, 0x30, 0x30,
  0x00, 0x1C, 0x18, 0x00, 0x07, 0x18, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xDF, 0x00, 0x38, 0x38, 0x03,
  0x80, 0xC0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0C,
  0x01, 0xC0, 0xE0, 0x06, 0x0E, 0x00, 0x38, 0xF0, 0x00, 0xCF, 0x00, 0x07,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xEE, 0x00,
  0x0E, 0x38, 0x0C, 0xE1, 0xE0, 0xEE, 0x07, 0x07, 0x70, 0x1C, 0x3B, 0x00,
  0x71, 0x98, 0x03, 0x8C, 0xC0, 0x0E, 0xE6, 0x00, 0x3E, 0x30, 0x00, 0xF1,
  0xC0, 0x07, 0x0E, 0x00, 0x7C, 0x3C, 0x07, 0xF0, 0xF9, 0xFB, 0xC3, 0xFF,
  0x0E, 0x07, 0xE0, 0x38, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x60, 0x18, 0x0C,
  0x07, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60,
  0x18, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x80, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x1C,
  0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0E,
  0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x0E, 0x0C, 0x1F, 0xE3, 0x1F, 0x7F, 0xFF, 0x83, 0xFF, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xF0, 0x01, 0xCE, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x1C,
  0x0E, 0x0E, 0x01, 0xC0, 0x80, 0x60, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0xC6, 0x33, 0x9C, 0xE6, 0x73,
  0x18, 0xFF, 0xFF, 0xF0, 0x6F, 0xF7, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x07,
  0xFC, 0x07, 0x9F, 0x07, 0x01, 0xC7, 0x00, 0x63, 0x80, 0x39, 0x80, 0x0D,
  0xC0, 0x06, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0x98, 0x00, 0xCE, 0x00, 0xE7, 0x00, 0x61, 0xC0,
  0x70, 0x7D, 0xF0, 0x1F, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0xC0, 0xF0, 0xFD,
  0xFF, 0xF9, 0xF8, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x7C, 0xF8, 0x1E, 0x03, 0x83,
  0x80, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x01, 0x9C,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xF3, 0xE0, 0xF0, 0x1C, 0x38, 0x03, 0x9C, 0x00, 0xE7, 0x00,
  0x19, 0x80, 0x06, 0x60, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xFE, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xD8, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x06,
  0x38, 0x03, 0x8F, 0x01, 0xC1, 0xFB, 0xF0, 0x3F, 0xF0, 0x03, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0x60, 0x00, 0x66, 0x00, 0x0E, 0x60, 0x00, 0xC6, 0x00, 0x1C,
  0x60, 0x01, 0x86, 0x00, 0x38, 0x60, 0x03, 0x06, 0x00, 0x70, 0x60, 0x06,
  0x06, 0x00, 0xE0, 0x60, 0x1C, 0x06, 0x01, 0xC0, 0x60, 0x38, 0x06, 0x03,
  0x00, 0x60, 0x70, 0x06, 0x06, 0x00, 0x60, 0xE0, 0x06, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x3F,
  0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC6, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x3E, 0x03, 0x7F, 0xC1, 0xFF, 0xF0, 0xE0, 0x3C, 0x60, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xB8, 0x00, 0xDC, 0x00, 0xE7, 0x00,
  0x73, 0xC0, 0x70, 0xF9, 0xF0, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0xFE, 0x01, 0xFE, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x3E, 0x0E,
  0x7F, 0xC7, 0x79, 0xF3, 0xF0, 0x3D, 0xE0, 0x0E, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xB0, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x63, 0x80, 0x71,
  0xE0, 0x70, 0x7C, 0xF8, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xDF, 0x87, 0x01,
  0xC7, 0x00, 0x73, 0x00, 0x3B, 0x80, 0x0D, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xCC, 0x00, 0x67, 0x00, 0x71, 0xC0, 0x70, 0x7D, 0xF0,
  0x1F, 0xF0, 0x1F, 0xFC, 0x1E, 0x0F, 0x1C, 0x01, 0xCC, 0x00, 0xEE, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xFC, 0x00, 0x77, 0x00, 0x73, 0xC0, 0x78, 0xFD, 0xF8, 0x3F, 0xF8,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xF3, 0xE0, 0x70, 0x3C,
  0x38, 0x07, 0x1C, 0x00, 0xE7, 0x00, 0x39, 0x80, 0x06, 0x60, 0x01, 0xB8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xD8, 0x00, 0x76, 0x00,
  0x1D, 0xC0, 0x07, 0x70, 0x03, 0xCE, 0x01, 0xF3, 0xC0, 0xFC, 0x7C, 0xF7,
  0x0F, 0xF9, 0xC0, 0xF8, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x0F, 0x80, 0x00, 0x6F, 0xF6, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0xFF, 0x60, 0x18, 0xF3, 0xCE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x61,
  0x86, 0x18, 0x63, 0x8E, 0x31, 0xC6, 0x18, 0x00, 0x01, 0x00, 0x07, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFB, 0xE3, 0xC0,
  0xE7, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x00, 0x18, 0x70, 0x00, 0x00, 0x18, 0xC0, 0x0F,
  0x80, 0x31, 0x80, 0x3F, 0xC0, 0x67, 0x00, 0xE1, 0xC0, 0x6C, 0x03, 0x81,
  0x80, 0xD8, 0x0E, 0x03, 0x01, 0xB0, 0x18, 0x06, 0x03, 0xC0, 0x30, 0x1C,
  0x07, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0x80, 0x60, 0x1E, 0x03, 0x00, 0xC0,
  0x3C, 0x06, 0x01, 0x80, 0x78, 0x1C, 0x03, 0x00, 0xF0, 0x38, 0x06, 0x01,
  0xE0, 0x60, 0x0C, 0x03, 0xC0, 0xC0, 0x18, 0x07, 0x81, 0x80, 0x30, 0x0F,
  0x03, 0x80, 0xE0, 0x36, 0x07, 0x01, 0xC0, 0x6C, 0x06, 0x07, 0x81, 0xD8,
  0x0E, 0x0F, 0x03, 0x18, 0x1E, 0x73, 0x0C, 0x30, 0x1F, 0xC7, 0xF0, 0x60,
  0x1F, 0x07, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x66, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xC3, 0x00,
  0x01, 0xC3, 0x00, 0x01, 0x83, 0x80, 0x01, 0x81, 0x80, 0x03, 0x81, 0x80,
  0x03, 0x81, 0xC0, 0x03, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x07, 0x00, 0xE0,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0x60, 0x0E, 0x00, 0x70, 0x0C, 0x00, 0x70,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x18, 0x00, 0x38, 0x38, 0x00, 0x18,
  0x38, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0x81, 0xFC, 0x70, 0x03, 0x8E, 0x00, 0x39, 0xC0, 0x07, 0x38,
  0x00, 0x67, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x06, 0x70,
  0x01, 0xCE, 0x00, 0x39, 0xC0, 0x0E, 0x38, 0x1F, 0x87, 0xFF, 0xC0, 0xFF,
  0xFE, 0x1C, 0x01, 0xE3, 0x80, 0x0E, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0,
  0x01, 0xB8, 0x00, 0x37, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1B, 0x80,
  0x07, 0x70, 0x00, 0xEE, 0x00, 0x3D, 0xC0, 0x0F, 0x38, 0x0F, 0xC7, 0xFF,
  0xF0, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xF7, 0xF0,
  0x3C, 0x03, 0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00,
  0x06, 0x60, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x60, 0x00, 0x3B, 0x80, 0x01,
  0x9C, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0E, 0x0F, 0x00, 0xF0, 0x3F,
  0x7F, 0x00, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0xE0, 0xFE, 0x0E, 0x00, 0xF0, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x00,
  0xCE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0E,
  0xE0, 0x00, 0xCE, 0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x00, 0xF0, 0xE0, 0xFE,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFB, 0xF0,
  0x3C, 0x03, 0xC3, 0xC0, 0x07, 0x1C, 0x00, 0x39, 0xC0, 0x00, 0xEE, 0x00,
  0x07, 0x60, 0x00, 0x3B, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x80, 0x00,
  0xDC, 0x00, 0x06, 0x70, 0x00, 0x31, 0xC0, 0x03, 0x8F, 0x00, 0x7C, 0x3F,
  0xBF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x38, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xDC, 0x00, 0xE7, 0x00,
  0x73, 0xC0, 0x70, 0xFD, 0xF0, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0xE0, 0x00,
  0xE7, 0x00, 0x0F, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0x70,
  0x07, 0x83, 0x80, 0x78, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x03, 0x80,
  0x38, 0x3C, 0x01, 0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0x71, 0xC0, 0x03, 0x9C,
  0x00, 0x1D, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xEE, 0x00, 0x3E, 0x38, 0x01,
  0xE1, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0xE0, 0x0E, 0x07, 0x00, 0x78, 0x38, 0x01, 0xC1, 0xC0, 0x07, 0x0E,
  0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x0E, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xB0, 0x00, 0x06, 0xF7, 0x00, 0x01, 0xDE, 0xE0, 0x00, 0x3B, 0xCC, 0x00,
  0x06, 0x79, 0xC0, 0x01, 0xCF, 0x18, 0x00, 0x39, 0xE3, 0x00, 0x06, 0x3E,
  0x70, 0x01, 0xC7, 0xC6, 0x00, 0x38, 0xF8, 0xC0, 0x06, 0x1F, 0x1C, 0x01,
  0xC3, 0xE1, 0x80, 0x30, 0x7C, 0x38, 0x06, 0x0F, 0x87, 0x01, 0xC1, 0xF0,
  0x60, 0x30, 0x3E, 0x0E, 0x06, 0x07, 0xC1, 0xC1, 0xC0, 0xF8, 0x18, 0x30,
  0x1F, 0x03, 0x8E, 0x03, 0xE0, 0x31, 0xC0, 0x7C, 0x06, 0x30, 0x0F, 0x80,
  0xEE, 0x01, 0xF0, 0x0D, 0xC0, 0x3E, 0x01, 0xB0, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0x80, 0x1F, 0x00, 0x70, 0x03, 0xE0, 0x0E, 0x00, 0x60, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0xB0, 0x00, 0xFD, 0xC0, 0x07, 0xE6, 0x00, 0x3F, 0x38,
  0x01, 0xF8, 0xE0, 0x0F, 0xC7, 0x00, 0x7E, 0x1C, 0x03, 0xF0, 0xE0, 0x1F,
  0x83, 0x80, 0xFC, 0x0C, 0x07, 0xE0, 0x70, 0x3F, 0x01, 0x81, 0xF8, 0x0E,
  0x0F, 0xC0, 0x38, 0x7E, 0x01, 0xC3, 0xF0, 0x07, 0x1F, 0x80, 0x38, 0xFC,
  0x00, 0xE7, 0xE0, 0x03, 0x3F, 0x00, 0x1D, 0xF8, 0x00, 0x6F, 0xC0, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x38, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0x80,
  0x78, 0x38, 0x00, 0xF0, 0xE0, 0x01, 0xC7, 0x00, 0x03, 0x9C, 0x00, 0x0E,
  0xE0, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x06, 0x60, 0x00, 0x19, 0xC0,
  0x00, 0xE7, 0x00, 0x03, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0x78, 0x07,
  0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC3, 0x80, 0xFC, 0x70, 0x01, 0xCE, 0x00, 0x1D, 0xC0, 0x03, 0xB8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x37, 0x00, 0x0E, 0xE0,
  0x03, 0x9C, 0x07, 0xF3, 0xFF, 0xF8, 0x7F, 0xFC, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0x80, 0x78, 0x38, 0x00, 0xF1, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x98,
  0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00,
  0x39, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x9E, 0x00, 0x1C, 0x38, 0x00, 0xF0,
  0x78, 0x07, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xE0, 0x7F, 0x0E,
  0x00, 0x78, 0xE0, 0x03, 0xCE, 0x00, 0x1C, 0xE0, 0x00, 0xCE, 0x00, 0x0E,
  0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0C, 0xE0, 0x01,
  0xCE, 0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x3F, 0x0F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x0E, 0x01, 0x80, 0xE0, 0x1C, 0x0E, 0x00, 0xC0, 0xE0,
  0x0E, 0x0E, 0x00, 0x60, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x8E,
  0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x0E,
  0xE0, 0x00, 0x70, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xDF, 0x81, 0xC0,
  0x3C, 0x38, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70,
  0x00, 0x77, 0x00, 0x03, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00, 0x77, 0x00,
  0x07, 0x38, 0x00, 0xE3, 0xC0, 0x1E, 0x1F, 0xDF, 0xC0, 0x7F, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x77, 0x00, 0x1C, 0xF0, 0x07, 0x8F, 0xEF, 0xE0, 0xFF,
  0xF0, 0x03, 0xF8, 0x00, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x1D, 0xC0, 0x00,
  0x3B, 0x80, 0x00, 0xE3, 0x00, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x06,
  0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x60, 0x70, 0x01, 0xC0,
  0x60, 0x03, 0x80, 0xE0, 0x06, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xC0, 0x06, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C,
  0x0C, 0x00, 0x18, 0x38, 0x00, 0x30, 0x70, 0x00, 0x70, 0xC0, 0x00, 0x63,
  0x80, 0x00, 0xC7, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x98, 0x00, 0x03, 0x70,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0xB8,
  0x00, 0xF0, 0x00, 0xDC, 0x00, 0x78, 0x00, 0xE6, 0x00, 0x3E, 0x00, 0x73,
  0x00, 0x1B, 0x00, 0x39, 0xC0, 0x0D, 0x80, 0x18, 0xE0, 0x0E, 0xC0, 0x0C,
  0x70, 0x06, 0x70, 0x0E, 0x18, 0x03, 0x38, 0x07, 0x0E, 0x01, 0x8C, 0x03,
  0x87, 0x01, 0xC6, 0x01, 0x83, 0x80, 0xC3, 0x00, 0xC0, 0xC0, 0x61, 0xC0,
  0xE0, 0x60, 0x30, 0x60, 0x70, 0x38, 0x38, 0x30, 0x30, 0x1C, 0x18, 0x18,
  0x18, 0x0E, 0x0C, 0x0E, 0x0C, 0x03, 0x06, 0x03, 0x0E, 0x01, 0x87, 0x01,
  0x87, 0x00, 0xE3, 0x00, 0xC3, 0x00, 0x71, 0x80, 0x71, 0x80, 0x38, 0xC0,
  0x19, 0xC0, 0x0C, 0xE0, 0x0C, 0xE0, 0x06, 0x60, 0x06, 0x70, 0x03, 0xB0,
  0x03, 0xB0, 0x01, 0xD8, 0x00, 0xD8, 0x00, 0x7C, 0x00, 0x6C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x39, 0xC0,
  0x01, 0xE7, 0x00, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x70, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00,
  0x38, 0xE0, 0x00, 0xE3, 0x80, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x77, 0x00, 0x01, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0x78, 0x70, 0x01,
  0xC1, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x00,
  0x38, 0x38, 0x00, 0xE1, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x3C, 0x00, 0x0E,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xE1,
  0xC0, 0x01, 0xC3, 0x80, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x18, 0x06,
  0x00, 0x70, 0x0E, 0x00, 0xC0, 0x0C, 0x03, 0x80, 0x1C, 0x06, 0x00, 0x18,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE7,
  0x00, 0x00, 0xEE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xFC, 0x60,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0xFF, 0xFC, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xE0, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x1F, 0x00, 0xD8, 0x06, 0xC0, 0x77, 0x03, 0x18,
  0x18, 0xC1, 0xC7, 0x0C, 0x18, 0x60, 0xC7, 0x07, 0x38, 0x19, 0x80, 0xDC,
  0x07, 0xE0, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x38, 0x1C, 0x1C,
  0x0E, 0x07, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xCF, 0x87, 0x00, 0xE3, 0x00,
  0x73, 0x80, 0x19, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0xFF, 0xE1, 0xFF, 0xF1, 0xF0, 0x39, 0xC0, 0x1D, 0xC0, 0x0E, 0xC0, 0x07,
  0x60, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xEC, 0x00, 0xF7, 0x00, 0xFB, 0x80,
  0xFC, 0xFF, 0xEE, 0x3F, 0xE7, 0x0F, 0xC3, 0x80, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x7C, 0x1C, 0xFF, 0x8E, 0xF7, 0xE7,
  0xC0, 0x7B, 0xC0, 0x1D, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x1D, 0xF0, 0x1E, 0xEF, 0x7E, 0x73, 0xFE, 0x38, 0x7C, 0x00, 0x03,
  0xF0, 0x07, 0xFE, 0x07, 0xCF, 0x87, 0x00, 0xE7, 0x00, 0x33, 0x80, 0x1D,
  0x80, 0x06, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0xD8, 0x00, 0x6E, 0x00, 0x77, 0x00, 0x39, 0xC0, 0x38, 0x7C, 0xF8,
  0x1F, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0xF8, 0x61, 0xFF, 0x31, 0xF3, 0xD9, 0xE0, 0x3C, 0xE0,
  0x0E, 0xE0, 0x07, 0x70, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00,
  0xD8, 0x00, 0x6C, 0x00, 0x37, 0x00, 0x1B, 0x80, 0x0C, 0xE0, 0x0E, 0x78,
  0x0F, 0x1F, 0xFD, 0x87, 0xFC, 0xC0, 0xFC, 0x60, 0x03, 0xF0, 0x07, 0xFE,
  0x07, 0xCF, 0x87, 0x80, 0xE3, 0x80, 0x33, 0x80, 0x1D, 0x80, 0x0E, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x11, 0xE0, 0x1C, 0x7E, 0x7C, 0x1F, 0xFC, 0x03,
  0xF8, 0x00, 0x01, 0xF0, 0x7F, 0x0F, 0xB0, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xFF, 0xEF, 0xFE, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0xE1, 0x87, 0xFC, 0xC7,
  0xCF, 0x67, 0x80, 0xF3, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x06, 0xC0, 0x03,
  0x60, 0x01, 0xB0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xDC, 0x00, 0x6E,
  0x00, 0x73, 0x80, 0x39, 0xE0, 0x3C, 0x7E, 0xF6, 0x1F, 0xF3, 0x03, 0xF1,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x40,
  0x0E, 0x70, 0x0E, 0x1F, 0x3E, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE1, 0xF0, 0xE7, 0xFC, 0xEF, 0xBE,
  0xFC, 0x0E, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x6F, 0xF6, 0x00, 0x00,
  0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x06, 0x0E, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0xBC, 0xFC, 0xF0, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x03, 0xDC, 0x01, 0xCE, 0x01,
  0xC7, 0x01, 0xC3, 0x81, 0xC1, 0xC1, 0xC0, 0xE1, 0xE0, 0x70, 0xE0, 0x38,
  0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xF7, 0x00,
  0xF1, 0xC0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x0E, 0x03, 0x87, 0x01,
  0xC3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x0E, 0x70, 0x03, 0xB8, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE1, 0xF0, 0x0F,
  0xC3, 0x9F, 0xF0, 0xFF, 0x8E, 0xF7, 0xE7, 0xDF, 0x3F, 0x03, 0xB8, 0x1E,
  0xF0, 0x07, 0xC0, 0x3B, 0xC0, 0x1E, 0x00, 0x6E, 0x00, 0x78, 0x01, 0xB8,
  0x00, 0xC0, 0x07, 0xE0, 0x03, 0x00, 0x1F, 0x80, 0x0C, 0x00, 0x7E, 0x00,
  0x30, 0x01, 0xF8, 0x00, 0xC0, 0x07, 0xE0, 0x03, 0x00, 0x1F, 0x80, 0x0C,
  0x00, 0x7E, 0x00, 0x30, 0x01, 0xF8, 0x00, 0xC0, 0x07, 0xE0, 0x03, 0x00,
  0x1F, 0x80, 0x0C, 0x00, 0x7E, 0x00, 0x30, 0x01, 0xF8, 0x00, 0xC0, 0x07,
  0xE0, 0x03, 0x00, 0x1F, 0x80, 0x0C, 0x00, 0x7E, 0x00, 0x30, 0x01, 0xF8,
  0x00, 0xC0, 0x07, 0xE0, 0x03, 0x00, 0x1C, 0xE1, 0xF0, 0xE7, 0xFC, 0xEF,
  0xBE, 0xFC, 0x0E, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7E, 0xFC, 0x1E, 0x03, 0xC3, 0x80, 0x38, 0xE0, 0x03, 0x9C,
  0x00, 0x73, 0x00, 0x06, 0x60, 0x00, 0xDC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3B, 0x00, 0x07, 0x60,
  0x00, 0xCC, 0x00, 0x19, 0xC0, 0x07, 0x38, 0x00, 0xE3, 0x80, 0x38, 0x38,
  0x0F, 0x07, 0xE7, 0xC0, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0xE1, 0xF0, 0x73,
  0xFE, 0x3B, 0xDF, 0x9F, 0x01, 0xEF, 0x00, 0x77, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x77, 0xC0, 0x7B, 0xBC, 0xF9, 0xCF, 0xF8,
  0xE1, 0xF0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xE1, 0x87, 0xFC, 0xC7, 0xCF, 0x67, 0x80, 0xF3, 0x80, 0x3B, 0x80,
  0x1D, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01,
  0xB0, 0x00, 0xDC, 0x00, 0x6E, 0x00, 0x33, 0x80, 0x39, 0xE0, 0x3C, 0x7C,
  0xF6, 0x1F, 0xF3, 0x03, 0xE1, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0xE3, 0xF9, 0xFE, 0xFF, 0xF0, 0xF8, 0x3C, 0x0F, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x07,
  0xF0, 0x0F, 0xFC, 0x3E, 0x7E, 0x38, 0x0E, 0x70, 0x07, 0x70, 0x07, 0x70,
  0x03, 0x70, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0xE0,
  0x03, 0x60, 0x03, 0x70, 0x07, 0x78, 0x0F, 0x3F, 0x3E, 0x1F, 0xFC, 0x07,
  0xF0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x3F, 0xF7, 0xFE,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x07, 0x00, 0xFE, 0x0F, 0xC0, 0xF8, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0x60, 0x07,
  0x70, 0x0F, 0x78, 0x1F, 0x3E, 0xFB, 0x1F, 0xF3, 0x0F, 0xC3, 0xE0, 0x01,
  0xD8, 0x00, 0x67, 0x00, 0x39, 0xC0, 0x0E, 0x30, 0x03, 0x0C, 0x01, 0xC3,
  0x80, 0x70, 0x60, 0x18, 0x18, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30,
  0x30, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0x61, 0x80, 0x18, 0x60, 0x07, 0x38,
  0x00, 0xCC, 0x00, 0x33, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0xFC, 0x01,
  0xC0, 0x1F, 0x80, 0x38, 0x03, 0x70, 0x0F, 0x00, 0x66, 0x01, 0xF0, 0x1C,
  0xC0, 0x3E, 0x03, 0x9C, 0x0E, 0xC0, 0x63, 0x81, 0x98, 0x0C, 0x30, 0x33,
  0x83, 0x86, 0x06, 0x30, 0x70, 0xE1, 0xC6, 0x0C, 0x1C, 0x30, 0xC1, 0x81,
  0x86, 0x1C, 0x30, 0x30, 0xC1, 0x8E, 0x07, 0x38, 0x31, 0x80, 0xE6, 0x06,
  0x30, 0x0C, 0xC0, 0xE6, 0x01, 0x98, 0x0D, 0xC0, 0x37, 0x01, 0xB0, 0x07,
  0xC0, 0x36, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x70, 0x03, 0x8C, 0x00,
  0xE3, 0x80, 0x70, 0x70, 0x1C, 0x1C, 0x0E, 0x03, 0x83, 0x00, 0xE1, 0xC0,
  0x1C, 0xE0, 0x03, 0x38, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0E, 0xC0, 0x07, 0x38, 0x01, 0x87,
  0x00, 0xE1, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x01, 0xC3, 0x80, 0x71,
  0xC0, 0x0E, 0x70, 0x01, 0xC0, 0xE0, 0x01, 0xD8, 0x00, 0xE7, 0x00, 0x39,
  0xC0, 0x0E, 0x70, 0x03, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x18, 0x18,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x30, 0x30, 0x0E, 0x1C, 0x03, 0x87,
  0x00, 0x61, 0x80, 0x18, 0x60, 0x07, 0x38, 0x00, 0xCC, 0x00, 0x33, 0x00,
  0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x00,
  0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC1, 0xF0,
  0x3C, 0x07, 0x80, 0x38, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x30, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x70, 0x07, 0xC0, 0x78, 0x0F, 0x03, 0x80, 0xE0, 0x18, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0x00, 0x77, 0xFE, 0x01, 0xDC, 0x1C, 0x06, 0x60,
  0x38, 0x3B, 0x80, 0x7F, 0xCE, 0x00, 0xFF, 0x00, 0x01, 0xF0,
};

const GFXglyph RobotoCondensed_Light47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 33, 10, 3, -33 },
  { 18, 8, 10, 14, 3, -35 },
  { 28, 22, 33, 24, 2, -33 },
  { 119, 17, 42, 23, 3, -38 },
  { 209, 25, 33, 30, 3, -33 },
  { 313, 21, 33, 25, 3, -33 },
  { 400, 2, 10, 8, 3, -35 },
  { 403, 10, 49, 14, 3, -38 },
  { 465, 10, 49, 14, 1, -38 },
  { 527, 18, 19, 20, 1, -33 },
  { 570, 19, 25, 23, 2, -28 },
  { 630, 5, 11, 9, 1, -4 },
  { 637, 10, 2, 12, 1, -16 },
  { 640, 4, 4, 11, 3, -4 },
  { 642, 14, 36, 17, 1, -33 },
  { 705, 17, 33, 23, 3, -33 },
  { 776, 10, 33, 23, 4, -33 },
  { 818, 19, 33, 23, 2, -33 },
  { 897, 18, 33, 23, 2, -33 },
  { 972, 20, 33, 23, 2, -33 },
  { 1055, 17, 33, 23, 4, -33 },
  { 1126, 17, 33, 23, 3, -33 },
  { 1197, 19, 33, 23, 2, -33 },
  { 1276, 17, 33, 23, 3, -33 },
  { 1347, 18, 33, 23, 2, -33 },
  { 1422, 4, 25, 9, 3, -25 },
  { 1435, 6, 32, 9, 1, -25 },
  { 1459, 16, 20, 21, 2, -25 },
  { 1499, 16, 13, 23, 3, -22 },
  { 1525, 16, 20, 21, 3, -25 },
  { 1565, 15, 33, 19, 2, -33 },
  { 1627, 31, 43, 37, 3, -33 },
  { 1794, 24, 33, 26, 1, -33 },
  { 1893, 19, 33, 25, 4, -33 },
  { 1972, 21, 33, 27, 3, -33 },
  { 2059, 20, 33, 27, 4, -33 },
  { 2142, 17, 33, 23, 4, -33 },
  { 2213, 17, 33, 23, 4, -33 },
  { 2284, 21, 33, 28, 3, -33 },
  { 2371, 21, 33, 29, 4, -33 },
  { 2458, 3, 33, 11, 4, -33 },
  { 2471, 17, 33, 23, 2, -33 },
  { 2542, 21, 33, 26, 4, -33 },
  { 2629, 16, 33, 22, 4, -33 },
  { 2695, 27, 33, 35, 4, -33 },
  { 2807, 21, 33, 29, 4, -33 },
  { 2894, 22, 33, 28, 3, -33 },
  { 2985, 19, 33, 25, 4, -33 },
  { 3064, 22, 39, 28, 3, -33 },
  { 3172, 20, 33, 26, 4, -33 },
  { 3255, 20, 33, 24, 2, -33 },
  { 3338, 22, 33, 24, 1, -33 },
  { 3429, 19, 33, 27, 4, -33 },
  { 3508, 23, 33, 25, 1, -33 },
  { 3603, 33, 33, 36, 2, -33 },
  { 3740, 22, 33, 25, 2, -33 },
  { 3831, 23, 33, 25, 1, -33 },
  { 3926, 20, 33, 25, 2, -33 },
  { 4009, 6, 45, 11, 4, -38 },
  { 4043, 15, 36, 17, 1, -33 },
  { 4111, 7, 45, 11, 0, -38 },
  { 4151, 13, 17, 17, 2, -33 },
  { 4179, 17, 2, 18, 1, 0 },
  { 4184, 8, 6, 13, 2, -35 },
  { 4190, 17, 25, 22, 2, -25 },
  { 4244, 17, 35, 23, 3, -35 },
  { 4319, 17, 25, 21, 2, -25 },
  { 4373, 17, 35, 23, 2, -35 },
  { 4448, 17, 25, 22, 2, -25 },
  { 4502, 12, 35, 14, 2, -35 },
  { 4555, 17, 35, 23, 2, -25 },
  { 4630, 16, 35, 23, 3, -35 },
  { 4700, 4, 34, 10, 3, -34 },
  { 4717, 8, 44, 10, -1, -34 },
  { 4761, 17, 35, 20, 3, -35 },
  { 4836, 2, 35, 10, 4, -35 },
  { 4845, 30, 25, 36, 3, -25 },
  { 4939, 16, 25, 23, 3, -25 },
  { 4989, 19, 25, 23, 2, -25 },
  { 5049, 17, 35, 23, 3, -25 },
  { 5124, 17, 35, 23, 2, -25 },
  { 5199, 10, 25, 14, 3, -25 },
  { 5231, 16, 25, 21, 2, -25 },
  { 5281, 11, 31, 14, 1, -31 },
  { 5324, 16, 25, 23, 3, -25 },
  { 5374, 18, 25, 20, 1, -25 },
  { 5431, 27, 25, 31, 2, -25 },
  { 5516, 18, 25, 20, 1, -25 },
  { 5573, 18, 35, 20, 1, -25 },
  { 5652, 17, 25, 20, 2, -25 },
  { 5706, 11, 46, 14, 2, -37 },
  { 5770, 2, 39, 10, 4, -33 },
  { 5780, 11, 46, 14, 1, -37 },
  { 5844, 22, 8, 28, 3, -18 },
};

const GFXfont RobotoCondensed_Light47pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Light47pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Light47pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOCONDENSED_LIGHT47PT7B_H_
