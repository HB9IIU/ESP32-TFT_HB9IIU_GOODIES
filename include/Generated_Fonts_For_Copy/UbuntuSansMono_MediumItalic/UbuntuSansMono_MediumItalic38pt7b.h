#ifndef _UBUNTUSANSMONO_MEDIUMITALIC38PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0xF8, 0x1F,
  0x00, 0x80, 0x00, 0x3C, 0x3C, 0xF1, 0xE7, 0xC7, 0x9E, 0x1E, 0x78, 0x79,
  0xE3, 0xC7, 0x0F, 0x1C, 0x3C, 0x70, 0xE3, 0x83, 0x8E, 0x0E, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x78, 0x78, 0x00, 0xE0, 0xE0, 0x03, 0xC3, 0xC0, 0x07,
  0x87, 0x80, 0x0E, 0x1E, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x38, 0x78,
  0x00, 0xF0, 0xF0, 0x01, 0xC1, 0xC0, 0x07, 0x87, 0x80, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0xE0, 0xE0, 0x03, 0xC3, 0xC0, 0x07,
  0x07, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x70, 0xF0, 0x01, 0xE1,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7E, 0x0E, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x82,
  0x00, 0xF8, 0x78, 0x1F, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0x80,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x03, 0xC1, 0xFE, 0x03, 0xC0, 0xE7,
  0x03, 0xC0, 0xE3, 0x81, 0xC0, 0x71, 0xC1, 0xC0, 0x38, 0xE1, 0xC0, 0x18,
  0x71, 0xC0, 0x0C, 0x39, 0xE0, 0x06, 0x39, 0xE0, 0x03, 0xBC, 0xE0, 0x01,
  0xFC, 0xE0, 0x00, 0x7C, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF1, 0x00,
  0x00, 0xF7, 0xE0, 0x00, 0xF3, 0xF8, 0x00, 0x73, 0x9C, 0x00, 0x73, 0x8E,
  0x00, 0x71, 0xC7, 0x00, 0x70, 0xE3, 0x80, 0x78, 0x61, 0xC0, 0x78, 0x30,
  0xE0, 0x38, 0x18, 0xE0, 0x38, 0x0E, 0x70, 0x38, 0x07, 0xF0, 0x38, 0x01,
  0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x07, 0xFE,
  0x01, 0xF3, 0xC0, 0x78, 0x38, 0x0F, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x3C,
  0x07, 0x0F, 0x00, 0xE1, 0xE0, 0x1E, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xC3, 0xC7, 0xF8, 0x79, 0xFF, 0x8E, 0x78, 0xF3, 0xCF, 0x0F, 0x73,
  0xC1, 0xFE, 0x78, 0x1F, 0x8F, 0x01, 0xF1, 0xE0, 0x3C, 0x3C, 0x0F, 0xC7,
  0xC3, 0xF8, 0xFF, 0xF7, 0x8F, 0xFC, 0xF0, 0xFE, 0x1E, 0x00, 0x3D, 0xF7,
  0xDE, 0x79, 0xEF, 0x3C, 0xF3, 0x8E, 0x38, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xE0, 0x00,
  0x20, 0x00, 0x00, 0x20, 0x00, 0x60, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x40, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x70, 0x08, 0x38,
  0x27, 0x1C, 0x73, 0xEE, 0xFB, 0xFF, 0xFE, 0xFF, 0xFE, 0x01, 0xC0, 0x03,
  0xF0, 0x03, 0xDE, 0x03, 0xEF, 0x81, 0xE3, 0xC1, 0xF1, 0xF0, 0x30, 0x60,
  0x08, 0x20, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x1E, 0x1E, 0x1F, 0x7F, 0x3E, 0x1C, 0x00, 0x7F,
  0xF7, 0xFE, 0x7F, 0xEF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE2, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0,
  0xF8, 0x3C, 0x1E, 0x07, 0xC7, 0x80, 0x79, 0xF0, 0x0F, 0x3C, 0x01, 0xE7,
  0x80, 0x3D, 0xE0, 0x07, 0xBC, 0x78, 0xF7, 0x9F, 0x3F, 0xF3, 0xE7, 0xBC,
  0x7C, 0xF7, 0x8F, 0x1E, 0xF0, 0x07, 0xDE, 0x00, 0xF3, 0xC0, 0x1E, 0x78,
  0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0x0F, 0x87, 0xC3, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x3F, 0x00, 0x7E, 0x01, 0xFE, 0x07, 0xFE, 0x1F, 0xFE, 0x0F, 0xBC, 0x0E,
  0x3C, 0x08, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0x81, 0xF0, 0x20, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0x81, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x40, 0x07, 0xC7, 0x01, 0xF8, 0x7F, 0xFF, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xE7, 0x80, 0x1E, 0x3C, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0,
  0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC1, 0x00, 0x3F, 0x07, 0x03, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xFF,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xDF,
  0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x7C, 0x0F, 0x8F, 0x80, 0x78, 0xF8,
  0x07, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F,
  0x80, 0xF8, 0x78, 0x0F, 0x07, 0xC3, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x10, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE4, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xC0, 0xF0, 0x78,
  0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x07,
  0x83, 0xE0, 0x7C, 0x7C, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFF, 0x01,
  0xF1, 0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0x7C, 0x78, 0x03, 0xC7, 0x80, 0x3C,
  0xF8, 0x03, 0xCF, 0x80, 0x7C, 0x78, 0x07, 0x87, 0xC1, 0xF8, 0x7F, 0xFF,
  0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x1F,
  0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1,
  0xE0, 0x0F, 0x1F, 0x01, 0xF1, 0xFD, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x01, 0xF3, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0x87, 0xE1, 0xFC, 0x7E, 0x1F, 0x87, 0xC0,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0x80, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x0F, 0x00, 0xF0, 0x0F, 0x83, 0xF8, 0x1F, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC,
  0x07, 0xFC, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xF8,
  0x00, 0x0E, 0x00, 0x00, 0x40, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xE0,
  0x00, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE,
  0x1F, 0xFE, 0x10, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x78, 0x00,
  0x20, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xE3,
  0xF0, 0x7C, 0x07, 0x83, 0xC0, 0x3C, 0x3C, 0x00, 0xE3, 0xC0, 0x0F, 0x1E,
  0x01, 0x79, 0xE0, 0xFF, 0xCF, 0x0F, 0xFE, 0x70, 0xFF, 0xE7, 0x8F, 0x8F,
  0x3C, 0x78, 0x79, 0xC7, 0x83, 0xCE, 0x3C, 0x1C, 0xF1, 0xC1, 0xE7, 0x8E,
  0x0F, 0x3C, 0x70, 0x79, 0xE3, 0x83, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0xFF, 0x1E, 0x1F, 0xF8, 0xF0, 0x7F, 0x83, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x1E, 0xE0, 0x01, 0xCE, 0x00, 0x3C, 0xF0, 0x07,
  0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x01,
  0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F,
  0x3C, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7C, 0x1F, 0x83,
  0xC0, 0x7C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x07,
  0x83, 0xC0, 0x7C, 0x1E, 0x3F, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x03, 0xC0, 0xFC, 0x1E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x78,
  0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3E, 0x01, 0xF1, 0xE0, 0x1F, 0x0F, 0x07,
  0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0x02, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x04, 0x0F, 0xE1, 0xC0,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x78, 0x3F,
  0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC1, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0x78,
  0x03, 0xC3, 0xC0, 0x1E, 0x3E, 0x01, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x78,
  0x78, 0x03, 0xC7, 0xC0, 0x1E, 0x3E, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x00,
  0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x7C, 0x3C, 0x07, 0xC1, 0xE0, 0x7E, 0x0F,
  0x3F, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xC0, 0x60, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0xCF,
  0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF8,
  0xF0, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x07, 0xE1, 0xF0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x1E, 0x07,
  0x80, 0x7C, 0x1F, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0,
  0x0F, 0x83, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x00,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x0F, 0x80, 0x7C, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0,
  0xF0, 0x0F, 0x83, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1E,
  0x01, 0xF0, 0x7C, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x00, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x01, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x30, 0x0F, 0x01, 0xE1, 0xF8, 0x1F, 0xFF, 0x80, 0xFF,
  0xF8, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0x03, 0xC0,
  0x7C, 0x03, 0xC0, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0x83, 0xE0, 0x07, 0x87,
  0xC0, 0x07, 0x87, 0x80, 0x07, 0x8F, 0x80, 0x0F, 0x9F, 0x00, 0x0F, 0x7C,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1E, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3E,
  0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x78, 0x0F,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0xF8, 0x03, 0xC0, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0xF8, 0x0F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x1D, 0xC0, 0xFC,
  0x3F, 0x83, 0xF8, 0xEE, 0x07, 0x31, 0xDC, 0x0E, 0x67, 0x38, 0x3C, 0xEE,
  0xF0, 0x79, 0xF9, 0xE0, 0xE3, 0xF3, 0x83, 0xC7, 0xC7, 0x07, 0x8F, 0x0E,
  0x0F, 0x1E, 0x3C, 0x1C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xC1,
  0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x07,
  0xC0, 0x3C, 0x0F, 0x80, 0x70, 0x3F, 0x01, 0xE0, 0x7F, 0x03, 0xC0, 0xFE,
  0x07, 0x81, 0xDC, 0x0F, 0x07, 0xB8, 0x3C, 0x0F, 0x78, 0x78, 0x1E, 0x70,
  0xF0, 0x38, 0xE1, 0xE0, 0xF1, 0xC3, 0x81, 0xE3, 0xCF, 0x03, 0xC3, 0x9E,
  0x07, 0x07, 0x3C, 0x1E, 0x0E, 0x70, 0x3C, 0x1D, 0xE0, 0x78, 0x3F, 0xC0,
  0xE0, 0x3F, 0x83, 0xC0, 0x7E, 0x07, 0x80, 0xFC, 0x0F, 0x01, 0xF8, 0x1C,
  0x03, 0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0x3E, 0x3E,
  0x03, 0xC7, 0x80, 0x79, 0xF0, 0x0F, 0x3C, 0x01, 0xEF, 0x80, 0x3D, 0xE0,
  0x07, 0xBC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00,
  0xF9, 0xE0, 0x3E, 0x3E, 0x07, 0x87, 0xE3, 0xF0, 0x7F, 0xFC, 0x07, 0xFF,
  0x00, 0x7F, 0x80, 0x03, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xC1, 0xF8, 0x0F, 0x01, 0xE0, 0x7C,
  0x07, 0xC1, 0xE0, 0x1F, 0x07, 0x80, 0x7C, 0x1E, 0x01, 0xE0, 0xF8, 0x07,
  0x83, 0xC0, 0x3E, 0x0F, 0x01, 0xF0, 0x3C, 0x1F, 0xC1, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0x3E, 0x3E, 0x03, 0xC7,
  0x80, 0x79, 0xF0, 0x0F, 0x3C, 0x01, 0xEF, 0x80, 0x3D, 0xE0, 0x07, 0xBC,
  0x00, 0xF7, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1E, 0xF0,
  0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF9, 0xE0,
  0x3E, 0x3E, 0x07, 0x87, 0xE3, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0x80, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xE0, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x7C, 0x1F, 0x83, 0xC0, 0x7C, 0x1E, 0x01,
  0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x07, 0xC3, 0xC0, 0x3C, 0x1E,
  0x03, 0xE0, 0xF0, 0x3E, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x1F, 0xFC, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x1E, 0x03, 0xC0,
  0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x87,
  0xC0, 0x3E, 0x3C, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xE0, 0x10, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x02, 0x00, 0x7C, 0x1E, 0x07, 0xE0, 0x7F,
  0xFF, 0x83, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE8, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x78, 0x07, 0xC7, 0xC0, 0x3C, 0x3C,
  0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0x80, 0x3C,
  0x3C, 0x01, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80,
  0x3C, 0x3C, 0x03, 0xE3, 0xE0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87,
  0x80, 0x7C, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x01, 0xF0, 0x78, 0x0F,
  0x03, 0xE1, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00,
  0x80, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x79, 0xF0, 0x07,
  0xCF, 0x80, 0x3C, 0x7C, 0x03, 0xE3, 0xE0, 0x1E, 0x1F, 0x01, 0xF0, 0xF8,
  0x0F, 0x07, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x83, 0xC0,
  0x3C, 0x1E, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x1E, 0x78, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0,
  0x03, 0xC3, 0xC0, 0x07, 0x07, 0x80, 0x1E, 0x0E, 0x00, 0x3C, 0x3C, 0x00,
  0x78, 0x78, 0xF0, 0xE0, 0xF1, 0xE3, 0xC1, 0xC7, 0xC7, 0x83, 0x8F, 0x8E,
  0x0F, 0x3F, 0x1C, 0x1E, 0x7E, 0x78, 0x39, 0xCC, 0xF0, 0x73, 0x99, 0xC0,
  0xEE, 0x33, 0x81, 0xDC, 0x7F, 0x07, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F,
  0x83, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0,
  0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0x80,
  0x1E, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x03, 0xC7, 0xC0, 0x01, 0xE3, 0xC0,
  0x00, 0xFB, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xF7, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x7C, 0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xFF, 0x00, 0x3E, 0xF0, 0x07, 0xCF, 0x00, 0x78, 0xF0, 0x0F,
  0x87, 0x80, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0x78, 0x3C, 0x03, 0xC7,
  0x80, 0x3C, 0xF0, 0x03, 0xDF, 0x00, 0x3D, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x0F, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x07, 0xDE, 0x01, 0xF1, 0xE0, 0x7C, 0x3C, 0x0F, 0x07,
  0x83, 0xE0, 0x78, 0xF8, 0x0F, 0x3E, 0x01, 0xEF, 0x80, 0x3E, 0x60, 0x03,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x30,
  0x78, 0xFC, 0x7E, 0x1F, 0x0F, 0x06, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x1F,
  0xFF, 0x87, 0xF0, 0xF1, 0xF8, 0x3E, 0x7C, 0x07, 0x8F, 0x00, 0xF3, 0xE0,
  0x1E, 0x78, 0x07, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x80,
  0xF9, 0xF0, 0x1E, 0x3E, 0x03, 0xC3, 0xC0, 0xF8, 0x7C, 0x3F, 0x0F, 0xFF,
  0xE0, 0xFF, 0xDE, 0x0F, 0xF3, 0xC0, 0x00, 0x20, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3D, 0xFC, 0x07, 0xFF, 0xC0, 0xFF,
  0xFC, 0x3F, 0x8F, 0x87, 0xC0, 0xF8, 0xF0, 0x1F, 0x1E, 0x01, 0xE7, 0xC0,
  0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x3C, 0x78, 0x07, 0x9E, 0x01,
  0xF3, 0xC0, 0x3C, 0x78, 0x0F, 0x8F, 0x03, 0xE3, 0xE1, 0xF8, 0x7F, 0xFE,
  0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0xFF,
  0xF0, 0xFF, 0xFC, 0x7F, 0x06, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x0E, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xE1, 0xE0, 0xFC, 0x0F, 0x07, 0xC0, 0xF8, 0x7C,
  0x07, 0x83, 0xC0, 0x3C, 0x3E, 0x01, 0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF0,
  0x78, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0x80,
  0xF0, 0x3E, 0x1F, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xE7, 0x80,
  0x01, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x1F, 0x3E, 0x03, 0xDF,
  0x00, 0xF7, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xBF, 0xFF, 0xCF, 0xFF,
  0xE3, 0xFF, 0xC0, 0xFC, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x06, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0x84, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFE, 0x1E, 0x03, 0xE0, 0x78, 0x1F,
  0x01, 0xE0, 0xF8, 0x0F, 0x83, 0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x78, 0x03,
  0xC1, 0xE0, 0x1F, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x81,
  0xF0, 0x3E, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x04, 0x01, 0xF0,
  0x1F, 0x3F, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x9F, 0xC3, 0xC0, 0xF8,
  0x78, 0x0F, 0x1F, 0x01, 0xE3, 0xE0, 0x3C, 0x78, 0x0F, 0x8F, 0x01, 0xE1,
  0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x8F,
  0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0x80, 0xF1, 0xF0, 0x1E, 0x00,
  0x01, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x08, 0x0F, 0x80,
  0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x10, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0xF0, 0x3E, 0x07, 0x83, 0xE0,
  0x3C, 0x7C, 0x03, 0xE7, 0xC0, 0x1E, 0x7C, 0x00, 0xF7, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x03, 0xDF, 0x00, 0x1E, 0x7C, 0x00, 0xF3, 0xE0, 0x0F,
  0x8F, 0x80, 0x78, 0x3E, 0x03, 0xC1, 0xF0, 0x1E, 0x07, 0xC1, 0xF0, 0x3E,
  0x0F, 0x80, 0xF8, 0x78, 0x07, 0xC0, 0x7F, 0xE7, 0xFE, 0x7F, 0xC8, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x03, 0xE3, 0x3F, 0xF3, 0xFF,
  0x1F, 0xF0, 0x07, 0xF3, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x70, 0xE1, 0xC3, 0x87, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x88, 0x1E,
  0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0xF0, 0x03, 0xC7, 0x80,
  0x1E, 0x3C, 0x00, 0xF1, 0xC0, 0x07, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x07, 0xC7, 0xE1, 0xF0, 0x3C, 0x3C, 0x07, 0xC7, 0x80, 0xF0,
  0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xC3,
  0xC0, 0x78, 0xF8, 0x0F, 0x1E, 0x03, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x1F,
  0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xF8, 0x7E, 0x7E, 0x3E, 0x07, 0xDF, 0x01, 0xF7, 0x80, 0x3D, 0xE0,
  0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1E, 0xF0, 0x07,
  0xBC, 0x03, 0xEF, 0x01, 0xF3, 0xC0, 0xF8, 0xFC, 0x7E, 0x1F, 0xFF, 0x07,
  0xFF, 0x80, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0xFF, 0xFC, 0x0F, 0x83, 0xE0, 0x78, 0x0F, 0x83, 0xC0, 0x7C, 0x1E,
  0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x07, 0xC3, 0xC0, 0x3E,
  0x1E, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x83, 0xC0,
  0xF8, 0x3E, 0x3F, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x8F, 0xE1, 0xE1, 0xF0, 0x3C, 0x7C, 0x0F, 0x9F, 0x01, 0xF3, 0xC0,
  0x3C, 0xF8, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0x8F, 0x00,
  0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0x80, 0xF0, 0xF8, 0x7E, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xE0, 0xE0, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC2, 0x00,
  0x78, 0x78, 0x3F, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x60, 0x7F, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x1E, 0x03, 0xE7,
  0xC0, 0x78, 0xF8, 0x0F, 0x1E, 0x03, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x1F,
  0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x8F, 0x01, 0xE3, 0xE0, 0x3C, 0x78,
  0x07, 0x8F, 0x01, 0xF1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x81, 0xF0, 0xF8,
  0x7E, 0x1F, 0xFF, 0xC1, 0xFF, 0xBC, 0x1F, 0xE7, 0x80, 0xF0, 0x07, 0xFC,
  0x01, 0xEF, 0x00, 0xFB, 0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0x8F, 0x03,
  0xE3, 0xC0, 0xF0, 0xF0, 0x7C, 0x3E, 0x1E, 0x07, 0x8F, 0x81, 0xE3, 0xC0,
  0x79, 0xE0, 0x1E, 0x78, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE,
  0x00, 0x3C, 0xE0, 0x01, 0xE7, 0x00, 0x0F, 0x78, 0x78, 0x73, 0xC3, 0xC7,
  0x9E, 0x3E, 0x3C, 0xF1, 0xF1, 0xC7, 0x1F, 0x9E, 0x38, 0xFC, 0xE1, 0xCE,
  0xE7, 0x0E, 0xF7, 0x78, 0x77, 0x3B, 0x83, 0xF1, 0xFC, 0x1F, 0x8F, 0xC0,
  0xF8, 0x3E, 0x07, 0xC1, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x00, 0x07,
  0x80, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0x03, 0xE0, 0x1F, 0x0F, 0x80, 0x1E,
  0x1E, 0x00, 0x3E, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x7D, 0xE0, 0x01, 0xF3, 0xE0, 0x07, 0xC3, 0xC0, 0x1F, 0x07, 0xC0,
  0x7C, 0x07, 0x81, 0xF0, 0x0F, 0x07, 0xC0, 0x1F, 0x00, 0x01, 0xE0, 0x0F,
  0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x7C, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF9, 0xE0,
  0x00, 0x79, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0x1F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x09, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0x00, 0x81, 0xFC, 0x0F, 0x3F, 0xE0, 0xE7, 0xFF, 0xFE, 0x79, 0xFF, 0xCF,
  0x07, 0xF8, 0x60, 0x3F, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 11, 27, 21, 6, -26 },
  { 39, 14, 11, 21, 7, -29 },
  { 59, 23, 26, 21, 0, -26 },
  { 134, 20, 33, 21, 1, -29 },
  { 217, 25, 28, 21, -1, -27 },
  { 305, 19, 27, 21, 1, -27 },
  { 370, 6, 12, 21, 11, -29 },
  { 379, 17, 37, 21, 4, -30 },
  { 458, 16, 37, 21, 1, -30 },
  { 532, 17, 16, 21, 4, -26 },
  { 566, 18, 19, 21, 2, -21 },
  { 609, 9, 12, 21, 3, -6 },
  { 623, 12, 4, 21, 5, -13 },
  { 629, 6, 7, 21, 6, -6 },
  { 635, 24, 37, 21, -2, -30 },
  { 746, 19, 28, 21, 2, -27 },
  { 813, 16, 26, 21, 2, -26 },
  { 865, 20, 27, 21, 1, -27 },
  { 933, 20, 28, 21, 0, -27 },
  { 1003, 21, 26, 21, 0, -26 },
  { 1072, 22, 27, 21, 0, -26 },
  { 1147, 20, 28, 21, 2, -27 },
  { 1217, 20, 26, 21, 4, -26 },
  { 1282, 20, 28, 21, 1, -27 },
  { 1352, 20, 27, 21, 1, -27 },
  { 1420, 10, 20, 21, 6, -19 },
  { 1445, 13, 25, 21, 3, -19 },
  { 1486, 19, 18, 21, 2, -20 },
  { 1529, 20, 12, 21, 1, -17 },
  { 1559, 19, 18, 21, 1, -20 },
  { 1602, 16, 28, 21, 5, -27 },
  { 1658, 21, 33, 21, 1, -27 },
  { 1745, 20, 26, 21, -2, -26 },
  { 1810, 21, 27, 21, 0, -27 },
  { 1881, 21, 28, 21, 2, -27 },
  { 1955, 21, 27, 21, 0, -27 },
  { 2026, 22, 26, 21, 1, -26 },
  { 2098, 22, 26, 21, 1, -26 },
  { 2170, 20, 28, 21, 2, -27 },
  { 2240, 23, 26, 21, 0, -26 },
  { 2315, 21, 26, 21, 1, -26 },
  { 2384, 21, 27, 21, 1, -26 },
  { 2455, 24, 26, 21, 0, -26 },
  { 2533, 16, 26, 21, 1, -26 },
  { 2585, 23, 26, 21, -1, -26 },
  { 2660, 23, 26, 21, 0, -26 },
  { 2735, 19, 28, 21, 2, -27 },
  { 2802, 22, 27, 21, 0, -27 },
  { 2877, 19, 34, 21, 2, -27 },
  { 2958, 21, 27, 21, 0, -27 },
  { 3029, 22, 28, 21, 0, -27 },
  { 3106, 20, 26, 21, 4, -26 },
  { 3171, 21, 27, 21, 2, -26 },
  { 3242, 21, 26, 21, 4, -26 },
  { 3311, 23, 26, 21, 1, -26 },
  { 3386, 25, 26, 21, -1, -26 },
  { 3468, 20, 26, 21, 5, -26 },
  { 3533, 23, 26, 21, 0, -26 },
  { 3608, 20, 37, 21, 2, -30 },
  { 3701, 8, 37, 21, 7, -30 },
  { 3738, 20, 37, 21, -1, -30 },
  { 3831, 19, 14, 21, 2, -26 },
  { 3865, 20, 4, 21, -3, 3 },
  { 3875, 8, 7, 21, 9, -29 },
  { 3882, 19, 20, 21, 1, -20 },
  { 3930, 19, 31, 21, 1, -30 },
  { 4004, 18, 20, 21, 2, -20 },
  { 4049, 21, 30, 21, 2, -30 },
  { 4128, 18, 21, 21, 2, -20 },
  { 4176, 26, 36, 21, -2, -29 },
  { 4293, 22, 27, 21, -1, -20 },
  { 4368, 19, 30, 21, 0, -30 },
  { 4440, 13, 29, 21, 4, -29 },
  { 4488, 21, 36, 21, -1, -29 },
  { 4583, 21, 30, 21, 1, -30 },
  { 4662, 12, 29, 21, 5, -29 },
  { 4706, 21, 20, 21, 0, -20 },
  { 4759, 19, 20, 21, 1, -20 },
  { 4807, 18, 21, 21, 2, -20 },
  { 4855, 21, 27, 21, -1, -20 },
  { 4926, 19, 27, 21, 2, -20 },
  { 4991, 19, 20, 21, 2, -20 },
  { 5039, 19, 21, 21, 1, -20 },
  { 5089, 17, 26, 21, 4, -26 },
  { 5145, 19, 20, 21, 2, -20 },
  { 5193, 18, 20, 21, 4, -20 },
  { 5238, 21, 20, 21, 2, -20 },
  { 5291, 23, 20, 21, -1, -20 },
  { 5349, 24, 27, 21, -3, -20 },
  { 5430, 19, 20, 21, 1, -20 },
  { 5478, 21, 37, 21, 2, -30 },
  { 5576, 13, 37, 21, 4, -30 },
  { 5637, 21, 37, 21, -2, -30 },
  { 5735, 20, 7, 21, 1, -15 },
};

const GFXfont UbuntuSansMono_MediumItalic38pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic38pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic38pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC38PT7B_H_
