#ifndef _UBUNTUSANSMONO_MEDIUMITALIC34PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0xF8, 0x3F, 0x0F, 0x83, 0xE0, 0x78, 0xF7, 0x8E, 0x71, 0xEF,
  0x1E, 0xF1, 0xCE, 0x1C, 0xE1, 0xCE, 0x18, 0xC3, 0x8C, 0x38, 0x00, 0x38,
  0x70, 0x07, 0x8F, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x0E,
  0x1C, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x03,
  0x87, 0x00, 0x70, 0xF0, 0x07, 0x0E, 0x00, 0xF1, 0xE0, 0x0E, 0x1C, 0x07,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x3C, 0x78, 0x03, 0x87, 0x00,
  0x78, 0xF0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xF0,
  0xFE, 0x78, 0x3C, 0x02, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x18, 0x0F, 0x87,
  0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x0E, 0x0F, 0xE0, 0x38,
  0x1D, 0xC0, 0xE0, 0x73, 0x83, 0x80, 0xC7, 0x0E, 0x03, 0x8E, 0x38, 0x07,
  0x1C, 0x70, 0x0E, 0x31, 0xC0, 0x1C, 0xE7, 0x00, 0x3F, 0x9C, 0x00, 0x3F,
  0x70, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0xF8, 0x00, 0x3B,
  0xF8, 0x00, 0xE7, 0x70, 0x03, 0x9C, 0x60, 0x0E, 0x30, 0xC0, 0x38, 0x63,
  0x80, 0x71, 0xC7, 0x01, 0xC3, 0x8E, 0x07, 0x07, 0x38, 0x1C, 0x07, 0xE0,
  0x70, 0x0F, 0xC0, 0x00, 0x04, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0xF1, 0xC0, 0xF0, 0xF0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x38, 0x0E,
  0x3C, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0xF8, 0x41, 0xFC, 0x79, 0xFE, 0x39,
  0xE7, 0x9C, 0xE1, 0xFC, 0xF0, 0xFE, 0x70, 0x3E, 0x38, 0x0F, 0x1C, 0x0F,
  0x8F, 0x0F, 0xC7, 0xFF, 0xF1, 0xFF, 0x78, 0x7E, 0x1C, 0x7B, 0xDE, 0xFF,
  0x7B, 0xDC, 0xE6, 0x30, 0x00, 0x04, 0x00, 0x38, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0C, 0x00, 0x00, 0x80, 0x03, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x3C, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x0E,
  0x38, 0xDF, 0x67, 0xBF, 0xFF, 0x7F, 0xFF, 0x07, 0x80, 0x1F, 0x80, 0x7B,
  0x81, 0xE7, 0x87, 0xCF, 0x83, 0x0E, 0x02, 0x08, 0x00, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x07, 0xC7, 0xE3, 0xF1, 0xF8, 0x7C,
  0x1C, 0x1E, 0x1E, 0x7E, 0x1E, 0x18, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFE,
  0x39, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xF1, 0xE1, 0xE0, 0x70, 0xF0,
  0x3C, 0xF0, 0x1E, 0x70, 0x0F, 0x78, 0x07, 0xBC, 0x43, 0xDC, 0xF1, 0xDE,
  0x78, 0xEF, 0x3C, 0xF7, 0x9E, 0x7B, 0x80, 0x3D, 0xC0, 0x3C, 0xE0, 0x1E,
  0x70, 0x0E, 0x38, 0x0F, 0x1E, 0x0F, 0x0F, 0x0F, 0x87, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0x80, 0x04, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x0F, 0xC0,
  0x7E, 0x07, 0xF8, 0x7F, 0xE1, 0xF7, 0x87, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x3E, 0x3E, 0x06, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0E, 0x1F, 0x02, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x01, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x60, 0x1F, 0x1F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xC0,
  0x03, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0xF7, 0x00, 0x3D, 0xE0, 0x0F, 0x3C, 0x03, 0xC7,
  0x80, 0x70, 0xE0, 0x1C, 0x1C, 0x07, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x1C,
  0x0E, 0x03, 0x83, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xF0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x20, 0x3E, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFE,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E,
  0x38, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0xFE, 0x7E, 0x3C, 0x07, 0x8F, 0x00,
  0xF3, 0xC0, 0x3C, 0xF0, 0x0E, 0x3C, 0x03, 0x8F, 0x01, 0xE3, 0xC0, 0x78,
  0xF8, 0x3C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x02, 0x00, 0x00,
  0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x1E, 0x1F,
  0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xE0, 0x3C, 0x38, 0x0F, 0x0F, 0x07, 0x83,
  0xC3, 0xE0, 0x7D, 0xF0, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0x9F, 0x83, 0xC1,
  0xE1, 0xE0, 0x3C, 0x70, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C,
  0xF8, 0x1E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3E, 0x1E, 0x1E, 0x03, 0xC7,
  0x80, 0xF1, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x3C, 0x78, 0x3E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3E, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x1F,
  0xF8, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0x06, 0x07, 0xC7, 0xE3, 0xF1, 0xF8,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x83, 0xE3, 0xF1, 0xF8,
  0xFC, 0x3C, 0x00, 0x00, 0xC0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x07, 0x00, 0xF0, 0x1E, 0x0F, 0xC0,
  0x78, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x1F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00,
  0x30, 0x3F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x80,
  0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0xFF, 0x03,
  0xFE, 0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xC0, 0x01, 0x00, 0x00, 0x0F, 0xE0,
  0xFF, 0xC3, 0xFF, 0x8C, 0x1E, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03,
  0xE0, 0xF0, 0xF0, 0x1E, 0x3C, 0x01, 0xC7, 0x00, 0x39, 0xE0, 0x3F, 0x38,
  0x3F, 0xEF, 0x1F, 0xF9, 0xC3, 0xEF, 0x38, 0xF1, 0xE7, 0x3C, 0x3D, 0xE7,
  0x87, 0x38, 0xE0, 0xE7, 0x1C, 0x3C, 0xE3, 0x87, 0x9C, 0x70, 0xE3, 0x8F,
  0x1C, 0x71, 0xF7, 0x8E, 0x1F, 0xF1, 0xE1, 0xFC, 0x3C, 0x04, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x81, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x77, 0x80, 0x1E, 0xF0, 0x03, 0x9E, 0x00, 0xF3, 0xC0, 0x1C,
  0x38, 0x07, 0x07, 0x01, 0xE0, 0xE0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0,
  0x70, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x78, 0x07, 0x1E, 0x00,
  0xE3, 0xC0, 0x1C, 0xF0, 0x03, 0xDE, 0x00, 0x7F, 0x80, 0x0F, 0x01, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xC7, 0xE0, 0x70, 0x1E, 0x0E, 0x03,
  0xC3, 0xC0, 0x78, 0x78, 0x0E, 0x0F, 0x03, 0xC1, 0xC0, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x38, 0x3F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C,
  0x3C, 0x03, 0x87, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0x81, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0xF0,
  0x3F, 0xFC, 0x1F, 0x0E, 0x0F, 0x00, 0x87, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x08, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xE0, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xFF, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x0F, 0x00, 0xE1, 0xC0, 0x3C, 0x78,
  0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3C, 0x38, 0x07, 0x8F, 0x01, 0xF1, 0xE0,
  0x7C, 0x3C, 0x1F, 0x07, 0x0F, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x3F, 0x0E, 0x1F, 0x00, 0x87, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x0F, 0x3C, 0x03, 0xCE, 0x01, 0xE3, 0x80, 0x78, 0xE0, 0x1E,
  0x3C, 0x07, 0x8F, 0x01, 0xC3, 0xC0, 0xF0, 0xF8, 0x3C, 0x1F, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0xE0, 0x03, 0x00, 0x00, 0x07, 0x80, 0x78, 0x3C, 0x03,
  0x81, 0xE0, 0x3C, 0x0E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x70, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1E, 0x01, 0xE0, 0xF0, 0x0E, 0x07, 0x80,
  0xF0, 0x38, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xC0, 0xF0, 0x1E, 0x07,
  0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x38, 0x1E, 0x03, 0xC0, 0x07, 0xFF,
  0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x01,
  0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x3F, 0xF8,
  0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x20, 0x1E, 0x06, 0x07, 0x81, 0xFF, 0xF0, 0x3F,
  0xFC, 0x01, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x03, 0x80, 0x78, 0x3C, 0x07,
  0x81, 0xE0, 0x78, 0x0F, 0x07, 0xC0, 0x78, 0x7C, 0x07, 0x87, 0xC0, 0x3C,
  0x7C, 0x01, 0xE7, 0xC0, 0x0F, 0x7C, 0x00, 0x77, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0E, 0xF8, 0x00, 0xF3, 0xC0, 0x07, 0x8F,
  0x00, 0x3C, 0x78, 0x01, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x3C, 0x07,
  0x81, 0xE0, 0x38, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x38, 0x0F, 0x03,
  0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x83, 0xF0, 0xD8, 0x1D,
  0x8F, 0xC0, 0xEC, 0x6E, 0x06, 0x67, 0x70, 0x73, 0x33, 0x83, 0x9B, 0x9C,
  0x1C, 0xD9, 0xC1, 0xC7, 0xCE, 0x0E, 0x3C, 0x70, 0x71, 0xE3, 0x87, 0x80,
  0x3C, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0xF0, 0x07, 0x87,
  0x00, 0x3C, 0x38, 0x01, 0xC3, 0xC0, 0x0E, 0x1E, 0x00, 0xF0, 0x03, 0x80,
  0x78, 0x3C, 0x03, 0x81, 0xF0, 0x1C, 0x0F, 0x80, 0xE0, 0x7C, 0x0F, 0x07,
  0xF0, 0x78, 0x3B, 0x83, 0x81, 0xDC, 0x1C, 0x0E, 0xE1, 0xE0, 0xF3, 0x8F,
  0x07, 0x1C, 0x70, 0x38, 0xE3, 0x81, 0xC7, 0x3C, 0x1E, 0x1D, 0xE0, 0xF0,
  0xEE, 0x07, 0x07, 0x70, 0x38, 0x3B, 0x83, 0xC1, 0xFC, 0x1E, 0x07, 0xC0,
  0xE0, 0x3E, 0x07, 0x01, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x78, 0x1C, 0x01,
  0xC0, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0x1E, 0x0F, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCE, 0x00, 0xF7,
  0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDC, 0x00, 0xE7, 0x00, 0x7B, 0xC0,
  0x1E, 0xF0, 0x07, 0x3C, 0x03, 0xCF, 0x01, 0xE1, 0xE0, 0x78, 0x78, 0x3C,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x03, 0xE7, 0xF0, 0x78, 0x1E, 0x0F, 0x03,
  0xC1, 0xC0, 0x38, 0x78, 0x07, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x38, 0x0F,
  0x0F, 0x03, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x01, 0xFC, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0,
  0x3F, 0xF8, 0x1F, 0x1E, 0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x03, 0xCE, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x03,
  0xDC, 0x00, 0xE7, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0x3C, 0x03, 0xCF,
  0x01, 0xE1, 0xE0, 0x78, 0x78, 0x3C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F,
  0x80, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x1C, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xC7,
  0xE0, 0x78, 0x3E, 0x0E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01,
  0xC1, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x0F, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x01, 0xE3, 0xC0, 0x3C, 0x3C, 0x07, 0x07, 0x81, 0xE0, 0x78,
  0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xE0, 0x1C, 0x3C, 0x03, 0xC7, 0x80, 0x78,
  0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xE0, 0x60, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x87,
  0x01, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0xF0, 0x0E, 0x0F, 0x01, 0xE0, 0xE0,
  0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1C, 0x1E, 0x03, 0xC1, 0xC0, 0x3C, 0x3C,
  0x03, 0xC3, 0xC0, 0x38, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x07, 0x87,
  0x80, 0x70, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0xE0,
  0xF0, 0x1E, 0x07, 0x01, 0xE0, 0x78, 0x3C, 0x07, 0xFF, 0xC0, 0x3F, 0xF8,
  0x01, 0xFE, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x01, 0xEF, 0x00,
  0x7B, 0xC0, 0x1E, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0x78,
  0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x3C,
  0x38, 0x0F, 0x1E, 0x03, 0xC7, 0x00, 0xF3, 0xC0, 0x1C, 0xE0, 0x07, 0x78,
  0x01, 0xDC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x0E, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x80, 0x1C, 0x3C, 0x01, 0xE1, 0xC0,
  0x0E, 0x0E, 0x00, 0x70, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x38, 0x01, 0xC1,
  0xC7, 0x0E, 0x0E, 0x38, 0xF0, 0xF3, 0xC7, 0x07, 0x1F, 0x38, 0x39, 0xF9,
  0xC1, 0xDD, 0xDE, 0x0E, 0xEE, 0xE0, 0x6E, 0x77, 0x07, 0x73, 0xB8, 0x3F,
  0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0,
  0x1C, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x78, 0x07, 0x81, 0xE0,
  0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF0, 0x00,
  0x3B, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xF7,
  0x00, 0x03, 0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0xF8, 0x3C,
  0x01, 0xE0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0xE0, 0x7C, 0x01, 0xE0,
  0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x79, 0xC0, 0x3C, 0x70, 0x0F, 0x1E,
  0x07, 0x87, 0x83, 0xC1, 0xE0, 0xE0, 0x38, 0x78, 0x0F, 0x3C, 0x03, 0xDE,
  0x00, 0x77, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xE3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xC7, 0x1C, 0x71, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xE3, 0x8E, 0x38, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x3E, 0xE0, 0x1E, 0x78, 0x1E, 0x3C, 0x1E, 0x0E, 0x1E, 0x07, 0x9E, 0x03,
  0xDF, 0x00, 0xE7, 0x00, 0x78, 0x80, 0x20, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x20, 0xE3, 0xE1, 0xE1, 0xE1, 0xC1, 0x00, 0x00, 0xFF, 0x01,
  0xFF, 0xC3, 0xFF, 0xE3, 0xF0, 0xF3, 0xE0, 0x71, 0xE0, 0x79, 0xE0, 0x3C,
  0xF0, 0x1E, 0x70, 0x0E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01,
  0xE7, 0x80, 0xE1, 0xE1, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xEF, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC3,
  0xE1, 0xE1, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x38, 0x07,
  0xBC, 0x03, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE3, 0x81, 0xF3, 0xC1,
  0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x81, 0xFF,
  0xC3, 0xFF, 0xE3, 0xF0, 0x23, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x10, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0x81, 0xF8, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0x70, 0x7C, 0x0F,
  0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x00, 0xE0, 0xF0, 0x1E, 0x0F, 0x01,
  0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0x78, 0x3E, 0x07, 0xFF, 0xE0, 0x3F,
  0xFE, 0x01, 0xFC, 0xE0, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xE0,
  0xF3, 0xE0, 0x79, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x3E, 0x73, 0xFE, 0x7F,
  0xFE, 0x3F, 0xFC, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x10,
  0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3E,
  0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xC1, 0xE0, 0x3C, 0x1E,
  0x03, 0xC1, 0xE0, 0x3C, 0x1C, 0x03, 0x81, 0xC0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x60, 0x3C, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0xFE, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xE1, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C,
  0x0F, 0x1C, 0x07, 0x9E, 0x03, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0x80, 0xF3,
  0xC0, 0x71, 0xE0, 0x78, 0xF0, 0x3C, 0x70, 0x1E, 0x78, 0x1E, 0x00, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC7, 0xFC, 0xFF, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xFF, 0x0F,
  0xF0, 0x7F, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x06, 0x0F, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x03, 0xE1, 0xE0, 0xF0, 0x38, 0x3C, 0x0F, 0x0F, 0x01, 0xE3,
  0xC0, 0x3D, 0xF0, 0x07, 0x7C, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xE7, 0x80, 0x3C, 0x78, 0x07, 0x8F, 0x80, 0xF0, 0xF0, 0x1C, 0x0F,
  0x07, 0x81, 0xE0, 0xF0, 0x1E, 0x1E, 0x03, 0xC0, 0xFF, 0x9F, 0xF3, 0xFE,
  0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x0B, 0xFE, 0x7F, 0xE7, 0xF8, 0x07, 0xE7, 0x81, 0xFF,
  0xF8, 0x7F, 0xFF, 0x0E, 0x3C, 0xF1, 0xC7, 0x1C, 0x38, 0xE3, 0x8F, 0x1C,
  0x71, 0xC7, 0x8E, 0x38, 0xE3, 0xC7, 0x1C, 0x71, 0xE3, 0x8E, 0x38, 0x81,
  0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0F,
  0x1C, 0x01, 0xC0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x1E, 0x1F, 0x1E,
  0x0F, 0x1C, 0x07, 0x3C, 0x07, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78,
  0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1E, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x3C, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xE3,
  0xE0, 0x79, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xB8, 0x03,
  0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xE7, 0xC0, 0xF1, 0xE1, 0xF0, 0xFF,
  0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78,
  0x0F, 0x0F, 0x01, 0xE3, 0xC0, 0x38, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0,
  0x78, 0x38, 0x1F, 0x0F, 0x0F, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFE,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x3E, 0x1E,
  0x1E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x71, 0xE0, 0x3C, 0x78, 0x0F, 0x1C,
  0x03, 0xC7, 0x00, 0xE3, 0xC0, 0x78, 0x70, 0x1E, 0x1E, 0x07, 0x87, 0x83,
  0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0x87,
  0xFF, 0x87, 0xFF, 0xC3, 0xF0, 0x41, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xC1, 0xE0, 0x40, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF1, 0x80, 0xF0, 0xFF, 0xF8, 0xFF, 0xF8,
  0x3F, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x8F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x43, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x00, 0x3C,
  0x07, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x78,
  0x1E, 0x70, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xE0,
  0x38, 0xF0, 0x78, 0xF0, 0xF8, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0x3C, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1C, 0x70, 0x3C, 0x78,
  0x3C, 0x78, 0x78, 0x78, 0x70, 0x78, 0xF0, 0x79, 0xE0, 0x79, 0xE0, 0x7B,
  0xC0, 0x3B, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x38,
  0x00, 0xF3, 0x80, 0x0E, 0x78, 0x00, 0xE7, 0x80, 0x1C, 0x70, 0xE1, 0xC7,
  0x0E, 0x1C, 0x71, 0xE3, 0x87, 0x1E, 0x38, 0x73, 0xE3, 0x87, 0x3E, 0x70,
  0x77, 0x77, 0x07, 0x67, 0x70, 0x6E, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7C,
  0x0F, 0x87, 0xC0, 0xF0, 0x78, 0x0F, 0x03, 0x80, 0x0F, 0x80, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x3C, 0x03, 0xC7, 0x80, 0x1E, 0xF0, 0x01,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xDE, 0x00, 0xF9, 0xE0, 0x1F, 0x0F, 0x03, 0xE0, 0xF0,
  0x3C, 0x07, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x1C,
  0x07, 0x80, 0x70, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x83, 0xC0, 0x1E, 0x0F,
  0x00, 0x78, 0x38, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x00, 0x0E, 0x3C, 0x00,
  0x3C, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xF0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x01,
  0x4F, 0xF0, 0xE7, 0xFF, 0x79, 0xEF, 0xFC, 0xE0, 0xFE, 0x18, 0x1F, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 10, 24, 19, 5, -24 },
  { 31, 12, 10, 19, 7, -26 },
  { 46, 20, 24, 19, 0, -24 },
  { 106, 18, 30, 19, 1, -26 },
  { 174, 23, 25, 19, -1, -24 },
  { 246, 17, 24, 19, 1, -24 },
  { 297, 5, 11, 19, 10, -26 },
  { 304, 15, 33, 19, 4, -27 },
  { 366, 14, 33, 19, 1, -27 },
  { 424, 15, 15, 19, 4, -24 },
  { 453, 16, 16, 19, 2, -18 },
  { 485, 9, 12, 19, 2, -6 },
  { 499, 10, 4, 19, 5, -12 },
  { 504, 6, 6, 19, 5, -6 },
  { 509, 22, 33, 19, -2, -27 },
  { 600, 17, 25, 19, 2, -24 },
  { 654, 14, 24, 19, 2, -24 },
  { 696, 18, 24, 19, 1, -24 },
  { 750, 18, 25, 19, 0, -24 },
  { 807, 19, 24, 19, 0, -24 },
  { 864, 20, 25, 19, 0, -24 },
  { 927, 18, 25, 19, 2, -24 },
  { 984, 17, 24, 19, 4, -24 },
  { 1035, 18, 25, 19, 1, -24 },
  { 1092, 18, 24, 19, 1, -24 },
  { 1146, 9, 18, 19, 5, -18 },
  { 1167, 12, 24, 19, 2, -18 },
  { 1203, 17, 16, 19, 2, -18 },
  { 1237, 18, 10, 19, 1, -15 },
  { 1260, 17, 16, 19, 1, -18 },
  { 1294, 14, 24, 19, 5, -24 },
  { 1336, 19, 29, 19, 1, -24 },
  { 1405, 19, 24, 19, -2, -24 },
  { 1462, 19, 24, 19, 0, -24 },
  { 1519, 18, 25, 19, 2, -24 },
  { 1576, 19, 24, 19, 0, -24 },
  { 1633, 19, 24, 19, 1, -24 },
  { 1690, 20, 24, 19, 1, -24 },
  { 1750, 18, 25, 19, 2, -24 },
  { 1807, 21, 24, 19, 0, -24 },
  { 1870, 19, 24, 19, 1, -24 },
  { 1927, 19, 25, 19, 1, -24 },
  { 1987, 21, 24, 19, 0, -24 },
  { 2050, 15, 24, 19, 0, -24 },
  { 2095, 21, 24, 19, -1, -24 },
  { 2158, 21, 24, 19, 0, -24 },
  { 2221, 18, 25, 19, 1, -24 },
  { 2278, 19, 24, 19, 0, -24 },
  { 2335, 18, 30, 19, 1, -24 },
  { 2403, 19, 24, 19, 0, -24 },
  { 2460, 19, 25, 19, 0, -24 },
  { 2520, 17, 24, 19, 4, -24 },
  { 2571, 20, 25, 19, 1, -24 },
  { 2634, 18, 24, 19, 4, -24 },
  { 2688, 21, 24, 19, 1, -24 },
  { 2751, 23, 24, 19, -1, -24 },
  { 2820, 18, 24, 19, 4, -24 },
  { 2874, 20, 24, 19, 0, -24 },
  { 2934, 18, 33, 19, 2, -27 },
  { 3009, 6, 33, 19, 7, -27 },
  { 3034, 18, 33, 19, -1, -27 },
  { 3109, 17, 14, 19, 2, -24 },
  { 3139, 18, 3, 19, -3, 3 },
  { 3146, 7, 7, 19, 8, -26 },
  { 3153, 17, 18, 19, 1, -18 },
  { 3192, 17, 26, 19, 1, -26 },
  { 3248, 17, 18, 19, 1, -18 },
  { 3287, 20, 26, 19, 1, -26 },
  { 3352, 17, 18, 19, 1, -18 },
  { 3391, 23, 32, 19, -2, -26 },
  { 3483, 20, 24, 19, -1, -18 },
  { 3543, 17, 26, 19, 0, -26 },
  { 3599, 12, 26, 19, 3, -26 },
  { 3638, 19, 32, 19, -1, -26 },
  { 3714, 19, 26, 19, 1, -26 },
  { 3776, 11, 26, 19, 5, -26 },
  { 3812, 19, 18, 19, 0, -18 },
  { 3855, 16, 18, 19, 1, -18 },
  { 3891, 17, 18, 19, 1, -18 },
  { 3930, 19, 24, 19, -1, -18 },
  { 3987, 18, 24, 19, 1, -18 },
  { 4041, 17, 18, 19, 2, -18 },
  { 4080, 17, 18, 19, 1, -18 },
  { 4119, 15, 23, 19, 3, -23 },
  { 4163, 16, 18, 19, 2, -18 },
  { 4199, 16, 18, 19, 3, -18 },
  { 4235, 20, 18, 19, 1, -18 },
  { 4280, 20, 18, 19, -1, -18 },
  { 4325, 22, 24, 19, -3, -18 },
  { 4391, 17, 18, 19, 1, -18 },
  { 4430, 18, 33, 19, 2, -27 },
  { 4505, 12, 33, 19, 4, -27 },
  { 4555, 18, 33, 19, -1, -27 },
  { 4630, 18, 6, 19, 1, -13 },
};

const GFXfont UbuntuSansMono_MediumItalic34pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic34pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic34pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC34PT7B_H_
