#ifndef _UBUNTUSANSMONO_MEDIUMITALIC48PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0x40,
  0x00, 0x3F, 0x0F, 0x9F, 0x0F, 0xCF, 0x87, 0xEF, 0xC3, 0xE7, 0xC1, 0xF3,
  0xE0, 0xF9, 0xF0, 0x78, 0xF0, 0x7C, 0x78, 0x3E, 0x3C, 0x1E, 0x3C, 0x0F,
  0x1E, 0x07, 0x8F, 0x03, 0x87, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0x83, 0xE0, 0x00, 0xF0, 0x3C, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0,
  0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x1F, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x87, 0xC0,
  0x3F, 0x00, 0x10, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x03, 0x00, 0x1F, 0xC0, 0xF8, 0x1F, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x80, 0x3F, 0x80, 0x07, 0x80, 0x3F, 0xE0, 0x07, 0x80, 0x3E, 0xF0, 0x07,
  0x80, 0x1E, 0x38, 0x07, 0x80, 0x1E, 0x1E, 0x07, 0xC0, 0x0F, 0x0F, 0x07,
  0xC0, 0x07, 0x07, 0x03, 0xC0, 0x07, 0x83, 0x83, 0xC0, 0x03, 0xC3, 0xC3,
  0xC0, 0x01, 0xE1, 0xE3, 0xC0, 0x00, 0xF0, 0xE3, 0xE0, 0x00, 0x78, 0xF3,
  0xE0, 0x00, 0x3F, 0xF1, 0xE0, 0x00, 0x0F, 0xF9, 0xE0, 0x00, 0x03, 0xF1,
  0xE0, 0x00, 0x00, 0x61, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xF1, 0xE0, 0x00, 0x01, 0xF3, 0xF8, 0x00, 0x00, 0xF3, 0xFE, 0x00, 0x00,
  0xF3, 0xEF, 0x00, 0x00, 0xF1, 0xE3, 0xC0, 0x00, 0xF1, 0xE1, 0xE0, 0x00,
  0xF8, 0xF0, 0xF0, 0x00, 0xF8, 0x70, 0x78, 0x00, 0x78, 0x38, 0x38, 0x00,
  0x78, 0x3C, 0x1C, 0x00, 0x78, 0x1E, 0x1E, 0x00, 0x78, 0x0F, 0x0F, 0x00,
  0x78, 0x07, 0x8F, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0xFF, 0x80,
  0x7C, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xF8, 0x7C,
  0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x7C,
  0x03, 0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE1, 0xF0, 0x03, 0xE3, 0xF0,
  0x01, 0xEF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x0E,
  0x07, 0xFC, 0x1F, 0x0F, 0xFC, 0x1F, 0x1F, 0xBE, 0x1E, 0x3E, 0x3F, 0x3E,
  0x7C, 0x1F, 0x3C, 0x7C, 0x0F, 0xFC, 0xF8, 0x0F, 0xF8, 0xF8, 0x07, 0xF8,
  0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xF0,
  0xFC, 0x1F, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0xF8, 0x3F, 0xFC, 0x7C,
  0x1F, 0xF0, 0x7C, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0xF8,
  0xF8, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x0E, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x38,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x07, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x04, 0x07, 0x81, 0x3C, 0x3C, 0x39,
  0xF1, 0xE7, 0xCF, 0xEE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xE0, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xEF, 0x80, 0x3F, 0x3E, 0x01,
  0xF1, 0xF8, 0x3F, 0x8F, 0xE0, 0xF8, 0x3E, 0x01, 0xC0, 0xE0, 0x04, 0x04,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x3F, 0x81, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0xFE, 0x01,
  0xF0, 0x0F, 0x00, 0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0x81, 0xF0, 0x0C, 0x00,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x3E, 0x3F, 0x9F,
  0xDF, 0xFF, 0xFF, 0xFB, 0xFC, 0xFC, 0x18, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x03, 0xF8, 0x3F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F,
  0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x3F,
  0x00, 0x1F, 0x3E, 0x0C, 0x1F, 0x3E, 0x3E, 0x1F, 0x7E, 0x3F, 0x1F, 0x7C,
  0x7F, 0x1F, 0x7C, 0x7E, 0x3F, 0x7C, 0x7E, 0x3E, 0x7C, 0x3C, 0x3E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8,
  0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x7C,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xE7, 0xE0, 0x3E, 0x3E, 0x00, 0x81,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0x00, 0x7E, 0x02, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x06, 0x01, 0xFC, 0x02, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x84, 0x00, 0x1F, 0x83, 0x80, 0x3F, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x02, 0x00,
  0x1F, 0xC0, 0x38, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0xFB, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80,
  0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F,
  0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xC7,
  0xF0, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x1F, 0x07, 0xC0,
  0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C,
  0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xE3, 0xF0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xF0, 0xFE, 0x03,
  0xF0, 0x1F, 0x83, 0xF0, 0x07, 0xE1, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F,
  0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xDF, 0xE0, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x3E,
  0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x03,
  0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3F, 0x00,
  0x3E, 0x1F, 0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0x1F, 0xE7, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x3F, 0x81, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0xFC, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F,
  0xE0, 0x7E, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x01, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xF8,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x60, 0x0F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x04,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xFF,
  0x0F, 0xFF, 0xE1, 0xF9, 0xFE, 0x30, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0xFF, 0xF1, 0xF0, 0x3F,
  0xFC, 0x3C, 0x1F, 0xFF, 0x8F, 0x87, 0xFF, 0xF1, 0xF0, 0xFC, 0x3E, 0x3C,
  0x3E, 0x07, 0xCF, 0x87, 0xC1, 0xF1, 0xF1, 0xF0, 0x3E, 0x3C, 0x3E, 0x07,
  0xC7, 0x87, 0xC0, 0xF8, 0xF0, 0xF0, 0x1E, 0x1E, 0x1E, 0x07, 0xC7, 0xC7,
  0xC0, 0xF8, 0xF8, 0x78, 0x1F, 0x1F, 0x0F, 0x03, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3F, 0x9F, 0x0F, 0x83, 0xFF, 0xE0, 0xF0, 0x7F, 0xF8, 0x1E, 0x07,
  0xFF, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x04, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x78,
  0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0,
  0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xCF, 0x80,
  0x01, 0xF3, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7C, 0x07, 0xF0, 0x1F, 0x00, 0x7C, 0x0F,
  0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0x7C, 0x7F,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x3E, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC1,
  0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x1F, 0x01,
  0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFE, 0x01, 0xC0, 0x7F,
  0x00, 0x10, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x20, 0x1F, 0xE0, 0x78, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0xFC, 0x1F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x03,
  0xE0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x1F,
  0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF0,
  0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x7F, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x0F,
  0xC1, 0xF8, 0x07, 0xF0, 0x7C, 0x07, 0xF8, 0x1F, 0x0F, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0xE0, 0x3F, 0x00, 0x10, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x87, 0xC0,
  0x03, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F,
  0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x3E,
  0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0,
  0x7C, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0xC0,
  0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1F,
  0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x7C, 0x03,
  0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80,
  0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07,
  0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x80,
  0x0F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E,
  0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0xFC, 0x07,
  0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x3E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x80, 0x0F, 0xC0, 0x18, 0x03, 0xF8, 0x07, 0xC0, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF0, 0x1F, 0xC0,
  0x07, 0xC0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x03,
  0xE0, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFB, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x07,
  0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x3F, 0x80, 0x7F, 0x03, 0xFC, 0x07, 0xF8, 0x1D, 0xC0, 0x3D, 0xC1,
  0xFE, 0x01, 0xEE, 0x0E, 0xF0, 0x1F, 0x70, 0xF7, 0x80, 0xF3, 0x87, 0x3C,
  0x07, 0x9C, 0x79, 0xE0, 0x3C, 0xF3, 0x9F, 0x03, 0xE7, 0xBC, 0xF0, 0x1E,
  0x3F, 0xC7, 0x80, 0xF1, 0xFE, 0x3C, 0x0F, 0x8F, 0xE3, 0xE0, 0x7C, 0x7E,
  0x1F, 0x03, 0xC3, 0xF0, 0xF0, 0x3E, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x7C,
  0x0F, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x3E,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0xF8,
  0x0F, 0xC0, 0x07, 0xC0, 0x7F, 0x00, 0x3E, 0x03, 0xF8, 0x01, 0xE0, 0x1F,
  0xC0, 0x1F, 0x01, 0xFE, 0x00, 0xF8, 0x0F, 0xF8, 0x07, 0xC0, 0x7F, 0xC0,
  0x3C, 0x03, 0xDE, 0x03, 0xE0, 0x3E, 0xF8, 0x1F, 0x01, 0xF3, 0xC0, 0xF8,
  0x0F, 0x9E, 0x07, 0x80, 0x78, 0xF0, 0x7C, 0x03, 0xC7, 0xC3, 0xE0, 0x3E,
  0x1E, 0x1F, 0x01, 0xF0, 0xF0, 0xF0, 0x0F, 0x87, 0x8F, 0x80, 0x78, 0x3E,
  0x7C, 0x07, 0xC0, 0xF3, 0xE0, 0x3E, 0x07, 0x9F, 0x01, 0xF0, 0x3C, 0xF0,
  0x0F, 0x01, 0xEF, 0x80, 0xF8, 0x0F, 0x7C, 0x07, 0xC0, 0x3F, 0xE0, 0x3E,
  0x01, 0xFE, 0x01, 0xE0, 0x0F, 0xF0, 0x1F, 0x00, 0x7F, 0x80, 0xF8, 0x01,
  0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0x3C, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF0,
  0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F,
  0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7C, 0x00,
  0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xDF, 0x80, 0x07, 0xEF, 0xC0,
  0x03, 0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xF8, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3E, 0x07,
  0xC0, 0x3F, 0x03, 0xF0, 0x7F, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0xFC, 0x0F, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x1F,
  0x03, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00,
  0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x3E,
  0x00, 0xFE, 0x0F, 0x80, 0x7F, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE7,
  0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x01,
  0xF9, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x7F, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7C, 0x07, 0xF0,
  0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x01,
  0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x07, 0xC1, 0xF0,
  0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0xC1, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x3F, 0x01,
  0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x7E,
  0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0,
  0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x03, 0xF8, 0x03, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0x00, 0x0F, 0xC0, 0x78, 0x07, 0xF8,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xFC,
  0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C,
  0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80,
  0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x81,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x01,
  0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x3F, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x3F,
  0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xEF, 0xC0,
  0x01, 0xFB, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x8F,
  0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x3E,
  0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F,
  0x03, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3F, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xF8,
  0x00, 0x0F, 0x3E, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x03,
  0xE0, 0x78, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0x81,
  0xF0, 0xF0, 0x7C, 0x0F, 0x0F, 0xC3, 0xE0, 0x78, 0x7E, 0x1E, 0x07, 0xC7,
  0xF1, 0xF0, 0x3E, 0x3F, 0x8F, 0x81, 0xE3, 0xFC, 0x78, 0x0F, 0x1D, 0xE3,
  0xC0, 0x79, 0xE7, 0x3E, 0x03, 0xCE, 0x39, 0xE0, 0x3C, 0xF1, 0xCF, 0x01,
  0xE7, 0x0E, 0x78, 0x0F, 0x78, 0x77, 0x80, 0x7F, 0x83, 0xBC, 0x03, 0xFC,
  0x1D, 0xE0, 0x1F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01,
  0xF8, 0xF8, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xC7, 0xC0, 0x07,
  0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x7E, 0x03,
  0xF0, 0x1F, 0x03, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xF1,
  0xF8, 0x00, 0xF9, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFC, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x7E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x7C, 0x00, 0xFC, 0xF8, 0x03, 0xF1, 0xF8,
  0x0F, 0xC1, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE1, 0xF8, 0x07, 0xC7,
  0xE0, 0x0F, 0x9F, 0x80, 0x1F, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x30,
  0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x20, 0x1C, 0x0F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xFC, 0x1E, 0x03, 0x00, 0x40, 0x00, 0x01, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xF0, 0x3E, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0x7C, 0x3F, 0x00, 0x7C, 0x7E,
  0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xFC, 0x07, 0xF0, 0xFE,
  0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFD, 0xF0, 0x1F,
  0xF8, 0xF8, 0x01, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE1, 0x80, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F,
  0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7C,
  0x01, 0xF8, 0x7C, 0x03, 0xF8, 0x7C, 0x1F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xF0, 0x04, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x10, 0x7F, 0x80, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x6F,
  0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xF0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x7E, 0x01, 0xF8,
  0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x00,
  0x3F, 0x03, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03,
  0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x01, 0xF8, 0x03,
  0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x0F, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x7C, 0x00, 0xFF, 0x8F,
  0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFC, 0x0F, 0xC7, 0xE0,
  0x0F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF0, 0x01,
  0xFB, 0xE0, 0x0F, 0xEF, 0xC7, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x0C, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x60, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00,
  0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x80,
  0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x1F, 0x80,
  0x1F, 0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x01, 0xF8, 0x03, 0xF0,
  0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xF7, 0xC0, 0x00, 0x7C, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x06, 0x00, 0x7F, 0x00, 0x7F, 0x7F, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF3, 0x80,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xE0, 0x7F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x1F,
  0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E,
  0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7C,
  0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8,
  0x7E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8,
  0xFC, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F,
  0xE1, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x60, 0x1F, 0x80, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0xFE,
  0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xC0,
  0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x1F, 0xC0, 0x07, 0xE7, 0xF0, 0x00,
  0xF9, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x1F,
  0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x81, 0xF8,
  0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0xF8, 0xFF,
  0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x06, 0xFF,
  0xFC, 0xFF, 0xF9, 0xFF, 0xF1, 0xFF, 0xC0, 0x70, 0x00, 0x00, 0x08, 0x02,
  0x00, 0x3F, 0xE3, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x0F, 0x87, 0xC7, 0xC1, 0xF0, 0xF0, 0xF8, 0x3C, 0x1E, 0x1F,
  0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0xC3,
  0xC3, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0,
  0xF8, 0x78, 0x3C, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00,
  0x3C, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xC0, 0xFE, 0x07, 0xC0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x1F, 0x80,
  0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00,
  0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00,
  0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01,
  0xF0, 0xFC, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F,
  0xC7, 0xE0, 0x1F, 0x8F, 0x80, 0x3F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7D,
  0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xE0,
  0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x7F, 0x0F, 0xC1, 0xFC, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7C, 0x07, 0xF0, 0x3F, 0x00, 0xFC,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7E, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xC1,
  0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x01, 0xFE, 0x07, 0xC1, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x03, 0xEC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xF0,
  0x3F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x7E, 0x3E, 0x00,
  0x7E, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01,
  0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x07,
  0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x00, 0x87, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF8, 0x0E, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFC, 0x03, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x84, 0x00, 0x3F, 0x0F, 0x00,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x38, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80,
  0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00,
  0x7E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x01,
  0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0x7E, 0x0F,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFD, 0xF0, 0x1F, 0xF0,
  0xF8, 0x01, 0x80, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3E, 0x3E,
  0x01, 0xF8, 0xFC, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x1F, 0x07,
  0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00,
  0x7C, 0x7C, 0x01, 0xFB, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x3E,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x1F, 0x07, 0x83,
  0xE3, 0xC1, 0xF0, 0x7C, 0x78, 0x3E, 0x0F, 0x0F, 0x0F, 0xC3, 0xE1, 0xE1,
  0xF8, 0x78, 0x3C, 0x7F, 0x0F, 0x0F, 0x8F, 0xE3, 0xE1, 0xF3, 0xDE, 0x78,
  0x3E, 0x7B, 0xCF, 0x07, 0x9E, 0x7B, 0xE0, 0xF3, 0x8F, 0x78, 0x1E, 0xF1,
  0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xE0, 0x7E, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07,
  0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x0F, 0x80,
  0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0xFC, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F,
  0x80, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x40, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x03, 0x83,
  0xFF, 0x03, 0xE3, 0xFF, 0xC1, 0xE3, 0xFF, 0xFF, 0xF1, 0xF3, 0xFF, 0xF1,
  0xF0, 0x7F, 0xF9, 0xF0, 0x1F, 0xF0, 0x30, 0x03, 0xF0, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 14, 34, 27, 7, -33 },
  { 61, 17, 14, 27, 9, -36 },
  { 91, 28, 33, 27, 0, -33 },
  { 207, 26, 42, 27, 1, -37 },
  { 344, 33, 35, 27, -2, -34 },
  { 489, 24, 34, 27, 1, -34 },
  { 591, 8, 15, 27, 14, -36 },
  { 606, 20, 47, 27, 6, -38 },
  { 724, 21, 47, 27, 1, -38 },
  { 848, 21, 20, 27, 5, -33 },
  { 901, 23, 24, 27, 2, -26 },
  { 970, 13, 16, 27, 3, -8 },
  { 996, 14, 5, 27, 7, -16 },
  { 1005, 9, 9, 27, 7, -8 },
  { 1016, 31, 47, 27, -3, -38 },
  { 1199, 24, 35, 27, 2, -34 },
  { 1304, 21, 33, 27, 2, -33 },
  { 1391, 25, 34, 27, 1, -34 },
  { 1498, 25, 35, 27, 1, -34 },
  { 1608, 26, 33, 27, 0, -33 },
  { 1716, 28, 34, 27, 0, -33 },
  { 1835, 25, 35, 27, 3, -34 },
  { 1945, 25, 33, 27, 5, -33 },
  { 2049, 25, 35, 27, 2, -34 },
  { 2159, 25, 34, 27, 2, -34 },
  { 2266, 13, 26, 27, 7, -25 },
  { 2309, 17, 33, 27, 3, -25 },
  { 2380, 24, 22, 27, 2, -25 },
  { 2446, 26, 15, 27, 1, -22 },
  { 2495, 24, 22, 27, 1, -25 },
  { 2561, 19, 35, 27, 7, -34 },
  { 2645, 27, 41, 27, 1, -34 },
  { 2784, 26, 33, 27, -3, -33 },
  { 2892, 26, 34, 27, 0, -34 },
  { 3003, 26, 35, 27, 3, -34 },
  { 3117, 26, 34, 27, 0, -34 },
  { 3228, 28, 33, 27, 1, -33 },
  { 3344, 27, 33, 27, 2, -33 },
  { 3456, 26, 35, 27, 2, -34 },
  { 3570, 29, 33, 27, 0, -33 },
  { 3690, 27, 33, 27, 1, -33 },
  { 3802, 27, 34, 27, 1, -33 },
  { 3917, 30, 33, 27, 0, -33 },
  { 4041, 20, 33, 27, 1, -33 },
  { 4124, 29, 33, 27, -1, -33 },
  { 4244, 29, 33, 27, 0, -33 },
  { 4364, 25, 35, 27, 2, -34 },
  { 4474, 26, 34, 27, 1, -34 },
  { 4585, 25, 43, 27, 2, -34 },
  { 4720, 26, 34, 27, 0, -34 },
  { 4831, 27, 35, 27, 0, -34 },
  { 4950, 24, 33, 27, 6, -33 },
  { 5049, 27, 34, 27, 2, -33 },
  { 5164, 26, 33, 27, 5, -33 },
  { 5272, 29, 33, 27, 1, -33 },
  { 5392, 33, 33, 27, -2, -33 },
  { 5529, 25, 33, 27, 6, -33 },
  { 5633, 29, 33, 27, 0, -33 },
  { 5753, 25, 47, 27, 3, -38 },
  { 5900, 10, 47, 27, 9, -38 },
  { 5959, 25, 47, 27, -1, -38 },
  { 6106, 23, 18, 27, 3, -33 },
  { 6158, 26, 5, 27, -4, 4 },
  { 6175, 10, 10, 27, 12, -37 },
  { 6188, 24, 27, 27, 2, -26 },
  { 6269, 24, 38, 27, 1, -37 },
  { 6383, 24, 27, 27, 2, -26 },
  { 6464, 27, 38, 27, 2, -37 },
  { 6593, 23, 27, 27, 2, -26 },
  { 6671, 33, 46, 27, -3, -37 },
  { 6861, 28, 35, 27, -1, -26 },
  { 6984, 24, 37, 27, 0, -37 },
  { 7095, 17, 37, 27, 5, -37 },
  { 7174, 26, 46, 27, -1, -37 },
  { 7324, 27, 37, 27, 1, -37 },
  { 7449, 15, 38, 27, 7, -37 },
  { 7521, 27, 26, 27, -1, -26 },
  { 7609, 24, 26, 27, 1, -26 },
  { 7687, 23, 27, 27, 2, -26 },
  { 7765, 26, 35, 27, -1, -26 },
  { 7879, 24, 35, 27, 2, -26 },
  { 7984, 24, 26, 27, 2, -26 },
  { 8062, 23, 27, 27, 2, -26 },
  { 8140, 21, 34, 27, 5, -33 },
  { 8230, 24, 26, 27, 2, -25 },
  { 8308, 22, 25, 27, 5, -25 },
  { 8377, 27, 25, 27, 2, -25 },
  { 8462, 28, 25, 27, -1, -25 },
  { 8550, 31, 34, 27, -4, -25 },
  { 8682, 25, 25, 27, 1, -25 },
  { 8761, 26, 47, 27, 3, -38 },
  { 8914, 16, 47, 27, 6, -38 },
  { 9008, 26, 47, 27, -2, -38 },
  { 9161, 25, 9, 27, 1, -19 },
};

const GFXfont UbuntuSansMono_MediumItalic48pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic48pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic48pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC48PT7B_H_
