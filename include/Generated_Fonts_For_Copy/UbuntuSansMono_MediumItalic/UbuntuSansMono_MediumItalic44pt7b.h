#ifndef _UBUNTUSANSMONO_MEDIUMITALIC44PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0x30, 0x00,
  0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1E, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C,
  0x78, 0x3C, 0x78, 0x3C, 0x78, 0x38, 0x70, 0x38, 0x70, 0x78, 0xF0, 0x70,
  0x00, 0x0F, 0x87, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x78,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xC1, 0xE0, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8,
  0x03, 0xC1, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x0F,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF8, 0x07, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x81,
  0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80,
  0x07, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xF0, 0x0C, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x20,
  0x01, 0xF0, 0x38, 0x07, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x04, 0x03, 0xF8, 0x01, 0xE0, 0x1F, 0xF0, 0x0F, 0x00, 0xF1,
  0xC0, 0x3C, 0x03, 0xC7, 0x01, 0xE0, 0x0E, 0x1C, 0x0F, 0x00, 0x78, 0x70,
  0x78, 0x01, 0xC1, 0xC3, 0xC0, 0x07, 0x0F, 0x1E, 0x00, 0x1C, 0x3C, 0x70,
  0x00, 0x70, 0xE3, 0xC0, 0x01, 0xE7, 0x9E, 0x00, 0x07, 0xFC, 0xF0, 0x00,
  0x0F, 0xE7, 0x80, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x84, 0x00, 0x00, 0x3C, 0xFC, 0x00, 0x01, 0xE7, 0xF8, 0x00, 0x0F,
  0x3F, 0xE0, 0x00, 0x79, 0xE3, 0x80, 0x03, 0xC7, 0x8F, 0x00, 0x0E, 0x1C,
  0x3C, 0x00, 0x78, 0x70, 0xE0, 0x03, 0xC3, 0xC3, 0x80, 0x1E, 0x0F, 0x0E,
  0x00, 0xF0, 0x3C, 0x78, 0x07, 0x80, 0xF1, 0xC0, 0x3C, 0x03, 0xFF, 0x00,
  0xF0, 0x07, 0xF8, 0x0F, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xE0,
  0xF0, 0x0F, 0x83, 0xC0, 0x3C, 0x0F, 0x01, 0xF0, 0x3C, 0x07, 0xC1, 0xF0,
  0x1F, 0x07, 0x80, 0x7C, 0x3C, 0x00, 0xF1, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0x0F, 0xF8, 0x3C, 0x7D, 0xF1,
  0xE3, 0xE7, 0xC7, 0x9F, 0x0F, 0xBE, 0x78, 0x1F, 0xF3, 0xE0, 0x7F, 0xCF,
  0x80, 0xFE, 0x3C, 0x03, 0xF0, 0xF0, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0x81,
  0xFE, 0x3F, 0xBF, 0xF8, 0x7F, 0xFD, 0xF1, 0xFF, 0xE7, 0xC1, 0xFE, 0x1F,
  0x00, 0x7E, 0xF9, 0xF3, 0xE7, 0xDF, 0x3E, 0x7C, 0xF1, 0xE3, 0xC7, 0x0E,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x06, 0x0E, 0x0C, 0xF1, 0xC7, 0xBF, 0xBB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xDE, 0x00, 0xFB, 0xE0, 0x3E, 0x7E,
  0x0F, 0xC7, 0xC1, 0xF0, 0xFC, 0x0E, 0x0E, 0x00, 0x80, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x03, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0x03, 0xC0, 0xF1, 0xFE, 0x7F,
  0x8F, 0xC1, 0xE0, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x08, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xF0, 0xF8, 0x1F, 0x01, 0xF0, 0xFC, 0x07,
  0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xCF,
  0x80, 0x1F, 0x3C, 0x38, 0x7D, 0xF1, 0xF1, 0xF7, 0xC7, 0xC7, 0xDF, 0x3F,
  0x1F, 0x78, 0xFC, 0x7B, 0xE1, 0xE3, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3C,
  0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8,
  0x07, 0xC3, 0xE0, 0x3F, 0x07, 0xC1, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0x3E, 0x7C, 0x07, 0x0F, 0x80, 0x81, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xFF,
  0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0x0F, 0xE0,
  0x70, 0x07, 0xC0, 0x40, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0xE0, 0x7E, 0x00, 0x80, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x30, 0x03, 0xF0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xBC,
  0x00, 0x1E, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0x78,
  0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF0,
  0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xE0,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x80, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x18, 0x03, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0x03, 0xF0, 0xF8,
  0x03, 0xE1, 0xF0, 0x03, 0xE3, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00,
  0x1F, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF8, 0x07,
  0xC1, 0xF8, 0x1F, 0x81, 0xFC, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x07, 0xC3, 0xE0,
  0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x78, 0x3E, 0x01,
  0xF0, 0x7C, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0xFE, 0xFC, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0x3F, 0x80, 0xF8, 0x1F, 0x83,
  0xE0, 0x1F, 0x87, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x78,
  0x00, 0xF8, 0xF0, 0x01, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xF0,
  0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xF0, 0x7E, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x1E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1E, 0x1F, 0x00,
  0x1E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x7E, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xC1,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x83, 0xF0, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xF8, 0x04, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x60, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x00, 0x04, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x03,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFF,
  0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1C, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0x81, 0xF0,
  0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x8F, 0x80, 0x07, 0xC7, 0x80, 0xFF, 0xC3, 0xC1, 0xFF, 0xE3, 0xC1, 0xFF,
  0xF1, 0xE1, 0xFD, 0xF9, 0xF1, 0xF8, 0x78, 0xF0, 0xF8, 0x3C, 0x78, 0x78,
  0x1E, 0x3C, 0x7C, 0x1F, 0x1E, 0x3C, 0x0F, 0x1F, 0x1E, 0x07, 0x8F, 0x8F,
  0x03, 0xC7, 0x87, 0x83, 0xE3, 0xC3, 0xC1, 0xF1, 0xE1, 0xE0, 0xF0, 0xF0,
  0xF8, 0x78, 0x7C, 0x7F, 0xFC, 0x3E, 0x1F, 0xFE, 0x0F, 0x07, 0xFE, 0x07,
  0x80, 0xFE, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xF7,
  0x80, 0x03, 0xCF, 0x00, 0x0F, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0x7C, 0x78,
  0x00, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x1E, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0x80, 0x7C, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xC0,
  0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x00,
  0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xE0,
  0xFF, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x07, 0xC0, 0x3E, 0x07, 0x80,
  0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x1F, 0x01, 0xFC, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1E, 0x00,
  0x3C, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3C, 0x00,
  0xFC, 0x7C, 0x01, 0xF8, 0x7C, 0x03, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0x83, 0xC0, 0xFC, 0x00,
  0x83, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x06,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x03, 0xF3, 0xFC, 0x03, 0xE0, 0x7E, 0x03, 0xC0, 0x3E,
  0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F,
  0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF8,
  0x3C, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7C, 0x07, 0xF0, 0x7C, 0x1F, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x01, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFC, 0x1E, 0x07, 0xF0, 0x04, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xE0,
  0xFC, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7E, 0x03, 0xC0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0,
  0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00,
  0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07,
  0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C,
  0x00, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8,
  0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80,
  0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x20, 0x07, 0xC0, 0x3C, 0x0F,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x07, 0xC1,
  0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC7, 0xE0, 0x00,
  0xF9, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xDF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x87, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF8, 0x01, 0xF0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x00,
  0x78, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x07,
  0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xB8, 0x3F, 0x80, 0x77, 0x07, 0xF0, 0x1E,
  0xE1, 0xFE, 0x03, 0xDC, 0x3B, 0xC0, 0x7B, 0x8E, 0x78, 0x1E, 0x71, 0xCE,
  0x03, 0xCE, 0x73, 0xC0, 0x79, 0xDE, 0x78, 0x1F, 0x3B, 0x8F, 0x03, 0xC7,
  0xF1, 0xE0, 0x78, 0xFC, 0x7C, 0x0F, 0x1F, 0x8F, 0x03, 0xC3, 0xE1, 0xE0,
  0x78, 0x3C, 0x3C, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x78, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x0F,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x07,
  0xC1, 0xE0, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x78,
  0x0F, 0xE0, 0x0F, 0x01, 0xFC, 0x03, 0xE0, 0x3F, 0x80, 0x7C, 0x07, 0xF0,
  0x0F, 0x01, 0xFF, 0x01, 0xE0, 0x3F, 0xE0, 0x7C, 0x07, 0xBC, 0x0F, 0x80,
  0xF3, 0xC1, 0xE0, 0x1E, 0x78, 0x3C, 0x07, 0xCF, 0x07, 0x80, 0xF1, 0xE1,
  0xF0, 0x1E, 0x1E, 0x3C, 0x03, 0xC3, 0xC7, 0x80, 0xF8, 0x78, 0xF0, 0x1E,
  0x0F, 0x3E, 0x03, 0xC0, 0xE7, 0xC0, 0x78, 0x1E, 0xF0, 0x1F, 0x03, 0xDE,
  0x03, 0xC0, 0x7F, 0xC0, 0x78, 0x07, 0xF8, 0x0F, 0x00, 0xFE, 0x03, 0xE0,
  0x1F, 0xC0, 0x7C, 0x03, 0xF8, 0x0F, 0x00, 0x7F, 0x01, 0xE0, 0x0F, 0xC0,
  0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F,
  0x0F, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0, 0x1F, 0x1F, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF7, 0xC0, 0x03,
  0xEF, 0x80, 0x07, 0x9F, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F,
  0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0,
  0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0x0F, 0xF0, 0x0F,
  0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81,
  0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x1F, 0x07, 0xFC, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x0F, 0xC0, 0xF8,
  0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00,
  0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07,
  0x9F, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB,
  0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xF0,
  0x3F, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x03, 0xE0, 0xFF, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x03, 0xE0,
  0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0xFC, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x07, 0x80, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0xF8, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F,
  0x80, 0xF0, 0x1F, 0x80, 0x10, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x10, 0x00, 0xFC, 0x0E, 0x00, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07,
  0xC0, 0x0F, 0x83, 0xE0, 0x07, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F,
  0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0,
  0x07, 0xEF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0x3E,
  0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80,
  0x78, 0x3E, 0x00, 0xF0, 0x78, 0x01, 0xE1, 0xF0, 0x03, 0xC3, 0xC0, 0x07,
  0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x78,
  0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x1E, 0x00,
  0x0F, 0x03, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x03,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x0F, 0x0F, 0x83, 0xE3, 0xE1,
  0xE0, 0x78, 0x7C, 0x3C, 0x0F, 0x1F, 0x87, 0x81, 0xE3, 0xF1, 0xE0, 0x3C,
  0xEE, 0x3C, 0x07, 0x1D, 0xC7, 0x81, 0xE7, 0x3C, 0xE0, 0x3D, 0xE7, 0xBC,
  0x07, 0xB8, 0x77, 0x80, 0xEF, 0x0E, 0xE0, 0x1D, 0xC1, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0x78, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x3C, 0x03,
  0xE0, 0x3C, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x1F,
  0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x02, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x78,
  0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF0, 0x02, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFB, 0xE0,
  0x0F, 0xCF, 0x00, 0xFC, 0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0xC0,
  0x7C, 0x7E, 0x03, 0xE7, 0xE0, 0x1F, 0x7E, 0x00, 0x7F, 0xE0, 0x03, 0xE6,
  0x00, 0x1C, 0x00, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x20, 0x38, 0x3E, 0x1F, 0x87, 0xE1, 0xF8,
  0x3E, 0x0E, 0x02, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x03, 0xE3, 0xF8, 0x0F, 0x8F,
  0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00,
  0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF0,
  0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3F, 0x07, 0xF0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xBC, 0x07, 0xF8, 0xF8, 0x02, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x20, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xF0, 0x3E, 0x0F, 0x80, 0x7C,
  0x3C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x78,
  0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF0, 0x03,
  0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0x7C, 0x07, 0xE1, 0xE0, 0x7F, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x80, 0x41, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x30, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0x81,
  0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x3C, 0x0F, 0x80,
  0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0x81, 0xF0,
  0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x7E, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFB, 0xE0, 0x0F, 0xF9, 0xF0, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0xFF, 0x3F, 0x8F, 0xC0, 0x7C, 0xFC, 0x01, 0xE7, 0xC0, 0x0F, 0x7C, 0x00,
  0xFB, 0xE0, 0x0F, 0xFE, 0x00, 0xFD, 0xF0, 0x7F, 0xCF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x01, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xF8, 0x10, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0x0F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x0F, 0xC0, 0x78, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F,
  0x00, 0x7C, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xE7, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x10, 0x01, 0xF8, 0x0E, 0x01, 0xF8,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x20, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xF0, 0x3F, 0x0F, 0xC0, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C,
  0x01, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x03,
  0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xF8, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x7F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x01, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x40, 0x1F, 0x00, 0x70, 0x3F,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x3F, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0x83,
  0xF0, 0x0F, 0x87, 0xE0, 0x0F, 0x8F, 0xC0, 0x0F, 0xBF, 0x00, 0x0F, 0x7E,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F,
  0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7C, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7F, 0xF9, 0xFF, 0xC7, 0xFF,
  0x3F, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x13,
  0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0x10, 0x00, 0x01, 0xFE, 0x7E,
  0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFB, 0xFF, 0xF0, 0x78, 0x78,
  0x78, 0x3C, 0x3C, 0x3C, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x0F, 0x0F,
  0x0F, 0x07, 0x87, 0x87, 0x87, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE1, 0xE1,
  0xE1, 0xE0, 0xF0, 0xF0, 0xF0, 0x78, 0x00, 0x78, 0x7C, 0x00, 0x7C, 0x3C,
  0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x87,
  0x80, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE0, 0x00, 0x04, 0x00,
  0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3E,
  0x07, 0xE0, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x01,
  0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xE3,
  0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0,
  0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0x00, 0x04, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xC0, 0xFC, 0xFC, 0x03, 0xE7, 0xC0, 0x1F,
  0x7E, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7B, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xE7,
  0xC0, 0x1F, 0x3E, 0x01, 0xF1, 0xF8, 0x3F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x1F, 0x00, 0xFC, 0x1F, 0x01, 0xF8, 0x1F, 0x07, 0xF8, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F,
  0x83, 0xE1, 0xF8, 0x0F, 0x8F, 0xC0, 0x3E, 0x3E, 0x00, 0xF9, 0xF0, 0x07,
  0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x8F,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x80,
  0x7C, 0x3F, 0x03, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE,
  0x07, 0xC0, 0x08, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0x80, 0x40, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x0C, 0x01, 0xF8,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x02,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x10, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x60, 0x00, 0x1F, 0x00, 0x7C, 0x7C,
  0x01, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1E, 0x00, 0xF8, 0xF8, 0x03,
  0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3C, 0x01, 0xF1, 0xF0, 0x07, 0x87,
  0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0xC1, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xEF, 0x01, 0xFE, 0x3E, 0x00,
  0x40, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x07,
  0xEF, 0x80, 0x3E, 0x3C, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C,
  0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0,
  0x3E, 0x3E, 0x00, 0xF1, 0xF0, 0x07, 0x9F, 0x00, 0x3E, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0x9F, 0x00, 0x07,
  0xCF, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC1, 0xE0, 0xF1, 0xE0, 0xF0,
  0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x7C, 0x3C, 0x7C, 0x7E, 0x3C, 0x3C, 0x3F,
  0x1E, 0x1E, 0x3F, 0x8F, 0x0F, 0x3D, 0xCF, 0x07, 0x9C, 0xE7, 0x83, 0xDE,
  0x73, 0x81, 0xEE, 0x3B, 0xC0, 0xFF, 0x1D, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F,
  0x87, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x78, 0x03,
  0xC0, 0x3C, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x07,
  0xDF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xF3, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x1F,
  0x80, 0x3E, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8,
  0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x40, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x18, 0x1F, 0xE0, 0x3C, 0x7F, 0xE0,
  0xF1, 0xFF, 0xF7, 0xE7, 0xEF, 0xFF, 0x8F, 0x07, 0xFF, 0x3C, 0x07, 0xFC,
  0x08, 0x03, 0xE0,
};

const GFXglyph UbuntuSansMono_MediumItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 12, 31, 25, 7, -30 },
  { 48, 16, 12, 25, 8, -33 },
  { 72, 26, 30, 25, 0, -30 },
  { 170, 24, 39, 25, 1, -34 },
  { 287, 30, 32, 25, -2, -31 },
  { 407, 22, 31, 25, 1, -31 },
  { 493, 7, 13, 25, 13, -33 },
  { 505, 19, 43, 25, 5, -35 },
  { 608, 19, 43, 25, 1, -35 },
  { 711, 19, 18, 25, 5, -30 },
  { 754, 21, 22, 25, 2, -24 },
  { 812, 11, 14, 25, 3, -7 },
  { 832, 13, 5, 25, 6, -15 },
  { 841, 7, 8, 25, 7, -7 },
  { 848, 29, 42, 25, -3, -34 },
  { 1001, 22, 32, 25, 2, -31 },
  { 1089, 19, 30, 25, 2, -30 },
  { 1161, 23, 31, 25, 1, -31 },
  { 1251, 24, 32, 25, 0, -31 },
  { 1347, 24, 30, 25, 0, -30 },
  { 1437, 25, 31, 25, 0, -30 },
  { 1534, 23, 32, 25, 2, -31 },
  { 1626, 22, 30, 25, 5, -30 },
  { 1709, 23, 32, 25, 2, -31 },
  { 1801, 24, 31, 25, 1, -31 },
  { 1894, 11, 23, 25, 7, -22 },
  { 1926, 15, 29, 25, 3, -22 },
  { 1981, 22, 20, 25, 2, -23 },
  { 2036, 23, 14, 25, 1, -20 },
  { 2077, 22, 20, 25, 1, -23 },
  { 2132, 18, 32, 25, 6, -31 },
  { 2204, 25, 38, 25, 1, -31 },
  { 2323, 23, 30, 25, -2, -30 },
  { 2410, 24, 31, 25, 0, -31 },
  { 2503, 23, 32, 25, 3, -31 },
  { 2595, 24, 31, 25, 0, -31 },
  { 2688, 25, 30, 25, 1, -30 },
  { 2782, 26, 30, 25, 1, -30 },
  { 2880, 24, 32, 25, 2, -31 },
  { 2976, 27, 30, 25, 0, -30 },
  { 3078, 25, 30, 25, 1, -30 },
  { 3172, 25, 31, 25, 1, -30 },
  { 3269, 27, 30, 25, 0, -30 },
  { 3371, 19, 30, 25, 1, -30 },
  { 3443, 27, 30, 25, -1, -30 },
  { 3545, 27, 30, 25, 0, -30 },
  { 3647, 23, 32, 25, 2, -31 },
  { 3739, 25, 31, 25, 0, -31 },
  { 3836, 23, 39, 25, 2, -31 },
  { 3949, 24, 31, 25, 0, -31 },
  { 4042, 25, 32, 25, 0, -31 },
  { 4142, 22, 30, 25, 5, -30 },
  { 4225, 25, 31, 25, 2, -30 },
  { 4322, 23, 30, 25, 5, -30 },
  { 4409, 27, 30, 25, 1, -30 },
  { 4511, 30, 30, 25, -2, -30 },
  { 4624, 24, 30, 25, 5, -30 },
  { 4714, 26, 30, 25, 0, -30 },
  { 4812, 23, 42, 25, 3, -34 },
  { 4933, 8, 42, 25, 9, -34 },
  { 4975, 23, 42, 25, -1, -34 },
  { 5096, 21, 17, 25, 3, -30 },
  { 5141, 23, 4, 25, -3, 4 },
  { 5153, 9, 9, 25, 11, -34 },
  { 5164, 22, 25, 25, 2, -24 },
  { 5233, 22, 35, 25, 1, -34 },
  { 5330, 22, 25, 25, 2, -24 },
  { 5399, 25, 35, 25, 2, -34 },
  { 5509, 21, 25, 25, 2, -24 },
  { 5575, 30, 42, 25, -2, -34 },
  { 5733, 25, 32, 25, -1, -24 },
  { 5833, 22, 34, 25, 0, -34 },
  { 5927, 16, 34, 25, 4, -34 },
  { 5995, 24, 42, 25, -1, -34 },
  { 6121, 24, 34, 25, 1, -34 },
  { 6223, 14, 35, 25, 6, -34 },
  { 6285, 25, 23, 25, -1, -23 },
  { 6357, 22, 24, 25, 1, -24 },
  { 6423, 21, 25, 25, 2, -24 },
  { 6489, 24, 32, 25, -1, -24 },
  { 6585, 22, 32, 25, 2, -24 },
  { 6673, 22, 23, 25, 2, -23 },
  { 6737, 22, 25, 25, 1, -24 },
  { 6806, 20, 31, 25, 4, -30 },
  { 6884, 22, 24, 25, 2, -23 },
  { 6950, 21, 23, 25, 4, -23 },
  { 7011, 25, 23, 25, 2, -23 },
  { 7083, 26, 23, 25, -1, -23 },
  { 7158, 28, 31, 25, -3, -23 },
  { 7267, 23, 23, 25, 1, -23 },
  { 7334, 23, 42, 25, 3, -34 },
  { 7455, 15, 42, 25, 5, -34 },
  { 7534, 24, 42, 25, -2, -34 },
  { 7660, 23, 8, 25, 1, -17 },
};

const GFXfont UbuntuSansMono_MediumItalic44pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic44pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic44pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC44PT7B_H_
