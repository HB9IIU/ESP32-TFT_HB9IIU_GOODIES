#ifndef _UBUNTUSANSMONO_MEDIUMITALIC37PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0xF8, 0x1F, 0x07, 0xE0, 0x7C, 0x0F,
  0x00, 0x3C, 0x7B, 0xC3, 0xDE, 0x1E, 0xF1, 0xE7, 0x8F, 0x38, 0x79, 0xC3,
  0x9E, 0x1C, 0xE0, 0xE7, 0x06, 0x30, 0x30, 0x00, 0x1C, 0x3C, 0x00, 0xF0,
  0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x70, 0x01, 0xC3, 0xC0,
  0x0F, 0x0E, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x3C,
  0x3C, 0x00, 0xF0, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1C, 0x00, 0x70, 0xF0,
  0x03, 0xC3, 0xC0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x07,
  0x0F, 0x00, 0x3C, 0x38, 0x00, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1C,
  0x00, 0x70, 0xF0, 0x03, 0xC3, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xC0, 0x40, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x84, 0x00, 0xF8, 0x70, 0x1F, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x07, 0x81, 0xF8, 0x07,
  0x81, 0xDE, 0x07, 0x81, 0xC7, 0x03, 0x80, 0xE3, 0x83, 0x80, 0x71, 0xC3,
  0x80, 0x30, 0xE3, 0x80, 0x38, 0x73, 0xC0, 0x1C, 0x73, 0xC0, 0x07, 0x39,
  0xC0, 0x03, 0xF9, 0xC0, 0x01, 0xF9, 0xC0, 0x00, 0x31, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE7, 0xC0, 0x01, 0xEF, 0xE0, 0x00, 0xE7, 0x78, 0x00,
  0xE7, 0x1C, 0x00, 0xE3, 0x8E, 0x00, 0xE1, 0x87, 0x00, 0xF1, 0xC3, 0x80,
  0xF0, 0xE3, 0x80, 0x70, 0x71, 0xC0, 0x70, 0x39, 0xE0, 0x70, 0x0F, 0xE0,
  0x70, 0x07, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0,
  0x3F, 0xF8, 0x1F, 0x1E, 0x07, 0x87, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x3C, 0x0F, 0x0F, 0x01, 0xC7, 0x80, 0x7F, 0xC0, 0x1F, 0xC0, 0x07, 0xE1,
  0xC3, 0xF8, 0x73, 0xFE, 0x3C, 0xF3, 0xCE, 0x78, 0xF3, 0xBC, 0x1F, 0xEF,
  0x03, 0xF3, 0xC0, 0xF8, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x07, 0xF3, 0xFF,
  0xFC, 0x7F, 0xE7, 0x0F, 0xE1, 0xE0, 0x7D, 0xE7, 0x9E, 0xFB, 0xCF, 0x3C,
  0xE3, 0x8C, 0x00, 0x00, 0x02, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xE0,
  0x00, 0x40, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x61,
  0xC2, 0x79, 0xCF, 0xFD, 0xBF, 0xFF, 0xFF, 0x1F, 0xFC, 0x03, 0xE0, 0x07,
  0xF0, 0x0F, 0x78, 0x1E, 0x7C, 0x3E, 0x3C, 0x1C, 0x38, 0x08, 0x10, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x00, 0x0F, 0x0F, 0xC7, 0xE7, 0xF1, 0xF8, 0xFC, 0x1C, 0x1E, 0x3E,
  0x7E, 0x3E, 0x1C, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0xFF, 0xE0, 0x3C, 0xFD,
  0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F,
  0x3F, 0x0F, 0x83, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03,
  0xDE, 0x00, 0xF7, 0x8E, 0x3D, 0xE7, 0x8F, 0xF1, 0xF3, 0xFC, 0x78, 0xFF,
  0x1E, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x00, 0xF3, 0xC0,
  0x7C, 0xF0, 0x1E, 0x3C, 0x0F, 0x8F, 0x87, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0,
  0x0F, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xBC, 0x0F, 0x3C, 0x0C, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0xF8, 0x3F, 0xFF, 0x03, 0xF3, 0xF0, 0x70, 0x1E, 0x08, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x1E, 0x3F, 0x01, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x70, 0x1F, 0x87, 0xFF, 0xF0, 0xFF,
  0xFE, 0x03, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7D,
  0xE0, 0x0F, 0x9C, 0x00, 0xF3, 0xC0, 0x1E, 0x3C, 0x03, 0xC3, 0xC0, 0x78,
  0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x83, 0xC0, 0x78, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0xC0, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x00,
  0x01, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF3,
  0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFE, 0x3F, 0x3E, 0x03, 0xE7, 0x80,
  0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00,
  0xF1, 0xF0, 0x1E, 0x1F, 0x0F, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFE,
  0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x03,
  0xFF, 0xE0, 0x7E, 0x3E, 0x07, 0x81, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0xF8, 0x3E, 0x07, 0x87, 0xC0, 0x7E, 0xF8,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0x3F, 0x03, 0xE0, 0xF8, 0x3C, 0x07,
  0x87, 0x80, 0x78, 0x78, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x80,
  0xF8, 0x7C, 0x1F, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x01,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFC, 0x7E,
  0x0F, 0x01, 0xE1, 0xF0, 0x1E, 0x1E, 0x01, 0xF1, 0xE0, 0x0F, 0x1E, 0x00,
  0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1F, 0x07, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xBC, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0x83, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x07, 0xE1, 0xF8, 0xFE, 0x1F, 0x87, 0xC0, 0x01, 0xE0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x80,
  0x70, 0x0F, 0x03, 0xE0, 0xFC, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x04, 0x00,
  0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x08, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xF8,
  0x7F, 0xF8, 0xC1, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xC1, 0xE0, 0x78, 0x07, 0x07, 0x80,
  0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x3C, 0x0F, 0xF1, 0xE1, 0xFF, 0x8E,
  0x1F, 0xFC, 0xF1, 0xF1, 0xE7, 0x8F, 0x0E, 0x38, 0xF0, 0x71, 0xC7, 0x87,
  0x9E, 0x38, 0x3C, 0xF3, 0xC1, 0xC7, 0x9E, 0x0E, 0x3C, 0xF0, 0xF1, 0xE7,
  0x87, 0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xC3, 0xC3, 0xFE, 0x1E, 0x0F, 0xF0,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xDE,
  0x00, 0x3D, 0xE0, 0x03, 0x9E, 0x00, 0x78, 0xE0, 0x0F, 0x0E, 0x00, 0xF0,
  0xE0, 0x1E, 0x0E, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78,
  0x0F, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1E,
  0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF,
  0x00, 0x0F, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF,
  0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x1E, 0x0F, 0x07, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF,
  0xF8, 0x1E, 0x0F, 0xC1, 0xE0, 0x3E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C,
  0x01, 0xE3, 0xC0, 0x3E, 0x78, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x3F, 0x87,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF,
  0x03, 0xFF, 0xF0, 0x7F, 0xBE, 0x0F, 0xC0, 0x20, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x20, 0x7E, 0x0E, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0xFE, 0x07, 0x83, 0xE0, 0x78, 0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1,
  0xE0, 0x0F, 0x1E, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x3E,
  0x3C, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x0F, 0x87, 0x81, 0xF0, 0x78, 0xFF,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x02, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0x3E,
  0x0F, 0x80, 0x41, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF0,
  0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x81, 0xE0, 0x7C, 0x1E, 0x07,
  0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x03, 0xC0,
  0x3E, 0x07, 0x80, 0x78, 0x1F, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x07,
  0xC0, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF8,
  0x1E, 0x01, 0xE0, 0x7C, 0x03, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0x80, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78,
  0x07, 0x80, 0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x1E,
  0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x06, 0x03,
  0xE0, 0x70, 0x7E, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x02,
  0x00, 0x00, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0xF8, 0x0F, 0x03, 0xE0, 0x3E,
  0x0F, 0x80, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x01, 0xE1, 0xF0, 0x07, 0xC7,
  0xC0, 0x0F, 0x1F, 0x00, 0x1E, 0x7C, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0x3C, 0x00,
  0x3C, 0x7C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF8, 0x01, 0xE0, 0xF0, 0x07,
  0xC1, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0xF8,
  0x07, 0xC1, 0xE0, 0x0F, 0x80, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x1E, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x3F, 0x07, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x3F, 0x03, 0xB8, 0xEE, 0x07, 0x71, 0xDC, 0x0E, 0xE7, 0x78, 0x3D,
  0xCC, 0xE0, 0x71, 0xB9, 0xC0, 0xE3, 0x63, 0x83, 0xC7, 0xCF, 0x07, 0x8F,
  0x1E, 0x0E, 0x1E, 0x38, 0x1C, 0x38, 0x70, 0x78, 0x01, 0xE0, 0xF0, 0x03,
  0xC1, 0xC0, 0x07, 0x83, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x78,
  0x38, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x1E,
  0x07, 0x80, 0x38, 0x0F, 0x00, 0xF0, 0x3F, 0x01, 0xE0, 0x7E, 0x03, 0xC0,
  0xFC, 0x07, 0x01, 0xFC, 0x1E, 0x07, 0xB8, 0x3C, 0x0F, 0x70, 0x78, 0x1C,
  0xE0, 0xE0, 0x39, 0xE3, 0xC0, 0xF1, 0xC7, 0x81, 0xE3, 0x8F, 0x03, 0xC7,
  0x1C, 0x07, 0x0F, 0x78, 0x1E, 0x0E, 0xF0, 0x3C, 0x1D, 0xE0, 0x78, 0x3B,
  0x80, 0xE0, 0x77, 0x03, 0xC0, 0x7E, 0x07, 0x80, 0xFC, 0x0F, 0x01, 0xF0,
  0x1C, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0xF0, 0x0F, 0x81, 0xE0, 0x0F, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xE7, 0xE0, 0xF0, 0x3C,
  0x3C, 0x07, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x00, 0x3D,
  0xE0, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7,
  0x80, 0x1E, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0x8F,
  0x01, 0xF1, 0xE0, 0x7C, 0x3E, 0x1F, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x03,
  0xFC, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3C, 0x0F, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0,
  0xF0, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x3C, 0x1E, 0x03,
  0xE0, 0xF0, 0x3E, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F,
  0xF0, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xE7, 0xE0,
  0xF0, 0x3C, 0x3C, 0x07, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x7C, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x07, 0xBC,
  0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3E, 0x78,
  0x07, 0x8F, 0x01, 0xF1, 0xE0, 0x7C, 0x3E, 0x1F, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x03, 0xFC, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x30, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0x81, 0xF0, 0x78, 0x0F,
  0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01,
  0xF0, 0xF0, 0x3E, 0x1E, 0x0F, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF,
  0xC0, 0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xC0, 0xF0, 0x7C,
  0x0F, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x87, 0x80, 0x78, 0xF8, 0x07, 0x8F,
  0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xE3,
  0xE0, 0x7C, 0x01, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x10, 0x03, 0xC1,
  0xE0, 0x7E, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x70,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0,
  0x1F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x1E, 0x3C,
  0x03, 0xC3, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0x87,
  0x80, 0x78, 0xF8, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x8F, 0x00, 0xF0,
  0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0xF8, 0x7C,
  0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0x02, 0x00, 0x00, 0xF0,
  0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF,
  0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xE0,
  0xF0, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x87, 0x80, 0x78, 0x78,
  0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07, 0xBC,
  0x00, 0x7B, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xE0, 0x03,
  0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x38, 0x78, 0x01, 0xE1, 0xC0, 0x07, 0x87,
  0x00, 0x1C, 0x3C, 0x00, 0x70, 0xF0, 0x03, 0xC3, 0xC7, 0x0F, 0x0E, 0x3E,
  0x38, 0x38, 0xF8, 0xE1, 0xE7, 0xE7, 0x87, 0x9F, 0x9C, 0x1C, 0xEE, 0x70,
  0x73, 0x39, 0xC1, 0xDC, 0xEE, 0x07, 0xE3, 0xB8, 0x3B, 0x8E, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0x78,
  0x07, 0x80, 0x3E, 0x07, 0x80, 0x0F, 0x07, 0xC0, 0x07, 0x87, 0xC0, 0x01,
  0xE3, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF7, 0x80, 0x01, 0xF3, 0xC0,
  0x00, 0xF1, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x1E,
  0x00, 0xF8, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x7C, 0x01, 0xE0, 0x7C, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xF7, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0x80, 0x3C,
  0x78, 0x07, 0xC7, 0x80, 0xF8, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x3E,
  0x03, 0xC3, 0xC0, 0x1C, 0x78, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0xF1, 0xE3, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7C,
  0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0x00, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0xFB, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x0F, 0x07, 0x87,
  0xC1, 0xE3, 0xE0, 0x79, 0xF0, 0x0F, 0xF8, 0x03, 0xCC, 0x00, 0xE1, 0x00,
  0x20, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0x20,
  0x70, 0xF8, 0xFC, 0x3E, 0x1F, 0x0E, 0x04, 0x00, 0x3F, 0x00, 0x3F, 0xFC,
  0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xF8, 0x3C, 0x3E, 0x07, 0x8F, 0x80, 0xF3,
  0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x78, 0x07, 0x8F,
  0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0xC0, 0xF8, 0x7C, 0x3F, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xE3, 0xC0, 0x00, 0x60, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xCF, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF,
  0xC7, 0xC1, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0,
  0x3E, 0x78, 0x1F, 0x3C, 0x1F, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xE1, 0xF8,
  0x04, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x07, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x3E, 0x0F, 0x01, 0xF0, 0x3C, 0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xC1,
  0xF0, 0x1E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x83, 0xE0,
  0x3C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x01, 0xF0, 0xFC,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xE7, 0x80, 0x00, 0x3E, 0x00,
  0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xF0, 0x3E, 0x3C, 0x03, 0xCF,
  0x00, 0xFB, 0xE0, 0x1E, 0x78, 0x07, 0xCF, 0x0F, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFE, 0x0F, 0xF8, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7E,
  0x07, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFE, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xC0, 0x3C,
  0x1F, 0x00, 0xF0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1E,
  0x01, 0xE0, 0x78, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0xE7, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x04, 0x01, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF7, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1E, 0x0F, 0x83, 0xC0, 0xF8, 0xF8, 0x1F, 0x1E, 0x03, 0xC3, 0xC0, 0x78,
  0x78, 0x0F, 0x0F, 0x01, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x01, 0xE1,
  0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x8F,
  0x81, 0xF0, 0x00, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x8F, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0xC7, 0xFE, 0x1F, 0xF0,
  0x7F, 0x80, 0x00, 0x00, 0x60, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x04, 0x07, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x01, 0xF0,
  0xF0, 0x3E, 0x0F, 0x07, 0xC0, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xE7, 0xC0,
  0x1E, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3D, 0xF0,
  0x03, 0xCF, 0x80, 0x7C, 0x78, 0x07, 0x87, 0xC0, 0x78, 0x3E, 0x07, 0x81,
  0xE0, 0xF8, 0x1F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x80, 0x7F, 0xE7, 0xFC,
  0x7F, 0xCF, 0xFC, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC3,
  0x3F, 0xF3, 0xFF, 0x1F, 0xF0, 0x01, 0xE1, 0xC0, 0xFF, 0x7E, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x1E, 0x38, 0xF1, 0xE3, 0x8F, 0x1C, 0x38, 0xF1, 0xC7,
  0x8F, 0x3C, 0x78, 0xE3, 0xC7, 0x0E, 0x38, 0x71, 0xE3, 0x8F, 0x1E, 0x78,
  0xF1, 0xC7, 0x80, 0x1C, 0x70, 0x03, 0xC7, 0x00, 0x3C, 0xF0, 0x03, 0xCF,
  0x00, 0x38, 0xE0, 0x07, 0x8E, 0x00, 0x78, 0x00, 0xFC, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78,
  0x0F, 0x3E, 0x03, 0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07,
  0x9E, 0x03, 0xE7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3C, 0x07, 0xCF,
  0x01, 0xE3, 0xC0, 0x78, 0x00, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xF3, 0xE0, 0xF9, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0xF8, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x7D,
  0xE0, 0x7C, 0xF8, 0x7C, 0x7F, 0xFE, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0x81, 0xF0,
  0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1E, 0x01, 0xE1, 0xE0, 0x3E, 0x1E, 0x03,
  0xE1, 0xE0, 0xFC, 0x3C, 0x3F, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF,
  0x80, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xF0,
  0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0x07, 0xCF, 0x81, 0xE7, 0xC0, 0x79, 0xE0,
  0x1E, 0xF8, 0x0F, 0xBC, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F,
  0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF8, 0x7E, 0x1F, 0xFF, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x01, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0x00, 0x87, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFE, 0x0F, 0x80, 0x83, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x70, 0x3E, 0x1F, 0xFF, 0x8F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x01, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7E,
  0x18, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x3E, 0x03, 0xCF, 0x01, 0xF3,
  0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x9E, 0x03, 0xE7, 0x80, 0xF1, 0xE0,
  0x3C, 0x78, 0x0F, 0x3C, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x3C, 0x07, 0x8F, 0x03, 0xE3, 0xE3, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x83,
  0xF9, 0xE0, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xCF, 0x01,
  0xE7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x3E,
  0x3C, 0x0F, 0x3C, 0x07, 0xBE, 0x03, 0xDE, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x79, 0xC0, 0x03,
  0xCE, 0x00, 0x1C, 0xF0, 0x00, 0xE7, 0x87, 0x0F, 0x3C, 0x38, 0x71, 0xE3,
  0xC3, 0x8F, 0x1E, 0x3C, 0x71, 0xF1, 0xC3, 0x8D, 0xCE, 0x1C, 0xEE, 0xF0,
  0xEE, 0x77, 0x07, 0x73, 0xB8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x87,
  0xE0, 0x78, 0x3E, 0x07, 0xC1, 0xF0, 0x3C, 0x07, 0x00, 0x07, 0x80, 0x7C,
  0x0F, 0x03, 0xE0, 0x3C, 0x1F, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xC0, 0x03,
  0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0x3C, 0x00,
  0xF8, 0xF8, 0x07, 0xC1, 0xE0, 0x3E, 0x07, 0x81, 0xF0, 0x0F, 0x0F, 0x80,
  0x3C, 0x00, 0x01, 0xE0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xF0, 0x78, 0x01,
  0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF1, 0xE0, 0x00,
  0xF1, 0xE0, 0x00, 0xF3, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xE1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x7F, 0x80,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x88, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0xC7, 0xFC, 0x3C, 0xFF, 0xEF, 0x3F, 0xFF, 0xEF, 0x0F,
  0xF9, 0xC0, 0x7E, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 11, 26, 21, 5, -26 },
  { 37, 13, 11, 21, 7, -28 },
  { 55, 22, 26, 21, 0, -26 },
  { 127, 20, 33, 21, 1, -29 },
  { 210, 25, 27, 21, -1, -26 },
  { 295, 18, 26, 21, 1, -26 },
  { 354, 6, 11, 21, 11, -28 },
  { 363, 16, 36, 21, 4, -29 },
  { 435, 16, 36, 21, 1, -29 },
  { 507, 16, 16, 21, 4, -26 },
  { 539, 17, 18, 21, 2, -20 },
  { 578, 9, 12, 21, 3, -6 },
  { 592, 11, 4, 21, 5, -13 },
  { 598, 7, 6, 21, 5, -6 },
  { 604, 24, 36, 21, -2, -29 },
  { 712, 18, 27, 21, 2, -26 },
  { 773, 16, 26, 21, 2, -26 },
  { 825, 19, 26, 21, 1, -26 },
  { 887, 20, 27, 21, 0, -26 },
  { 955, 20, 26, 21, 0, -26 },
  { 1020, 21, 27, 21, 0, -26 },
  { 1091, 19, 27, 21, 2, -26 },
  { 1156, 19, 26, 21, 4, -26 },
  { 1218, 20, 27, 21, 1, -26 },
  { 1286, 20, 26, 21, 1, -26 },
  { 1351, 10, 19, 21, 5, -19 },
  { 1375, 12, 25, 21, 3, -19 },
  { 1413, 18, 17, 21, 2, -19 },
  { 1452, 19, 12, 21, 1, -17 },
  { 1481, 18, 17, 21, 1, -19 },
  { 1520, 15, 26, 21, 5, -26 },
  { 1569, 21, 32, 21, 1, -26 },
  { 1653, 20, 26, 21, -2, -26 },
  { 1718, 20, 26, 21, 0, -26 },
  { 1783, 20, 27, 21, 2, -26 },
  { 1851, 20, 26, 21, 0, -26 },
  { 1916, 21, 26, 21, 1, -26 },
  { 1985, 21, 26, 21, 1, -26 },
  { 2054, 20, 27, 21, 2, -26 },
  { 2122, 23, 26, 21, 0, -26 },
  { 2197, 20, 26, 21, 1, -26 },
  { 2262, 20, 27, 21, 1, -26 },
  { 2330, 23, 26, 21, 0, -26 },
  { 2405, 15, 26, 21, 1, -26 },
  { 2454, 23, 26, 21, -1, -26 },
  { 2529, 23, 26, 21, 0, -26 },
  { 2604, 19, 27, 21, 2, -26 },
  { 2669, 21, 26, 21, 0, -26 },
  { 2738, 19, 33, 21, 2, -26 },
  { 2817, 20, 26, 21, 0, -26 },
  { 2882, 21, 27, 21, 0, -26 },
  { 2953, 19, 26, 21, 4, -26 },
  { 3015, 20, 27, 21, 2, -26 },
  { 3083, 20, 26, 21, 4, -26 },
  { 3148, 22, 26, 21, 1, -26 },
  { 3220, 25, 26, 21, -1, -26 },
  { 3302, 20, 26, 21, 4, -26 },
  { 3367, 22, 26, 21, 0, -26 },
  { 3439, 20, 36, 21, 2, -29 },
  { 3529, 7, 36, 21, 7, -29 },
  { 3561, 20, 36, 21, -1, -29 },
  { 3651, 18, 15, 21, 2, -26 },
  { 3685, 20, 4, 21, -3, 3 },
  { 3695, 8, 8, 21, 9, -29 },
  { 3703, 19, 20, 21, 1, -20 },
  { 3751, 18, 29, 21, 1, -29 },
  { 3817, 19, 20, 21, 1, -20 },
  { 3865, 22, 29, 21, 1, -29 },
  { 3945, 19, 20, 21, 1, -20 },
  { 3993, 25, 36, 21, -2, -29 },
  { 4106, 22, 27, 21, -1, -20 },
  { 4181, 19, 29, 21, 0, -29 },
  { 4250, 13, 29, 21, 4, -29 },
  { 4298, 20, 36, 21, -1, -29 },
  { 4388, 20, 29, 21, 1, -29 },
  { 4461, 12, 29, 21, 5, -29 },
  { 4505, 20, 20, 21, 0, -20 },
  { 4555, 18, 20, 21, 1, -20 },
  { 4600, 17, 20, 21, 2, -20 },
  { 4643, 20, 27, 21, -1, -20 },
  { 4711, 18, 27, 21, 2, -20 },
  { 4772, 18, 20, 21, 2, -20 },
  { 4817, 18, 21, 21, 1, -20 },
  { 4865, 16, 25, 21, 4, -25 },
  { 4915, 18, 19, 21, 2, -19 },
  { 4958, 17, 19, 21, 4, -19 },
  { 4999, 21, 19, 21, 1, -19 },
  { 5049, 22, 19, 21, -1, -19 },
  { 5102, 24, 26, 21, -3, -19 },
  { 5180, 19, 19, 21, 1, -19 },
  { 5226, 20, 36, 21, 2, -29 },
  { 5316, 13, 36, 21, 4, -29 },
  { 5375, 19, 36, 21, -1, -29 },
  { 5461, 19, 6, 21, 1, -14 },
};

const GFXfont UbuntuSansMono_MediumItalic37pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic37pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic37pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC37PT7B_H_
