#ifndef _UBUNTUSANSMONO_MEDIUMITALIC19PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xCE, 0x63, 0x19, 0xCC, 0x00, 0x39, 0xCE, 0x00, 0xEF, 0x3C,
  0xE2, 0x98, 0x06, 0x60, 0xCC, 0x33, 0x1F, 0xF7, 0xFE, 0x33, 0x06, 0x41,
  0x98, 0xFF, 0xDF, 0xF9, 0x98, 0x22, 0x0C, 0xC0, 0x01, 0x80, 0x20, 0x0E,
  0x07, 0xF1, 0x84, 0x30, 0x06, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x06, 0x00,
  0xC4, 0x39, 0xFE, 0x0F, 0x00, 0xC0, 0x18, 0x00, 0x1E, 0x18, 0x91, 0x8C,
  0x98, 0x6D, 0x83, 0x78, 0x0E, 0x80, 0x08, 0x00, 0xFC, 0x0D, 0x20, 0xD9,
  0x0C, 0xD8, 0x46, 0xCC, 0x1C, 0x00, 0x0F, 0x86, 0x61, 0x98, 0x66, 0x1B,
  0x07, 0x83, 0xCD, 0xBB, 0x67, 0xB0, 0xEC, 0x31, 0xFE, 0x7D, 0x80, 0x76,
  0x64, 0x4C, 0x01, 0x07, 0x0E, 0x1C, 0x18, 0x30, 0x70, 0x60, 0x60, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x38, 0x10, 0x04, 0x07, 0x01,
  0x80, 0x60, 0x30, 0x18, 0x0E, 0x03, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60,
  0x70, 0x70, 0x70, 0x70, 0x70, 0x10, 0x00, 0x18, 0x18, 0xEB, 0xFF, 0x18,
  0x3E, 0x76, 0x24, 0x0E, 0x06, 0x03, 0x01, 0x8F, 0xF8, 0xC0, 0x60, 0x30,
  0x30, 0x00, 0x39, 0xCE, 0x37, 0x70, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x07, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x00, 0x1F, 0x9C, 0xCC, 0x6C, 0x36, 0x1E, 0x6F, 0x77, 0x93,
  0xC3, 0xE1, 0xB1, 0xDF, 0xC7, 0xC0, 0x03, 0x0F, 0x3E, 0x36, 0x06, 0x06,
  0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0xFF, 0xFE, 0x0F, 0xC7, 0x71, 0x0C, 0x03,
  0x00, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x07, 0x01, 0xFE, 0xFF, 0x80,
  0x1F, 0x86, 0x70, 0x0C, 0x03, 0x01, 0xC3, 0xC0, 0xF0, 0x06, 0x01, 0x80,
  0x60, 0x19, 0xFC, 0xFE, 0x00, 0x01, 0xC0, 0xF0, 0x7C, 0x36, 0x19, 0x86,
  0x63, 0x19, 0x86, 0xFF, 0xFF, 0xF0, 0x30, 0x0C, 0x06, 0x00, 0x0F, 0xE1,
  0xFC, 0x30, 0x0C, 0x01, 0x80, 0x3C, 0x0B, 0xE0, 0x0C, 0x01, 0x80, 0x30,
  0x0E, 0x3F, 0x8F, 0xE0, 0x03, 0xC3, 0xF1, 0x80, 0xC0, 0x60, 0x1F, 0xCF,
  0xF3, 0x06, 0xC1, 0xB0, 0x6C, 0x31, 0x9C, 0x7E, 0x00, 0x7F, 0xDF, 0xE0,
  0x30, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80,
  0xC0, 0x00, 0x1F, 0x8E, 0x63, 0x0C, 0xC3, 0x31, 0x8E, 0xC3, 0xE1, 0x9C,
  0xC3, 0x30, 0xCC, 0x33, 0xBC, 0x7E, 0x00, 0x1F, 0x0E, 0x66, 0x19, 0x83,
  0x61, 0xD8, 0x67, 0xF8, 0xF6, 0x03, 0x01, 0xC0, 0xE3, 0xF0, 0xF0, 0x00,
  0x3B, 0xCC, 0x00, 0x00, 0x1C, 0xE7, 0x00, 0x0E, 0x3C, 0x30, 0x00, 0x00,
  0x00, 0x1C, 0x38, 0x70, 0x63, 0x8E, 0x00, 0x00, 0x81, 0xC7, 0xCF, 0x0E,
  0x07, 0x80, 0xF0, 0x1E, 0x02, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x20, 0x0E, 0x01, 0xE0, 0x1F, 0x01, 0xC1, 0xE3, 0xE3, 0xC0,
  0x40, 0x00, 0x7E, 0x8C, 0x18, 0x30, 0xC3, 0x0C, 0x30, 0x00, 0x03, 0x07,
  0x0C, 0x00, 0x0F, 0x8E, 0x33, 0x0D, 0x83, 0x47, 0xF3, 0x3D, 0x8B, 0x66,
  0x99, 0xA6, 0x69, 0xF3, 0x3C, 0xC0, 0x38, 0x07, 0xE0, 0xF0, 0x01, 0x80,
  0xF0, 0x6C, 0x1B, 0x0C, 0xC3, 0x31, 0x8C, 0x63, 0x3F, 0xCF, 0xF6, 0x0D,
  0x83, 0xC0, 0xC0, 0x1F, 0xC6, 0x71, 0x8C, 0xC3, 0x30, 0xCF, 0xE3, 0xF9,
  0x86, 0x60, 0xD8, 0x76, 0x1B, 0xFE, 0xFE, 0x00, 0x0F, 0xC7, 0x33, 0x01,
  0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0xFC, 0x3F,
  0x00, 0x1F, 0x87, 0xF3, 0x0C, 0xC3, 0x30, 0xCC, 0x37, 0x0D, 0x83, 0x61,
  0xD8, 0x6E, 0x3B, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xF3, 0x00, 0xC0, 0x30,
  0x1F, 0xC7, 0xF1, 0x80, 0x60, 0x38, 0x0C, 0x03, 0xFC, 0xFF, 0x00, 0x1F,
  0xE7, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0xFE, 0x1F, 0xC3, 0x00, 0x60, 0x1C,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x0F, 0xC7, 0x33, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x1B, 0x06, 0xC3, 0x30, 0xCE, 0x31, 0xFC, 0x7E, 0x00, 0x18, 0x71,
  0x86, 0x38, 0x63, 0x06, 0x30, 0xC3, 0xFC, 0x7F, 0xC6, 0x0C, 0x61, 0x86,
  0x18, 0xE1, 0x8C, 0x18, 0xC3, 0x00, 0x1F, 0xE3, 0xFC, 0x0C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x3F, 0x8F, 0xF0,
  0x0F, 0xE1, 0xFC, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x31, 0x0C, 0x7F, 0x87, 0xE0, 0x18, 0x71, 0x8C, 0x19, 0x83, 0x30,
  0x36, 0x03, 0xC0, 0x3C, 0x06, 0xE0, 0x66, 0x06, 0x30, 0x63, 0x0C, 0x38,
  0xC1, 0x80, 0x1C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60,
  0x60, 0x7F, 0xFF, 0x0C, 0x30, 0xE7, 0x0E, 0x71, 0xEF, 0x1E, 0xB1, 0x7A,
  0x37, 0x63, 0x36, 0x30, 0x66, 0x06, 0x60, 0x46, 0x0C, 0xE0, 0xC0, 0x18,
  0x31, 0xC6, 0x3C, 0x63, 0xC6, 0x34, 0x43, 0x6C, 0x66, 0xC6, 0x6C, 0x62,
  0xC6, 0x38, 0x43, 0x8C, 0x38, 0xC3, 0x80, 0x1F, 0x8E, 0x63, 0x1D, 0x83,
  0x60, 0xF0, 0x7C, 0x1B, 0x06, 0xC1, 0xB0, 0xCC, 0x33, 0xF8, 0x7C, 0x00,
  0x1F, 0xC3, 0xF8, 0x61, 0x9C, 0x33, 0x06, 0x61, 0x8F, 0xF1, 0xF8, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x1F, 0x8E, 0x63, 0x1D, 0x83, 0x60,
  0xF0, 0x7C, 0x1B, 0x06, 0xC1, 0xB0, 0xCC, 0x33, 0xF8, 0x7C, 0x0C, 0x03,
  0x80, 0x78, 0x02, 0x00, 0x1F, 0x86, 0x71, 0x8C, 0xC3, 0x30, 0xCC, 0x73,
  0xF9, 0xF8, 0x67, 0x18, 0xC6, 0x33, 0x86, 0xC1, 0x80, 0x0F, 0xE3, 0x88,
  0x60, 0x0C, 0x01, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x06,
  0x3F, 0x8F, 0xE0, 0xFF, 0xFF, 0xE0, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x00, 0x30, 0xCC, 0x36, 0x0D,
  0x87, 0x61, 0x98, 0x6E, 0x1B, 0x06, 0xC3, 0x30, 0xCC, 0x33, 0xF8, 0x7C,
  0x00, 0xC0, 0xF0, 0x6C, 0x1B, 0x0E, 0xC3, 0x31, 0x8C, 0x63, 0x30, 0xCC,
  0x16, 0x07, 0x81, 0xC0, 0x70, 0x00, 0x38, 0x33, 0x03, 0x30, 0x63, 0x06,
  0x20, 0x66, 0x64, 0x6E, 0xC6, 0xAC, 0x7A, 0xC5, 0x28, 0x73, 0x8E, 0x38,
  0xE3, 0x00, 0x0C, 0x38, 0x71, 0x81, 0x98, 0x0D, 0x80, 0x7C, 0x01, 0xC0,
  0x0C, 0x00, 0xF0, 0x0D, 0x80, 0xCC, 0x0E, 0x30, 0x61, 0x8E, 0x0C, 0x00,
  0xC0, 0xD8, 0x66, 0x39, 0x8C, 0x66, 0x0F, 0x83, 0xC0, 0xE0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x60, 0x00, 0x1F, 0xE3, 0xFC, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x7F, 0xCF, 0xF8, 0x07,
  0xC3, 0xF0, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x3F, 0x0F, 0xC0, 0xDB,
  0x6D, 0xB6, 0xED, 0xB6, 0xDB, 0x6D, 0x80, 0x0F, 0xC3, 0xE0, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x3E, 0x0F, 0x80, 0x06, 0x07, 0x87, 0xC7, 0x63,
  0x1B, 0x0F, 0x06, 0xFF, 0xFF, 0xE0, 0x8C, 0x63, 0x1F, 0x9F, 0xD8, 0x7C,
  0x6C, 0x36, 0x1B, 0x0D, 0x8E, 0xFF, 0x3D, 0x80, 0x0C, 0x07, 0x01, 0x80,
  0x60, 0x18, 0x07, 0xE3, 0xFC, 0xC3, 0x30, 0xCC, 0x36, 0x0D, 0x86, 0x63,
  0x9F, 0xCF, 0xE0, 0x1F, 0x9F, 0xDC, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xFF, 0x3F, 0x80, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x3F, 0x0F,
  0xE3, 0x8C, 0xE1, 0x98, 0x63, 0x0C, 0x61, 0x8C, 0x31, 0xFE, 0x1E, 0xC0,
  0x1F, 0x1F, 0xD8, 0x78, 0x3C, 0x77, 0xF3, 0x01, 0x80, 0xFF, 0x3F, 0x80,
  0x00, 0x70, 0x0F, 0xC0, 0x60, 0x06, 0x00, 0x30, 0x07, 0xF8, 0x7F, 0x80,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x98, 0x07, 0xC0, 0x18, 0x00, 0x07, 0xF0, 0xFE, 0x1C, 0x61,
  0x86, 0x30, 0xE3, 0x0C, 0x30, 0xC3, 0x9C, 0x1F, 0xC0, 0x18, 0x01, 0x84,
  0x30, 0xFF, 0x01, 0x80, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0F, 0xE3,
  0xF8, 0xC7, 0x31, 0x9C, 0x66, 0x19, 0x86, 0x63, 0xB8, 0xCC, 0x30, 0x08,
  0x38, 0x70, 0x00, 0x1F, 0x3E, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x07, 0xCF,
  0x80, 0x00, 0x40, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x06,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x46,
  0x1F, 0xC0, 0xE0, 0x00, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x31,
  0xCE, 0x71, 0x98, 0x36, 0x07, 0x80, 0xF8, 0x33, 0x06, 0x30, 0xC6, 0x38,
  0x60, 0xFB, 0xE3, 0x8C, 0x30, 0xC7, 0x18, 0x61, 0x86, 0x30, 0xC3, 0xF7,
  0xC0, 0x3D, 0xCF, 0xF2, 0x6D, 0x9B, 0x64, 0xDB, 0x34, 0x0B, 0x06, 0xC1,
  0xB0, 0x60, 0x1F, 0x8F, 0xF3, 0x1C, 0xC3, 0x31, 0xDC, 0x66, 0x19, 0x86,
  0x63, 0xB8, 0xC0, 0x1F, 0x1F, 0xD8, 0x7C, 0x3C, 0x1E, 0x0F, 0x0D, 0x8E,
  0xFE, 0x3E, 0x00, 0x0F, 0xC3, 0xFC, 0x61, 0x8C, 0x31, 0x86, 0x60, 0xCC,
  0x31, 0x8E, 0x3F, 0x8F, 0xE1, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x00, 0x1F,
  0x9F, 0xDC, 0x6C, 0x3C, 0x36, 0x1B, 0x0D, 0x86, 0xFE, 0x3F, 0x01, 0x80,
  0xC0, 0xE0, 0x60, 0x1F, 0x9F, 0xCC, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xC0, 0x60, 0x00, 0x1F, 0x9F, 0x8C, 0x06, 0x03, 0xC0, 0xF0, 0x1C, 0x06,
  0xFE, 0x7E, 0x00, 0x18, 0x18, 0x38, 0xFF, 0xFF, 0x30, 0x30, 0x60, 0x60,
  0x60, 0x60, 0x7E, 0x7E, 0x71, 0xB0, 0xD8, 0x6C, 0x6C, 0x36, 0x1B, 0x0D,
  0x8E, 0xFF, 0x3D, 0x80, 0xC3, 0xE1, 0xB0, 0xD8, 0xCC, 0x66, 0x63, 0x70,
  0xF0, 0x70, 0x30, 0x00, 0xC0, 0xF8, 0x1B, 0x33, 0x66, 0x4D, 0xD9, 0xAB,
  0x3D, 0x47, 0x38, 0xC6, 0x18, 0xC0, 0x18, 0x70, 0xCE, 0x0C, 0xC0, 0x78,
  0x07, 0x00, 0x70, 0x0F, 0x01, 0x98, 0x31, 0x8E, 0x0C, 0x18, 0x71, 0x86,
  0x18, 0x61, 0x8C, 0x1C, 0xC0, 0xD8, 0x0D, 0x80, 0xF0, 0x0F, 0x00, 0xE0,
  0x0C, 0x09, 0xC0, 0xF8, 0x04, 0x00, 0x1F, 0xC7, 0xF0, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x80, 0xC0, 0x7F, 0x3F, 0xC0, 0x03, 0xC1, 0xF0, 0x60, 0x30,
  0x0C, 0x03, 0x00, 0x80, 0x60, 0x78, 0x3C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x01, 0x80, 0x72, 0x0F, 0x00, 0xC0, 0x06, 0x18, 0x30, 0x60, 0xC3,
  0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x00,
  0x0F, 0x03, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x01, 0xC0,
  0x70, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x3E, 0x0E, 0x00,
  0x79, 0xFF, 0xE3, 0xC0,
};

const GFXglyph UbuntuSansMono_MediumItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 13, 11, 3, -13 },
  { 10, 6, 5, 11, 4, -14 },
  { 14, 11, 13, 11, 0, -13 },
  { 32, 11, 17, 11, 0, -15 },
  { 56, 13, 13, 11, -1, -13 },
  { 78, 10, 13, 11, 0, -13 },
  { 95, 4, 6, 11, 5, -14 },
  { 98, 8, 19, 11, 2, -15 },
  { 117, 9, 19, 11, 0, -15 },
  { 139, 8, 8, 11, 2, -13 },
  { 147, 9, 9, 11, 1, -10 },
  { 158, 5, 6, 11, 1, -3 },
  { 162, 5, 2, 11, 3, -6 },
  { 164, 3, 3, 11, 3, -3 },
  { 166, 12, 19, 11, -1, -15 },
  { 195, 9, 13, 11, 1, -13 },
  { 210, 8, 13, 11, 1, -13 },
  { 223, 10, 13, 11, 0, -13 },
  { 240, 10, 13, 11, 0, -13 },
  { 257, 10, 13, 11, 0, -13 },
  { 274, 11, 13, 11, 0, -13 },
  { 292, 10, 13, 11, 1, -13 },
  { 309, 10, 13, 11, 2, -13 },
  { 326, 10, 13, 11, 1, -13 },
  { 343, 10, 13, 11, 1, -13 },
  { 360, 5, 10, 11, 3, -10 },
  { 367, 7, 13, 11, 1, -10 },
  { 379, 9, 9, 11, 1, -10 },
  { 390, 10, 6, 11, 0, -9 },
  { 398, 10, 9, 11, 0, -10 },
  { 410, 7, 13, 11, 3, -13 },
  { 422, 10, 16, 11, 1, -13 },
  { 442, 10, 13, 11, -1, -13 },
  { 459, 10, 13, 11, 0, -13 },
  { 476, 10, 13, 11, 1, -13 },
  { 493, 10, 13, 11, 0, -13 },
  { 510, 10, 13, 11, 1, -13 },
  { 527, 11, 13, 11, 1, -13 },
  { 545, 10, 13, 11, 1, -13 },
  { 562, 12, 13, 11, 0, -13 },
  { 582, 11, 13, 11, 0, -13 },
  { 600, 11, 13, 11, 0, -13 },
  { 618, 12, 13, 11, 0, -13 },
  { 638, 8, 13, 11, 0, -13 },
  { 651, 12, 13, 11, -1, -13 },
  { 671, 12, 13, 11, 0, -13 },
  { 691, 10, 13, 11, 1, -13 },
  { 708, 11, 13, 11, 0, -13 },
  { 726, 10, 17, 11, 1, -13 },
  { 748, 10, 13, 11, 0, -13 },
  { 765, 11, 13, 11, 0, -13 },
  { 783, 10, 13, 11, 2, -13 },
  { 800, 10, 13, 11, 1, -13 },
  { 817, 10, 13, 11, 2, -13 },
  { 834, 12, 13, 11, 0, -13 },
  { 854, 13, 13, 11, -1, -13 },
  { 876, 10, 13, 11, 2, -13 },
  { 893, 11, 13, 11, 0, -13 },
  { 911, 10, 19, 11, 1, -15 },
  { 935, 3, 19, 11, 4, -15 },
  { 943, 10, 19, 11, 0, -15 },
  { 967, 9, 7, 11, 1, -13 },
  { 975, 10, 2, 11, -1, 2 },
  { 978, 4, 4, 11, 5, -15 },
  { 980, 9, 10, 11, 1, -10 },
  { 992, 10, 15, 11, 0, -15 },
  { 1011, 9, 10, 11, 1, -10 },
  { 1023, 11, 15, 11, 1, -15 },
  { 1044, 9, 10, 11, 1, -10 },
  { 1056, 13, 19, 11, -1, -15 },
  { 1087, 12, 14, 11, -1, -10 },
  { 1108, 10, 15, 11, 0, -15 },
  { 1127, 7, 15, 11, 2, -15 },
  { 1141, 11, 19, 11, -1, -15 },
  { 1168, 11, 15, 11, 0, -15 },
  { 1189, 6, 15, 11, 3, -15 },
  { 1201, 10, 10, 11, 0, -10 },
  { 1214, 10, 10, 11, 0, -10 },
  { 1227, 9, 10, 11, 1, -10 },
  { 1239, 11, 14, 11, -1, -10 },
  { 1259, 9, 14, 11, 1, -10 },
  { 1275, 9, 10, 11, 1, -10 },
  { 1287, 9, 10, 11, 1, -10 },
  { 1299, 8, 13, 11, 2, -13 },
  { 1312, 9, 10, 11, 1, -10 },
  { 1324, 9, 10, 11, 2, -10 },
  { 1336, 11, 10, 11, 1, -10 },
  { 1350, 12, 10, 11, -1, -10 },
  { 1365, 12, 14, 11, -1, -10 },
  { 1386, 10, 10, 11, 0, -10 },
  { 1399, 10, 19, 11, 1, -15 },
  { 1423, 7, 19, 11, 2, -15 },
  { 1440, 10, 19, 11, -1, -15 },
  { 1464, 9, 3, 11, 1, -7 },
};

const GFXfont UbuntuSansMono_MediumItalic19pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic19pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic19pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC19PT7B_H_
