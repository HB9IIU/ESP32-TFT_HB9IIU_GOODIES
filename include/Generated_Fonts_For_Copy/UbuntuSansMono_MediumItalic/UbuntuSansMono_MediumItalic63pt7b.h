#ifndef _UBUNTUSANSMONO_MEDIUMITALIC63PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x7F, 0x07,
  0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3,
  0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0,
  0x3F, 0x1F, 0x81, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xF0, 0x07, 0xF8,
  0x00, 0x10, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x40, 0x00, 0x0F, 0xE0, 0x38, 0x00, 0x1F,
  0xF0, 0x1F, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7C,
  0x00, 0x7F, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x87, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0xF0, 0x07, 0xE0, 0x01, 0xF0, 0x3C,
  0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x7C,
  0x00, 0x0F, 0x81, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x80, 0x00,
  0xF8, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x87, 0xE0, 0x00, 0x0F, 0x83,
  0xE1, 0xF0, 0x00, 0x03, 0xE1, 0xF0, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x7E,
  0x00, 0x00, 0x1F, 0xFE, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0x1F, 0x80, 0x00,
  0x00, 0xFF, 0x8F, 0xC0, 0x00, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0x8F, 0xFE,
  0x00, 0x00, 0x0F, 0xC7, 0xFF, 0x80, 0x00, 0x03, 0xE3, 0xFF, 0xE0, 0x00,
  0x01, 0xF0, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7C, 0x1F, 0x00, 0x00, 0x7E,
  0x1F, 0x07, 0xC0, 0x00, 0x3F, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x83, 0xE0,
  0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x1E, 0x00, 0x03, 0xE0, 0x3C, 0x0F, 0x80,
  0x01, 0xF0, 0x0F, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0xF8, 0x00, 0x7E,
  0x01, 0xF0, 0x3C, 0x00, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x8F, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0xFF, 0xF0,
  0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x01,
  0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7E, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x3F, 0x01, 0xFF, 0xE0, 0x3F, 0x03, 0xFF, 0xE0, 0x7E, 0x07, 0xFF, 0xF0,
  0x7E, 0x0F, 0xE7, 0xF8, 0x7E, 0x1F, 0xC3, 0xF8, 0xFC, 0x3F, 0x81, 0xFC,
  0xFC, 0x3F, 0x01, 0xFD, 0xF8, 0x7F, 0x00, 0xFF, 0xF8, 0x7E, 0x00, 0x7F,
  0xF0, 0xFE, 0x00, 0x7F, 0xF0, 0xFE, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x3F,
  0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F,
  0xE0, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0x83, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF3, 0xF0, 0x3F, 0xFF, 0xE3, 0xF8, 0x1F, 0xFF, 0xC3,
  0xF8, 0x07, 0xFE, 0x01, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC7, 0xF3,
  0xFC, 0xFF, 0x3F, 0x8F, 0xE3, 0xF9, 0xFE, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8,
  0x7E, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xC0, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x40, 0x1F, 0x80, 0x07, 0x81, 0xF0, 0x1C, 0x7E, 0x1F, 0x07,
  0xC7, 0xF9, 0xF1, 0xFC, 0xFF, 0xCF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x3F, 0x9F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x80, 0x20, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x20, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x07, 0x01, 0xFC,
  0x3F, 0xE7, 0xFE, 0x7F, 0xEF, 0xFF, 0xFF, 0xEF, 0xFE, 0x7F, 0xE7, 0xFC,
  0x3F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xE7, 0xFC, 0x01, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x83, 0xE0, 0x7E, 0x3F, 0x87, 0xF0, 0x7E,
  0x3F, 0x0F, 0xF0, 0xFE, 0x7F, 0x0F, 0xF0, 0xFE, 0x7F, 0x0F, 0xF0, 0xFE,
  0x7F, 0x0F, 0xF0, 0xFE, 0x7E, 0x0F, 0xE0, 0xFC, 0xFE, 0x0F, 0xE1, 0xFC,
  0xFE, 0x07, 0x81, 0xFC, 0xFE, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0x3F,
  0x80, 0x1F, 0x87, 0xF0, 0x03, 0xC0, 0xFE, 0x00, 0x60, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0x3C, 0x00, 0x3F, 0x80, 0x0C, 0x00, 0x0F, 0xE0, 0x02, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFE, 0x0F, 0xFC, 0x00, 0x38, 0x01, 0xFF, 0x00, 0x10,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x81, 0x00, 0x00,
  0x7F, 0x80, 0xC0, 0x00, 0x7F, 0xC0, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF0, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x20, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x02, 0x00, 0x00, 0xFF, 0x00,
  0x60, 0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x87, 0xFC, 0x00, 0x3F,
  0xBF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03,
  0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFE, 0x3F, 0xF0, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFC,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x0F, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8,
  0x1F, 0xFC, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xBF, 0x80, 0x03, 0xFE, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0x07,
  0xFE, 0x18, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x7E, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0xF8, 0x7E, 0x00, 0xFF,
  0xFE, 0x1F, 0xC0, 0x7F, 0xFF, 0xC3, 0xF0, 0x1F, 0xFF, 0xF8, 0x7E, 0x07,
  0xFF, 0xFF, 0x1F, 0x81, 0xFF, 0xFF, 0xC3, 0xF0, 0x7F, 0xC1, 0xF8, 0x7E,
  0x0F, 0xE0, 0x3F, 0x1F, 0x83, 0xF8, 0x0F, 0xE3, 0xF0, 0x7F, 0x01, 0xF8,
  0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xC3, 0xF8, 0x07, 0xE3, 0xF0, 0x7E, 0x01,
  0xFC, 0x7E, 0x0F, 0xC0, 0x3F, 0x8F, 0xC1, 0xF8, 0x07, 0xE1, 0xF8, 0x3F,
  0x00, 0xFC, 0x3F, 0x0F, 0xE0, 0x3F, 0x87, 0xE1, 0xFC, 0x07, 0xF0, 0xFC,
  0x3F, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x7E, 0x03, 0xF0,
  0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC1, 0xFF, 0x1F, 0x81, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0x03, 0xFF, 0xFE, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xC0, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x02,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x07, 0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x1F, 0xC0, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0,
  0x1F, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x1F,
  0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xE0,
  0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x3F,
  0xC0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x1F, 0xF8, 0x1F, 0xFE, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x3C, 0x01, 0xFF, 0x00, 0x02, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x20, 0x07, 0xFC, 0x00, 0x38, 0x00, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x1F,
  0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFF,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0x00, 0x3F,
  0xF0, 0x1F, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0x00, 0x3C,
  0x01, 0xFF, 0x00, 0x02, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00,
  0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0x00, 0x01, 0xFE, 0x00, 0x18,
  0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x81, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x3F,
  0x87, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x7D, 0xF0, 0x1F, 0xF8, 0x00, 0xFB, 0xE0,
  0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0xFB, 0xE0, 0x07, 0xEF, 0x83, 0xEF, 0xC0,
  0x0F, 0x9F, 0x07, 0x9F, 0x00, 0x1F, 0x3E, 0x1F, 0x3E, 0x00, 0x7E, 0x7C,
  0x3C, 0x7C, 0x00, 0xFC, 0xF8, 0xF9, 0xF8, 0x01, 0xF1, 0xF1, 0xE3, 0xF0,
  0x03, 0xE1, 0xE7, 0xC7, 0xE0, 0x0F, 0xC3, 0xDF, 0x0F, 0x80, 0x1F, 0x87,
  0xBE, 0x3F, 0x00, 0x3E, 0x0F, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0xF0, 0xFC,
  0x01, 0xF8, 0x3F, 0xC1, 0xF8, 0x03, 0xF0, 0x7F, 0x03, 0xE0, 0x0F, 0xC0,
  0xFE, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x3F,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0xF0,
  0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xE0,
  0x07, 0xFE, 0x00, 0x1F, 0x80, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xE0,
  0x03, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00,
  0x3F, 0xFC, 0x01, 0xFC, 0x01, 0xFD, 0xF0, 0x07, 0xE0, 0x07, 0xE7, 0xE0,
  0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x7E, 0x00, 0x7E, 0x7E, 0x03, 0xF8, 0x03,
  0xF8, 0xF8, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0xFC, 0x00, 0xFC, 0x1F, 0x03, 0xF0, 0x07, 0xF0, 0x7C, 0x1F, 0xC0, 0x1F,
  0x81, 0xF8, 0x7E, 0x00, 0x7E, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x0F, 0x87,
  0xE0, 0x0F, 0xE0, 0x3E, 0x3F, 0x80, 0x3F, 0x00, 0xF8, 0xFC, 0x00, 0xFC,
  0x03, 0xF3, 0xF0, 0x03, 0xF0, 0x0F, 0xCF, 0xC0, 0x0F, 0xC0, 0x1F, 0x7F,
  0x00, 0x7E, 0x00, 0x7D, 0xF8, 0x01, 0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xE0,
  0x07, 0xDF, 0x80, 0x1F, 0x80, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xF0,
  0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0x00,
  0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xE0, 0x00, 0x7F, 0x80,
  0x1F, 0x80, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xE7, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x3F, 0xF0, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x0F,
  0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xF0,
  0x0F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xE7, 0xFE, 0x01, 0xFF, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFD, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0xF0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x38, 0x00, 0x7F, 0x80, 0x00, 0x80, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x01, 0x80, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x0F,
  0xF8, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07,
  0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x07, 0xE0, 0x0F, 0xE0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xF0,
  0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x7C, 0x00, 0xF8, 0x3F, 0xC1, 0xF8, 0x03,
  0xF0, 0x7F, 0x83, 0xF0, 0x07, 0xE1, 0xFF, 0x07, 0xE0, 0x0F, 0xC3, 0xDE,
  0x0F, 0x80, 0x1F, 0x8F, 0xBC, 0x3F, 0x00, 0x3E, 0x1E, 0x7C, 0x7E, 0x00,
  0x7C, 0x7C, 0xF8, 0xF8, 0x01, 0xF9, 0xF1, 0xF1, 0xF0, 0x03, 0xF3, 0xE3,
  0xE7, 0xE0, 0x07, 0xCF, 0x87, 0xCF, 0x80, 0x0F, 0x9F, 0x0F, 0x9F, 0x00,
  0x1F, 0x7C, 0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x1E, 0xFC, 0x00, 0xFB, 0xE0,
  0x3D, 0xF0, 0x01, 0xF7, 0xC0, 0x7B, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x1F, 0xE1, 0xF8, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF0,
  0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F,
  0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF8, 0xFE, 0x00,
  0x3F, 0xC3, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x80,
  0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7E, 0x7F, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x0F, 0x87, 0x00, 0x00, 0x38,
  0x04, 0x00, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x70, 0x03, 0xE0, 0x0F, 0xC0,
  0x7F, 0x83, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0x80, 0x3C, 0x00, 0x20, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xE1, 0xFE, 0x03, 0xFE, 0x00, 0xFE,
  0x07, 0xFC, 0x00, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFC,
  0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE7, 0xE0, 0x07, 0xFF, 0x87, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x1E, 0x00, 0x00, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0x87, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFE,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xF0,
  0x7F, 0x00, 0x7F, 0xE0, 0x7F, 0x87, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x40,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x3E, 0x03,
  0xFF, 0x00, 0x04, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0C, 0x07, 0xFF, 0x81, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x23, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xF8,
  0x01, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x01,
  0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFB,
  0xF8, 0x00, 0xFF, 0xFE, 0x7F, 0x00, 0x07, 0xFF, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x01,
  0xFC, 0x7F, 0x80, 0x03, 0xF3, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7F,
  0x7F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0xFF, 0xBF,
  0x80, 0x1F, 0xFC, 0xFE, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x60,
  0x7F, 0xF0, 0x0F, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x30, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0x9F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xC0, 0x07, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0,
  0x00, 0xFF, 0xEF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x0C,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x01,
  0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x03,
  0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07,
  0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x02, 0x00, 0x0F, 0xF0, 0x00, 0x70, 0x03, 0xFC, 0x00,
  0x0F, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0,
  0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x81, 0xFF, 0x00, 0x0F, 0xE0, 0xFF,
  0x80, 0x07, 0xF0, 0x7F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xE0,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x33,
  0xFE, 0x1F, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x80, 0x04, 0x00, 0x07, 0xFF,
  0x0F, 0xF0, 0x03, 0xFF, 0xF7, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x1F, 0xE3, 0xF8,
  0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07,
  0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0,
  0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x81,
  0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xF7,
  0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x01,
  0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F,
  0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0,
  0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFB, 0xFF,
  0x83, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1,
  0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFD, 0xFC,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F,
  0x3F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x8F,
  0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE7, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xF8, 0x07, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0x9F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC1, 0xFE,
  0x07, 0xFE, 0x01, 0xFC, 0x0F, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFC,
  0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0,
  0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0x00,
  0x00, 0x70, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0x40, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x08, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x3E, 0x00, 0xFF, 0x00, 0x08, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x80, 0x00, 0x7F,
  0x81, 0xC0, 0x01, 0xFE, 0x03, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x02, 0x01, 0xFF, 0x87, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE,
  0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x0F,
  0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC,
  0x03, 0xFE, 0x03, 0xFE, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xC7, 0xE0, 0x0F, 0xFF,
  0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF8,
  0xFF, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x1F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x0F,
  0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x1F, 0xBF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x03, 0xE0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF8, 0x3F, 0x07, 0xC0, 0xFF, 0x07, 0xE0, 0xF8, 0x1F, 0xE0, 0xFC, 0x3F,
  0x07, 0xFC, 0x3F, 0x07, 0xE1, 0xFF, 0x87, 0xE0, 0xFC, 0x3F, 0xF0, 0xF8,
  0x1F, 0x8F, 0xFE, 0x3F, 0x03, 0xF1, 0xF7, 0xC7, 0xE0, 0x7E, 0x7C, 0xF8,
  0xF8, 0x0F, 0x8F, 0x9F, 0x3F, 0x01, 0xF3, 0xE1, 0xE7, 0xC0, 0x3E, 0x7C,
  0x3C, 0xF8, 0x07, 0xDF, 0x07, 0xBF, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00,
  0x7F, 0xBF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0xFE, 0x00,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x18, 0x07, 0xFF, 0x00, 0x1F, 0x0F, 0xFF, 0xC0, 0x3F,
  0x1F, 0xFF, 0xE0, 0x7E, 0x3F, 0xFF, 0xF8, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0x7F, 0x0F, 0xFF, 0xFC, 0x7E, 0x07, 0xFF, 0xF8, 0xFC, 0x01, 0xFF, 0xF0,
  0xF8, 0x00, 0xFF, 0xE0, 0x18, 0x00, 0x3F, 0x80,
};

const GFXglyph UbuntuSansMono_MediumItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 18, 45, 35, 9, -44 },
  { 103, 22, 19, 35, 12, -48 },
  { 156, 37, 44, 35, 0, -44 },
  { 360, 33, 56, 35, 2, -49 },
  { 591, 42, 46, 35, -2, -45 },
  { 833, 32, 46, 35, 1, -45 },
  { 1017, 10, 20, 35, 18, -48 },
  { 1042, 28, 62, 35, 7, -50 },
  { 1259, 27, 62, 35, 1, -50 },
  { 1469, 28, 27, 35, 7, -44 },
  { 1564, 30, 31, 35, 3, -34 },
  { 1681, 16, 21, 35, 5, -11 },
  { 1723, 18, 6, 35, 9, -21 },
  { 1737, 12, 12, 35, 9, -11 },
  { 1755, 41, 61, 35, -4, -49 },
  { 2068, 32, 46, 35, 3, -45 },
  { 2252, 27, 44, 35, 3, -44 },
  { 2401, 34, 45, 35, 1, -45 },
  { 2593, 33, 46, 35, 1, -45 },
  { 2783, 34, 44, 35, 0, -44 },
  { 2970, 35, 45, 35, 1, -44 },
  { 3167, 32, 45, 35, 4, -44 },
  { 3347, 32, 44, 35, 7, -44 },
  { 3523, 33, 46, 35, 2, -45 },
  { 3713, 33, 45, 35, 2, -45 },
  { 3899, 17, 34, 35, 9, -33 },
  { 3972, 21, 43, 35, 5, -33 },
  { 4085, 31, 29, 35, 3, -33 },
  { 4198, 34, 19, 35, 1, -28 },
  { 4279, 32, 29, 35, 1, -33 },
  { 4395, 25, 46, 35, 9, -45 },
  { 4539, 35, 54, 35, 2, -45 },
  { 4776, 34, 44, 35, -3, -44 },
  { 4963, 35, 44, 35, 0, -44 },
  { 5156, 34, 46, 35, 4, -45 },
  { 5352, 34, 44, 35, 0, -44 },
  { 5539, 35, 44, 35, 2, -44 },
  { 5732, 36, 44, 35, 2, -44 },
  { 5930, 34, 46, 35, 3, -45 },
  { 6126, 38, 44, 35, 0, -44 },
  { 6335, 36, 44, 35, 1, -44 },
  { 6533, 36, 45, 35, 1, -44 },
  { 6736, 39, 44, 35, 0, -44 },
  { 6951, 27, 44, 35, 1, -44 },
  { 7100, 39, 44, 35, -2, -44 },
  { 7315, 38, 44, 35, 0, -44 },
  { 7524, 32, 46, 35, 3, -45 },
  { 7708, 35, 44, 35, 1, -44 },
  { 7901, 32, 57, 35, 3, -45 },
  { 8129, 35, 44, 35, 0, -44 },
  { 8322, 36, 46, 35, 0, -45 },
  { 8529, 32, 44, 35, 7, -44 },
  { 8705, 35, 45, 35, 3, -44 },
  { 8902, 34, 44, 35, 7, -44 },
  { 9089, 39, 44, 35, 1, -44 },
  { 9304, 42, 44, 35, -2, -44 },
  { 9535, 33, 44, 35, 8, -44 },
  { 9717, 38, 44, 35, 0, -44 },
  { 9926, 33, 61, 35, 4, -49 },
  { 10178, 13, 61, 35, 12, -49 },
  { 10278, 33, 61, 35, -1, -49 },
  { 10530, 30, 25, 35, 4, -44 },
  { 10624, 33, 6, 35, -5, 6 },
  { 10649, 14, 13, 35, 15, -49 },
  { 10672, 32, 35, 35, 2, -34 },
  { 10812, 32, 50, 35, 1, -49 },
  { 11012, 31, 35, 35, 3, -34 },
  { 11148, 35, 50, 35, 3, -49 },
  { 11367, 30, 35, 35, 3, -34 },
  { 11499, 42, 61, 35, -3, -49 },
  { 11820, 37, 46, 35, -2, -34 },
  { 12033, 32, 49, 35, 0, -49 },
  { 12229, 22, 49, 35, 6, -49 },
  { 12364, 35, 61, 35, -2, -49 },
  { 12631, 34, 49, 35, 2, -49 },
  { 12840, 20, 50, 35, 9, -49 },
  { 12965, 35, 34, 35, -1, -34 },
  { 13114, 31, 34, 35, 1, -34 },
  { 13246, 30, 35, 35, 3, -34 },
  { 13378, 35, 46, 35, -2, -34 },
  { 13580, 32, 46, 35, 3, -34 },
  { 13764, 32, 34, 35, 3, -34 },
  { 13900, 31, 35, 35, 2, -34 },
  { 14036, 28, 44, 35, 6, -43 },
  { 14190, 31, 34, 35, 3, -33 },
  { 14322, 30, 33, 35, 6, -33 },
  { 14446, 35, 33, 35, 3, -33 },
  { 14591, 38, 33, 35, -2, -33 },
  { 14748, 41, 45, 35, -5, -33 },
  { 14979, 33, 33, 35, 1, -33 },
  { 15116, 34, 61, 35, 4, -49 },
  { 15376, 22, 61, 35, 7, -49 },
  { 15544, 34, 61, 35, -3, -49 },
  { 15804, 32, 11, 35, 2, -24 },
};

const GFXfont UbuntuSansMono_MediumItalic63pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic63pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic63pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC63PT7B_H_
