#ifndef _UBUNTUSANSMONO_MEDIUMITALIC43PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x3E, 0x00, 0x40, 0x00, 0x3E, 0x1F, 0x3E, 0x1E, 0x3C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3C, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x78, 0x78, 0x70, 0x78,
  0xF0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0x00, 0x0F, 0x87, 0x80, 0x07, 0x83,
  0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF8, 0x78, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x1E, 0x0F, 0x00, 0x0F,
  0x07, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xE0, 0x03,
  0xC1, 0xE0, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xE0, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00,
  0x1E, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x87, 0xC0,
  0x07, 0x83, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xF8, 0x3C, 0x0F, 0xC0, 0x10, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x80, 0x0F, 0x81, 0x80, 0x3F,
  0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x78, 0x0F, 0xF0,
  0x07, 0x80, 0x7F, 0xC0, 0x38, 0x07, 0x9E, 0x03, 0xC0, 0x38, 0x70, 0x3C,
  0x03, 0xC3, 0x83, 0xC0, 0x1C, 0x3C, 0x3C, 0x00, 0xE1, 0xE3, 0xC0, 0x07,
  0x0E, 0x1C, 0x00, 0x38, 0x71, 0xE0, 0x01, 0xC7, 0x9E, 0x00, 0x0F, 0xF9,
  0xE0, 0x00, 0x7F, 0x9E, 0x00, 0x01, 0xF9, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF3, 0xF8, 0x00,
  0x0F, 0x3F, 0xE0, 0x00, 0xF3, 0xCF, 0x00, 0x0F, 0x1C, 0x38, 0x00, 0x70,
  0xE1, 0xC0, 0x07, 0x8F, 0x0E, 0x00, 0x78, 0x70, 0xF0, 0x07, 0x83, 0x87,
  0x80, 0x78, 0x1C, 0x38, 0x07, 0x80, 0xE3, 0xC0, 0x38, 0x07, 0xBC, 0x03,
  0xC0, 0x3F, 0xE0, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7C, 0x7C, 0x03, 0xE0,
  0xF0, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0,
  0x1E, 0x0F, 0x00, 0x7C, 0x7C, 0x00, 0xF7, 0xE0, 0x03, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x83, 0xC3, 0xFE, 0x1E, 0x1F, 0xF8, 0x78, 0xF9, 0xF1,
  0xE7, 0xC3, 0xCF, 0x1E, 0x0F, 0xBC, 0xF8, 0x1F, 0xE3, 0xC0, 0x7F, 0x8F,
  0x00, 0xFC, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0xC3, 0xE0, 0x7F, 0x0F, 0xEF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xF1, 0xE0, 0x7F, 0x87, 0xC0, 0x3E, 0x7C,
  0xF9, 0xF7, 0xCF, 0x9F, 0x3C, 0x78, 0xF1, 0xC7, 0x8F, 0x1C, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x10,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x04,
  0x1E, 0x04, 0xE3, 0xC7, 0xBF, 0x39, 0xF7, 0xF6, 0xFE, 0xFF, 0xFF, 0xE7,
  0xFF, 0xF0, 0x07, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3E, 0x7C, 0x07,
  0xCF, 0xC1, 0xF0, 0xF8, 0x1E, 0x1E, 0x01, 0x81, 0x80, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFE,
  0x1F, 0xC3, 0xF8, 0x1E, 0x03, 0xC1, 0xF1, 0xFC, 0x7F, 0x0F, 0xC1, 0xC0,
  0x00, 0x7F, 0xFB, 0xFF, 0x9F, 0xFD, 0xFF, 0xEF, 0xFF, 0x00, 0x3E, 0x7F,
  0x7F, 0xFF, 0xFF, 0x7E, 0x7E, 0x18, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xE0, 0xF8, 0x3F,
  0x01, 0xE0, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x01,
  0xF3, 0xE0, 0x07, 0xCF, 0x0C, 0x1E, 0x7C, 0x78, 0x79, 0xF3, 0xF1, 0xE7,
  0x8F, 0xCF, 0x9E, 0x3F, 0x3E, 0xF8, 0xF8, 0xFB, 0xE1, 0x83, 0xCF, 0x80,
  0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xF0, 0x7E, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xBE, 0x07, 0x8F, 0x01, 0x87, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3C, 0x07, 0xC0, 0x60, 0x0F,
  0xC0, 0x80, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0C, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x60, 0x0F,
  0xE1, 0xFC, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x0F, 0xBE, 0x00, 0x3E, 0x78, 0x00, 0xF8, 0xF0, 0x03, 0xE3, 0xE0,
  0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0x00, 0xF8, 0x1E, 0x01, 0xE0, 0x7C, 0x07,
  0x80, 0xF8, 0x1E, 0x01, 0xF0, 0x7C, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x10, 0x03, 0xF8, 0x1F, 0xDF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x60, 0x03, 0xEF, 0xF8, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x3F, 0xC3, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1,
  0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x3C, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xFC,
  0x7F, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x30,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0xFE, 0xFF, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07,
  0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0x83,
  0xF0, 0x7C, 0x07, 0xE3, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xE0, 0x1F, 0xBF, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0x3E, 0x1E, 0x00, 0xF8,
  0xF8, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0xE1, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7E, 0x07, 0xC1, 0xF0, 0x07,
  0xC3, 0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xF0, 0x07, 0xC3,
  0xF0, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x07,
  0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x07, 0xE0, 0x18, 0x00, 0x00, 0x78, 0x01,
  0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x80, 0xFE, 0x03, 0xF8, 0x07,
  0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0xFE,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x00, 0x0C,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF,
  0xF1, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFC, 0x3F, 0x03, 0xF0,
  0x1F, 0x07, 0xE0, 0x0F, 0x07, 0xC0, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00,
  0x0F, 0x1E, 0x03, 0xFF, 0x1E, 0x0F, 0xFF, 0x3C, 0x1F, 0xFE, 0x3C, 0x3F,
  0xFE, 0x3C, 0x7E, 0x1E, 0x78, 0x7C, 0x3E, 0x78, 0xF8, 0x3C, 0x78, 0xF0,
  0x3C, 0x78, 0xF0, 0x3C, 0xF8, 0xF0, 0x7C, 0xF0, 0xF0, 0x7C, 0xF0, 0xF0,
  0x78, 0xF0, 0xF0, 0x78, 0xF0, 0xF0, 0xF8, 0xF0, 0xF8, 0xF8, 0xF0, 0xFF,
  0xF0, 0xF0, 0x7F, 0xF0, 0x78, 0x3F, 0xF0, 0x78, 0x1F, 0xE0, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC1,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xDF, 0x00, 0x0F, 0x9E, 0x00, 0x1E, 0x3C,
  0x00, 0x7C, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0,
  0x1E, 0x07, 0x80, 0x7C, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07,
  0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0x03, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x1E, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0x3E, 0x07, 0x80,
  0xFC, 0x0F, 0x8F, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0x07, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x1E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3C, 0x00,
  0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x0C, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3E, 0x0F, 0xC0, 0x78, 0x0F, 0xC1, 0xF0, 0x0F,
  0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x3C, 0x3E, 0x00, 0x78,
  0x7C, 0x00, 0xF0, 0xF8, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0,
  0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0x00, 0x7E, 0x3E, 0x01,
  0xF8, 0x7C, 0x07, 0xE0, 0xF8, 0x3F, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x3F, 0x00, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7E, 0x01, 0xF0,
  0x7C, 0x03, 0xC0, 0xFC, 0x0F, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x78, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1E, 0x03, 0xE0,
  0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3C, 0x07,
  0xC0, 0x1F, 0x01, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x78,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x81,
  0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x1F,
  0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x3E, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x20, 0x0F, 0xC0, 0x70, 0x1F, 0x80, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x07, 0x80, 0x7E,
  0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x07, 0xC1, 0xF8, 0x00, 0xF0,
  0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xF8, 0x00,
  0x1F, 0x3E, 0x00, 0x03, 0xCF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE0, 0xF8,
  0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3C, 0x00, 0xF8,
  0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x07, 0xF0,
  0x1F, 0xC1, 0xFC, 0x0F, 0xF0, 0xEE, 0x03, 0xDC, 0x3B, 0x80, 0xE7, 0x1D,
  0xE0, 0x79, 0xCF, 0x78, 0x1E, 0x73, 0x9E, 0x07, 0x9D, 0xE7, 0x81, 0xC7,
  0x71, 0xC0, 0xF1, 0xFC, 0xF0, 0x3C, 0x7E, 0x3C, 0x0F, 0x1F, 0x0F, 0x07,
  0x87, 0xC3, 0xC1, 0xE1, 0xE1, 0xE0, 0x78, 0x00, 0x78, 0x3E, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0x7C, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0x78, 0x3C, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x7C, 0x00,
  0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x1E, 0x03, 0xF8, 0x07, 0x80, 0xFE,
  0x01, 0xE0, 0x7F, 0x80, 0xF8, 0x1E, 0xF0, 0x3C, 0x07, 0xBC, 0x0F, 0x01,
  0xEF, 0x03, 0xC0, 0x79, 0xC1, 0xF0, 0x3E, 0x78, 0x78, 0x0F, 0x1E, 0x1E,
  0x03, 0xC7, 0x87, 0x80, 0xF0, 0xE3, 0xE0, 0x7C, 0x3C, 0xF8, 0x1E, 0x0F,
  0x3C, 0x07, 0x83, 0xCF, 0x01, 0xE0, 0x73, 0xC0, 0xF8, 0x1D, 0xF0, 0x3C,
  0x07, 0xF8, 0x0F, 0x01, 0xFE, 0x03, 0xC0, 0x7F, 0x81, 0xF0, 0x0F, 0xE0,
  0x78, 0x03, 0xF0, 0x1E, 0x00, 0xFC, 0x07, 0x80, 0x3F, 0x03, 0xE0, 0x0F,
  0xC0, 0xF8, 0x03, 0xE0, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xE0, 0xFC, 0x3F, 0x01,
  0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0xF8, 0x01, 0xF3,
  0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0x80,
  0x07, 0xFE, 0x00, 0x1E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xBE, 0x00, 0x3C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x3E,
  0x01, 0xF8, 0xF8, 0x07, 0xC3, 0xF0, 0x7E, 0x07, 0xF7, 0xF0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1E,
  0x07, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x1F, 0x03,
  0xC0, 0x0F, 0x03, 0xE0, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0,
  0x78, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xE0, 0xFC, 0x3F, 0x01,
  0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0xF8, 0x01, 0xF3,
  0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0x80,
  0x07, 0xFE, 0x00, 0x1E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xBE, 0x00, 0x3C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x3E,
  0x01, 0xF8, 0xF8, 0x07, 0xC3, 0xF0, 0x7E, 0x07, 0xF7, 0xF8, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03,
  0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x07,
  0xC0, 0x1E, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0xFC, 0x0F,
  0x8F, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x07, 0x80, 0x3E, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C,
  0x01, 0xE0, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01,
  0xF0, 0x06, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x30, 0x03, 0xF0, 0x7F, 0xBF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00,
  0x3E, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3C, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xFC, 0x0F,
  0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFB, 0xE0, 0x01,
  0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x7C,
  0x0F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x78, 0x03, 0xE1, 0xF0, 0x03, 0xC7,
  0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3D, 0xF0,
  0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC1, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83,
  0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x1E, 0x00, 0x0F,
  0x07, 0x80, 0x07, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x78, 0x78, 0x3E, 0x3E,
  0x1E, 0x0F, 0x0F, 0x8F, 0x03, 0xC7, 0xE3, 0xC0, 0xF1, 0xF8, 0xF0, 0x3C,
  0xEE, 0x3C, 0x1E, 0x7B, 0x9E, 0x07, 0x9C, 0xE7, 0x81, 0xEF, 0x39, 0xE0,
  0x7B, 0x8E, 0x70, 0x1D, 0xE3, 0xBC, 0x07, 0x70, 0xEF, 0x01, 0xFC, 0x3F,
  0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x3C, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0xF8, 0x1E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xF9, 0xE0, 0x03, 0xF3, 0xC0,
  0x07, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x1E, 0x03,
  0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x7C, 0x00, 0xF1, 0xF0,
  0x01, 0xE3, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1F,
  0x0F, 0x87, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x78, 0x03, 0xF7, 0xC0, 0x3E, 0x7C,
  0x07, 0xC3, 0xC0, 0xF8, 0x3E, 0x1F, 0x03, 0xE3, 0xF0, 0x1E, 0x3E, 0x01,
  0xF7, 0xC0, 0x1F, 0xF8, 0x00, 0xF7, 0x00, 0x0E, 0x10, 0x00, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x10, 0x0E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x0C, 0x01, 0x00, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xF0, 0x78,
  0x3F, 0x03, 0xE1, 0xF8, 0x0F, 0x8F, 0xC0, 0x3E, 0x3E, 0x00, 0xF1, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x78, 0x01, 0xE1, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x78, 0x03, 0xE1, 0xF0, 0x1F, 0x07,
  0xC0, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0x1E, 0x00, 0x40, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xE1, 0xF0, 0x1F, 0x0F, 0x00,
  0xF8, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0x9F,
  0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3C, 0x01, 0xF3, 0xE0, 0x0F,
  0x9F, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0x81, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0x03, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x20,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xE0, 0xF8, 0x1F, 0x80,
  0xF0, 0x3F, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03,
  0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFB,
  0xC0, 0x1F, 0xE3, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF,
  0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFC, 0x1F, 0x8F, 0x80, 0x7C, 0xF8,
  0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x01, 0xF3, 0xC0, 0x1F, 0xBE, 0x07, 0xF9,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFE, 0x03, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x20, 0xFF, 0xBF, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x04, 0x3F, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xC1, 0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0x80,
  0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xC0,
  0x0F, 0x83, 0xE0, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0x3E, 0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC1, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x20, 0x03, 0xE0,
  0x1C, 0x07, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3D, 0xF8, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7E, 0x1F, 0x83, 0xE0, 0x3E,
  0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xC0, 0x1E, 0x1F,
  0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0x80, 0x3C, 0x3E, 0x01,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0x78, 0x7C, 0x03, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1E, 0x00, 0xF0, 0xF8, 0x07, 0xC0, 0x00,
  0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0x1F,
  0xFE, 0x3F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x01,
  0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x40, 0x1F,
  0x00, 0x70, 0x7E, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x01, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0x83,
  0xF0, 0x0F, 0x87, 0xE0, 0x0F, 0x8F, 0xC0, 0x0F, 0xBF, 0x00, 0x0F, 0x7E,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xFC,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x3C, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07,
  0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7F, 0xF1, 0xFF, 0xCF, 0xFF,
  0x3F, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x05, 0xFF, 0xF3,
  0xFF, 0xCF, 0xFF, 0x1F, 0xF8, 0x04, 0x00, 0x00, 0x7C, 0x3C, 0x03, 0xFE,
  0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0x8F, 0x8F, 0x07, 0x8F,
  0x0F, 0x0F, 0x8F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x20, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFC, 0x3F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xE0,
  0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xE3,
  0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0x80, 0x3C, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x07, 0x8F, 0x80, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC1, 0xFC, 0x3F, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xCF,
  0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xBE, 0x00, 0x3D, 0xF0, 0x03,
  0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8,
  0x07, 0xE7, 0xC0, 0x7E, 0x3F, 0x07, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xE0, 0x7E, 0x03,
  0xE0, 0x3E, 0x03, 0xC0, 0x1E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07,
  0xC0, 0x1F, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F,
  0x01, 0xF8, 0x1E, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xE0, 0xF8, 0x7E, 0x03, 0xE3, 0xF0, 0x0F,
  0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x1E, 0x3E,
  0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x3E, 0x01,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0xF8, 0x1F, 0xDF, 0xE0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFE, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xF4, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xF8, 0x70, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0x03,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x0C, 0x01,
  0xF0, 0xFE, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x00,
  0x38, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x01, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x80, 0x00, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0x80, 0x3C, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x07, 0x8F, 0x80, 0x7C,
  0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0xF8, 0x0F, 0x87, 0xE0,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xF1, 0xE0,
  0x0C, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80,
  0x3E, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0x78, 0x0F, 0x87, 0x80, 0xF8, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7C, 0x07,
  0xC7, 0x80, 0x3C, 0xF8, 0x03, 0xDF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x3C, 0x78, 0x38, 0x3C, 0x78, 0x78, 0x3C, 0x78, 0x78, 0x78, 0xF0, 0xFC,
  0x78, 0xF0, 0xFC, 0x78, 0xF1, 0xFC, 0xF0, 0xF3, 0xFC, 0xF0, 0xF3, 0x9C,
  0xE0, 0xF7, 0x9D, 0xE0, 0xF7, 0x1D, 0xE0, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x1F,
  0x00, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x7C,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xCF, 0xC0, 0x01,
  0xF7, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xDF, 0x00, 0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x07, 0xE1, 0xF0,
  0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x0F, 0x87, 0xE0, 0x07,
  0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x78, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03,
  0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xC0, 0x01,
  0xE0, 0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF0,
  0x00, 0x1F, 0x3E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x08, 0x3F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x3F, 0x80, 0x71, 0xFF,
  0x83, 0xCF, 0xFF, 0x1F, 0x7F, 0xFF, 0xF9, 0xE1, 0xFF, 0xCF, 0x01, 0xFE,
  0x0C, 0x03, 0xF0,
};

const GFXglyph UbuntuSansMono_MediumItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 13, 31, 24, 6, -30 },
  { 52, 16, 13, 24, 8, -33 },
  { 78, 25, 30, 24, 0, -30 },
  { 172, 23, 38, 24, 1, -33 },
  { 282, 29, 31, 24, -2, -30 },
  { 395, 22, 30, 24, 1, -30 },
  { 478, 7, 14, 24, 12, -33 },
  { 491, 19, 42, 24, 5, -34 },
  { 591, 18, 42, 24, 1, -34 },
  { 686, 19, 18, 24, 5, -30 },
  { 729, 21, 21, 24, 2, -23 },
  { 785, 11, 14, 24, 3, -7 },
  { 805, 13, 5, 24, 6, -15 },
  { 814, 8, 8, 24, 6, -7 },
  { 822, 28, 42, 24, -3, -34 },
  { 969, 22, 31, 24, 2, -30 },
  { 1055, 18, 30, 24, 2, -30 },
  { 1123, 23, 30, 24, 1, -30 },
  { 1210, 23, 31, 24, 0, -30 },
  { 1300, 23, 30, 24, 0, -30 },
  { 1387, 25, 31, 24, 0, -30 },
  { 1484, 23, 31, 24, 2, -30 },
  { 1574, 23, 30, 24, 4, -30 },
  { 1661, 22, 31, 24, 2, -30 },
  { 1747, 23, 30, 24, 1, -30 },
  { 1834, 12, 23, 24, 6, -22 },
  { 1869, 15, 29, 24, 3, -22 },
  { 1924, 21, 20, 24, 2, -22 },
  { 1977, 23, 13, 24, 1, -19 },
  { 2015, 21, 20, 24, 1, -22 },
  { 2068, 17, 31, 24, 6, -30 },
  { 2134, 24, 36, 24, 1, -30 },
  { 2242, 23, 30, 24, -2, -30 },
  { 2329, 24, 30, 24, 0, -30 },
  { 2419, 24, 31, 24, 2, -30 },
  { 2512, 23, 30, 24, 0, -30 },
  { 2599, 25, 30, 24, 1, -30 },
  { 2693, 25, 30, 24, 1, -30 },
  { 2787, 23, 31, 24, 2, -30 },
  { 2877, 26, 30, 24, 0, -30 },
  { 2975, 24, 30, 24, 1, -30 },
  { 3065, 24, 31, 24, 1, -30 },
  { 3158, 27, 30, 24, 0, -30 },
  { 3260, 18, 30, 24, 1, -30 },
  { 3328, 26, 30, 24, -1, -30 },
  { 3426, 26, 30, 24, 0, -30 },
  { 3524, 22, 31, 24, 2, -30 },
  { 3610, 25, 30, 24, 0, -30 },
  { 3704, 22, 38, 24, 2, -30 },
  { 3809, 24, 30, 24, 0, -30 },
  { 3899, 24, 31, 24, 0, -30 },
  { 3992, 22, 30, 24, 5, -30 },
  { 4075, 24, 31, 24, 2, -30 },
  { 4168, 23, 30, 24, 5, -30 },
  { 4255, 26, 30, 24, 1, -30 },
  { 4353, 30, 30, 24, -2, -30 },
  { 4466, 23, 30, 24, 5, -30 },
  { 4553, 26, 30, 24, 0, -30 },
  { 4651, 22, 42, 24, 3, -34 },
  { 4767, 9, 42, 24, 8, -34 },
  { 4815, 23, 42, 24, -1, -34 },
  { 4936, 20, 17, 24, 3, -30 },
  { 4979, 22, 4, 24, -3, 4 },
  { 4990, 10, 9, 24, 10, -33 },
  { 5002, 22, 24, 24, 1, -23 },
  { 5068, 21, 34, 24, 1, -33 },
  { 5158, 21, 24, 24, 2, -23 },
  { 5221, 24, 34, 24, 2, -33 },
  { 5323, 21, 24, 24, 2, -23 },
  { 5386, 29, 41, 24, -2, -33 },
  { 5535, 25, 31, 24, -1, -23 },
  { 5632, 22, 33, 24, 0, -33 },
  { 5723, 15, 33, 24, 4, -33 },
  { 5785, 24, 41, 24, -1, -33 },
  { 5908, 24, 33, 24, 1, -33 },
  { 6007, 14, 34, 24, 6, -33 },
  { 6067, 24, 23, 24, -1, -23 },
  { 6136, 21, 23, 24, 1, -23 },
  { 6197, 21, 24, 24, 2, -23 },
  { 6260, 24, 31, 24, -1, -23 },
  { 6353, 22, 31, 24, 2, -23 },
  { 6439, 22, 23, 24, 2, -23 },
  { 6503, 21, 24, 24, 1, -23 },
  { 6566, 19, 30, 24, 4, -29 },
  { 6638, 21, 23, 24, 2, -22 },
  { 6699, 20, 22, 24, 4, -22 },
  { 6754, 24, 22, 24, 2, -22 },
  { 6820, 25, 22, 24, -1, -22 },
  { 6889, 27, 30, 24, -3, -22 },
  { 6991, 22, 22, 24, 1, -22 },
  { 7052, 23, 42, 24, 3, -34 },
  { 7173, 15, 42, 24, 5, -34 },
  { 7252, 23, 42, 24, -2, -34 },
  { 7373, 22, 8, 24, 1, -17 },
};

const GFXfont UbuntuSansMono_MediumItalic43pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic43pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic43pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC43PT7B_H_
