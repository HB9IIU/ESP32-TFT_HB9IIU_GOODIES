#ifndef _UBUNTUSANSMONO_MEDIUMITALIC59PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3F,
  0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0xFC, 0x1F,
  0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC,
  0x1F, 0xCF, 0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF0,
  0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xC1, 0xE0, 0x3E, 0x1F, 0x01,
  0xF0, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x1F, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07,
  0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0x80, 0x3F, 0x80, 0x03, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x04, 0x00, 0x03, 0xF8, 0x0E, 0x00, 0x1F, 0xF0, 0x3F,
  0xE3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x00, 0x3F, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0x00, 0xFC, 0x00, 0xFD,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x78, 0x03,
  0xE0, 0x01, 0xF0, 0x78, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x0F, 0x80, 0x03,
  0xE0, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0xF8, 0x3F, 0x00, 0x03, 0xC0, 0xF8,
  0x3E, 0x00, 0x03, 0xC0, 0xF0, 0x7C, 0x00, 0x03, 0xC1, 0xF0, 0xF8, 0x00,
  0x03, 0xC1, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE3, 0xE0, 0x00, 0x03, 0xF7,
  0xE7, 0xE0, 0x00, 0x01, 0xFF, 0xC7, 0xC0, 0x00, 0x01, 0xFF, 0x8F, 0x80,
  0x00, 0x00, 0xFF, 0x1F, 0x00, 0x00, 0x00, 0x18, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x10, 0x00, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x00, 0x01, 0xF1, 0xFF, 0x00, 0x00, 0x03, 0xE3, 0xFF, 0x80,
  0x00, 0x07, 0xC7, 0xFF, 0x80, 0x00, 0x0F, 0x8F, 0x87, 0x80, 0x00, 0x1F,
  0x0F, 0x87, 0xC0, 0x00, 0x3F, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x07,
  0xC0, 0x00, 0x7C, 0x1E, 0x07, 0x80, 0x00, 0xF8, 0x1E, 0x07, 0x80, 0x01,
  0xF0, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x07, 0xE0, 0x3E,
  0x0F, 0x80, 0x0F, 0xC0, 0x3E, 0x0F, 0x00, 0x0F, 0x80, 0x3E, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0xFE, 0x00, 0x7C, 0x00,
  0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03,
  0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xF8,
  0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x78, 0x07, 0xFE, 0x03, 0xF0,
  0x3F, 0xFC, 0x0F, 0x81, 0xFF, 0xF0, 0x3E, 0x0F, 0xCF, 0xE1, 0xF8, 0x7E,
  0x1F, 0xC7, 0xC3, 0xF0, 0x3F, 0x3F, 0x0F, 0xC0, 0xFE, 0xF8, 0x7E, 0x01,
  0xFF, 0xE1, 0xF8, 0x03, 0xFF, 0x0F, 0xC0, 0x0F, 0xFC, 0x3F, 0x00, 0x1F,
  0xE0, 0xFC, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xF8,
  0x3F, 0x80, 0x3F, 0xE0, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0xF3, 0xF8, 0x1F, 0xFF, 0x87, 0xE0, 0x3F,
  0xF8, 0x1F, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xE3, 0xF8, 0xFE,
  0x3F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x3F,
  0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x03, 0x01, 0xF0, 0x18, 0xF0, 0x7C,
  0x1E, 0x7F, 0x1F, 0x1F, 0x9F, 0xF7, 0x9F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x3F,
  0x80, 0x1F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0x7C,
  0x0F, 0xC0, 0x0F, 0x01, 0xC0, 0x00, 0x80, 0x20, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x07, 0xFC, 0x7F, 0xF0, 0xFF, 0xC1, 0xFE,
  0x01, 0xF0, 0x02, 0x00, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF9,
  0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x1F, 0x0F, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xC1, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x3F, 0x3F, 0x81, 0x01, 0xF9, 0xF8, 0x3E, 0x0F, 0xDF, 0xC3, 0xF0,
  0x7E, 0xFE, 0x3F, 0xC3, 0xF7, 0xE1, 0xFE, 0x3F, 0xBF, 0x0F, 0xF1, 0xFB,
  0xF8, 0x7F, 0x0F, 0xDF, 0xC3, 0xF8, 0x7E, 0xFE, 0x0F, 0x07, 0xF7, 0xE0,
  0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF0,
  0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFC,
  0x03, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3C, 0x1F, 0xC0, 0x18, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x3C, 0x00, 0x7F, 0x00, 0x70, 0x00, 0xFE,
  0x00, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x02,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0xFF, 0x00,
  0x18, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x81,
  0x00, 0x01, 0xFE, 0x07, 0xC0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x01,
  0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F,
  0x00, 0x0F, 0xC2, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x08,
  0x00, 0x0F, 0xF0, 0x0F, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x8F, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0xFE,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xE0,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFC, 0xFF, 0xC0, 0x0F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0xFE, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0xFE, 0x07, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x01, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x03,
  0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFE,
  0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xE0,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xC7, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x0E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x01, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0x00, 0x07, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0E, 0x00, 0xFF, 0x08, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x1F, 0x01, 0xFC, 0x00,
  0x0F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x3F, 0xF8, 0x7E, 0x00, 0xFF, 0xFC, 0x3F, 0x01,
  0xFF, 0xFE, 0x3F, 0x01, 0xFF, 0xFF, 0x1F, 0x81, 0xFF, 0xFF, 0x0F, 0xC1,
  0xFF, 0xBF, 0x8F, 0xC1, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x07, 0xE3, 0xF0,
  0xFC, 0x07, 0xE1, 0xF0, 0x7E, 0x03, 0xF0, 0xF8, 0x7E, 0x01, 0xF8, 0xFC,
  0x3F, 0x00, 0xFC, 0x7E, 0x1F, 0x80, 0x7C, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x07, 0xE0, 0x3F, 0x0F, 0x83, 0xE0, 0x1F, 0x87, 0xC1, 0xF0, 0x0F, 0x83,
  0xE0, 0xFC, 0x0F, 0xC1, 0xF0, 0x7E, 0x07, 0xE0, 0xF8, 0x3F, 0x03, 0xF0,
  0x7C, 0x1F, 0xC1, 0xF0, 0x3E, 0x07, 0xFF, 0xF8, 0x1F, 0x03, 0xFF, 0xFC,
  0x0F, 0xC0, 0xFF, 0xFE, 0x07, 0xE0, 0x3F, 0xFF, 0x03, 0xF0, 0x07, 0xFE,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x7F, 0x1F,
  0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7E, 0x03, 0xFF, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x03,
  0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x3F, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F,
  0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F,
  0x00, 0x07, 0xF8, 0x3F, 0x00, 0x1F, 0xF0, 0x7F, 0x00, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x3E, 0x01,
  0xFF, 0x00, 0x0C, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0x00, 0x3F, 0xE0, 0x1F, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x1F, 0xFC, 0x00,
  0xFC, 0x03, 0xFE, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x1F,
  0x80, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x3F,
  0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x7F, 0xC0, 0x7F, 0x00, 0xFF, 0xC0, 0x7F, 0x0F, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x7C, 0x01, 0xFF, 0x00, 0x08,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x3F, 0x80, 0x7F, 0xC0, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x10, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x08, 0x00, 0x3F, 0xC0, 0x0F,
  0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xFC, 0x3F,
  0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xBF, 0xC0, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x01, 0xEF,
  0x01, 0xEF, 0x80, 0x1F, 0x78, 0x1F, 0x78, 0x00, 0xFB, 0xE0, 0xF7, 0xC0,
  0x07, 0xDF, 0x0F, 0xBE, 0x00, 0x7C, 0xF8, 0x79, 0xF0, 0x03, 0xE7, 0xC7,
  0xCF, 0x80, 0x1F, 0x3E, 0x7C, 0xFC, 0x01, 0xF8, 0xF3, 0xC7, 0xC0, 0x0F,
  0x87, 0xBE, 0x3E, 0x00, 0x7C, 0x3D, 0xE1, 0xF0, 0x07, 0xE1, 0xFF, 0x0F,
  0x80, 0x3F, 0x0F, 0xF0, 0xFC, 0x01, 0xF0, 0x7F, 0x87, 0xE0, 0x0F, 0x83,
  0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0xC1, 0xF0, 0x07, 0xE0, 0xFC, 0x1F, 0x80,
  0x3E, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x07,
  0xE0, 0x0F, 0xF8, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x0F, 0xFC,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x1F, 0xFC, 0x00, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0x80, 0x1F, 0xBE, 0x01, 0xF8, 0x01, 0xF3, 0xE0, 0x1F,
  0x80, 0x3F, 0x3F, 0x01, 0xF8, 0x03, 0xF1, 0xF0, 0x1F, 0x80, 0x3F, 0x1F,
  0x03, 0xF0, 0x03, 0xE1, 0xF0, 0x3F, 0x00, 0x7E, 0x1F, 0x83, 0xF0, 0x07,
  0xE0, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0x87, 0xE0, 0x07, 0xE0, 0xF8, 0x7E,
  0x00, 0xFC, 0x0F, 0x87, 0xE0, 0x0F, 0xC0, 0x7C, 0x7E, 0x00, 0xFC, 0x07,
  0xCF, 0xC0, 0x0F, 0xC0, 0x7C, 0xFC, 0x00, 0xF8, 0x07, 0xCF, 0xC0, 0x1F,
  0x80, 0x7C, 0xFC, 0x01, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x80, 0x3F, 0xF8,
  0x01, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x3F, 0xF8, 0x03, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0x7E,
  0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xE0,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x7E, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0xFE, 0x7E, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x1F,
  0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x3F, 0xF8, 0x03, 0xF0, 0x03, 0xFC, 0x01,
  0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7E, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x7E, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0xFE, 0x7E, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F,
  0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x1F, 0xF8, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xE0,
  0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFF,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFC, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x08, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x01, 0x00, 0x00, 0x7F, 0x00, 0x60, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F,
  0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x01, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0xFC,
  0x1F, 0x03, 0xF0, 0x0F, 0x81, 0xF0, 0x3F, 0x00, 0xF8, 0x3F, 0x83, 0xE0,
  0x1F, 0x87, 0xF8, 0x3E, 0x01, 0xF8, 0x7F, 0x87, 0xE0, 0x1F, 0x0F, 0xF8,
  0x7E, 0x01, 0xF0, 0xF7, 0x87, 0xC0, 0x1F, 0x1F, 0x78, 0x7C, 0x01, 0xF1,
  0xE7, 0x8F, 0xC0, 0x3F, 0x3E, 0x78, 0xF8, 0x03, 0xE3, 0xC7, 0x8F, 0x80,
  0x3E, 0x7C, 0x78, 0xF8, 0x03, 0xE7, 0x87, 0x9F, 0x00, 0x3E, 0xF8, 0x79,
  0xF0, 0x07, 0xCF, 0x07, 0xDF, 0x00, 0x7D, 0xF0, 0x7D, 0xF0, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xF8,
  0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x08, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x0F,
  0xE3, 0xF8, 0x01, 0xFE, 0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xC1, 0xFE, 0x00, 0xFE, 0x1F,
  0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0x7E, 0x00, 0x03, 0xF1, 0xC0, 0x00, 0x3C, 0x08, 0x00, 0x03, 0x00,
  0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x08,
  0x00, 0xC0, 0x0F, 0x00, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7C, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0x81, 0xFF, 0x00,
  0xFC, 0x0F, 0xF0, 0x03, 0xF0, 0x7F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x0F,
  0xE0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xF9, 0xFC, 0x01, 0xFF, 0xC3, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC1, 0x00, 0x00, 0x7F, 0x7F, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC,
  0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x1F,
  0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xE0,
  0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x83, 0xF0, 0x03,
  0xFC, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x04, 0x03, 0xFE, 0x00,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x03, 0xF0, 0x07, 0xF0,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xF0,
  0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x3F, 0x80, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xCF, 0xC0, 0x01,
  0xFF, 0xC3, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00,
  0x7F, 0x0F, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7E,
  0x7F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x07, 0xF9, 0xF8,
  0x00, 0xFF, 0x8F, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x04, 0x0F, 0xF8, 0x01, 0xC0, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x04, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x40, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xF0,
  0x03, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x80,
  0x03, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x1F, 0x80, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xE7, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x10, 0x00, 0x1F, 0xE0, 0x03, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0xDF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE1, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F,
  0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7E, 0x07,
  0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0x7E,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x38, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x10, 0x00, 0xFE, 0x00, 0x0E, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x3F,
  0x00, 0xFF, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x07, 0xE1, 0xFE, 0x00, 0x03, 0xF1, 0xFE, 0x00, 0x03,
  0xF9, 0xFE, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xCF, 0xF0, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0xC0,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x07,
  0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F,
  0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x07, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0xFD, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x1F, 0x87, 0xF0, 0xFC, 0x0F, 0xC1, 0xF0, 0x7E, 0x07, 0xE0, 0xF8,
  0x3F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x7E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0,
  0x7F, 0xE0, 0x7F, 0x00, 0xFF, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F,
  0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83,
  0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F,
  0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87,
  0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x1F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x00,
  0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE,
  0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xFD, 0xFC,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x1F, 0x9F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7E,
  0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xF8, 0x7F,
  0x00, 0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x07,
  0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x1F, 0xC0,
  0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xF8, 0x07,
  0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xFC, 0x03, 0xF8, 0x1F, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xBC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x0F, 0xC1, 0xFF, 0x00, 0x7E, 0x0F,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xF8, 0x7F, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xF8, 0x00, 0x3F,
  0x1F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xDF, 0x80, 0x00, 0xF1, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x07,
  0x80, 0x7F, 0x00, 0x04, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x81, 0x80, 0x01, 0xFC, 0x0F, 0x00, 0x3F,
  0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x03, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFC,
  0x1F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC,
  0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x1F, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0x9F, 0x80, 0x3F, 0xF8, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xF8,
  0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x7E, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x03,
  0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F,
  0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x0F,
  0xDF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0,
  0xFC, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0x7E, 0x0F, 0x81, 0xF8, 0x1F,
  0x83, 0xE0, 0x7E, 0x07, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xE0,
  0xF8, 0x1F, 0x87, 0xF8, 0x3E, 0x07, 0xE1, 0xFE, 0x1F, 0x81, 0xF0, 0xFF,
  0x87, 0xC0, 0x7C, 0x3D, 0xF1, 0xF0, 0x1F, 0x1F, 0x7C, 0xFC, 0x07, 0xCF,
  0x9F, 0x3E, 0x01, 0xF3, 0xE7, 0xCF, 0x80, 0x7D, 0xF1, 0xF7, 0xC0, 0x1F,
  0x7C, 0x3D, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0,
  0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0xFF, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x00,
  0x7E, 0x3F, 0x80, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x80, 0x3F, 0xC0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x40, 0x1F, 0xF0, 0x01, 0xE0, 0xFF, 0xF0, 0x0F, 0xC7, 0xFF, 0xE0,
  0x3E, 0x3F, 0xFF, 0xE1, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xF1, 0xFF, 0xFF,
  0x1F, 0x03, 0xFF, 0xF8, 0xFC, 0x03, 0xFF, 0xC3, 0xE0, 0x07, 0xFE, 0x01,
  0x00, 0x07, 0xE0, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 17, 42, 33, 9, -41 },
  { 91, 21, 17, 33, 11, -45 },
  { 136, 35, 41, 33, 0, -41 },
  { 316, 31, 52, 33, 2, -46 },
  { 518, 40, 43, 33, -2, -42 },
  { 733, 30, 43, 33, 1, -42 },
  { 895, 10, 19, 33, 17, -45 },
  { 919, 25, 58, 33, 7, -47 },
  { 1101, 25, 58, 33, 1, -47 },
  { 1283, 26, 25, 33, 6, -41 },
  { 1365, 28, 29, 33, 3, -32 },
  { 1467, 15, 20, 33, 4, -10 },
  { 1505, 18, 6, 33, 8, -20 },
  { 1519, 10, 11, 33, 9, -10 },
  { 1533, 38, 57, 33, -3, -46 },
  { 1804, 29, 43, 33, 3, -42 },
  { 1960, 25, 41, 33, 3, -41 },
  { 2089, 31, 42, 33, 1, -42 },
  { 2252, 31, 43, 33, 1, -42 },
  { 2419, 32, 41, 33, 0, -41 },
  { 2583, 33, 42, 33, 1, -41 },
  { 2757, 31, 42, 33, 3, -41 },
  { 2920, 31, 41, 33, 6, -41 },
  { 3079, 31, 43, 33, 2, -42 },
  { 3246, 31, 42, 33, 2, -42 },
  { 3409, 15, 32, 33, 9, -31 },
  { 3469, 20, 41, 33, 4, -31 },
  { 3572, 29, 28, 33, 3, -31 },
  { 3674, 32, 18, 33, 1, -26 },
  { 3746, 30, 28, 33, 1, -31 },
  { 3851, 24, 43, 33, 8, -42 },
  { 3980, 33, 51, 33, 2, -42 },
  { 4191, 32, 41, 33, -3, -41 },
  { 4355, 32, 41, 33, 0, -41 },
  { 4519, 32, 43, 33, 3, -42 },
  { 4691, 32, 41, 33, 0, -41 },
  { 4855, 33, 41, 33, 2, -41 },
  { 5025, 34, 41, 33, 2, -41 },
  { 5200, 32, 43, 33, 3, -42 },
  { 5372, 36, 41, 33, 0, -41 },
  { 5557, 33, 41, 33, 1, -41 },
  { 5727, 33, 42, 33, 1, -41 },
  { 5901, 37, 41, 33, 0, -41 },
  { 6091, 25, 41, 33, 1, -41 },
  { 6220, 37, 41, 33, -2, -41 },
  { 6410, 36, 41, 33, 0, -41 },
  { 6595, 31, 43, 33, 2, -42 },
  { 6762, 33, 41, 33, 1, -41 },
  { 6932, 31, 53, 33, 2, -42 },
  { 7138, 33, 41, 33, 0, -41 },
  { 7308, 34, 43, 33, 0, -42 },
  { 7491, 30, 41, 33, 7, -41 },
  { 7645, 33, 42, 33, 3, -41 },
  { 7819, 32, 41, 33, 6, -41 },
  { 7983, 36, 41, 33, 1, -41 },
  { 8168, 40, 41, 33, -2, -41 },
  { 8373, 32, 41, 33, 7, -41 },
  { 8537, 35, 41, 33, 0, -41 },
  { 8717, 30, 57, 33, 4, -46 },
  { 8931, 11, 57, 33, 12, -46 },
  { 9010, 31, 57, 33, -1, -46 },
  { 9231, 28, 23, 33, 4, -41 },
  { 9312, 30, 6, 33, -4, 5 },
  { 9335, 13, 12, 33, 14, -46 },
  { 9355, 30, 33, 33, 2, -32 },
  { 9479, 30, 47, 33, 1, -46 },
  { 9656, 30, 33, 33, 2, -32 },
  { 9780, 34, 47, 33, 2, -46 },
  { 9980, 29, 33, 33, 2, -32 },
  { 10100, 40, 57, 33, -3, -46 },
  { 10385, 35, 43, 33, -2, -32 },
  { 10574, 30, 46, 33, 0, -46 },
  { 10747, 21, 46, 33, 6, -46 },
  { 10868, 33, 57, 33, -2, -46 },
  { 11104, 33, 46, 33, 1, -46 },
  { 11294, 19, 46, 33, 8, -45 },
  { 11404, 33, 31, 33, -1, -31 },
  { 11532, 29, 32, 33, 1, -32 },
  { 11648, 29, 33, 33, 2, -32 },
  { 11768, 33, 43, 33, -2, -32 },
  { 11946, 29, 43, 33, 3, -32 },
  { 12102, 29, 31, 33, 3, -31 },
  { 12215, 29, 33, 33, 2, -32 },
  { 12335, 26, 41, 33, 6, -40 },
  { 12469, 29, 32, 33, 3, -31 },
  { 12585, 27, 31, 33, 6, -31 },
  { 12690, 34, 31, 33, 2, -31 },
  { 12822, 36, 31, 33, -2, -31 },
  { 12962, 37, 42, 33, -4, -31 },
  { 13157, 31, 31, 33, 1, -31 },
  { 13278, 32, 57, 33, 4, -46 },
  { 13506, 20, 57, 33, 7, -46 },
  { 13649, 31, 57, 33, -2, -46 },
  { 13870, 30, 11, 33, 2, -23 },
};

const GFXfont UbuntuSansMono_MediumItalic59pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic59pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic59pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC59PT7B_H_
