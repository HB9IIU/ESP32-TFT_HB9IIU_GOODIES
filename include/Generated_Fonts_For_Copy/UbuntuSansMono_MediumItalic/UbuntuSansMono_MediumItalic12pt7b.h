#ifndef _UBUNTUSANSMONO_MEDIUMITALIC12PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0xA4, 0x36, 0x5A, 0xA4, 0x1A, 0x29, 0xF9, 0x66, 0x9F, 0x94,
  0x58, 0x08, 0x3C, 0x89, 0x03, 0x01, 0x83, 0x26, 0xF0, 0x40, 0x21, 0x52,
  0x54, 0x58, 0x70, 0x1C, 0x2C, 0x54, 0x9C, 0x08, 0xF2, 0x4A, 0x31, 0x5D,
  0xF2, 0x7C, 0x56, 0x0C, 0x42, 0x18, 0x41, 0x0C, 0x30, 0x41, 0x02, 0x00,
  0x10, 0xC2, 0x10, 0x84, 0x22, 0x33, 0x30, 0x33, 0xB3, 0x1E, 0x50, 0x11,
  0x89, 0xF2, 0x30, 0x6D, 0xC0, 0xE0, 0xF0, 0x03, 0x02, 0x04, 0x04, 0x08,
  0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x11, 0xE4, 0xE3, 0xAA, 0xA8, 0xA4,
  0xF0, 0x1B, 0xA4, 0x63, 0x10, 0x9F, 0x08, 0x78, 0x18, 0x20, 0xC3, 0x18,
  0x20, 0xFC, 0x08, 0xF0, 0x41, 0x38, 0x30, 0x43, 0xF8, 0x0E, 0x38, 0xD3,
  0x64, 0x9F, 0x82, 0x0C, 0x1E, 0x60, 0x81, 0xC0, 0xC1, 0x83, 0x7C, 0x3D,
  0x8C, 0x3E, 0x8A, 0x29, 0xBC, 0x7C, 0x21, 0x8C, 0x21, 0x84, 0x30, 0x08,
  0x7C, 0x99, 0x23, 0x8D, 0x91, 0x66, 0x78, 0x08, 0x79, 0x9A, 0x36, 0x67,
  0x83, 0x0C, 0xE0, 0x6C, 0x0D, 0x80, 0x33, 0x00, 0x66, 0x68, 0x0D, 0xC8,
  0x38, 0x38, 0x7E, 0x03, 0xF0, 0x60, 0xE0, 0x4E, 0xC0, 0x27, 0x86, 0x66,
  0x60, 0x10, 0xC0, 0x08, 0x7C, 0x8A, 0x75, 0x7E, 0xAD, 0x4E, 0x40, 0xC0,
  0xE0, 0x0C, 0x1C, 0x58, 0xB2, 0x67, 0xD1, 0xE3, 0x3C, 0x4D, 0x93, 0xC4,
  0x48, 0xB3, 0x7C, 0x08, 0xF4, 0x30, 0x82, 0x08, 0x20, 0xF8, 0x3C, 0xC9,
  0x9A, 0x24, 0x49, 0xB2, 0x78, 0x3E, 0x40, 0x83, 0xE6, 0x08, 0x10, 0x7E,
  0x3E, 0x40, 0x83, 0xE6, 0x08, 0x10, 0x60, 0x09, 0xF4, 0x20, 0x82, 0x28,
  0xA6, 0xF0, 0x22, 0xC5, 0x9B, 0xE4, 0x48, 0xB3, 0x44, 0x3E, 0x10, 0x60,
  0x81, 0x02, 0x0C, 0x7C, 0x1E, 0x0C, 0x10, 0x20, 0xC1, 0xA2, 0x7C, 0x26,
  0x59, 0xE3, 0x85, 0x0B, 0x32, 0x46, 0x31, 0x18, 0xC4, 0x21, 0x1F, 0x26,
  0x6D, 0x6A, 0xF5, 0x58, 0xA1, 0x46, 0x22, 0x65, 0x5A, 0xA5, 0x49, 0xB3,
  0x44, 0x08, 0x78, 0x9A, 0x34, 0x68, 0xB1, 0x26, 0x78, 0x3C, 0x4D, 0x9B,
  0x27, 0x88, 0x30, 0x60, 0x08, 0x78, 0x9A, 0x34, 0x68, 0xB1, 0x26, 0x78,
  0x40, 0x60, 0x3C, 0x4D, 0x9A, 0x67, 0x89, 0x32, 0x46, 0x08, 0x7C, 0x81,
  0x03, 0x81, 0x83, 0x46, 0xF8, 0xFC, 0xC3, 0x08, 0x20, 0x86, 0x10, 0x47,
  0x3C, 0xE2, 0x8A, 0x29, 0xBC, 0xC7, 0x8B, 0x26, 0x45, 0x0A, 0x18, 0x30,
  0x63, 0x42, 0x42, 0x56, 0x6C, 0x6C, 0xCC, 0xC8, 0x23, 0x34, 0x1C, 0x18,
  0x38, 0x28, 0x4C, 0xCC, 0xC6, 0x99, 0x23, 0x82, 0x04, 0x18, 0x20, 0x3E,
  0x08, 0x20, 0x83, 0x0C, 0x10, 0x7E, 0x3C, 0x82, 0x08, 0x61, 0x04, 0x10,
  0xC2, 0x0E, 0x00, 0xC9, 0x24, 0x92, 0x4D, 0x80, 0x3C, 0x30, 0x82, 0x08,
  0x61, 0x04, 0x10, 0xCE, 0x00, 0x30, 0xE4, 0xA3, 0xFC, 0x90, 0x3D, 0x94,
  0x73, 0xC9, 0xF0, 0x30, 0x82, 0x1F, 0x65, 0x14, 0x53, 0xF0, 0x3D, 0x84,
  0x30, 0x41, 0xE0, 0x02, 0x04, 0x19, 0xE6, 0x48, 0xB3, 0x26, 0x7C, 0x3D,
  0x14, 0xFC, 0x41, 0xE0, 0x07, 0x86, 0x02, 0x07, 0xE0, 0x80, 0xC0, 0x60,
  0x20, 0x10, 0x18, 0x38, 0x00, 0x3E, 0xC9, 0x12, 0x64, 0xC7, 0x02, 0x78,
  0x30, 0x82, 0x1F, 0x65, 0x14, 0xF2, 0xC8, 0x32, 0x1E, 0x22, 0x66, 0x30,
  0x0C, 0x10, 0x0F, 0x08, 0x20, 0x86, 0x10, 0x4F, 0x00, 0x30, 0x40, 0x89,
  0x27, 0x8E, 0x14, 0x24, 0xCC, 0xE6, 0x44, 0x4C, 0x88, 0xF0, 0x7E, 0xA9,
  0x56, 0xA8, 0x51, 0x80, 0x3D, 0x94, 0x53, 0x4F, 0x20, 0x3D, 0x94, 0x71,
  0x4D, 0xE0, 0x7D, 0x94, 0x51, 0x4F, 0xE8, 0x20, 0x7F, 0x28, 0xA6, 0x93,
  0xC1, 0x0C, 0x7D, 0x0C, 0x30, 0x82, 0x00, 0x3C, 0x83, 0x02, 0x0F, 0xE0,
  0x31, 0x3E, 0xC4, 0x21, 0x0F, 0xCC, 0x67, 0x39, 0x7C, 0xCF, 0x2D, 0xB4,
  0x61, 0x80, 0x42, 0xA5, 0x53, 0xA6, 0xD9, 0x00, 0x66, 0x50, 0x61, 0xC6,
  0x99, 0x80, 0x33, 0x32, 0x36, 0x14, 0x1C, 0x18, 0x10, 0xE0, 0x3C, 0x21,
  0x08, 0x43, 0xE0, 0x1C, 0xC2, 0x08, 0x63, 0x04, 0x10, 0x43, 0x07, 0x00,
  0x18, 0x8C, 0x62, 0x10, 0x8C, 0x42, 0x30, 0x38, 0x20, 0x82, 0x18, 0x31,
  0x04, 0x30, 0x8E, 0x00, 0x26, 0xFB, 0x20,
};

const GFXglyph UbuntuSansMono_MediumItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 8, 7, 2, -8 },
  { 4, 5, 3, 7, 2, -9 },
  { 6, 7, 8, 7, 0, -8 },
  { 13, 7, 10, 7, 0, -9 },
  { 22, 8, 9, 7, 0, -9 },
  { 31, 6, 9, 7, 0, -9 },
  { 38, 2, 4, 7, 3, -9 },
  { 39, 6, 11, 7, 1, -9 },
  { 48, 5, 11, 7, 0, -9 },
  { 55, 6, 5, 7, 1, -8 },
  { 59, 5, 6, 7, 1, -7 },
  { 63, 3, 4, 7, 1, -2 },
  { 65, 3, 1, 7, 2, -4 },
  { 66, 2, 2, 7, 2, -2 },
  { 67, 8, 11, 7, -1, -9 },
  { 78, 6, 9, 7, 1, -9 },
  { 85, 5, 8, 7, 1, -8 },
  { 90, 7, 9, 7, 0, -9 },
  { 98, 6, 9, 7, 0, -9 },
  { 105, 7, 8, 7, 0, -8 },
  { 112, 7, 8, 7, 0, -8 },
  { 119, 6, 8, 7, 1, -8 },
  { 125, 6, 8, 7, 1, -8 },
  { 131, 7, 9, 7, 0, -9 },
  { 139, 7, 9, 7, 0, -9 },
  { 147, 3, 6, 7, 2, -6 },
  { 150, 4, 8, 7, 1, -6 },
  { 154, 6, 5, 7, 1, -6 },
  { 158, 7, 3, 7, 0, -5 },
  { 161, 6, 5, 7, 0, -6 },
  { 165, 5, 9, 7, 2, -9 },
  { 171, 7, 11, 7, 0, -9 },
  { 181, 7, 8, 7, -1, -8 },
  { 188, 7, 8, 7, 0, -8 },
  { 195, 6, 9, 7, 1, -9 },
  { 202, 7, 8, 7, 0, -8 },
  { 209, 7, 8, 7, 0, -8 },
  { 216, 7, 8, 7, 0, -8 },
  { 223, 6, 9, 7, 1, -9 },
  { 230, 7, 8, 7, 0, -8 },
  { 237, 7, 8, 7, 0, -8 },
  { 244, 7, 8, 7, 0, -8 },
  { 251, 7, 8, 7, 0, -8 },
  { 258, 5, 8, 7, 0, -8 },
  { 263, 7, 8, 7, 0, -8 },
  { 270, 7, 8, 7, 0, -8 },
  { 277, 7, 9, 7, 0, -9 },
  { 285, 7, 8, 7, 0, -8 },
  { 292, 7, 11, 7, 0, -9 },
  { 302, 7, 8, 7, 0, -8 },
  { 309, 7, 9, 7, 0, -9 },
  { 317, 6, 8, 7, 1, -8 },
  { 323, 6, 8, 7, 1, -8 },
  { 329, 7, 8, 7, 1, -8 },
  { 336, 8, 8, 7, 0, -8 },
  { 344, 8, 8, 7, 0, -8 },
  { 352, 7, 8, 7, 1, -8 },
  { 359, 7, 8, 7, 0, -8 },
  { 366, 6, 11, 7, 1, -9 },
  { 375, 3, 11, 7, 2, -9 },
  { 380, 6, 11, 7, 0, -9 },
  { 389, 6, 4, 7, 1, -8 },
  { 392, 6, 1, 7, -1, 1 },
  { 393, 2, 2, 7, 3, -9 },
  { 394, 6, 6, 7, 0, -6 },
  { 399, 6, 9, 7, 0, -9 },
  { 406, 6, 6, 7, 0, -6 },
  { 411, 7, 9, 7, 0, -9 },
  { 419, 6, 6, 7, 0, -6 },
  { 424, 9, 11, 7, -1, -9 },
  { 437, 7, 8, 7, 0, -6 },
  { 444, 6, 9, 7, 0, -9 },
  { 451, 4, 9, 7, 1, -9 },
  { 456, 6, 11, 7, 0, -9 },
  { 465, 7, 9, 7, 0, -9 },
  { 473, 4, 9, 7, 2, -9 },
  { 478, 7, 6, 7, 0, -6 },
  { 484, 6, 6, 7, 0, -6 },
  { 489, 6, 6, 7, 0, -6 },
  { 494, 6, 8, 7, 0, -6 },
  { 500, 6, 8, 7, 1, -6 },
  { 506, 6, 6, 7, 1, -6 },
  { 511, 6, 6, 7, 0, -6 },
  { 516, 5, 8, 7, 1, -8 },
  { 521, 5, 6, 7, 1, -6 },
  { 525, 6, 6, 7, 1, -6 },
  { 530, 7, 6, 7, 0, -6 },
  { 536, 7, 6, 7, 0, -6 },
  { 542, 8, 8, 7, -1, -6 },
  { 550, 6, 6, 7, 0, -6 },
  { 555, 6, 11, 7, 1, -9 },
  { 564, 5, 11, 7, 1, -9 },
  { 571, 6, 11, 7, 0, -9 },
  { 580, 7, 3, 7, 0, -5 },
};

const GFXfont UbuntuSansMono_MediumItalic12pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic12pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC12PT7B_H_
