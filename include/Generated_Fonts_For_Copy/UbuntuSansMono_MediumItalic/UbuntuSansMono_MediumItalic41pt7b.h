#ifndef _UBUNTUSANSMONO_MEDIUMITALIC41PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x07, 0xC0, 0x30, 0x00, 0x3C, 0x3D, 0xF0,
  0xF7, 0xC7, 0xDE, 0x1F, 0x78, 0x79, 0xE1, 0xEF, 0x07, 0xBC, 0x3C, 0xF0,
  0xF3, 0x83, 0xCE, 0x0E, 0x38, 0x38, 0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x0E,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x3C,
  0x00, 0x78, 0x78, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x01, 0xE1, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC3, 0xC0,
  0x03, 0xC3, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x87, 0x80, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x1E, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xF8, 0xF8, 0x1F, 0x00, 0x40, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x83, 0x00, 0x7C, 0x1F, 0x9F, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x10, 0x0F, 0xC0, 0x0E, 0x01, 0xFE, 0x01, 0xE0, 0x3C, 0xE0, 0x3C, 0x03,
  0x8E, 0x07, 0x80, 0x70, 0xE0, 0xF0, 0x07, 0x0E, 0x0E, 0x00, 0x70, 0xE1,
  0xC0, 0x07, 0x0E, 0x38, 0x00, 0x71, 0xC7, 0x80, 0x07, 0x1C, 0xF0, 0x00,
  0x7F, 0x9E, 0x00, 0x07, 0xFB, 0xC0, 0x00, 0x3E, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF1, 0x80, 0x00, 0x1E, 0x7E, 0x00, 0x03, 0xCF, 0xE0,
  0x00, 0x79, 0xEF, 0x00, 0x07, 0x3C, 0x70, 0x00, 0xE3, 0x87, 0x00, 0x1C,
  0x38, 0x70, 0x03, 0xC3, 0x87, 0x00, 0x78, 0x78, 0xF0, 0x0F, 0x07, 0x0E,
  0x01, 0xE0, 0x78, 0xE0, 0x1C, 0x03, 0x9C, 0x03, 0x80, 0x3F, 0xC0, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0x7E, 0x03, 0xC1, 0xE0, 0x7C, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x07, 0x8F, 0x80, 0x7F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x70, 0xFF, 0x0F, 0x1E, 0xF8,
  0xF3, 0xC7, 0x8E, 0x78, 0x7D, 0xEF, 0x83, 0xFC, 0xF0, 0x1F, 0xCF, 0x01,
  0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF8, 0x1F, 0x8F, 0xC7, 0xFC, 0xFF,
  0xFB, 0xC7, 0xFF, 0x3C, 0x3F, 0xC3, 0xE0, 0x3D, 0xF7, 0xDF, 0x7B, 0xEF,
  0xBC, 0xF3, 0xCE, 0x38, 0xE0, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x08, 0x00, 0x00,
  0x30, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0x80, 0x00, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x07, 0x0E, 0x18,
  0xF9, 0xCF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFF, 0x1F, 0xFF, 0x00, 0x3E, 0x00,
  0x0F, 0xE0, 0x03, 0xDE, 0x00, 0xFB, 0xE0, 0x3E, 0x3E, 0x0F, 0xC7, 0xC0,
  0x70, 0x70, 0x04, 0x08, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x83, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF0, 0xFC, 0x0F, 0x07, 0x83, 0xEF, 0xF3, 0xF8, 0xF8, 0x30,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0x08, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7E,
  0x1F, 0x07, 0xC0, 0x78, 0x3E, 0x03, 0xC3, 0xE0, 0x1F, 0x1E, 0x00, 0xF9,
  0xF0, 0x07, 0xCF, 0x00, 0x3C, 0xF8, 0x61, 0xE7, 0xCF, 0x8F, 0x3C, 0x7C,
  0x79, 0xE3, 0xE3, 0xDF, 0x1F, 0x3E, 0xF8, 0xF1, 0xE7, 0xC0, 0x0F, 0x3C,
  0x00, 0xF9, 0xE0, 0x07, 0xCF, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xC0, 0x3E,
  0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x03, 0xF3, 0xF0, 0x1F, 0xFF, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF8, 0x3F, 0x7C, 0x1F, 0x3E,
  0x0E, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x7F, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3C, 0x0F, 0x81, 0x80, 0x7C, 0x08,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0xC0, 0xFC, 0x04, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x20, 0x07, 0xE1, 0xF0, 0x7F, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7D, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x3C, 0x00, 0xF8, 0xF0,
  0x03, 0xC3, 0xC0, 0x1E, 0x1F, 0x00, 0xF0, 0x78, 0x07, 0x81, 0xE0, 0x3C,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF8, 0x3C, 0x03, 0xC1, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x20, 0x07, 0xE0, 0x7E, 0x3F, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x87, 0x00, 0x3D, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x1F, 0x81, 0xF8, 0x78, 0x03, 0xE3, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x3E,
  0x00, 0x78, 0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x1E, 0x01,
  0xF0, 0x7C, 0x0F, 0xC1, 0xF8, 0x7E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7C, 0x0F, 0x87, 0xC0, 0x7C,
  0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0x83, 0xC0,
  0x7C, 0x1F, 0x07, 0xC0, 0x7E, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01,
  0xFF, 0xE0, 0x1F, 0x1F, 0x81, 0xF0, 0x7E, 0x1E, 0x01, 0xF1, 0xF0, 0x07,
  0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF8,
  0x0F, 0xC7, 0xE0, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xC0, 0xF8, 0x3E, 0x01, 0xE0, 0xF0, 0x07, 0xC7, 0xC0,
  0x1F, 0x1F, 0x00, 0x7C, 0x78, 0x01, 0xF1, 0xE0, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x07, 0xF7, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0x81, 0xF8, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0x83, 0xE0, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xF0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x07, 0xC0, 0x20, 0x00, 0x00, 0x70, 0x07, 0xE0, 0x1F, 0xC0,
  0x7F, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0,
  0xFF, 0x03, 0xF8, 0x0F, 0x80, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0x70, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0E, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFF,
  0x10, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xF0, 0x0F, 0xF7, 0xE0, 0x3E, 0x03, 0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0x07,
  0x87, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3C, 0x07, 0xFC, 0xF0, 0x3F, 0xF9,
  0xE1, 0xFF, 0xE3, 0xC7, 0xFF, 0xCF, 0x0F, 0x87, 0x9E, 0x3E, 0x1F, 0x3C,
  0x78, 0x3C, 0x78, 0xF0, 0x79, 0xE3, 0xC0, 0xF3, 0xC7, 0x83, 0xE7, 0x8F,
  0x07, 0x8F, 0x1E, 0x0F, 0x1E, 0x3C, 0x1E, 0x3C, 0x7C, 0x3C, 0x78, 0x7C,
  0xF0, 0xF0, 0xFF, 0xE1, 0xE0, 0xFF, 0xC1, 0xE0, 0xFF, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE1, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0x78, 0x00,
  0x7D, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x01, 0xE1,
  0xE0, 0x07, 0x87, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0x81, 0xE0,
  0x1E, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xC0, 0x7C, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x78, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x3C, 0x0F, 0xC0, 0x78, 0x07, 0x81, 0xF0, 0x0F, 0x83, 0xE0,
  0x1E, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x7C, 0x0F,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x1F, 0x03, 0xF0, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xE1, 0xF0, 0x07, 0xC3,
  0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x7C,
  0x07, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0x03, 0x80, 0xFC, 0x01, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x01, 0x80, 0x7F, 0x9F, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xC3, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07,
  0xC1, 0xE0, 0x1F, 0x07, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xF8, 0x03, 0xC3,
  0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x7C, 0x00, 0xF1, 0xF0, 0x07, 0xC7, 0xC0,
  0x1F, 0x1E, 0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E,
  0x3C, 0x01, 0xF0, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E, 0x1F, 0x03, 0xF8, 0x78,
  0x1F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xF0, 0x38,
  0x3F, 0x00, 0x20, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x01, 0x3E, 0x00, 0x78, 0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0x8F,
  0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xE0, 0x1F, 0x0F, 0x80,
  0x7C, 0x3F, 0x01, 0xE0, 0x7C, 0x07, 0x81, 0xFE, 0x7E, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x03, 0xE0, 0x0F,
  0x81, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x03, 0xE0, 0x7C, 0x01,
  0xF0, 0x3E, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x7C, 0x0F, 0x80,
  0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x0F, 0x01, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3C, 0x00, 0xF0, 0x3E,
  0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3C, 0x07, 0x80, 0x1E, 0x03,
  0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0,
  0x78, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF0, 0x1E, 0x00, 0x78,
  0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF,
  0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x08, 0x03, 0xE0, 0x38, 0x0F, 0xC0, 0x7C, 0xFF, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x58, 0x00, 0x00, 0x01, 0xE0,
  0x1F, 0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x03,
  0xC0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x00,
  0x07, 0x8F, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0xF8, 0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x01, 0xE0, 0x07, 0xC0, 0x7C,
  0x01, 0xF0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0,
  0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0xC1, 0xF8,
  0x0F, 0xE1, 0xDC, 0x07, 0x70, 0xEE, 0x03, 0xB8, 0xEF, 0x03, 0xDC, 0x77,
  0x81, 0xEE, 0x73, 0xC0, 0xE7, 0x39, 0xC0, 0xF1, 0xF8, 0xE0, 0x78, 0xFC,
  0xF0, 0x3C, 0x7C, 0x78, 0x3C, 0x3E, 0x3C, 0x1E, 0x1E, 0x1E, 0x0F, 0x0E,
  0x1E, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0,
  0x03, 0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x07,
  0x81, 0xF0, 0x07, 0xC0, 0xFC, 0x03, 0xC0, 0x7E, 0x01, 0xE0, 0x3F, 0x00,
  0xF0, 0x3F, 0xC0, 0xF8, 0x1F, 0xE0, 0x78, 0x0F, 0x70, 0x3C, 0x07, 0xB8,
  0x1E, 0x07, 0x9E, 0x0F, 0x03, 0xCF, 0x0F, 0x01, 0xE3, 0x87, 0x80, 0xF1,
  0xC3, 0xC0, 0xF0, 0xF1, 0xE0, 0x78, 0x79, 0xE0, 0x3C, 0x1C, 0xF0, 0x1E,
  0x0E, 0x78, 0x1E, 0x07, 0xBC, 0x0F, 0x03, 0xFC, 0x07, 0x81, 0xFE, 0x03,
  0xC0, 0x7F, 0x03, 0xC0, 0x3F, 0x81, 0xE0, 0x1F, 0x80, 0xF0, 0x0F, 0xC0,
  0x78, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x78,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0,
  0x7C, 0x1F, 0x07, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x3E, 0x00,
  0x79, 0xF0, 0x03, 0xCF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0x80, 0x0F, 0xBC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1E, 0xF8, 0x01, 0xF7, 0x80, 0x0F,
  0xBC, 0x00, 0x79, 0xE0, 0x07, 0xCF, 0x00, 0x3E, 0x78, 0x01, 0xE3, 0xC0,
  0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x83, 0xF3, 0xF8, 0x1F, 0xFF, 0x80,
  0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3E, 0x0F, 0xE0, 0x7C,
  0x07, 0xC0, 0xF0, 0x0F, 0x81, 0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x80,
  0x3C, 0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F,
  0x83, 0xC0, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0x7C,
  0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x3E, 0x00, 0x79, 0xF0, 0x03, 0xCF, 0x00,
  0x3E, 0xF8, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x7F, 0xE0, 0x03, 0xDF,
  0x00, 0x1E, 0xF8, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x79, 0xE0, 0x07,
  0xCF, 0x00, 0x3E, 0x78, 0x01, 0xE3, 0xC0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8,
  0x1F, 0x83, 0xF3, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F,
  0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3C, 0x0F,
  0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E,
  0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x81,
  0xE0, 0x3F, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0xF8, 0x07, 0x80,
  0xF0, 0x0F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0xF0, 0x07,
  0xC1, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x01,
  0xC0, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x30, 0x03, 0xE0, 0xFC, 0x7F,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x18, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x78, 0x3C, 0x00, 0xF0,
  0x78, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x0F,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0,
  0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x01,
  0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x07, 0x80, 0x3E,
  0x0F, 0x00, 0x7C, 0x1E, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0xC0,
  0xFE, 0x7F, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7D, 0xE0,
  0x03, 0xEF, 0x00, 0x3E, 0x78, 0x01, 0xF3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8,
  0xF0, 0x07, 0x87, 0x80, 0x7C, 0x3C, 0x03, 0xC1, 0xE0, 0x3E, 0x0F, 0x01,
  0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x1E, 0x0F, 0x80, 0xF8, 0x78, 0x07,
  0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF3, 0xC0, 0x0F, 0x9E, 0x00, 0x3D, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x87, 0x80, 0x07, 0x83,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0xF0,
  0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x1E,
  0x0F, 0x0F, 0x0F, 0x07, 0x87, 0x87, 0x83, 0xC7, 0xC7, 0x81, 0xE7, 0xE3,
  0xC0, 0xE3, 0xF1, 0xE0, 0xF3, 0xF8, 0xE0, 0x79, 0xDC, 0xF0, 0x3D, 0xCE,
  0x78, 0x1C, 0xE3, 0xBC, 0x0E, 0xE1, 0xDC, 0x07, 0x70, 0xFE, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x03,
  0xE0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0x80, 0x07,
  0x81, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x3E, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xCF,
  0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xEF, 0x80, 0x1F, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xE1, 0xE0, 0x1F,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x1F, 0x00, 0xF0, 0xF8, 0x03,
  0xE3, 0xC0, 0x0F, 0x9F, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xDF, 0x01, 0xF1,
  0xE0, 0x7C, 0x3C, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0xF8, 0x0F, 0x3E, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xCC, 0x00, 0x70, 0x00, 0x08, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x20, 0x18, 0x1E,
  0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0E, 0x02, 0x00, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFE, 0x0F, 0x0F, 0xC0, 0x78,
  0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00,
  0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0x78, 0x07, 0xC3, 0xE0, 0x7E, 0x1F, 0x8F, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xBC, 0x0F, 0xF1, 0xE0, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x9F, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xC3, 0xF1, 0xF0, 0x1F, 0x1F, 0x00,
  0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xE0,
  0x1F, 0x3C, 0x01, 0xF3, 0xC0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x78,
  0x07, 0xC7, 0x81, 0xF8, 0xFC, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x00, 0x03, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x1F, 0xC0, 0x63, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x08, 0x7F, 0xDF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xF0, 0x7C, 0x0F, 0x80, 0xF0, 0x3E, 0x01,
  0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x1E, 0x0F, 0x80, 0x3C,
  0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81,
  0xE0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0xE7, 0xF8, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFD, 0xE0, 0x0F, 0xF3, 0xE0, 0x00, 0x7F, 0x00, 0x1F,
  0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x81, 0xF3, 0xE0, 0x1F, 0x3C,
  0x01, 0xF7, 0xC0, 0x1F, 0x78, 0x03, 0xEF, 0x80, 0x7E, 0xF1, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFE, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x08, 0x7F, 0x0F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0xFF, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF0, 0x40,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x04, 0x7E, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFE, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x3C, 0x07,
  0x80, 0x3C, 0x0F, 0x80, 0x7C, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x1F,
  0x00, 0x78, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x1F,
  0x00, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x01, 0xF1, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x40, 0x0F, 0x80, 0x78, 0x3F, 0x80, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF7,
  0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x78, 0x07, 0xC3, 0xC0, 0x3C, 0x3E, 0x01,
  0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x3C, 0x3E,
  0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0xC0, 0x3C,
  0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0x00, 0x70, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x04, 0x03, 0xE0, 0x1E, 0x1F, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x08, 0x3C, 0x07, 0xE0, 0x78, 0x1F, 0x81, 0xF0, 0x7E, 0x03, 0xE1,
  0xF8, 0x07, 0xC7, 0xE0, 0x0F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xBE, 0x00,
  0x1F, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xF0, 0x7F, 0xE7, 0xFF, 0x3F, 0xF9, 0xFF, 0xC0, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x17,
  0xF7, 0xBF, 0xFC, 0xFF, 0xE3, 0xFE, 0x01, 0xF0, 0x70, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0x1E, 0x3C, 0x78, 0x78, 0xF1, 0xE1,
  0xE3, 0xC7, 0x87, 0x0F, 0x1E, 0x3C, 0x3C, 0x70, 0xF1, 0xE3, 0xC3, 0xC7,
  0x8F, 0x0E, 0x1E, 0x3C, 0x78, 0x78, 0xE1, 0xE1, 0xE7, 0x80, 0x0F, 0x1E,
  0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x83, 0xF0, 0xF0, 0x1F, 0x0F, 0x01,
  0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xE3, 0xE0,
  0x1E, 0x3E, 0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xE7, 0xC0, 0x3C, 0x7C,
  0x07, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x07, 0x8F,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF1,
  0xF8, 0x7E, 0x7E, 0x07, 0xCF, 0x80, 0x7B, 0xE0, 0x0F, 0x7C, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xF7, 0x80, 0x3E, 0xF8, 0x0F, 0x9F, 0x03, 0xF3, 0xFF, 0xFC, 0x3F,
  0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3C, 0x0F, 0xC0,
  0x78, 0x0F, 0x81, 0xF0, 0x0F, 0x03, 0xE0, 0x1F, 0x07, 0x80, 0x3E, 0x0F,
  0x00, 0x78, 0x3E, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xE0,
  0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x1E, 0x03, 0xF0, 0x3C, 0x0F,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFC,
  0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3,
  0xC0, 0x1F, 0x3E, 0x00, 0xF1, 0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0x78, 0x03,
  0xE3, 0xC0, 0x1E, 0x1E, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3F,
  0x9F, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xE8, 0x1F, 0xFF,
  0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFE, 0x06, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xC0, 0x60, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC2,
  0x00, 0x7C, 0x7C, 0x3F, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0,
  0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x08, 0x3F, 0xBE, 0x0F,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x3E,
  0x01, 0xE3, 0xE0, 0x1E, 0x3E, 0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xC7,
  0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0xCF, 0x80, 0x78,
  0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F,
  0x0F, 0xEF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0x78, 0x3F, 0xC7, 0x80, 0xF8,
  0x03, 0xFF, 0x00, 0x7B, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xF9, 0xF0,
  0x1F, 0x3E, 0x03, 0xC7, 0xC0, 0xF8, 0x78, 0x1E, 0x0F, 0x07, 0xC1, 0xE1,
  0xF0, 0x3C, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x1F, 0x7C, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01,
  0xE7, 0x87, 0x87, 0x8E, 0x0F, 0x0F, 0x3C, 0x3E, 0x1C, 0x78, 0x7C, 0x78,
  0xF1, 0xF8, 0xF1, 0xE3, 0xF1, 0xC3, 0xCF, 0xE7, 0x87, 0x9D, 0xCF, 0x0F,
  0x7B, 0x9C, 0x1C, 0xE7, 0x78, 0x3B, 0x8E, 0xE0, 0x7F, 0x1F, 0xC0, 0xFC,
  0x3F, 0x81, 0xF8, 0x7E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x0F, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x01,
  0xF0, 0xF8, 0x01, 0xF1, 0xF0, 0x00, 0xF9, 0xE0, 0x00, 0xFB, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xE7, 0xC0, 0x07,
  0xC7, 0xC0, 0x0F, 0x83, 0xE0, 0x1F, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x7E,
  0x01, 0xF0, 0xFC, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x3C, 0x07,
  0xC0, 0x0F, 0x01, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF8, 0x00,
  0x1E, 0x3C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x41,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x10, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0x80, 0x20, 0x7F, 0x01, 0xCF, 0xFC, 0x1E, 0x7F, 0xFF,
  0xE7, 0xCF, 0xFF, 0x38, 0x3F, 0xF3, 0xC0, 0x7F, 0x00, 0x00, 0xC0,
};

const GFXglyph UbuntuSansMono_MediumItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 12, 29, 23, 6, -28 },
  { 45, 14, 12, 23, 8, -31 },
  { 66, 24, 28, 23, 0, -28 },
  { 150, 22, 36, 23, 1, -32 },
  { 249, 28, 30, 23, -2, -29 },
  { 354, 20, 29, 23, 1, -29 },
  { 427, 6, 13, 23, 12, -31 },
  { 437, 18, 40, 23, 5, -32 },
  { 527, 17, 40, 23, 1, -32 },
  { 612, 19, 17, 23, 4, -28 },
  { 653, 20, 20, 23, 2, -22 },
  { 703, 10, 14, 23, 3, -7 },
  { 721, 12, 4, 23, 6, -14 },
  { 727, 7, 8, 23, 6, -7 },
  { 734, 26, 40, 23, -2, -32 },
  { 864, 21, 30, 23, 2, -29 },
  { 943, 17, 28, 23, 2, -28 },
  { 1003, 21, 29, 23, 1, -29 },
  { 1080, 22, 30, 23, 0, -29 },
  { 1163, 22, 28, 23, 0, -28 },
  { 1240, 24, 29, 23, 0, -28 },
  { 1327, 22, 30, 23, 2, -29 },
  { 1410, 21, 28, 23, 4, -28 },
  { 1484, 21, 30, 23, 2, -29 },
  { 1563, 22, 29, 23, 1, -29 },
  { 1643, 11, 22, 23, 6, -21 },
  { 1674, 14, 28, 23, 3, -21 },
  { 1723, 20, 19, 23, 2, -21 },
  { 1771, 22, 12, 23, 1, -18 },
  { 1804, 20, 19, 23, 1, -21 },
  { 1852, 16, 30, 23, 6, -29 },
  { 1912, 23, 35, 23, 1, -29 },
  { 2013, 22, 28, 23, -2, -28 },
  { 2090, 23, 29, 23, 0, -29 },
  { 2174, 23, 30, 23, 2, -29 },
  { 2261, 22, 29, 23, 0, -29 },
  { 2341, 23, 28, 23, 1, -28 },
  { 2422, 24, 28, 23, 1, -28 },
  { 2506, 22, 30, 23, 2, -29 },
  { 2589, 25, 28, 23, 0, -28 },
  { 2677, 23, 28, 23, 1, -28 },
  { 2758, 23, 29, 23, 1, -28 },
  { 2842, 26, 28, 23, 0, -28 },
  { 2933, 17, 28, 23, 1, -28 },
  { 2993, 25, 28, 23, -1, -28 },
  { 3081, 25, 28, 23, 0, -28 },
  { 3169, 21, 30, 23, 2, -29 },
  { 3248, 23, 29, 23, 0, -29 },
  { 3332, 21, 37, 23, 2, -29 },
  { 3430, 23, 29, 23, 0, -29 },
  { 3514, 23, 30, 23, 0, -29 },
  { 3601, 21, 28, 23, 5, -28 },
  { 3675, 23, 29, 23, 2, -28 },
  { 3759, 21, 28, 23, 5, -28 },
  { 3833, 25, 28, 23, 1, -28 },
  { 3921, 27, 28, 23, -1, -28 },
  { 4016, 22, 28, 23, 5, -28 },
  { 4093, 25, 28, 23, 0, -28 },
  { 4181, 21, 40, 23, 3, -32 },
  { 4286, 8, 40, 23, 8, -32 },
  { 4326, 22, 40, 23, -1, -32 },
  { 4436, 19, 16, 23, 3, -28 },
  { 4474, 21, 4, 23, -3, 4 },
  { 4485, 9, 9, 23, 10, -32 },
  { 4496, 21, 22, 23, 1, -22 },
  { 4554, 20, 33, 23, 1, -32 },
  { 4637, 20, 22, 23, 2, -22 },
  { 4692, 23, 32, 23, 2, -32 },
  { 4784, 20, 23, 23, 2, -22 },
  { 4842, 28, 40, 23, -2, -32 },
  { 4982, 24, 30, 23, -1, -22 },
  { 5072, 21, 32, 23, 0, -32 },
  { 5156, 14, 32, 23, 4, -32 },
  { 5212, 22, 40, 23, -1, -32 },
  { 5322, 23, 32, 23, 1, -32 },
  { 5414, 13, 32, 23, 6, -32 },
  { 5466, 22, 22, 23, 0, -22 },
  { 5527, 20, 22, 23, 1, -22 },
  { 5582, 19, 23, 23, 2, -22 },
  { 5637, 23, 30, 23, -1, -22 },
  { 5724, 21, 30, 23, 2, -22 },
  { 5803, 21, 22, 23, 2, -22 },
  { 5861, 20, 23, 23, 1, -22 },
  { 5919, 18, 28, 23, 4, -28 },
  { 5982, 20, 21, 23, 2, -21 },
  { 6035, 19, 21, 23, 4, -21 },
  { 6085, 23, 21, 23, 2, -21 },
  { 6146, 24, 21, 23, -1, -21 },
  { 6209, 26, 29, 23, -3, -21 },
  { 6304, 21, 21, 23, 1, -21 },
  { 6360, 22, 40, 23, 3, -32 },
  { 6470, 14, 40, 23, 5, -32 },
  { 6540, 22, 40, 23, -2, -32 },
  { 6650, 21, 8, 23, 1, -16 },
};

const GFXfont UbuntuSansMono_MediumItalic41pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic41pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic41pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC41PT7B_H_
