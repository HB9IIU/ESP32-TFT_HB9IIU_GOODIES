#ifndef _UBUNTUSANSMONO_MEDIUMITALIC23PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x60, 0x00, 0x02,
  0x0E, 0x3C, 0x38, 0x73, 0xB9, 0x99, 0xCC, 0xC6, 0x66, 0x30, 0x03, 0x9C,
  0x0C, 0x60, 0x33, 0x81, 0x8C, 0x3F, 0xFC, 0xFF, 0xE4, 0xC6, 0x03, 0x38,
  0x18, 0xC0, 0x67, 0x0F, 0xFF, 0x3F, 0xFC, 0x73, 0x01, 0x8C, 0x06, 0x70,
  0x31, 0x80, 0x01, 0xC0, 0x18, 0x01, 0x80, 0xFF, 0x1F, 0xE3, 0x82, 0x38,
  0x03, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xC0, 0x0C, 0x81,
  0xCF, 0x78, 0xFF, 0x83, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x00, 0x0F, 0x07,
  0x1B, 0x0C, 0x19, 0x0C, 0x11, 0x18, 0x13, 0x30, 0x13, 0x60, 0x1E, 0xC0,
  0x0D, 0x80, 0x03, 0xB0, 0x03, 0x78, 0x06, 0xD8, 0x0C, 0x88, 0x19, 0x98,
  0x31, 0x98, 0x61, 0x90, 0xE0, 0xF0, 0x07, 0xC0, 0xFE, 0x0C, 0x61, 0xC6,
  0x1C, 0xE1, 0xDC, 0x0F, 0x80, 0xF2, 0x1E, 0x33, 0x76, 0x63, 0xE6, 0x1C,
  0xE1, 0xCE, 0x3C, 0x7F, 0xE3, 0xE6, 0xFF, 0xED, 0xA0, 0x00, 0x80, 0xF0,
  0x78, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x04,
  0x00, 0x02, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0xF0, 0x18, 0x00, 0x0E, 0x01, 0xC1, 0x19, 0x3A, 0xEF, 0xFE,
  0x1C, 0x06, 0xC1, 0xDC, 0x31, 0x82, 0x20, 0x03, 0x00, 0xE0, 0x18, 0x03,
  0x0F, 0xFF, 0xFF, 0xC3, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x00, 0x38,
  0xE7, 0xCE, 0x18, 0xCE, 0x20, 0x7F, 0xFF, 0xF0, 0x73, 0xFC, 0xE0, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xC0, 0xFE, 0x1C, 0x63, 0x87, 0x30,
  0x77, 0x07, 0x66, 0x76, 0xE6, 0xEE, 0x6E, 0x0E, 0xE0, 0xEE, 0x0C, 0xE1,
  0xCE, 0x38, 0x7F, 0x03, 0xE0, 0x01, 0xC0, 0xF0, 0xF8, 0xFE, 0x1B, 0x80,
  0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x8F, 0xFF,
  0xFE, 0x07, 0xE0, 0xFF, 0x83, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x01,
  0xFF, 0x9F, 0xF8, 0x07, 0xE0, 0xFF, 0x08, 0x70, 0x03, 0x00, 0x30, 0x07,
  0x01, 0xE0, 0x78, 0x07, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0xE4, 0x1E,
  0x7F, 0xCF, 0xF8, 0x00, 0x38, 0x07, 0x80, 0x7C, 0x07, 0xE0, 0x76, 0x07,
  0x30, 0x71, 0x83, 0x1C, 0x30, 0xE3, 0x06, 0x1F, 0xFD, 0xFF, 0xE0, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x07, 0xF8, 0x3F, 0xC1, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x7C, 0x03, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x18, 0x00,
  0xC0, 0x0E, 0x20, 0xF1, 0xFF, 0x1F, 0xE0, 0x00, 0xF0, 0x3F, 0x0F, 0x81,
  0xC0, 0x38, 0x03, 0x00, 0x77, 0x87, 0xFC, 0x70, 0xEE, 0x0E, 0xE0, 0xEE,
  0x0E, 0xE0, 0xC6, 0x1C, 0x7F, 0x83, 0xF0, 0x3F, 0xF7, 0xFF, 0x00, 0xE0,
  0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x07, 0xE1, 0xFE, 0x18, 0x73,
  0x87, 0x38, 0x73, 0x86, 0x1C, 0xE1, 0xF8, 0x3F, 0x87, 0x1C, 0xE0, 0xCC,
  0x0C, 0xC0, 0xCE, 0x1C, 0xFF, 0x87, 0xF0, 0x0F, 0xC1, 0xFE, 0x38, 0x63,
  0x07, 0x70, 0x77, 0x07, 0x70, 0x77, 0x8F, 0x3F, 0xE1, 0xEE, 0x00, 0xC0,
  0x1C, 0x03, 0x80, 0xF0, 0xFE, 0x0F, 0x00, 0x1C, 0x73, 0xC7, 0x00, 0x00,
  0x00, 0x71, 0xEF, 0x1C, 0x0E, 0x1C, 0x78, 0x70, 0x00, 0x00, 0x00, 0x38,
  0x71, 0xF1, 0xC1, 0x86, 0x38, 0x40, 0x00, 0x20, 0x0E, 0x07, 0xF1, 0xF8,
  0xFC, 0x0E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3C, 0x00, 0x80, 0x3F,
  0xF9, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0x3F, 0xF3, 0xFF, 0x80, 0x10,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x03, 0xF1, 0xF8, 0xFC,
  0x07, 0x00, 0x80, 0x00, 0x3F, 0x0F, 0xE4, 0x1C, 0x06, 0x01, 0x80, 0xE0,
  0xF0, 0x70, 0x38, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x3C, 0x0F, 0x03, 0x80,
  0x07, 0xE0, 0xFF, 0x1C, 0x33, 0x83, 0x70, 0x36, 0x3F, 0x67, 0xFC, 0xE7,
  0xCC, 0x6C, 0xC6, 0xCC, 0x6C, 0xCE, 0xCC, 0xEC, 0xFC, 0xC7, 0xCE, 0x00,
  0x60, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x3F, 0x03,
  0x70, 0x67, 0x06, 0x30, 0xC3, 0x0C, 0x31, 0x83, 0x3F, 0xF3, 0xFF, 0x70,
  0x36, 0x03, 0x60, 0x3E, 0x03, 0x0F, 0xE0, 0x7F, 0x87, 0x0E, 0x38, 0x71,
  0x83, 0x8C, 0x18, 0xE3, 0x87, 0xF8, 0x3F, 0xE1, 0x83, 0x9C, 0x1C, 0xE0,
  0xE6, 0x06, 0x30, 0xF3, 0xFF, 0x1F, 0xE0, 0x03, 0xF0, 0x7F, 0xC7, 0x84,
  0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x21, 0xFF, 0x07, 0xF0, 0x0F, 0xC0, 0xFF,
  0x07, 0x1C, 0x30, 0x61, 0x83, 0x9C, 0x1C, 0xE0, 0xE6, 0x06, 0x30, 0x33,
  0x83, 0x9C, 0x1C, 0xC1, 0xC6, 0x0E, 0x71, 0xE3, 0xFE, 0x1F, 0xC0, 0x1F,
  0xF8, 0xFF, 0x86, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xF8,
  0x7F, 0xC3, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0xFF, 0x1F,
  0xF8, 0x1F, 0xF8, 0xFF, 0xC7, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0xF8, 0x3F, 0xC3, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x00, 0x07, 0xF8, 0x7F, 0x87, 0x04, 0x70, 0x03, 0x00, 0x38,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0xE7, 0x07, 0x38, 0x31, 0xC1, 0x8E, 0x1C,
  0x38, 0xE1, 0xFF, 0x07, 0xF0, 0x0C, 0x1C, 0x70, 0x71, 0xC1, 0x86, 0x06,
  0x18, 0x38, 0xE0, 0xE3, 0x83, 0x0F, 0xFC, 0x3F, 0xF1, 0xC1, 0xC7, 0x06,
  0x18, 0x18, 0x60, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x30, 0x0F, 0xF8, 0x7F,
  0xC0, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x01, 0xFF, 0x1F, 0xF8, 0x07,
  0xF8, 0x3F, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x30, 0xE3, 0xFE, 0x0F,
  0xE0, 0x0C, 0x1C, 0x30, 0xE1, 0xC7, 0x07, 0x38, 0x19, 0xC0, 0x6E, 0x03,
  0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xDC, 0x07, 0x38, 0x1C, 0x60, 0x61, 0xC1,
  0x83, 0x0E, 0x0E, 0x38, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06,
  0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x07, 0xFF,
  0xFF, 0x07, 0x0E, 0x0E, 0x38, 0x3C, 0x70, 0x79, 0xE0, 0xF3, 0xC3, 0x6D,
  0x86, 0xD3, 0x0D, 0xEC, 0x3B, 0x98, 0x67, 0x30, 0xC0, 0x61, 0x81, 0xC7,
  0x03, 0x8C, 0x06, 0x18, 0x0C, 0x70, 0x38, 0x0C, 0x0C, 0x78, 0x71, 0xE1,
  0x87, 0x86, 0x1E, 0x18, 0xEC, 0xE3, 0x33, 0x0C, 0xCC, 0x33, 0x31, 0xC7,
  0xC7, 0x1F, 0x18, 0x78, 0x61, 0xE1, 0x87, 0x8E, 0x0E, 0x30, 0x30, 0x07,
  0xC1, 0xFE, 0x1C, 0x73, 0x87, 0x70, 0x77, 0x07, 0x60, 0x7E, 0x07, 0xE0,
  0x7E, 0x06, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x38, 0x7F, 0x83, 0xE0, 0x0F,
  0xE0, 0x7F, 0x87, 0x0E, 0x38, 0x71, 0xC1, 0x8C, 0x1C, 0x60, 0xE7, 0x0E,
  0x3F, 0xE1, 0xFE, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0x07, 0xC1, 0xFE, 0x1C, 0x73, 0x87, 0x70, 0x77, 0x07, 0x60, 0x7E,
  0x07, 0xE0, 0x6E, 0x06, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x38, 0x7F, 0x83,
  0xE0, 0x18, 0x01, 0xC0, 0x1F, 0x80, 0x70, 0x0F, 0xE0, 0x7F, 0x87, 0x1C,
  0x38, 0x71, 0x83, 0x8C, 0x18, 0xE1, 0xC7, 0x1C, 0x3F, 0xC1, 0xFC, 0x1C,
  0x60, 0xE3, 0x86, 0x1C, 0x30, 0x63, 0x83, 0x9C, 0x1C, 0x07, 0xF8, 0x7F,
  0xC7, 0x04, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xC0, 0x0E, 0x20, 0x73, 0xFF, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFC, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x18, 0x39, 0xC1,
  0xCE, 0x0C, 0x60, 0x63, 0x07, 0x38, 0x39, 0xC1, 0x8C, 0x0C, 0x60, 0xE7,
  0x07, 0x38, 0x31, 0xC1, 0x8E, 0x1C, 0x71, 0xC1, 0xFE, 0x0F, 0xE0, 0xC0,
  0x7C, 0x06, 0xC0, 0xEC, 0x0C, 0xC1, 0xCC, 0x18, 0xC3, 0x8C, 0x30, 0xC7,
  0x0C, 0x60, 0xCE, 0x0C, 0xC0, 0xD8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x1C,
  0x0E, 0x30, 0x18, 0x60, 0x31, 0xC0, 0xE3, 0x81, 0x86, 0x03, 0x0C, 0xC6,
  0x19, 0x98, 0x37, 0xB0, 0xDB, 0x61, 0xB6, 0xC3, 0xCF, 0x07, 0x9E, 0x0E,
  0x3C, 0x1C, 0x70, 0x70, 0xE0, 0x0E, 0x07, 0x07, 0x0E, 0x07, 0x1C, 0x03,
  0x38, 0x03, 0xB0, 0x03, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07,
  0xE0, 0x06, 0xE0, 0x0E, 0x60, 0x1C, 0x60, 0x38, 0x70, 0x70, 0x70, 0xF0,
  0x30, 0xC0, 0x7C, 0x0E, 0xE0, 0xCE, 0x1C, 0x63, 0x86, 0x30, 0x77, 0x07,
  0xE0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06,
  0x00, 0x0F, 0xFC, 0x3F, 0xE1, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x0F, 0xFE, 0x3F, 0xF0, 0x03, 0xF0, 0x7F, 0x07, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x7F,
  0x0F, 0xE0, 0xCC, 0xCC, 0xCE, 0xEE, 0xEE, 0xEE, 0x66, 0x66, 0x67, 0x77,
  0x77, 0x07, 0xF0, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0xFE, 0x0F, 0xC0, 0x03, 0x80,
  0x38, 0x07, 0xC0, 0xEC, 0x1C, 0xC3, 0x8E, 0x30, 0x6F, 0x07, 0x20, 0x40,
  0x7F, 0xFF, 0xFF, 0x4C, 0xE7, 0x10, 0x0F, 0xE3, 0xFC, 0xE3, 0xB8, 0x7E,
  0x0D, 0xC1, 0xB0, 0x76, 0x0E, 0xC1, 0x9C, 0x73, 0xFF, 0x3E, 0xE0, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1F, 0xE1, 0xFE, 0x18,
  0x73, 0x87, 0x38, 0x73, 0x07, 0x30, 0x77, 0x06, 0x70, 0xE6, 0x1C, 0x7F,
  0x8F, 0xF0, 0x0F, 0xE3, 0xFC, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x09, 0xFE, 0x1F, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x3F, 0x83, 0xFC, 0x38, 0x63, 0x87, 0x18,
  0x39, 0xC1, 0x8E, 0x0C, 0x60, 0xE3, 0x87, 0x1C, 0x78, 0x7F, 0xC3, 0xFE,
  0x00, 0x0F, 0xC7, 0xFC, 0xE1, 0xB8, 0x3E, 0x0F, 0xCF, 0xBF, 0xE6, 0x00,
  0xE0, 0x1C, 0x09, 0xFE, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0x88,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0xE1, 0x87, 0x0E, 0x18, 0x38, 0xE0, 0xC3, 0x83,
  0x0E, 0x1C, 0x38, 0x70, 0x7F, 0x81, 0xFE, 0x00, 0x18, 0x00, 0xE1, 0x07,
  0x07, 0xF8, 0x3F, 0xC0, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x1F, 0xC1, 0xFE, 0x38, 0x63, 0x87, 0x38, 0x63, 0x06, 0x70, 0xE7,
  0x0E, 0x70, 0xE6, 0x0C, 0x61, 0xCE, 0x1C, 0x06, 0x0F, 0x0E, 0x06, 0x00,
  0x00, 0x7E, 0xFC, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0x1F,
  0x1F, 0x00, 0x30, 0x03, 0xC0, 0x1E, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x87, 0x07, 0xF0, 0x7F,
  0x00, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x73,
  0x8E, 0x31, 0xC3, 0x78, 0x7E, 0x07, 0xC0, 0x6E, 0x06, 0x70, 0xE7, 0x0E,
  0x38, 0xC1, 0x8C, 0x1C, 0x7E, 0xFC, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x38,
  0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x60, 0x71, 0x7E, 0x3F, 0x3F, 0xF1,
  0xFF, 0x8C, 0xCE, 0x66, 0x63, 0x33, 0x31, 0x99, 0x99, 0xCC, 0x0C, 0x60,
  0x67, 0x03, 0x30, 0x19, 0x81, 0x80, 0x1F, 0xE1, 0xFE, 0x18, 0x73, 0x87,
  0x38, 0x73, 0x87, 0x30, 0x63, 0x0E, 0x70, 0xE7, 0x0E, 0x60, 0xCE, 0x1C,
  0x0F, 0xC7, 0xF8, 0xE3, 0xB8, 0x76, 0x0F, 0xC1, 0xF8, 0x3F, 0x06, 0xE1,
  0xDC, 0x71, 0xFE, 0x3F, 0x00, 0x0F, 0xF0, 0x7F, 0x83, 0x0E, 0x38, 0x71,
  0xC1, 0x8C, 0x1C, 0x60, 0xE7, 0x06, 0x38, 0x71, 0x87, 0x0F, 0xF0, 0xFF,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0x0F, 0xF1, 0xFE, 0x38, 0x67,
  0x0E, 0x60, 0xEE, 0x0C, 0xE0, 0xCE, 0x1C, 0xE1, 0xCE, 0x18, 0x7F, 0x87,
  0xF8, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x1F, 0xF1, 0xFE, 0x38, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0x0F, 0xE3, 0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x3E, 0x03, 0xE0, 0x1C,
  0x01, 0xD0, 0x33, 0xFE, 0x7F, 0x80, 0x02, 0x03, 0x00, 0xC0, 0x70, 0x7F,
  0xFF, 0xF1, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x23,
  0xF8, 0xFE, 0x30, 0x66, 0x0D, 0xC3, 0xB8, 0x76, 0x0C, 0xC1, 0xB8, 0x77,
  0x0E, 0xE1, 0x9C, 0x73, 0xFE, 0x3E, 0xE0, 0xE0, 0xFC, 0x1B, 0x87, 0x70,
  0xE6, 0x38, 0xC6, 0x19, 0xC3, 0x30, 0x7E, 0x0F, 0x81, 0xE0, 0x1C, 0x00,
  0x60, 0x3B, 0x01, 0x98, 0x0D, 0xCC, 0x6C, 0x66, 0x67, 0x33, 0x69, 0x9B,
  0x78, 0xF3, 0xC7, 0x9C, 0x38, 0xE1, 0x86, 0x00, 0x1C, 0x1C, 0x38, 0xE0,
  0x67, 0x01, 0xF8, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xF0, 0x0E, 0xC0,
  0x73, 0x83, 0x86, 0x3C, 0x1C, 0x0E, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0x30,
  0xE0, 0x61, 0x80, 0xC7, 0x01, 0xCC, 0x03, 0xB8, 0x03, 0x60, 0x07, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0xC0, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x1E, 0x00, 0xF0,
  0x09, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C,
  0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x60, 0x60,
  0xE0, 0xE0, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xF0, 0x0F, 0x01, 0xC0, 0x38,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0xFE, 0x0F, 0xC0,
  0x38, 0x37, 0xE6, 0xEF, 0xEC, 0x7C,
};

const GFXglyph UbuntuSansMono_MediumItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 16, 13, 3, -16 },
  { 15, 9, 6, 13, 4, -17 },
  { 22, 14, 16, 13, 0, -16 },
  { 50, 12, 21, 13, 1, -18 },
  { 82, 16, 16, 13, -1, -16 },
  { 114, 12, 16, 13, 0, -16 },
  { 138, 3, 7, 13, 7, -17 },
  { 141, 10, 22, 13, 3, -18 },
  { 169, 10, 22, 13, 0, -18 },
  { 197, 11, 10, 13, 2, -16 },
  { 211, 11, 11, 13, 1, -12 },
  { 227, 6, 8, 13, 2, -4 },
  { 233, 7, 3, 13, 3, -8 },
  { 236, 5, 4, 13, 3, -4 },
  { 239, 15, 22, 13, -1, -18 },
  { 281, 12, 16, 13, 1, -16 },
  { 305, 10, 16, 13, 1, -16 },
  { 325, 13, 16, 13, 0, -16 },
  { 351, 12, 16, 13, 0, -16 },
  { 375, 13, 16, 13, 0, -16 },
  { 401, 13, 16, 13, 0, -16 },
  { 427, 12, 16, 13, 1, -16 },
  { 451, 12, 16, 13, 2, -16 },
  { 475, 12, 16, 13, 1, -16 },
  { 499, 12, 16, 13, 1, -16 },
  { 523, 6, 12, 13, 3, -12 },
  { 532, 7, 16, 13, 2, -12 },
  { 546, 12, 11, 13, 1, -12 },
  { 563, 13, 7, 13, 0, -10 },
  { 575, 12, 11, 13, 0, -12 },
  { 592, 10, 16, 13, 3, -16 },
  { 612, 12, 19, 13, 1, -16 },
  { 641, 12, 16, 13, -1, -16 },
  { 665, 13, 16, 13, 0, -16 },
  { 691, 13, 16, 13, 1, -16 },
  { 717, 13, 16, 13, 0, -16 },
  { 743, 13, 16, 13, 1, -16 },
  { 769, 13, 16, 13, 1, -16 },
  { 795, 13, 16, 13, 1, -16 },
  { 821, 14, 16, 13, 0, -16 },
  { 849, 13, 16, 13, 0, -16 },
  { 875, 13, 16, 13, 0, -16 },
  { 901, 14, 16, 13, 0, -16 },
  { 929, 10, 16, 13, 0, -16 },
  { 949, 15, 16, 13, -1, -16 },
  { 979, 14, 16, 13, 0, -16 },
  { 1007, 12, 16, 13, 1, -16 },
  { 1031, 13, 16, 13, 0, -16 },
  { 1057, 12, 20, 13, 1, -16 },
  { 1087, 13, 16, 13, 0, -16 },
  { 1113, 13, 16, 13, 0, -16 },
  { 1139, 11, 16, 13, 3, -16 },
  { 1161, 13, 16, 13, 1, -16 },
  { 1187, 12, 16, 13, 3, -16 },
  { 1211, 15, 16, 13, 0, -16 },
  { 1241, 16, 16, 13, -1, -16 },
  { 1273, 12, 16, 13, 3, -16 },
  { 1297, 14, 16, 13, 0, -16 },
  { 1325, 12, 22, 13, 1, -18 },
  { 1358, 4, 22, 13, 5, -18 },
  { 1369, 12, 22, 13, 0, -18 },
  { 1402, 12, 9, 13, 1, -16 },
  { 1416, 12, 2, 13, -2, 2 },
  { 1419, 4, 5, 13, 6, -18 },
  { 1422, 11, 12, 13, 1, -12 },
  { 1439, 12, 18, 13, 0, -18 },
  { 1466, 11, 12, 13, 1, -12 },
  { 1483, 13, 18, 13, 1, -18 },
  { 1513, 11, 12, 13, 1, -12 },
  { 1530, 15, 22, 13, -1, -18 },
  { 1572, 14, 16, 13, -1, -12 },
  { 1600, 12, 18, 13, 0, -18 },
  { 1627, 8, 18, 13, 2, -18 },
  { 1645, 13, 22, 13, -1, -18 },
  { 1681, 12, 18, 13, 1, -18 },
  { 1708, 8, 18, 13, 3, -18 },
  { 1726, 13, 12, 13, 0, -12 },
  { 1746, 12, 12, 13, 0, -12 },
  { 1764, 11, 12, 13, 1, -12 },
  { 1781, 13, 16, 13, -1, -12 },
  { 1807, 12, 16, 13, 1, -12 },
  { 1831, 12, 12, 13, 1, -12 },
  { 1849, 11, 12, 13, 1, -12 },
  { 1866, 10, 16, 13, 2, -16 },
  { 1886, 11, 12, 13, 1, -12 },
  { 1903, 11, 12, 13, 2, -12 },
  { 1920, 13, 12, 13, 1, -12 },
  { 1940, 14, 12, 13, -1, -12 },
  { 1961, 15, 16, 13, -2, -12 },
  { 1991, 12, 12, 13, 0, -12 },
  { 2009, 13, 22, 13, 1, -18 },
  { 2045, 8, 22, 13, 3, -18 },
  { 2067, 12, 22, 13, -1, -18 },
  { 2100, 12, 4, 13, 1, -9 },
};

const GFXfont UbuntuSansMono_MediumItalic23pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic23pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic23pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC23PT7B_H_
