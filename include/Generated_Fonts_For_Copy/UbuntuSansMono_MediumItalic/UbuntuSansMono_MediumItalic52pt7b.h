#ifndef _UBUNTUSANSMONO_MEDIUMITALIC52PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0x00, 0x00, 0x3F,
  0x07, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xF8, 0x3F, 0x7E, 0x0F, 0x9F, 0x83,
  0xE7, 0xE1, 0xF9, 0xF0, 0x7E, 0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0x81, 0xF3,
  0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x0F, 0x01, 0xC3, 0x80, 0xF0, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFE, 0x03, 0xC0, 0x1F, 0x80,
  0x04, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x10,
  0x00, 0x7F, 0x03, 0xC0, 0x0F, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x01, 0xFF, 0x00,
  0x1F, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x1F, 0x3E, 0x00, 0xF0, 0x03, 0xC3,
  0xC0, 0x3C, 0x00, 0xF0, 0x78, 0x0F, 0x00, 0x1E, 0x0F, 0x03, 0xE0, 0x03,
  0xC1, 0xE0, 0xF8, 0x00, 0x78, 0x3C, 0x3E, 0x00, 0x0E, 0x0F, 0x0F, 0x80,
  0x03, 0xC1, 0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x1F,
  0x00, 0x00, 0xFF, 0xE7, 0xC0, 0x00, 0x1F, 0xF9, 0xF0, 0x00, 0x01, 0xFE,
  0x7C, 0x00, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x0F, 0x9F, 0xF0,
  0x00, 0x03, 0xE7, 0xFE, 0x00, 0x00, 0xF8, 0xFB, 0xE0, 0x00, 0x1E, 0x3C,
  0x3C, 0x00, 0x07, 0x87, 0x87, 0x80, 0x01, 0xF1, 0xE0, 0xF0, 0x00, 0x7C,
  0x3C, 0x1E, 0x00, 0x1F, 0x07, 0x83, 0xC0, 0x07, 0xC0, 0xE0, 0xF0, 0x00,
  0xF0, 0x3C, 0x1E, 0x00, 0x3C, 0x07, 0x83, 0xC0, 0x0F, 0x80, 0xF0, 0xF0,
  0x03, 0xE0, 0x0F, 0x1E, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0x3F,
  0xF0, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x07, 0xC0,
  0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x3F, 0x80,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x7C, 0x1F, 0xF8, 0x1F, 0x0F, 0xFF, 0x07, 0xC7, 0xE7, 0xE3, 0xE3, 0xF1,
  0xF8, 0xF8, 0xF8, 0x3F, 0x7C, 0x7C, 0x07, 0xDF, 0x1F, 0x01, 0xFF, 0x8F,
  0xC0, 0x3F, 0xE3, 0xE0, 0x07, 0xF0, 0xF8, 0x01, 0xFC, 0x3E, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x1F, 0xF0, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF,
  0xFF, 0x87, 0xFF, 0xF3, 0xE0, 0xFF, 0xF8, 0xFC, 0x1F, 0xF8, 0x3F, 0x00,
  0x60, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0xFC, 0xF8, 0xF8, 0xF8, 0xF0, 0xF0, 0xE0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x0C, 0x0F,
  0x01, 0x1E, 0x1E, 0x1E, 0x7F, 0x3C, 0xFE, 0xFF, 0x7B, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xC0, 0x03, 0xE7, 0xC0, 0x0F, 0xCF, 0xC0, 0x3F, 0x0F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xF8, 0x1F, 0x00, 0x70, 0x38, 0x00, 0x40, 0x20, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xC0,
  0x3F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x07,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0xFC, 0x7F, 0xC3, 0xFC, 0x1F, 0xC0,
  0xF8, 0x04, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFE, 0xFF, 0xFC, 0x1C, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFC,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x07, 0xC1,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF1, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x81, 0xF1, 0xF8, 0x78, 0x3E, 0x3F,
  0x1F, 0x87, 0xC7, 0xC7, 0xF1, 0xF9, 0xF8, 0xFE, 0x3F, 0x3F, 0x1F, 0xC7,
  0xE7, 0xE3, 0xF0, 0xF8, 0xF8, 0x3C, 0x3F, 0x1F, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xF8,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE0, 0xF8, 0x01, 0xF8, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x8F, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF,
  0xFC, 0x03, 0xFD, 0xF8, 0x07, 0xF3, 0xE0, 0x0F, 0x8F, 0xC0, 0x18, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xE1, 0xFE, 0x00, 0xF0, 0x07, 0xE0, 0x0C,
  0x00, 0x7E, 0x00, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0xF0, 0x3F, 0xC0, 0x10, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x83, 0x00, 0x0F, 0xF0, 0x7C, 0x07, 0xFC, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF0, 0xFC, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x01,
  0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x01,
  0x80, 0x07, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xCF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F,
  0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x83, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x1F, 0xC1, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x7F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F,
  0xE0, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x07, 0xF0, 0x7F, 0x03, 0xFC,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE1, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xC7, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x1F, 0x81, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFE,
  0x07, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x1F, 0x80, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x1F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87,
  0x01, 0xFC, 0x20, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0x01,
  0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0xFC, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0xFF, 0xF3,
  0xF0, 0x3F, 0xFF, 0x3E, 0x07, 0xFF, 0xF3, 0xE0, 0xFF, 0xFE, 0x7C, 0x1F,
  0xC3, 0xE7, 0xC3, 0xF0, 0x3E, 0x7C, 0x3E, 0x07, 0xEF, 0x87, 0xE0, 0x7C,
  0xF8, 0x7C, 0x07, 0xCF, 0x87, 0xC0, 0x7C, 0xF8, 0x7C, 0x0F, 0xCF, 0x8F,
  0xC0, 0xF8, 0xF8, 0xF8, 0x0F, 0x8F, 0x0F, 0x80, 0xF8, 0xF0, 0xF8, 0x0F,
  0x8F, 0x0F, 0xC1, 0xF0, 0xF0, 0x7C, 0x1F, 0x0F, 0x07, 0xE1, 0xF0, 0xF8,
  0x7F, 0xFF, 0x0F, 0x83, 0xFF, 0xF0, 0xF8, 0x1F, 0xFE, 0x0F, 0x80, 0xFF,
  0xE0, 0xF8, 0x01, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3F,
  0x00, 0x3E, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF1, 0xF8, 0x00,
  0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xE3, 0xFF, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0xFC,
  0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x01, 0xF0, 0x07,
  0xF0, 0x1F, 0x81, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFC,
  0x01, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xF0,
  0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x00, 0x1F, 0xC1, 0xF8,
  0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x7E, 0x03, 0xFC, 0x00, 0xC0, 0x7F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x01,
  0x80, 0x3F, 0xE1, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0x81, 0xFE, 0x01, 0xF0, 0x07, 0xE0, 0x3F,
  0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x07,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE1,
  0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0xFE, 0x3F, 0x00,
  0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x83, 0xF0, 0x03, 0xF8,
  0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x1F, 0xE0, 0x7E, 0x07, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xC1, 0xF0,
  0x07, 0xF8, 0x01, 0x80, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x7C, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F,
  0x00, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0xE1,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xF8,
  0x03, 0xF0, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8,
  0x07, 0xE0, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xC0,
  0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x18, 0x00, 0xFE, 0x00, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE3, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8,
  0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xF0, 0x3F, 0x80, 0x03, 0xF0,
  0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x0F, 0x8F,
  0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x01,
  0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xDE, 0x00, 0xFF, 0x03,
  0xFE, 0x01, 0xF7, 0x07, 0xBC, 0x01, 0xE7, 0x87, 0xBC, 0x01, 0xE7, 0x8F,
  0x3C, 0x03, 0xE7, 0x8F, 0x7C, 0x03, 0xE7, 0x9E, 0x7C, 0x03, 0xC7, 0x9E,
  0x7C, 0x07, 0xC7, 0xBC, 0x78, 0x07, 0xC7, 0xF8, 0x78, 0x07, 0xC7, 0xF8,
  0xF8, 0x07, 0x87, 0xF0, 0xF8, 0x0F, 0x87, 0xF0, 0xF8, 0x0F, 0x87, 0xE0,
  0xF8, 0x0F, 0x87, 0xE1, 0xF0, 0x1F, 0x07, 0xC1, 0xF0, 0x1F, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0xFE, 0x00,
  0x3E, 0x00, 0xFE, 0x00, 0x3E, 0x01, 0xFE, 0x00, 0x7E, 0x01, 0xFE, 0x00,
  0x7C, 0x01, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x00, 0x7C, 0x03, 0xFF, 0x00,
  0xFC, 0x03, 0xEF, 0x80, 0xF8, 0x03, 0xEF, 0x80, 0xF8, 0x03, 0xE7, 0x80,
  0xF8, 0x07, 0xE7, 0x81, 0xF8, 0x07, 0xC7, 0xC1, 0xF0, 0x07, 0xC7, 0xC1,
  0xF0, 0x07, 0xC3, 0xC1, 0xF0, 0x07, 0xC3, 0xC1, 0xF0, 0x0F, 0x83, 0xE3,
  0xE0, 0x0F, 0x83, 0xE3, 0xE0, 0x0F, 0x81, 0xE3, 0xE0, 0x0F, 0x81, 0xE3,
  0xE0, 0x1F, 0x01, 0xE7, 0xE0, 0x1F, 0x01, 0xF7, 0xC0, 0x1F, 0x01, 0xF7,
  0xC0, 0x1F, 0x00, 0xF7, 0xC0, 0x3E, 0x00, 0xFF, 0xC0, 0x3E, 0x00, 0xFF,
  0x80, 0x3E, 0x00, 0xFF, 0x80, 0x3E, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x7F,
  0x80, 0x7C, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x0F,
  0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFC,
  0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFC, 0xFC, 0x00,
  0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0x8F, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xC0, 0x0F, 0xC0,
  0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01,
  0xF8, 0x1F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0,
  0x7E, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x3F,
  0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9,
  0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00,
  0x1F, 0xBF, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03,
  0xF3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE1, 0xF8,
  0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x8F, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xE3, 0xFF, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x01,
  0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x01, 0xFC, 0x07, 0xE0,
  0x3F, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x3F, 0x03,
  0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFC, 0x07, 0xC0, 0x0F, 0xC0,
  0x02, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x01, 0x00, 0x03, 0xF0, 0x0E, 0x00, 0x1F, 0xC0, 0x3F,
  0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x1F,
  0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E,
  0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF8, 0x3F,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00,
  0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0xFC,
  0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC,
  0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0xF0, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7C,
  0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x7E,
  0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x07,
  0xC1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x3E,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x7C, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x07, 0xC1, 0xF0,
  0x1F, 0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0xC1, 0xF0, 0x1F, 0x0F, 0xC3, 0xE0,
  0x1E, 0x1F, 0xC3, 0xE0, 0x3E, 0x1F, 0xC3, 0xE0, 0x3E, 0x3D, 0xC3, 0xC0,
  0x3E, 0x79, 0xC7, 0xC0, 0x3C, 0x79, 0xC7, 0xC0, 0x3C, 0xF1, 0xE7, 0x80,
  0x3C, 0xF1, 0xE7, 0x80, 0x7D, 0xE1, 0xEF, 0x80, 0x7D, 0xE1, 0xEF, 0x80,
  0x7B, 0xC1, 0xEF, 0x00, 0x7B, 0xC1, 0xEF, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F,
  0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7E, 0x7C, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x01, 0xF0, 0x3F, 0x00,
  0x1F, 0x03, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xF9,
  0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFD, 0xF8, 0x00,
  0xFC, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x07, 0xC0,
  0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x3F,
  0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xC1, 0x00, 0x01,
  0x80, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x18, 0x03, 0xC0, 0x3E, 0x0F, 0xF0,
  0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xE0, 0x0C, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0x07, 0xE0, 0xFF, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x3F,
  0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x3F, 0xC1,
  0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xE7,
  0xC0, 0x3F, 0xF1, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3E,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0x7C, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03,
  0xF8, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x87, 0xE0,
  0x3F, 0xC1, 0xF8, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x05, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0x80, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x81, 0xFF, 0xC3, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF0, 0x3E, 0x00, 0xFF, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0xC0,
  0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01,
  0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0x1F, 0xE3, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xF7, 0xE0, 0x03,
  0xFF, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81,
  0xFE, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x0F,
  0x8F, 0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFE, 0x7C, 0x00,
  0xFF, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x81, 0xFF, 0x03,
  0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x33, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFE,
  0x07, 0xE0, 0x1F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0x7C, 0x03, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xF8,
  0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03,
  0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xC3,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFE, 0xFC, 0x00, 0x03, 0x83, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x18,
  0x00, 0x7F, 0x00, 0x7C, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x1F,
  0xF0, 0x3E, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F,
  0x87, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x60, 0x0F, 0xE0, 0x03, 0xE1, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x01, 0xFC, 0x0F,
  0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x03,
  0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x3F, 0x80,
  0x03, 0xE3, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x7F,
  0x00, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x1F, 0x80,
  0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x0F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0xFE, 0x3F,
  0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x27,
  0xF8, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFE, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xF0, 0xFC, 0x7C, 0x0F,
  0x87, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F,
  0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F,
  0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F,
  0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x7C, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81,
  0xFE, 0x1F, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F, 0xC0,
  0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x1F,
  0x80, 0x3F, 0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01,
  0xF8, 0x7E, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xC7, 0xFC, 0x3F, 0x80, 0xFE,
  0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00,
  0x0F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE1, 0xF8,
  0x0F, 0xF0, 0xFF, 0xBF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0x3E, 0x03, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC,
  0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x3F,
  0x00, 0x1F, 0x81, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00,
  0xFE, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0x01, 0xFE, 0x01, 0xFD, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xF3, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0x1F, 0x83,
  0xFC, 0x03, 0xE0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xFC, 0x3F, 0xC0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFE,
  0xF8, 0x00, 0x0C, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xC0, 0x70, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0xC0, 0x07, 0xE0, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x04, 0x07, 0xF9, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0xFC,
  0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x01,
  0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8,
  0x01, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFE, 0x07, 0xF9, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0x9F, 0x00, 0xFF,
  0xC7, 0xC0, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E,
  0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E,
  0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x7E, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF9,
  0xF0, 0x3E, 0x0F, 0x8F, 0x81, 0xF0, 0x7C, 0x7C, 0x1F, 0x83, 0xE3, 0xE0,
  0xFC, 0x3E, 0x1F, 0x0F, 0xE1, 0xF0, 0xF8, 0x7F, 0x0F, 0x07, 0x87, 0xF8,
  0xF8, 0x3C, 0x3F, 0xC7, 0xC1, 0xE3, 0xDE, 0x3C, 0x0F, 0x1E, 0xF3, 0xE0,
  0xF9, 0xE7, 0x9F, 0x07, 0xDF, 0x3C, 0xF0, 0x3E, 0xF1, 0xEF, 0x81, 0xFF,
  0x07, 0x78, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFC, 0x03, 0xFC, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x3E, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xC0, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x41, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x03, 0x03, 0xFE, 0x00, 0xF1, 0xFF, 0xE0, 0x7C, 0xFF, 0xFC, 0x3E,
  0x7F, 0xFF, 0xFF, 0x9F, 0x1F, 0xFF, 0xCF, 0x81, 0xFF, 0xE3, 0xC0, 0x3F,
  0xF0, 0x70, 0x03, 0xF8, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 15, 37, 29, 8, -36 },
  { 71, 18, 16, 29, 10, -40 },
  { 107, 31, 36, 29, 0, -36 },
  { 247, 28, 46, 29, 1, -40 },
  { 408, 35, 38, 29, -2, -37 },
  { 575, 26, 38, 29, 1, -37 },
  { 699, 8, 17, 29, 15, -40 },
  { 716, 23, 51, 29, 6, -41 },
  { 863, 22, 51, 29, 1, -41 },
  { 1004, 23, 22, 29, 6, -36 },
  { 1068, 25, 26, 29, 2, -28 },
  { 1150, 13, 18, 29, 4, -9 },
  { 1180, 16, 6, 29, 7, -18 },
  { 1192, 9, 10, 29, 8, -9 },
  { 1204, 34, 51, 29, -3, -41 },
  { 1421, 27, 38, 29, 2, -37 },
  { 1550, 23, 36, 29, 2, -36 },
  { 1654, 28, 37, 29, 1, -37 },
  { 1784, 27, 38, 29, 1, -37 },
  { 1913, 28, 36, 29, 0, -36 },
  { 2039, 29, 37, 29, 1, -36 },
  { 2174, 27, 37, 29, 3, -36 },
  { 2299, 27, 36, 29, 5, -36 },
  { 2421, 27, 38, 29, 2, -37 },
  { 2550, 27, 37, 29, 2, -37 },
  { 2675, 13, 28, 29, 8, -27 },
  { 2721, 17, 36, 29, 4, -27 },
  { 2798, 26, 24, 29, 2, -27 },
  { 2876, 28, 16, 29, 1, -23 },
  { 2932, 26, 24, 29, 1, -27 },
  { 3010, 21, 38, 29, 7, -37 },
  { 3110, 28, 45, 29, 2, -37 },
  { 3268, 28, 36, 29, -3, -36 },
  { 3394, 29, 36, 29, 0, -36 },
  { 3525, 28, 38, 29, 3, -37 },
  { 3658, 28, 36, 29, 0, -36 },
  { 3784, 29, 36, 29, 2, -36 },
  { 3915, 29, 36, 29, 2, -36 },
  { 4046, 29, 38, 29, 2, -37 },
  { 4184, 32, 36, 29, 0, -36 },
  { 4328, 29, 36, 29, 1, -36 },
  { 4459, 29, 37, 29, 1, -36 },
  { 4594, 32, 36, 29, 0, -36 },
  { 4738, 22, 36, 29, 1, -36 },
  { 4837, 32, 36, 29, -1, -36 },
  { 4981, 32, 36, 29, 0, -36 },
  { 5125, 27, 38, 29, 2, -37 },
  { 5254, 29, 36, 29, 1, -36 },
  { 5385, 27, 47, 29, 2, -37 },
  { 5544, 29, 36, 29, 0, -36 },
  { 5675, 30, 38, 29, 0, -37 },
  { 5818, 26, 36, 29, 6, -36 },
  { 5935, 29, 37, 29, 2, -36 },
  { 6070, 28, 36, 29, 6, -36 },
  { 6196, 32, 36, 29, 1, -36 },
  { 6340, 35, 36, 29, -2, -36 },
  { 6498, 28, 36, 29, 6, -36 },
  { 6624, 31, 36, 29, 0, -36 },
  { 6764, 27, 51, 29, 3, -41 },
  { 6937, 10, 51, 29, 10, -41 },
  { 7001, 27, 51, 29, -1, -41 },
  { 7174, 25, 20, 29, 3, -36 },
  { 7237, 27, 5, 29, -4, 5 },
  { 7254, 12, 10, 29, 12, -40 },
  { 7269, 26, 29, 29, 2, -28 },
  { 7364, 26, 41, 29, 1, -40 },
  { 7498, 26, 29, 29, 2, -28 },
  { 7593, 30, 41, 29, 2, -40 },
  { 7747, 26, 29, 29, 2, -28 },
  { 7842, 36, 50, 29, -3, -40 },
  { 8067, 30, 38, 29, -1, -28 },
  { 8210, 26, 40, 29, 0, -40 },
  { 8340, 18, 40, 29, 5, -40 },
  { 8430, 29, 50, 29, -2, -40 },
  { 8612, 29, 40, 29, 1, -40 },
  { 8757, 17, 41, 29, 7, -40 },
  { 8845, 29, 28, 29, -1, -28 },
  { 8947, 26, 28, 29, 1, -28 },
  { 9038, 25, 29, 29, 2, -28 },
  { 9129, 29, 38, 29, -2, -28 },
  { 9267, 27, 38, 29, 2, -28 },
  { 9396, 26, 28, 29, 3, -28 },
  { 9487, 25, 29, 29, 2, -28 },
  { 9578, 23, 36, 29, 5, -35 },
  { 9682, 26, 28, 29, 2, -27 },
  { 9773, 24, 27, 29, 5, -27 },
  { 9854, 29, 27, 29, 2, -27 },
  { 9952, 31, 27, 29, -1, -27 },
  { 10057, 33, 37, 29, -4, -27 },
  { 10210, 27, 27, 29, 1, -27 },
  { 10302, 28, 51, 29, 3, -41 },
  { 10481, 18, 51, 29, 6, -41 },
  { 10596, 28, 51, 29, -2, -41 },
  { 10775, 26, 9, 29, 2, -20 },
};

const GFXfont UbuntuSansMono_MediumItalic52pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic52pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic52pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC52PT7B_H_
