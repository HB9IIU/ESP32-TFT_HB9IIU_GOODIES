#ifndef _UBUNTUSANSMONO_MEDIUMITALIC31PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E,
  0x0F, 0x07, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x60, 0x78, 0x3E, 0x1E, 0x0F,
  0x00, 0x78, 0xEF, 0x3D, 0xC7, 0x38, 0xEF, 0x1D, 0xC3, 0xB8, 0xE7, 0x1C,
  0xC3, 0x18, 0x60, 0x00, 0x71, 0xC0, 0x38, 0x70, 0x0E, 0x38, 0x07, 0x0E,
  0x01, 0xC7, 0x07, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x07, 0x0E, 0x01,
  0xC7, 0x00, 0xE1, 0xC0, 0x38, 0xE0, 0x0E, 0x38, 0x1F, 0xFF, 0xCF, 0xFF,
  0xF0, 0xE1, 0xC0, 0x38, 0xE0, 0x1C, 0x38, 0x07, 0x1C, 0x01, 0xC7, 0x00,
  0xE3, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x03,
  0xFF, 0x07, 0xFF, 0x0F, 0x06, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x3C, 0x40, 0x3C, 0x79, 0xF8, 0xFF, 0xF0, 0x7F,
  0xE0, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x08,
  0x3F, 0x03, 0x83, 0xB8, 0x38, 0x18, 0xC3, 0x81, 0xC6, 0x18, 0x0E, 0x71,
  0xC0, 0x63, 0x9C, 0x03, 0x19, 0xC0, 0x1D, 0xDC, 0x00, 0x7D, 0xC0, 0x01,
  0xCC, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0xF8, 0x00, 0xEF, 0xC0, 0x0E, 0x67,
  0x00, 0xE7, 0x38, 0x0E, 0x31, 0xC0, 0x61, 0x8C, 0x07, 0x0C, 0x60, 0x70,
  0x67, 0x07, 0x03, 0xF0, 0x70, 0x1F, 0x00, 0x00, 0x20, 0x00, 0x00, 0xF8,
  0x01, 0xFC, 0x03, 0xFE, 0x07, 0x8E, 0x07, 0x0E, 0x07, 0x0E, 0x0F, 0x1C,
  0x07, 0x3C, 0x07, 0x78, 0x07, 0xF0, 0x07, 0xC4, 0x0F, 0xC7, 0x1F, 0xC7,
  0x38, 0xEE, 0x70, 0xFE, 0x70, 0x7C, 0x70, 0x7C, 0xF0, 0x38, 0x70, 0x7C,
  0x7D, 0xFC, 0x7F, 0xDE, 0x3F, 0x8E, 0x7B, 0xDE, 0xEF, 0x7B, 0x9C, 0xE6,
  0x00, 0x00, 0x30, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xC0,
  0x04, 0x00, 0x00, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x00, 0x70, 0x01, 0x00, 0x00, 0x07, 0x80, 0x0E, 0x04, 0x38,
  0x1C, 0xC6, 0x7B, 0x7F, 0xFF, 0xF0, 0xFE, 0x01, 0xF0, 0x0F, 0xE0, 0x73,
  0xC3, 0xCF, 0x06, 0x18, 0x08, 0x40, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFF, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x1F, 0x1F, 0x1F, 0x1F, 0x07, 0x0E, 0x7C, 0xF8, 0xE0, 0x7F, 0xBF,
  0xDF, 0xFF, 0xF0, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x8F, 0x1E, 0x0F, 0x1E, 0x07, 0x3C, 0x07,
  0x3C, 0x07, 0x38, 0x07, 0x79, 0xC7, 0x73, 0xCF, 0x73, 0xCE, 0x71, 0xCE,
  0x70, 0x0E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0x70, 0x38, 0x70, 0x78,
  0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x1F, 0x81,
  0xFE, 0x1F, 0xF8, 0x39, 0xC0, 0x87, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x07, 0xFF, 0x9F, 0xFE, 0xFF, 0xF8, 0x01, 0xF8, 0x07, 0xFE, 0x0F,
  0xFE, 0x0E, 0x0F, 0x08, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xFF, 0xFC, 0xFF,
  0xF8, 0xFF, 0xF8, 0x00, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x61, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x10, 0x0F, 0x0F, 0xBF, 0x8F, 0xFF, 0x83,
  0xFF, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x0F, 0x70, 0x0F, 0x38, 0x0F, 0x1C, 0x0F, 0x1E, 0x07, 0x0F, 0x07,
  0x07, 0x07, 0x03, 0x87, 0x81, 0xC3, 0xFF, 0xF9, 0xFF, 0xFD, 0xFF, 0xFE,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x01,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x10, 0x0F, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x77, 0xF0, 0x7F, 0xF8, 0xFC, 0xF8, 0xF0,
  0x3C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xF0,
  0x78, 0x79, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x3F, 0xFF, 0x3F, 0xFF, 0x40,
  0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0x0F, 0x0E, 0x07, 0x1E,
  0x07, 0x1E, 0x07, 0x1E, 0x0F, 0x0E, 0x0E, 0x0F, 0xBC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1E, 0xF8, 0x38, 0x3C, 0x70, 0x1C, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0,
  0x1C, 0xF0, 0x3C, 0x7C, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x01, 0xF8, 0x07,
  0xFC, 0x0F, 0xFE, 0x1F, 0x0F, 0x1C, 0x0F, 0x3C, 0x07, 0x3C, 0x07, 0x38,
  0x07, 0x38, 0x07, 0x3C, 0x07, 0x3C, 0x1F, 0x1F, 0xFF, 0x0F, 0xFE, 0x03,
  0x9E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0xFF,
  0xC0, 0xFF, 0x00, 0xFC, 0x00, 0x1E, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF8, 0xF0, 0x03, 0xC0, 0xFC,
  0x1F, 0x83, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x07, 0x01, 0xC1, 0xF0, 0x7C,
  0x0E, 0x00, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x7F, 0x01, 0xFE, 0x0F, 0xF0,
  0x7F, 0x80, 0x7E, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x78, 0x00, 0x18, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0x10, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0x80, 0x1F, 0x01, 0xFE, 0x1F, 0xE1, 0xFF, 0x07, 0xF0,
  0x0F, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xC1, 0xFF, 0x8F, 0xFE, 0x20, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x38, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x81, 0xFF, 0xC1,
  0xE0, 0xF0, 0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0xFF, 0x70, 0xFF,
  0xB8, 0xFF, 0x9C, 0xF1, 0xDC, 0x70, 0xEE, 0x78, 0x77, 0x38, 0x73, 0x9C,
  0x39, 0xCE, 0x1C, 0xE7, 0x0E, 0x73, 0xCE, 0x38, 0xFF, 0x1C, 0x3F, 0x8E,
  0x07, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0xE0, 0x0F, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0x8F, 0x01, 0xC7, 0x81, 0xC1,
  0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x7F, 0xFC, 0x3F, 0xFE, 0x3F,
  0xFF, 0x1C, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xEF, 0x00, 0x7F, 0x00, 0x38,
  0x01, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x70,
  0x1C, 0x38, 0x0E, 0x1C, 0x0F, 0x1E, 0x0F, 0x0F, 0xFF, 0x07, 0xFE, 0x03,
  0xFF, 0x83, 0xC3, 0xE1, 0xC0, 0x78, 0xE0, 0x3C, 0x70, 0x1E, 0x78, 0x0F,
  0x3C, 0x07, 0x1C, 0x0F, 0x8F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x00, 0x00,
  0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xF0, 0x61, 0xE0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x04, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xF0,
  0x03, 0xFE, 0x03, 0xFF, 0x81, 0xE3, 0xE0, 0xE0, 0xF0, 0x70, 0x3C, 0x78,
  0x1E, 0x3C, 0x0F, 0x1C, 0x07, 0x8E, 0x03, 0xC7, 0x01, 0xE7, 0x80, 0xF3,
  0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x3C, 0xF0, 0x1C, 0x78, 0x1E, 0x38, 0x1E,
  0x1C, 0x3E, 0x1F, 0xFF, 0x0F, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x83,
  0xFF, 0xC3, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3F,
  0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0xF8, 0x60, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x01, 0xC7, 0x01, 0xE7, 0x80, 0xF3,
  0xC0, 0x71, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x1E, 0x1E, 0x0F, 0x0F, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0x01, 0xE1, 0xE0, 0x38, 0x3C, 0x07,
  0x07, 0x01, 0xE0, 0xE0, 0x3C, 0x1C, 0x07, 0x07, 0x80, 0xE0, 0xE0, 0x3C,
  0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x1E, 0x03, 0x83, 0x80, 0xF0,
  0x70, 0x1C, 0x1E, 0x03, 0x83, 0xC0, 0x70, 0x70, 0x1E, 0x0E, 0x03, 0xC3,
  0xC0, 0x70, 0x78, 0x0E, 0x0E, 0x03, 0xC0, 0x07, 0xFF, 0x87, 0xFF, 0xC0,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x3F, 0xFE, 0x1F,
  0xFE, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x20, 0x78, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC,
  0x00, 0x07, 0x83, 0xE0, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x87, 0x80, 0xE1,
  0xE0, 0x1C, 0x78, 0x03, 0x9E, 0x00, 0xF7, 0x80, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x71, 0xE0, 0x0E, 0x1C,
  0x03, 0xC3, 0xC0, 0x78, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x78, 0x0F,
  0x0F, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0xFF,
  0xDF, 0xFE, 0xFF, 0xF8, 0x03, 0xC0, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x83,
  0xE1, 0xF0, 0x7C, 0x7E, 0x0D, 0x8D, 0xC3, 0xB3, 0xB0, 0x76, 0x6E, 0x0E,
  0xDD, 0xC3, 0x9B, 0x38, 0x73, 0xE7, 0x0E, 0x78, 0xC1, 0xCE, 0x38, 0x70,
  0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0,
  0x1C, 0x38, 0x03, 0x8E, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0xF0, 0x38, 0x3E,
  0x07, 0x07, 0xC0, 0xE0, 0xFC, 0x1C, 0x1F, 0x87, 0x07, 0x70, 0xE0, 0xE7,
  0x1C, 0x1C, 0xE3, 0x83, 0x9C, 0xF0, 0xE1, 0x9C, 0x1C, 0x33, 0x83, 0x87,
  0x70, 0x70, 0xFE, 0x1E, 0x1F, 0x83, 0x81, 0xF0, 0x70, 0x3E, 0x0E, 0x07,
  0xC3, 0xC0, 0xF0, 0x70, 0x1E, 0x0E, 0x01, 0xC0, 0x00, 0xF8, 0x03, 0xFE,
  0x07, 0xFE, 0x0F, 0x0F, 0x1E, 0x07, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x78, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x0E,
  0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0x70, 0x78, 0x7F, 0xF0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1C,
  0x3E, 0x07, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x38, 0x0F, 0x0E, 0x03,
  0x87, 0x81, 0xE1, 0xE0, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFE,
  0x0F, 0x0F, 0x1E, 0x07, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07,
  0x78, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E,
  0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0x70, 0x78, 0x7F, 0xF0, 0x3F, 0xE0,
  0x1F, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xE0,
  0x00, 0x60, 0x01, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xE1, 0xF0, 0xF0,
  0x78, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x0F, 0x1E, 0x07, 0x8E, 0x07, 0x87,
  0x0F, 0x83, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0x80, 0xE1, 0xC0, 0x70, 0xF0,
  0x78, 0x38, 0x3C, 0x1C, 0x1C, 0x0F, 0x0E, 0x03, 0x8F, 0x01, 0xC7, 0x80,
  0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x1E, 0x04, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x82, 0x03, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x0E, 0x03, 0xC7, 0x80, 0xE1,
  0xE0, 0x38, 0x70, 0x1E, 0x1C, 0x07, 0x8F, 0x01, 0xC3, 0xC0, 0x70, 0xE0,
  0x3C, 0x38, 0x0F, 0x1E, 0x03, 0x87, 0x80, 0xE1, 0xC0, 0x78, 0x70, 0x1E,
  0x1C, 0x07, 0x0F, 0x01, 0xC3, 0xC0, 0xF0, 0xF0, 0x38, 0x1C, 0x1E, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xBC,
  0x03, 0xDE, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xE1, 0xC0, 0xF0, 0xE0, 0x70,
  0x70, 0x78, 0x38, 0x38, 0x1C, 0x3C, 0x0E, 0x1C, 0x07, 0x1C, 0x03, 0x8E,
  0x01, 0xCE, 0x00, 0xE7, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0xE0, 0x0E, 0x0E, 0x00, 0xE1,
  0xE0, 0x1E, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC6, 0x38,
  0x38, 0xE3, 0x83, 0x9E, 0x38, 0x39, 0xE3, 0x83, 0xBF, 0x70, 0x33, 0x77,
  0x03, 0x77, 0x70, 0x76, 0x36, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3,
  0xC0, 0x78, 0x3C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x00, 0x07, 0x80, 0xF8,
  0x1E, 0x07, 0x00, 0x70, 0x78, 0x03, 0x87, 0x80, 0x1E, 0x78, 0x00, 0x73,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xEE, 0x00, 0x1E, 0x78,
  0x01, 0xE3, 0xC0, 0x1E, 0x0E, 0x00, 0xF0, 0x70, 0x0F, 0x03, 0xC0, 0xF0,
  0x1E, 0x0F, 0x00, 0x70, 0x00, 0xE0, 0x0F, 0xE0, 0x1E, 0xF0, 0x1C, 0xF0,
  0x3C, 0x70, 0x78, 0x70, 0x70, 0x70, 0xF0, 0x79, 0xE0, 0x39, 0xC0, 0x3B,
  0x80, 0x3F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07,
  0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0xFF,
  0x80, 0xF3, 0xCF, 0x3C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x79, 0xE7,
  0x9E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0x3C, 0xF3, 0xCF, 0x1C, 0x70,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x0F, 0xF8, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0,
  0xF3, 0x81, 0xC7, 0x07, 0x8F, 0x1E, 0x0E, 0x78, 0x1D, 0xE0, 0x3D, 0x80,
  0x30, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x20, 0xE3, 0xE1,
  0xE1, 0xE1, 0x80, 0x00, 0x30, 0x03, 0xFF, 0x0F, 0xFE, 0x1F, 0x8E, 0x3E,
  0x0E, 0x3C, 0x1E, 0x78, 0x1C, 0x70, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x38, 0xF0, 0x38, 0xF0, 0x78, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F,
  0xBC, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x10, 0x1F, 0xF8, 0x3F, 0xF8, 0x7C, 0xF9, 0xE0, 0xF3,
  0xC0, 0xE7, 0x01, 0xCE, 0x03, 0xBC, 0x07, 0x78, 0x1E, 0xE0, 0x3D, 0xC0,
  0xF7, 0x81, 0xEF, 0x0F, 0x9F, 0xFE, 0x3F, 0xF8, 0x7F, 0xC0, 0x00, 0x30,
  0x03, 0xFF, 0x0F, 0xFE, 0x1F, 0x86, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x08, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x03, 0xFF, 0x01, 0xFF, 0xC1, 0xF8, 0xE0, 0xF8, 0x38, 0x3C,
  0x1E, 0x1E, 0x07, 0x87, 0x01, 0xC1, 0xC0, 0x70, 0xF0, 0x3C, 0x3C, 0x0F,
  0x0F, 0x03, 0x83, 0xC0, 0xE0, 0xF0, 0x78, 0x1F, 0xFE, 0x07, 0xFF, 0x80,
  0xFE, 0xF0, 0x00, 0x60, 0x07, 0xF8, 0x3F, 0xF8, 0xF8, 0xF3, 0xC0, 0xE7,
  0x01, 0xDE, 0x03, 0xB8, 0x1F, 0xFF, 0xFD, 0xFF, 0xE3, 0xFE, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x01, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x02, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x11, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x3F, 0xF0, 0x1F, 0xFC,
  0x1F, 0x8F, 0x07, 0x83, 0x83, 0xC0, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1C,
  0x07, 0x07, 0x01, 0xC1, 0xC0, 0xF0, 0x70, 0x3C, 0x1C, 0x0E, 0x07, 0xFF,
  0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC1,
  0x83, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x20, 0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xBE, 0x1E, 0x0E, 0x1C, 0x0F, 0x1C,
  0x0E, 0x3C, 0x0E, 0x3C, 0x0E, 0x3C, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x78,
  0x1C, 0x78, 0x3C, 0x70, 0x3C, 0x70, 0x38, 0xF0, 0x38, 0x03, 0x80, 0xF8,
  0x1F, 0x03, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x9F, 0xE3, 0xFC,
  0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xE0, 0x3F, 0xC7, 0xF8, 0x7F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x18, 0x78, 0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x0F, 0x8F, 0x0F, 0x07, 0x0F, 0x03, 0x8F, 0x03,
  0xCF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3B, 0xC0, 0x3D, 0xE0,
  0x1E, 0x78, 0x0E, 0x1E, 0x07, 0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xE1, 0xC0,
  0x78, 0x7F, 0x9F, 0xEF, 0xF8, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E,
  0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07,
  0x81, 0xE0, 0x78, 0x1F, 0xF3, 0xFC, 0x7F, 0x1F, 0xDF, 0x0F, 0xFF, 0xC7,
  0x3C, 0xE3, 0x9C, 0x73, 0x8E, 0x39, 0xC7, 0x38, 0xE3, 0x9C, 0x73, 0x8E,
  0x71, 0xC7, 0x38, 0xE3, 0x9C, 0x03, 0x8E, 0x01, 0xCE, 0x00, 0xE7, 0x00,
  0x73, 0x80, 0x71, 0xC0, 0x38, 0x00, 0x60, 0x3F, 0xF0, 0x7F, 0xF0, 0xFB,
  0xF1, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9C, 0x0F, 0x38, 0x1C, 0xF0, 0x39,
  0xE0, 0xF3, 0x81, 0xE7, 0x03, 0x9E, 0x07, 0x3C, 0x0E, 0x70, 0x3C, 0xE0,
  0x78, 0x00, 0x40, 0x0F, 0xF0, 0x3F, 0xF0, 0xFB, 0xF3, 0xC1, 0xE7, 0x01,
  0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xEF,
  0x03, 0xDE, 0x0F, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xC0, 0x00, 0x30, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0xF3, 0xF0, 0xF0, 0x78, 0x78, 0x1C, 0x38, 0x0E,
  0x1C, 0x07, 0x1E, 0x03, 0x8F, 0x03, 0xC7, 0x01, 0xE3, 0x81, 0xE3, 0xC1,
  0xF1, 0xE1, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x10,
  0x03, 0xFF, 0x07, 0xFF, 0x1F, 0x8F, 0x1E, 0x0E, 0x3C, 0x0E, 0x78, 0x1E,
  0x78, 0x1E, 0x70, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38,
  0x70, 0x78, 0x7F, 0xF8, 0x7F, 0xF8, 0x1F, 0xF0, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x20, 0x1F, 0xFC,
  0x7F, 0xF0, 0xFF, 0xE1, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x0F, 0xFC, 0x3F, 0xF8, 0x78, 0x61,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0x88, 0x0F, 0x1F, 0xFE, 0x7F, 0xF8, 0x7F, 0xC0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x01, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFE, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x1F,
  0xE0, 0x1C, 0x0F, 0x1C, 0x0E, 0x3C, 0x0E, 0x3C, 0x1E, 0x38, 0x1E, 0x38,
  0x1C, 0x78, 0x1C, 0x78, 0x3C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x38, 0xF0,
  0x38, 0x70, 0x78, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xBC, 0xF0, 0x1F, 0xE0,
  0x7B, 0xC0, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0E, 0x3C, 0x3C, 0x38, 0xF0,
  0x71, 0xC0, 0xE7, 0x81, 0xCE, 0x03, 0xBC, 0x07, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x03, 0xDC, 0x00, 0xE7, 0x00, 0x39, 0xC3, 0x0E,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x3C, 0x61, 0x8F, 0x38, 0x67, 0xCE, 0x3B,
  0xB3, 0x0E, 0xCD, 0xC3, 0xF3, 0xF0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x07,
  0x03, 0x81, 0xC0, 0x0F, 0x03, 0xE0, 0xF0, 0x70, 0x1E, 0x1E, 0x01, 0xE7,
  0x80, 0x3D, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x1E, 0xE0, 0x07, 0x9E, 0x01, 0xE1, 0xC0, 0x38, 0x3C,
  0x0F, 0x07, 0x87, 0xC0, 0x78, 0x07, 0x80, 0xE0, 0xF0, 0x3C, 0x1E, 0x07,
  0x83, 0xC0, 0xE0, 0x78, 0x3C, 0x07, 0x07, 0x00, 0xE1, 0xE0, 0x1C, 0x38,
  0x03, 0xC7, 0x00, 0x79, 0xC0, 0x07, 0x38, 0x00, 0xEE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x01,
  0x1E, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3E,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xC0,
  0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC0, 0xF0,
  0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38,
  0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x00,
  0x01, 0xF8, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xF8, 0x00,
  0x1E, 0x06, 0x3F, 0x87, 0x7F, 0xFE, 0xF3, 0xFC, 0xE0, 0xFC, 0x20, 0x30,
};

const GFXglyph UbuntuSansMono_MediumItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 9, 21, 17, 5, -21 },
  { 25, 11, 10, 17, 6, -24 },
  { 39, 18, 21, 17, 0, -21 },
  { 87, 16, 27, 17, 1, -24 },
  { 141, 21, 23, 17, -1, -22 },
  { 202, 16, 22, 17, 0, -22 },
  { 246, 5, 10, 17, 9, -24 },
  { 253, 13, 30, 17, 4, -24 },
  { 302, 14, 30, 17, 0, -24 },
  { 355, 14, 13, 17, 3, -21 },
  { 378, 15, 16, 17, 1, -17 },
  { 408, 8, 10, 17, 2, -5 },
  { 418, 9, 4, 17, 4, -11 },
  { 423, 5, 5, 17, 5, -5 },
  { 427, 20, 30, 17, -2, -24 },
  { 502, 16, 22, 17, 1, -22 },
  { 546, 14, 21, 17, 1, -21 },
  { 583, 16, 22, 17, 1, -22 },
  { 627, 17, 22, 17, 0, -22 },
  { 674, 17, 21, 17, 0, -21 },
  { 719, 18, 21, 17, 0, -21 },
  { 767, 16, 22, 17, 2, -22 },
  { 811, 16, 21, 17, 3, -21 },
  { 853, 16, 22, 17, 1, -22 },
  { 897, 16, 22, 17, 1, -22 },
  { 941, 8, 16, 17, 5, -16 },
  { 957, 11, 21, 17, 2, -16 },
  { 986, 16, 14, 17, 1, -16 },
  { 1014, 16, 10, 17, 1, -14 },
  { 1034, 15, 14, 17, 1, -16 },
  { 1061, 13, 22, 17, 4, -22 },
  { 1097, 17, 27, 17, 1, -22 },
  { 1155, 17, 21, 17, -2, -21 },
  { 1200, 17, 22, 17, 0, -22 },
  { 1247, 17, 22, 17, 2, -22 },
  { 1294, 17, 22, 17, 0, -22 },
  { 1341, 17, 21, 17, 1, -21 },
  { 1386, 18, 21, 17, 1, -21 },
  { 1434, 17, 22, 17, 1, -22 },
  { 1481, 19, 21, 17, 0, -21 },
  { 1531, 17, 21, 17, 1, -21 },
  { 1576, 17, 21, 17, 1, -21 },
  { 1621, 19, 21, 17, 0, -21 },
  { 1671, 14, 21, 17, 0, -21 },
  { 1708, 19, 21, 17, -1, -21 },
  { 1758, 19, 21, 17, 0, -21 },
  { 1808, 16, 22, 17, 1, -22 },
  { 1852, 18, 22, 17, 0, -22 },
  { 1902, 16, 28, 17, 1, -22 },
  { 1958, 17, 22, 17, 0, -22 },
  { 2005, 18, 22, 17, 0, -22 },
  { 2055, 15, 21, 17, 4, -21 },
  { 2095, 18, 21, 17, 1, -21 },
  { 2143, 17, 21, 17, 3, -21 },
  { 2188, 20, 21, 17, 0, -21 },
  { 2241, 21, 21, 17, -1, -21 },
  { 2297, 16, 21, 17, 4, -21 },
  { 2339, 19, 21, 17, 0, -21 },
  { 2389, 16, 30, 17, 2, -24 },
  { 2449, 6, 30, 17, 6, -24 },
  { 2472, 17, 30, 17, -1, -24 },
  { 2536, 15, 12, 17, 2, -21 },
  { 2559, 16, 3, 17, -2, 3 },
  { 2565, 7, 6, 17, 7, -24 },
  { 2571, 16, 17, 17, 1, -17 },
  { 2605, 15, 24, 17, 1, -24 },
  { 2650, 16, 17, 17, 1, -17 },
  { 2684, 18, 24, 17, 1, -24 },
  { 2738, 15, 17, 17, 1, -17 },
  { 2770, 21, 30, 17, -2, -24 },
  { 2849, 18, 23, 17, -1, -17 },
  { 2901, 16, 24, 17, 0, -24 },
  { 2949, 11, 24, 17, 3, -24 },
  { 2982, 17, 30, 17, -1, -24 },
  { 3046, 17, 24, 17, 1, -24 },
  { 3097, 10, 24, 17, 4, -24 },
  { 3127, 17, 16, 17, 0, -16 },
  { 3161, 15, 17, 17, 1, -17 },
  { 3193, 15, 17, 17, 1, -17 },
  { 3225, 17, 23, 17, -1, -17 },
  { 3274, 16, 23, 17, 1, -17 },
  { 3320, 15, 17, 17, 2, -17 },
  { 3352, 15, 17, 17, 1, -17 },
  { 3384, 14, 21, 17, 3, -21 },
  { 3421, 16, 16, 17, 1, -16 },
  { 3453, 15, 16, 17, 3, -16 },
  { 3483, 18, 16, 17, 1, -16 },
  { 3519, 19, 16, 17, -1, -16 },
  { 3557, 19, 22, 17, -2, -16 },
  { 3610, 16, 16, 17, 1, -16 },
  { 3642, 17, 30, 17, 2, -24 },
  { 3706, 10, 30, 17, 4, -24 },
  { 3744, 16, 30, 17, -1, -24 },
  { 3804, 16, 6, 17, 1, -12 },
};

const GFXfont UbuntuSansMono_MediumItalic31pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic31pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic31pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC31PT7B_H_
