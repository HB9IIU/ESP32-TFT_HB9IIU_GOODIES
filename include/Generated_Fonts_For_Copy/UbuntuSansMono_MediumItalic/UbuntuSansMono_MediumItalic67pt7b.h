#ifndef _UBUNTUSANSMONO_MEDIUMITALIC67PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F,
  0xC0, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x7F,
  0x81, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7E,
  0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xC0, 0xF0,
  0x07, 0xC0, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0x80, 0x3F, 0xF0, 0x00,
  0xE0, 0x07, 0xF8, 0x00, 0x04, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x40,
  0x00, 0x1F, 0xF0, 0x1E, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x40, 0x03, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0xF8, 0x1F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x00, 0x7C,
  0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x00, 0x1F, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xF8,
  0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x3F,
  0x00, 0x00, 0x1F, 0x87, 0xE3, 0xF0, 0x00, 0x00, 0x7C, 0x7E, 0x3F, 0x00,
  0x00, 0x03, 0xFF, 0xF1, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0xF1, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xC1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xC7, 0xFF, 0x80, 0x00, 0x00, 0xFC,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xF7, 0xE0, 0x00, 0x00, 0xFC, 0x3F,
  0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x7C, 0x00, 0x00, 0x7E, 0x1F, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0xF8,
  0x00, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x7E, 0x00,
  0x03, 0xF0, 0x1F, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x03,
  0xF0, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07,
  0xE0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00,
  0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x3C, 0x00, 0xFF, 0xE0, 0x0F,
  0xC0, 0x7F, 0xFC, 0x07, 0xF0, 0x3F, 0xFF, 0x81, 0xF8, 0x1F, 0xEF, 0xE0,
  0x7E, 0x0F, 0xF3, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x8F, 0xC3, 0xF8, 0x0F,
  0xE7, 0xF0, 0xFE, 0x03, 0xFD, 0xF8, 0x7F, 0x00, 0x7F, 0xFE, 0x1F, 0xC0,
  0x0F, 0xFF, 0x07, 0xF0, 0x03, 0xFF, 0xC3, 0xF8, 0x00, 0x7F, 0xE0, 0xFE,
  0x00, 0x1F, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xE0, 0x1F, 0xFE,
  0x07, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF9,
  0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0x80, 0xFF, 0xFE, 0x0F, 0xE0, 0x1F, 0xFC,
  0x03, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x03, 0x00,
  0xFC, 0x03, 0x0F, 0x03, 0xF0, 0x3C, 0x3F, 0x0F, 0xC3, 0xF1, 0xFF, 0x1E,
  0x3F, 0xE7, 0xFF, 0x7B, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x7F, 0x3F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0xFF,
  0x87, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0x80,
  0x7C, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x10, 0x02, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE0, 0x1F, 0xC3, 0xFE, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xE7, 0xFC, 0x7F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x03, 0xC0,
  0xFF, 0x3F, 0xC3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F,
  0xC3, 0xF9, 0xFE, 0x1F, 0xF0, 0xFE, 0x7F, 0x07, 0xF8, 0x3F, 0x9F, 0xC1,
  0xFE, 0x1F, 0xE7, 0xF0, 0x7F, 0x87, 0xF1, 0xFC, 0x1F, 0xC1, 0xFC, 0x7F,
  0x01, 0xC0, 0x7F, 0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x07, 0xFF,
  0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xF7, 0xF0, 0x03, 0xFE, 0x7F,
  0x80, 0x1F, 0xC3, 0xFC, 0x00, 0xF8, 0x1F, 0xC0, 0x03, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x03, 0xC0, 0x00,
  0xFF, 0x00, 0x10, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0xFC, 0x03, 0xFE, 0x00, 0x0C, 0x00, 0x3F, 0xE0, 0x01, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x20,
  0x00, 0x07, 0xFC, 0x07, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0x87, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x03, 0xFC,
  0x7F, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x0F,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE7, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xF0,
  0x00, 0x1F, 0xE7, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x03,
  0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x0F,
  0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x01, 0xFF, 0xDF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x01, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x01, 0xFC,
  0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xF0,
  0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF7, 0xF8,
  0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3C, 0x01,
  0xFF, 0x04, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x03, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0x7F, 0x0F, 0xE0,
  0x07, 0xFF, 0xF8, 0x7E, 0x00, 0xFF, 0xFF, 0x87, 0xF0, 0x0F, 0xFF, 0xFC,
  0x3F, 0x01, 0xFF, 0xFF, 0xE1, 0xF8, 0x0F, 0xFF, 0xFF, 0x1F, 0xC0, 0xFF,
  0xC7, 0xF8, 0xFC, 0x0F, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x01, 0xFC, 0x7F,
  0x07, 0xF0, 0x0F, 0xE3, 0xF8, 0x3F, 0x80, 0x7F, 0x1F, 0x83, 0xF8, 0x03,
  0xF0, 0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0xFC, 0x01, 0xFC, 0x7F, 0x07,
  0xE0, 0x0F, 0xE3, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x83, 0xF8, 0x07, 0xF0,
  0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x07, 0xF0,
  0x0F, 0xC1, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xC1, 0xFC, 0x07, 0xF0, 0x7E,
  0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x3F, 0xC1, 0xF8, 0x1F, 0x81, 0xFF, 0xFF,
  0xC0, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0x80,
  0x7F, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x03, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03,
  0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF0,
  0x00, 0x7F, 0xE0, 0x3F, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFC,
  0x00, 0xFF, 0xC0, 0x01, 0xC0, 0x1F, 0xF8, 0x00, 0x08, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x40, 0x03, 0xFF, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x03, 0xFF,
  0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0x81,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x7E, 0x00, 0x7F, 0xE0, 0x01, 0xC0,
  0x0F, 0xF8, 0x00, 0x04, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x80,
  0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x07, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x20, 0x00, 0x3F, 0xC0, 0x01,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xF3, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x03, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x00,
  0x07, 0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xFE, 0x00, 0x00, 0x0F, 0xE1, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x0F, 0xFE, 0x00, 0x1F, 0x7C, 0x03, 0xFF, 0x00, 0x07, 0xDF, 0x01, 0xFF,
  0xC0, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x00, 0xFD, 0xF0, 0x3E, 0xFC, 0x00,
  0x3F, 0x7C, 0x0F, 0xBF, 0x00, 0x0F, 0x9F, 0x07, 0xCF, 0xC0, 0x07, 0xE7,
  0xC1, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0xF8, 0xF8, 0x00, 0x7E, 0x7C, 0x3E,
  0x7E, 0x00, 0x3F, 0x1F, 0x1F, 0x1F, 0x80, 0x0F, 0xC7, 0xCF, 0xC7, 0xE0,
  0x03, 0xF1, 0xF3, 0xE1, 0xF8, 0x01, 0xFC, 0x3D, 0xF8, 0xFC, 0x00, 0x7E,
  0x0F, 0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0xFF,
  0x83, 0xF0, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x00, 0xFC, 0x0F, 0xF0, 0x7F,
  0x00, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xF8, 0x00,
  0x1F, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xF0,
  0x03, 0xFF, 0x80, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xCF, 0xC0, 0x1F, 0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0xC0, 0x07, 0xF3,
  0xF0, 0x07, 0xE0, 0x03, 0xF9, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x7E, 0x03,
  0xF8, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0xFC, 0x00,
  0x7F, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x81,
  0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x1F,
  0xC0, 0x07, 0xF0, 0x1F, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC7, 0xF0, 0x03,
  0xF8, 0x07, 0xE3, 0xF0, 0x01, 0xFC, 0x03, 0xF3, 0xF8, 0x00, 0xFE, 0x00,
  0xF9, 0xFC, 0x00, 0x7E, 0x00, 0x7C, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0x80, 0x0F,
  0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00,
  0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0x00, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8,
  0x7F, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x03,
  0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x01, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x07, 0xF9,
  0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x07, 0xF8, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xCF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xCF,
  0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x0F,
  0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x03, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xCF, 0xF0, 0x00,
  0x07, 0xF9, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF,
  0xCF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x03, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x04, 0x00, 0x00, 0x7F, 0xC0, 0x38, 0x00, 0x07, 0xFC, 0x01, 0xF0, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0x00,
  0x01, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFC, 0xFF,
  0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x1F,
  0xC0, 0x7E, 0x00, 0xFC, 0x1F, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xF8, 0x3F,
  0x00, 0x3F, 0x0F, 0xFC, 0x1F, 0x80, 0x3F, 0x87, 0xFE, 0x0F, 0xC0, 0x1F,
  0x87, 0xDF, 0x0F, 0xC0, 0x0F, 0xC3, 0xEF, 0x87, 0xE0, 0x07, 0xE3, 0xE7,
  0xC3, 0xF0, 0x03, 0xF1, 0xF3, 0xE3, 0xF0, 0x01, 0xF1, 0xF1, 0xF1, 0xF8,
  0x01, 0xF8, 0xF8, 0xF8, 0xFC, 0x00, 0xFC, 0xF8, 0x3C, 0x7E, 0x00, 0x7E,
  0xFC, 0x1E, 0x7E, 0x00, 0x3E, 0x7C, 0x0F, 0xBF, 0x00, 0x1F, 0x7E, 0x07,
  0xDF, 0x80, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x3F,
  0xC7, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x07, 0xF8,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x3F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xF7, 0xF0, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x3F, 0x87, 0xFC, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xF7, 0xFC,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0x3C, 0x00, 0x00, 0xFC, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x08,
  0x00, 0x70, 0x01, 0xE0, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0x40,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x01, 0xFE, 0x07, 0xFE,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x07, 0xF0, 0x7F,
  0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F,
  0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0xBF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0xFE,
  0x00, 0xFF, 0xFF, 0x3F, 0x80, 0x0F, 0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x0F, 0x80, 0x00, 0x3F, 0xDF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x00,
  0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0x80, 0x1F,
  0xF8, 0x1F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF7, 0xF8, 0x0F, 0xFF, 0x00, 0x0C, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x02, 0x03,
  0xFF, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xBF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x3F, 0x80, 0x01,
  0xFF, 0xE0, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x02, 0x03, 0xFF, 0x00, 0x07,
  0x01, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x8F, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x04, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF1, 0xFF, 0x00, 0x0F,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF1, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x10, 0x00, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03,
  0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x30,
  0x00, 0xFF, 0x80, 0x01, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x07,
  0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF1,
  0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x03, 0xF9, 0xFF, 0x00, 0x00,
  0x1F, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xDF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x18, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0x80,
  0x0F, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC3, 0xFE, 0x3F, 0x80,
  0x7E, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x03,
  0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0,
  0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x1F,
  0x81, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x81,
  0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFC,
  0x01, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F,
  0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00,
  0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x07,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xC0,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xE0, 0x03, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0xF0, 0x07, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFE, 0x01, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0x03, 0xFE,
  0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xBF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFE, 0xFF, 0x00, 0x00, 0x7C, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x18, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC7, 0xF8, 0x01, 0xFE,
  0x00, 0x18, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x01, 0x00, 0x00, 0xFF, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x87, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xC1, 0xFE,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xFC,
  0x07, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF7, 0xF0, 0x0F, 0xFF, 0xF3,
  0xF8, 0x01, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x00,
  0x01, 0xFE, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80,
  0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x0F,
  0xE1, 0xFC, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x1F, 0x80,
  0xFE, 0x07, 0xF0, 0x7E, 0x07, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xE0, 0x7E,
  0x07, 0xE0, 0xFF, 0x83, 0xF8, 0x1F, 0x83, 0xFE, 0x0F, 0xC0, 0x7E, 0x1F,
  0xF8, 0x3F, 0x03, 0xF8, 0x7F, 0xE1, 0xF8, 0x0F, 0xC3, 0xFF, 0x87, 0xE0,
  0x3F, 0x0F, 0xBF, 0x1F, 0x80, 0xFC, 0x7E, 0x7C, 0xFC, 0x03, 0xF1, 0xF1,
  0xF3, 0xF0, 0x0F, 0xCF, 0x87, 0xCF, 0x80, 0x3F, 0x7E, 0x1F, 0x7E, 0x00,
  0xFD, 0xF0, 0x7D, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x20,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x04,
  0x00, 0x7F, 0xC0, 0x01, 0xE0, 0x7F, 0xFC, 0x00, 0xFC, 0x3F, 0xFF, 0x80,
  0x3F, 0x1F, 0xFF, 0xF8, 0x1F, 0x87, 0xFF, 0xFF, 0xBF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFC, 0x1F, 0xFF, 0xFC, 0x7E, 0x01, 0xFF, 0xFE, 0x3F, 0x80,
  0x3F, 0xFF, 0x0F, 0xC0, 0x07, 0xFF, 0x80, 0x60, 0x00, 0x7F, 0x80,
};

const GFXglyph UbuntuSansMono_MediumItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 19, 47, 38, 10, -46 },
  { 113, 24, 20, 38, 13, -51 },
  { 173, 40, 46, 38, 0, -46 },
  { 403, 35, 59, 38, 2, -52 },
  { 662, 45, 49, 38, -2, -48 },
  { 938, 34, 49, 38, 1, -48 },
  { 1147, 11, 21, 38, 19, -51 },
  { 1176, 29, 66, 38, 8, -53 },
  { 1416, 29, 66, 38, 1, -53 },
  { 1656, 30, 28, 38, 7, -46 },
  { 1761, 32, 33, 38, 3, -36 },
  { 1893, 17, 22, 38, 5, -11 },
  { 1940, 20, 7, 38, 9, -23 },
  { 1958, 12, 12, 38, 10, -11 },
  { 1976, 44, 64, 38, -4, -52 },
  { 2328, 34, 49, 38, 3, -48 },
  { 2537, 29, 46, 38, 3, -46 },
  { 2704, 36, 48, 38, 1, -48 },
  { 2920, 35, 49, 38, 1, -48 },
  { 3135, 36, 46, 38, 1, -46 },
  { 3342, 38, 47, 38, 1, -46 },
  { 3566, 35, 48, 38, 4, -47 },
  { 3776, 35, 46, 38, 7, -46 },
  { 3978, 35, 49, 38, 3, -48 },
  { 4193, 35, 48, 38, 2, -48 },
  { 4403, 17, 36, 38, 10, -35 },
  { 4480, 22, 46, 38, 5, -35 },
  { 4607, 34, 31, 38, 3, -35 },
  { 4739, 36, 21, 38, 1, -30 },
  { 4834, 34, 31, 38, 1, -35 },
  { 4966, 27, 49, 38, 9, -48 },
  { 5132, 37, 58, 38, 2, -48 },
  { 5401, 37, 46, 38, -4, -46 },
  { 5614, 37, 47, 38, 0, -47 },
  { 5832, 36, 49, 38, 4, -48 },
  { 6053, 37, 47, 38, 0, -47 },
  { 6271, 38, 46, 38, 2, -46 },
  { 6490, 39, 46, 38, 2, -46 },
  { 6715, 36, 49, 38, 3, -48 },
  { 6936, 41, 46, 38, 0, -46 },
  { 7172, 38, 46, 38, 1, -46 },
  { 7391, 38, 47, 38, 1, -46 },
  { 7615, 42, 46, 38, 0, -46 },
  { 7857, 29, 46, 38, 1, -46 },
  { 8024, 42, 46, 38, -2, -46 },
  { 8266, 41, 46, 38, 0, -46 },
  { 8502, 35, 49, 38, 3, -48 },
  { 8717, 37, 47, 38, 1, -47 },
  { 8935, 35, 61, 38, 3, -48 },
  { 9202, 37, 47, 38, 0, -47 },
  { 9420, 37, 49, 38, 1, -48 },
  { 9647, 34, 46, 38, 8, -46 },
  { 9843, 37, 47, 38, 3, -46 },
  { 10061, 36, 46, 38, 7, -46 },
  { 10268, 41, 46, 38, 1, -46 },
  { 10504, 45, 46, 38, -2, -46 },
  { 10763, 36, 46, 38, 8, -46 },
  { 10970, 40, 46, 38, 0, -46 },
  { 11200, 35, 64, 38, 4, -52 },
  { 11480, 13, 64, 38, 13, -52 },
  { 11584, 35, 64, 38, -1, -52 },
  { 11864, 33, 26, 38, 4, -46 },
  { 11972, 35, 6, 38, -5, 6 },
  { 11999, 14, 14, 38, 16, -52 },
  { 12024, 34, 37, 38, 2, -36 },
  { 12182, 34, 53, 38, 1, -52 },
  { 12408, 33, 37, 38, 3, -36 },
  { 12561, 38, 53, 38, 3, -52 },
  { 12813, 33, 37, 38, 3, -36 },
  { 12966, 45, 65, 38, -3, -52 },
  { 13332, 39, 49, 38, -2, -36 },
  { 13571, 34, 52, 38, 0, -52 },
  { 13792, 24, 52, 38, 6, -52 },
  { 13948, 37, 65, 38, -2, -52 },
  { 14249, 37, 52, 38, 2, -52 },
  { 14490, 21, 53, 38, 10, -52 },
  { 14630, 38, 36, 38, -1, -36 },
  { 14801, 33, 36, 38, 1, -36 },
  { 14950, 32, 37, 38, 3, -36 },
  { 15098, 37, 48, 38, -2, -36 },
  { 15320, 34, 48, 38, 3, -36 },
  { 15524, 34, 36, 38, 3, -36 },
  { 15677, 33, 37, 38, 2, -36 },
  { 15830, 29, 47, 38, 7, -46 },
  { 16001, 33, 36, 38, 3, -35 },
  { 16150, 32, 35, 38, 6, -35 },
  { 16290, 38, 35, 38, 3, -35 },
  { 16457, 40, 35, 38, -2, -35 },
  { 16632, 43, 48, 38, -5, -35 },
  { 16890, 35, 35, 38, 1, -35 },
  { 17044, 36, 64, 38, 4, -52 },
  { 17332, 23, 64, 38, 8, -52 },
  { 17516, 36, 64, 38, -3, -52 },
  { 17804, 34, 12, 38, 2, -26 },
};

const GFXfont UbuntuSansMono_MediumItalic67pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic67pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic67pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC67PT7B_H_
