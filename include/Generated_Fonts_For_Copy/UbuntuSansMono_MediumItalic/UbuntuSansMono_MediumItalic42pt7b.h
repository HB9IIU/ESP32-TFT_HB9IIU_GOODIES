#ifndef _UBUNTUSANSMONO_MEDIUMITALIC42PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7C, 0x01, 0x00, 0x3E, 0x3E,
  0x78, 0x7D, 0xF0, 0xF3, 0xE1, 0xE7, 0x87, 0xCF, 0x0F, 0x9E, 0x1E, 0x3C,
  0x3C, 0xF0, 0x79, 0xE0, 0xE3, 0x81, 0xC7, 0x07, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x0F, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0x3C, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x87, 0x80, 0x07,
  0x83, 0xC0, 0x03, 0xC3, 0xE0, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC0, 0x78, 0x78, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0x80, 0x60, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x0C, 0x01, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xC0, 0x7F, 0x80, 0x38,
  0x07, 0x9C, 0x03, 0xC0, 0x38, 0xF0, 0x3C, 0x03, 0xC7, 0x83, 0xC0, 0x1C,
  0x3C, 0x3C, 0x00, 0xE1, 0xC3, 0xC0, 0x07, 0x0E, 0x1C, 0x00, 0x38, 0x71,
  0xC0, 0x01, 0xC7, 0x9E, 0x00, 0x0F, 0x79, 0xE0, 0x00, 0x7F, 0x9E, 0x00,
  0x01, 0xF9, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0xF3, 0xF8, 0x00, 0x0F, 0x3F, 0xC0, 0x00, 0xF3,
  0xCE, 0x00, 0x0F, 0x1C, 0x70, 0x00, 0x71, 0xE3, 0x80, 0x07, 0x8E, 0x1C,
  0x00, 0x78, 0x70, 0xE0, 0x07, 0x83, 0x87, 0x00, 0x78, 0x1C, 0x78, 0x07,
  0x80, 0xE3, 0x80, 0x38, 0x07, 0xBC, 0x03, 0x80, 0x3F, 0xC0, 0x7C, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3E, 0x1E, 0x01, 0xE0, 0xF0, 0x1F, 0x07,
  0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x1E, 0x01, 0xE1, 0xF0, 0x0F,
  0x9F, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xE1, 0x00, 0xFE, 0x0F,
  0x1F, 0xF8, 0x71, 0xF3, 0xC7, 0x8F, 0x1F, 0x3C, 0xF0, 0x7F, 0xCF, 0x83,
  0xFE, 0x78, 0x0F, 0xE3, 0xC0, 0x3F, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x87,
  0xC0, 0xFE, 0x3F, 0x1F, 0xF0, 0xFF, 0xF7, 0xC7, 0xFF, 0x3E, 0x0F, 0xE0,
  0xF0, 0x3E, 0x7D, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0xF9, 0xE3, 0xC7, 0x0E,
  0x00, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x01, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x02, 0x0F, 0x0C, 0xF1, 0xC7, 0x9F, 0xBB, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00,
  0x7B, 0xE0, 0x1F, 0x3E, 0x07, 0xC7, 0xE0, 0xF8, 0x78, 0x06, 0x0E, 0x00,
  0x40, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x81, 0xF8, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC3, 0xF0, 0x1E, 0x07, 0x81, 0xF3, 0xFC, 0x7F, 0x0F,
  0x81, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7C, 0x10, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F,
  0x3F, 0x03, 0xE0, 0x7C, 0x3E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0x79,
  0xF0, 0x03, 0xCF, 0x80, 0x1E, 0x78, 0x01, 0xF7, 0xC7, 0x8F, 0xBE, 0x7C,
  0x7D, 0xE3, 0xE3, 0xEF, 0x1F, 0x1E, 0xF8, 0xF8, 0xF7, 0xC3, 0x8F, 0xBE,
  0x00, 0x7D, 0xF0, 0x03, 0xCF, 0x00, 0x3E, 0x78, 0x01, 0xF3, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x1F, 0xBF, 0xC0, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE0,
  0xFE, 0xF0, 0x3F, 0x7C, 0x07, 0x1F, 0x01, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x1F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xF1, 0xFC, 0x0E, 0x01, 0xF0, 0x20, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x0F, 0x0F, 0xC0, 0x10, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0xBF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x40, 0x0F, 0xC1, 0xF8, 0x7F, 0x83, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x3C, 0x00, 0x7C, 0xF8, 0x01,
  0xF1, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x07, 0x80, 0x3C, 0x1F, 0x00, 0xF0,
  0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x78, 0x07,
  0xC1, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x20, 0x07, 0xE0,
  0x7E, 0x7F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x9F, 0xC0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0x00, 0xF8, 0x78,
  0x01, 0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01,
  0xE3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x1E, 0x00, 0xF8, 0x7C, 0x07, 0xC1,
  0xFC, 0x7E, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x07,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xE0, 0xF8,
  0x1F, 0x01, 0xE0, 0xF8, 0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x78, 0x3C,
  0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xE0, 0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xBF, 0x80, 0xFC, 0x7F, 0x07,
  0xC0, 0x7C, 0x1E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xC0, 0x0F, 0x8F, 0x00,
  0x3E, 0x3C, 0x00, 0xF8, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0xC1, 0xF8,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0xF1, 0xF8, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x0F, 0x1F, 0x00,
  0x3C, 0x7C, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x1F, 0x00, 0x3C,
  0x7C, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x07,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF0, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7E, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xE0, 0xF8, 0x04, 0x00, 0x00, 0x78, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x0F,
  0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0x3C, 0x01,
  0xE0, 0x0F, 0x83, 0xFC, 0x0F, 0xE0, 0x3E, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xE0,
  0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xFF,
  0x0F, 0xFF, 0xC3, 0xFF, 0xE1, 0xC1, 0xF9, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x00,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFE, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x1F, 0x0F,
  0x80, 0x0F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x5E, 0x1E, 0x07, 0xFE, 0x3C,
  0x1F, 0xFE, 0x3C, 0x3F, 0xFE, 0x3C, 0x7E, 0x3E, 0x78, 0x7C, 0x3C, 0x78,
  0xF8, 0x3C, 0x78, 0xF0, 0x3C, 0x78, 0xF0, 0x7C, 0xF1, 0xF0, 0x78, 0xF1,
  0xF0, 0x78, 0xF1, 0xE0, 0x78, 0xF1, 0xE0, 0xF8, 0xF1, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xFF, 0xF0, 0xF0, 0xFF, 0xF0, 0xF8, 0x7F, 0xE0, 0x78,
  0x1F, 0xC0, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0xC3, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0x9E,
  0x00, 0x3E, 0x78, 0x00, 0xF1, 0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x0F, 0x00,
  0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0,
  0x3C, 0x1F, 0x00, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF1, 0xE0, 0x03, 0xCF, 0x80, 0x0F, 0x3E, 0x00, 0x3D, 0xF0,
  0x00, 0xF7, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3C, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3E, 0x03,
  0xE0, 0x78, 0x07, 0xC1, 0xF0, 0x07, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E,
  0x0F, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x7C, 0x0F, 0xC0, 0xFF, 0xFF, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0x01, 0xF8, 0x3C,
  0x01, 0xF0, 0x78, 0x01, 0xE1, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x87, 0x80,
  0x1F, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7C, 0x07, 0xF0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xE7,
  0xC0, 0xFE, 0x01, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x01,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x3C, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x0F,
  0x83, 0xE0, 0x1F, 0x07, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x80, 0x1E, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0,
  0x07, 0xC3, 0xC0, 0x1F, 0x87, 0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x3E, 0x03,
  0xF0, 0x78, 0x1F, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x10, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xC7,
  0xC0, 0xFC, 0x01, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0,
  0x03, 0xE3, 0xE0, 0x07, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xFC, 0x07, 0xC0, 0xFC, 0x0F,
  0x81, 0xFF, 0x7E, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x3E,
  0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xC0, 0x0F, 0x01, 0xF0, 0x03, 0xC0,
  0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x1E, 0x03, 0xE0, 0x07,
  0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1E, 0x00, 0x7C, 0x0F,
  0x80, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3C, 0x00, 0xF8,
  0x1F, 0x00, 0x3C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x78, 0x01,
  0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8,
  0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x10, 0x07, 0xC0,
  0x70, 0x1F, 0x80, 0xFD, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x78, 0x07,
  0xE0, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xF0,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x01,
  0xE3, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x7E,
  0x00, 0x07, 0xCF, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x1F, 0x03, 0xE0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E,
  0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x3F, 0x83, 0xB8, 0x0F, 0xE1,
  0xFE, 0x03, 0xBC, 0x77, 0x81, 0xEF, 0x3D, 0xC0, 0x79, 0xCE, 0x70, 0x1E,
  0x77, 0x3C, 0x07, 0x1D, 0xCF, 0x03, 0xC7, 0xE3, 0xC0, 0xF1, 0xF8, 0xF0,
  0x3C, 0x7C, 0x78, 0x1E, 0x1F, 0x1E, 0x07, 0x87, 0x87, 0x81, 0xE0, 0x01,
  0xE0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0,
  0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x07,
  0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x07, 0xC0, 0xFC, 0x01, 0xE0, 0x3F, 0x00, 0x78, 0x0F, 0xC0, 0x1E, 0x03,
  0xF8, 0x0F, 0x01, 0xFE, 0x03, 0xC0, 0x7F, 0x80, 0xF0, 0x1E, 0xE0, 0x3C,
  0x07, 0xBC, 0x1F, 0x01, 0xEF, 0x07, 0x80, 0xF3, 0xC1, 0xE0, 0x3C, 0x70,
  0x78, 0x0F, 0x1E, 0x3E, 0x03, 0xC7, 0x8F, 0x01, 0xE1, 0xE3, 0xC0, 0x78,
  0x38, 0xF0, 0x1E, 0x0F, 0x7C, 0x07, 0x83, 0xDE, 0x03, 0xE0, 0xF7, 0x80,
  0xF0, 0x1D, 0xE0, 0x3C, 0x07, 0x78, 0x0F, 0x01, 0xFC, 0x07, 0xC0, 0x7F,
  0x01, 0xE0, 0x1F, 0xC0, 0x78, 0x03, 0xF0, 0x1E, 0x00, 0xF8, 0x0F, 0x80,
  0x3E, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xF3, 0xF8, 0x3F,
  0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x01,
  0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x79, 0xF0, 0x01, 0xE7,
  0x80, 0x07, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80,
  0x0F, 0x3C, 0x00, 0x7C, 0xF0, 0x01, 0xF3, 0xC0, 0x0F, 0x8F, 0x00, 0x3E,
  0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xF0, 0x7E, 0x07, 0xF7, 0xF0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03,
  0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xC0, 0x1F, 0x07,
  0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x3E, 0x0F,
  0x80, 0x7E, 0x0F, 0x80, 0xFC, 0x0F, 0x9F, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xF3, 0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x1F,
  0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x7C,
  0x00, 0x79, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0xBE, 0x00, 0x3E, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0x3C, 0x00, 0x7C, 0xF0, 0x01, 0xF3,
  0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xF0,
  0x7E, 0x07, 0xF7, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xDF, 0xE0, 0x3E,
  0x07, 0xE0, 0x78, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0,
  0x3E, 0x0F, 0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x0F,
  0xC1, 0xE0, 0x7F, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x78, 0x07,
  0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x3E, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0xF8,
  0x07, 0xC1, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01,
  0xF8, 0x3E, 0x03, 0xE0, 0x04, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x30, 0x03, 0xE0, 0x7F, 0x3F, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x01,
  0xF0, 0xF0, 0x03, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E,
  0x1E, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3,
  0xC0, 0x0F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x78,
  0x01, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x00,
  0x3C, 0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F,
  0x81, 0xFC, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xEF, 0x00, 0x0F,
  0xBC, 0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3C,
  0x00, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1E, 0x0F, 0x80, 0xF8, 0x3E, 0x03,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x00,
  0xF8, 0x7C, 0x03, 0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3C, 0x00, 0x79,
  0xF0, 0x01, 0xE7, 0x80, 0x07, 0xBE, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x78, 0x3C, 0x00,
  0x3E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x78,
  0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0,
  0xF0, 0xF0, 0xF0, 0x3C, 0x3C, 0x3C, 0x0F, 0x1F, 0x0F, 0x03, 0xCF, 0xE3,
  0x80, 0xE3, 0xB9, 0xE0, 0x79, 0xEE, 0x78, 0x1E, 0x73, 0x9E, 0x07, 0xBC,
  0xE7, 0x01, 0xEE, 0x3B, 0xC0, 0x77, 0x8E, 0xF0, 0x1D, 0xC3, 0xB8, 0x0F,
  0xE0, 0xEE, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80,
  0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xF1, 0xE0,
  0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x1F,
  0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x07,
  0x80, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x80,
  0x0F, 0x9E, 0x00, 0x7C, 0x78, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7C,
  0x1F, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x7C, 0x03, 0xE3, 0xE0, 0x07,
  0x8F, 0x00, 0x1E, 0x7C, 0x00, 0x7B, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x0F, 0x0F, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x03, 0xE7, 0x80, 0x7C, 0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0x3C,
  0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x01, 0xEF, 0x80, 0x1F, 0x70, 0x01,
  0xF3, 0x00, 0x08, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0x20, 0x18, 0x1E, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0E, 0x03,
  0x00, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE,
  0x0F, 0xC0, 0xF8, 0x7E, 0x03, 0xC3, 0xF0, 0x0F, 0x0F, 0x80, 0x7C, 0x3C,
  0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1E, 0x1E, 0x00, 0xF8, 0x78, 0x03,
  0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0xC1,
  0xF0, 0x3F, 0x07, 0xF7, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xCF, 0x80, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x7F,
  0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xF0, 0x3F, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F,
  0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF3, 0xE0,
  0x1F, 0x9F, 0x00, 0xF8, 0xF0, 0x0F, 0x87, 0x81, 0xFC, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x04, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xC1, 0xF0,
  0x3F, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0x7C, 0x03, 0xE0,
  0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xC0, 0xF0, 0x07, 0xC0,
  0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0x80, 0xF8, 0x07, 0x80,
  0xF8, 0x1F, 0x80, 0xFE, 0x7F, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xE3, 0xC0, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x07,
  0xFF, 0xF0, 0xFE, 0x7F, 0x1F, 0x81, 0xF3, 0xE0, 0x0F, 0x7C, 0x00, 0xF7,
  0xC0, 0x1F, 0x78, 0x03, 0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x08, 0x7F, 0x9F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF,
  0xF0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFC, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x47, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0x3F, 0x03, 0xF8, 0x1E, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3C, 0x0F, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x83, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xF9, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x40, 0x07, 0xC0, 0x70, 0x1F, 0x80, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x08,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE1, 0xF0, 0x3F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E,
  0x1E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x78, 0x7C, 0x07, 0xC3, 0xC0,
  0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x07, 0xC7,
  0xC0, 0x3E, 0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0xF8, 0xF8, 0x07,
  0xC0, 0x00, 0x20, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x87,
  0xFF, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x83,
  0xFF, 0x03, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x02, 0x01, 0xF0, 0x07, 0x07,
  0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x08, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xF0,
  0x7C, 0x0F, 0xC0, 0xF0, 0x3F, 0x03, 0xE0, 0xFC, 0x07, 0xC3, 0xF0, 0x0F,
  0x8F, 0xC0, 0x1E, 0x3E, 0x00, 0x7D, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xBE, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7E,
  0x00, 0x7C, 0x7C, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8,
  0x0F, 0x81, 0xF8, 0x1E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE0,
  0x7F, 0xF7, 0xFF, 0x3F, 0xF9, 0xFF, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x17, 0xFF, 0x9F,
  0xFC, 0xFF, 0xE3, 0xFF, 0x03, 0x00, 0x01, 0xFC, 0x7C, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x07, 0x9F, 0x9F, 0x07, 0x8F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x1F, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C, 0x1E, 0x3C, 0x3C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xF8,
  0x1F, 0x07, 0xC0, 0x7C, 0x3C, 0x03, 0xE3, 0xE0, 0x1E, 0x1F, 0x00, 0xF0,
  0xF8, 0x0F, 0x87, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1E, 0x1F, 0x00,
  0xF0, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xC3, 0xE0, 0x1E, 0x1E,
  0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x78, 0x7C, 0x07, 0xC0, 0x00, 0xFF,
  0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x83, 0xF3, 0xE0,
  0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF,
  0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x81, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xE0,
  0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xCF, 0xE0, 0x3C, 0x07, 0xE0, 0x78,
  0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00,
  0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xC1, 0xE0, 0x0F,
  0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF8, 0x3C, 0x0F, 0xE0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC, 0x1F,
  0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xC0,
  0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x7C, 0x03, 0xE3,
  0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x1F, 0x9F,
  0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xF7, 0xE0, 0x7C, 0x01, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC1, 0x00, 0x3E, 0x1F, 0x8F, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0x07, 0x80, 0x00, 0x00, 0x10, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x03, 0xFF, 0xFF,
  0x7F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x01, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x01, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0x80,
  0x7C, 0x3C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0xF0, 0x0F, 0x87,
  0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1E, 0x1F, 0x01, 0xF0, 0xF0, 0x0F,
  0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xC3, 0xE0, 0x1E, 0x1F, 0x01, 0xF0, 0xF8,
  0x0F, 0x87, 0xC0, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0x78,
  0x0F, 0xF3, 0xE0, 0x08, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x87,
  0x80, 0xF8, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x3E, 0x07, 0xC3, 0xC0,
  0x7C, 0x7C, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x03, 0xDF, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFB, 0xC0, 0x01,
  0xE7, 0x80, 0x03, 0xCF, 0x0F, 0x07, 0x9E, 0x1E, 0x1E, 0x78, 0x7C, 0x3C,
  0xF0, 0xF8, 0x79, 0xE3, 0xF1, 0xE3, 0xC7, 0xE3, 0xC7, 0x9F, 0xC7, 0x0F,
  0x3B, 0x9E, 0x1E, 0xF7, 0xBC, 0x3D, 0xCF, 0x70, 0x77, 0x9F, 0xE0, 0xFE,
  0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x01,
  0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x07, 0xCF, 0xC0,
  0x03, 0xE7, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xC3, 0xE0, 0x07, 0xC1,
  0xF0, 0x07, 0xE0, 0x78, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0x07, 0xE0,
  0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x01, 0xE0, 0x1F, 0x00, 0x3E,
  0x03, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x1E, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF9,
  0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3D, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x08, 0x3F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xC0, 0x30, 0x7F, 0xC0, 0xF3, 0xFF, 0x87, 0x8F, 0xFF, 0xFE, 0x78,
  0x7F, 0xF3, 0xC0, 0xFF, 0x87, 0x00, 0xFC, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 12, 30, 24, 6, -29 },
  { 46, 15, 12, 24, 8, -32 },
  { 69, 25, 29, 24, 0, -29 },
  { 160, 22, 38, 24, 1, -33 },
  { 265, 29, 31, 24, -2, -30 },
  { 378, 21, 30, 24, 1, -30 },
  { 457, 7, 13, 24, 12, -32 },
  { 469, 18, 41, 24, 5, -33 },
  { 562, 18, 41, 24, 1, -33 },
  { 655, 19, 18, 24, 4, -29 },
  { 698, 20, 21, 24, 2, -23 },
  { 751, 11, 14, 24, 3, -7 },
  { 771, 12, 4, 24, 6, -14 },
  { 777, 8, 8, 24, 6, -7 },
  { 785, 27, 41, 24, -2, -33 },
  { 924, 21, 31, 24, 2, -30 },
  { 1006, 18, 29, 24, 2, -29 },
  { 1072, 22, 30, 24, 1, -30 },
  { 1155, 23, 31, 24, 0, -30 },
  { 1245, 23, 29, 24, 0, -29 },
  { 1329, 24, 30, 24, 0, -29 },
  { 1419, 22, 30, 24, 2, -29 },
  { 1502, 22, 29, 24, 4, -29 },
  { 1582, 22, 31, 24, 2, -30 },
  { 1668, 22, 30, 24, 1, -30 },
  { 1751, 11, 23, 24, 6, -22 },
  { 1783, 14, 29, 24, 3, -22 },
  { 1834, 21, 20, 24, 2, -22 },
  { 1887, 22, 13, 24, 1, -19 },
  { 1923, 21, 20, 24, 1, -22 },
  { 1976, 17, 31, 24, 6, -30 },
  { 2042, 24, 36, 24, 1, -30 },
  { 2150, 22, 29, 24, -2, -29 },
  { 2230, 23, 29, 24, 0, -29 },
  { 2314, 23, 31, 24, 2, -30 },
  { 2404, 23, 29, 24, 0, -29 },
  { 2488, 24, 29, 24, 1, -29 },
  { 2575, 24, 29, 24, 1, -29 },
  { 2662, 23, 31, 24, 2, -30 },
  { 2752, 26, 29, 24, 0, -29 },
  { 2847, 23, 29, 24, 1, -29 },
  { 2931, 23, 30, 24, 1, -29 },
  { 3018, 26, 29, 24, 0, -29 },
  { 3113, 18, 29, 24, 1, -29 },
  { 3179, 26, 29, 24, -1, -29 },
  { 3274, 26, 29, 24, 0, -29 },
  { 3369, 22, 31, 24, 2, -30 },
  { 3455, 24, 29, 24, 0, -29 },
  { 3542, 22, 38, 24, 2, -30 },
  { 3647, 23, 29, 24, 0, -29 },
  { 3731, 24, 31, 24, 0, -30 },
  { 3824, 21, 29, 24, 5, -29 },
  { 3901, 23, 30, 24, 2, -29 },
  { 3988, 22, 29, 24, 5, -29 },
  { 4068, 26, 29, 24, 1, -29 },
  { 4163, 28, 29, 24, -1, -29 },
  { 4265, 22, 29, 24, 5, -29 },
  { 4345, 25, 29, 24, 0, -29 },
  { 4436, 22, 41, 24, 3, -33 },
  { 4549, 8, 41, 24, 8, -33 },
  { 4590, 22, 41, 24, -1, -33 },
  { 4703, 20, 16, 24, 3, -29 },
  { 4743, 22, 4, 24, -3, 4 },
  { 4754, 9, 9, 24, 10, -33 },
  { 4765, 22, 23, 24, 1, -22 },
  { 4829, 21, 34, 24, 1, -33 },
  { 4919, 21, 23, 24, 2, -22 },
  { 4980, 24, 34, 24, 2, -33 },
  { 5082, 20, 23, 24, 2, -22 },
  { 5140, 28, 41, 24, -2, -33 },
  { 5284, 24, 30, 24, -1, -22 },
  { 5374, 21, 33, 24, 0, -33 },
  { 5461, 15, 33, 24, 4, -33 },
  { 5523, 23, 41, 24, -1, -33 },
  { 5641, 23, 33, 24, 1, -33 },
  { 5736, 13, 33, 24, 6, -32 },
  { 5790, 24, 22, 24, -1, -22 },
  { 5856, 21, 22, 24, 1, -22 },
  { 5914, 20, 23, 24, 2, -22 },
  { 5972, 23, 30, 24, -1, -22 },
  { 6059, 21, 30, 24, 2, -22 },
  { 6138, 21, 22, 24, 2, -22 },
  { 6196, 21, 23, 24, 1, -22 },
  { 6257, 19, 30, 24, 4, -29 },
  { 6329, 21, 23, 24, 2, -22 },
  { 6390, 20, 22, 24, 4, -22 },
  { 6445, 23, 22, 24, 2, -22 },
  { 6509, 25, 22, 24, -1, -22 },
  { 6578, 27, 30, 24, -3, -22 },
  { 6680, 22, 22, 24, 1, -22 },
  { 6741, 22, 41, 24, 3, -33 },
  { 6854, 14, 41, 24, 5, -33 },
  { 6926, 23, 41, 24, -2, -33 },
  { 7044, 22, 7, 24, 1, -16 },
};

const GFXfont UbuntuSansMono_MediumItalic42pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic42pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic42pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC42PT7B_H_
