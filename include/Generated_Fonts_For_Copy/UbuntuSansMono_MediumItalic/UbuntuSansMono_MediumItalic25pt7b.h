#ifndef _UBUNTUSANSMONO_MEDIUMITALIC25PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x38, 0x70, 0xE1, 0xC7, 0x8E, 0x1C, 0x38, 0x60, 0xC0, 0x00,
  0x0C, 0x3C, 0x78, 0xE0, 0x73, 0xB1, 0xB9, 0xDC, 0xEC, 0x66, 0x33, 0x18,
  0x01, 0xCE, 0x07, 0x18, 0x0C, 0x70, 0x18, 0xC3, 0xFF, 0xE7, 0xFF, 0x83,
  0x8C, 0x06, 0x38, 0x0C, 0x60, 0x39, 0xC1, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF,
  0x8E, 0x30, 0x18, 0xE0, 0x31, 0x80, 0xE7, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0xF0, 0x1F, 0xF1, 0xFF, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x88, 0x1C, 0xFF, 0xC7,
  0xFC, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x87, 0xC1,
  0x87, 0x61, 0x83, 0x31, 0xC1, 0x99, 0xC0, 0xCC, 0xC0, 0x6C, 0xC0, 0x3E,
  0xC0, 0x0E, 0xC0, 0x00, 0xC0, 0x00, 0xEF, 0x00, 0x6F, 0x80, 0x6C, 0xC0,
  0x66, 0x60, 0x63, 0x30, 0x61, 0x98, 0x70, 0xD8, 0x70, 0x7C, 0x00, 0x01,
  0xC0, 0x3F, 0x83, 0xDC, 0x1C, 0x60, 0xC3, 0x06, 0x38, 0x33, 0x81, 0xF8,
  0x0F, 0x80, 0xF8, 0xCE, 0xCE, 0xE7, 0x66, 0x1F, 0x70, 0x73, 0x83, 0x8E,
  0x3C, 0x7F, 0xF1, 0xF3, 0x80, 0x77, 0x76, 0xEE, 0xCC, 0x00, 0x40, 0x18,
  0x07, 0x83, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30,
  0x07, 0x00, 0xE0, 0x0F, 0x00, 0xC0, 0x10, 0x00, 0x01, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x81,
  0xE0, 0x78, 0x3E, 0x03, 0x00, 0x40, 0x00, 0x0E, 0x01, 0x83, 0x31, 0x7E,
  0xEF, 0xFE, 0x18, 0x07, 0xC1, 0xDC, 0x73, 0x86, 0x20, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x1C, 0x00, 0x3C, 0xF3, 0xCF, 0x1C, 0xEF, 0x30, 0x7F,
  0xFE, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x3F, 0x03, 0xFC, 0x38, 0x73,
  0x83, 0x9C, 0x1D, 0xC0, 0xEE, 0x67, 0x67, 0x37, 0x39, 0xB9, 0x9D, 0xC0,
  0xEE, 0x06, 0x70, 0x73, 0x87, 0x1E, 0x78, 0x7F, 0x81, 0xF8, 0x00, 0x00,
  0xE0, 0x78, 0x3F, 0x1F, 0xE1, 0xDC, 0x23, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x8B, 0xFE, 0xFF, 0xC0, 0x03,
  0xC0, 0x7F, 0x87, 0xFC, 0x30, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C,
  0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x01, 0xE0, 0x7F, 0x83, 0xFE, 0x10, 0x70,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x1E, 0x07, 0xE0, 0x3F, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC8, 0x1C, 0x7F, 0xE7, 0xFC, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xB0, 0x1C, 0xC0, 0xE7, 0x07,
  0x1C, 0x38, 0x70, 0xC1, 0x87, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC4, 0x1E, 0x1F, 0xF0, 0xFF, 0x80, 0x00,
  0xF8, 0x1F, 0xC3, 0xE0, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xCE, 0x0F, 0xFC,
  0x7D, 0xE3, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0x30, 0x71, 0xC7, 0x8F,
  0xF8, 0x3F, 0x80, 0x7F, 0xFB, 0xFF, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x7F, 0x87, 0xFE,
  0x38, 0x71, 0x83, 0x9C, 0x1C, 0xE0, 0xC3, 0x8E, 0x0F, 0xE0, 0xFE, 0x0E,
  0x78, 0xE1, 0xCE, 0x06, 0x70, 0x33, 0x83, 0x9C, 0x3C, 0x7F, 0xC1, 0xFC,
  0x00, 0x03, 0xC0, 0x7F, 0x07, 0xFC, 0x70, 0x73, 0x83, 0x98, 0x1D, 0xC0,
  0xEE, 0x07, 0x38, 0x39, 0xFF, 0x87, 0xFC, 0x00, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x03, 0xF0, 0xFE, 0x07, 0xC0, 0x00, 0x3C, 0xF3, 0xCF, 0x00, 0x00,
  0x00, 0x03, 0xCF, 0x3C, 0xF0, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x38, 0xF0, 0xC0, 0x00, 0x10,
  0x03, 0xC0, 0xFE, 0x1F, 0x87, 0xE0, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x70, 0x00, 0x80, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x3F, 0xFC, 0x20, 0x03, 0x80, 0x7F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x01, 0xF0, 0xFC, 0x7F, 0x0F, 0x80, 0xE0,
  0x08, 0x00, 0x0F, 0x07, 0xF8, 0xFF, 0x00, 0x70, 0x0E, 0x03, 0x80, 0xF0,
  0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0xF0, 0x0E, 0x00, 0x01, 0xE0, 0x1F, 0xE0, 0xF7, 0x87, 0x07, 0x38, 0x1C,
  0xC0, 0x77, 0x1F, 0x98, 0xFE, 0xE7, 0x3B, 0xB8, 0xEC, 0xE3, 0x33, 0x0C,
  0xCC, 0x73, 0x39, 0xCC, 0xE6, 0x31, 0xF8, 0xC3, 0xE3, 0x80, 0x07, 0x00,
  0x1F, 0x20, 0x3F, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03,
  0x60, 0x3B, 0x81, 0x9C, 0x1C, 0xE1, 0xC7, 0x0C, 0x38, 0xE1, 0xC7, 0xFE,
  0x7F, 0xF3, 0xFF, 0xB8, 0x1D, 0xC0, 0xFC, 0x07, 0xE0, 0x38, 0x00, 0x80,
  0x3F, 0xE0, 0xFF, 0x83, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0xC3, 0x86, 0x1E,
  0x3F, 0xE0, 0xFF, 0xC3, 0x87, 0x0C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x07,
  0x18, 0x3C, 0xFF, 0xE3, 0xFE, 0x00, 0x00, 0xF0, 0x0F, 0xF0, 0xFF, 0x87,
  0x82, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x10, 0x3F, 0xE0,
  0x7F, 0x00, 0x01, 0x00, 0x3F, 0x80, 0xFF, 0x07, 0x0E, 0x1C, 0x38, 0x70,
  0x71, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x63, 0x03, 0x9C, 0x0E, 0x70,
  0x79, 0xC1, 0xC6, 0x0E, 0x38, 0xF8, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xFC,
  0x7F, 0xE1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xF8,
  0x3F, 0xE0, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00,
  0x3F, 0xF8, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF1, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x1F, 0xF0, 0xFF, 0x87, 0x82, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x63, 0x83, 0x8E, 0x0E,
  0x1C, 0x38, 0x7F, 0xC0, 0xFF, 0x00, 0x0E, 0x0E, 0x18, 0x1C, 0x70, 0x38,
  0xE0, 0xE1, 0xC1, 0xC3, 0x03, 0x8E, 0x07, 0x1F, 0xFC, 0x3F, 0xF8, 0x60,
  0x71, 0xC0, 0xE3, 0x81, 0x87, 0x07, 0x0C, 0x0E, 0x38, 0x1C, 0x70, 0x30,
  0xE0, 0xE0, 0x1F, 0xFC, 0x7F, 0xE0, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x18, 0x78,
  0x7F, 0xE0, 0x3F, 0x80, 0x0E, 0x0F, 0x0E, 0x1C, 0x0C, 0x38, 0x1C, 0x70,
  0x1C, 0xE0, 0x1D, 0xC0, 0x1B, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x33, 0x80, 0x71, 0xC0, 0x71, 0xC0, 0x70, 0xE0, 0x60, 0xE0, 0xE0, 0x70,
  0xE0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0x07, 0x07, 0x0F, 0x07, 0x0E, 0x0F, 0x1E, 0x0D, 0x1E,
  0x0D, 0x36, 0x1D, 0xA6, 0x19, 0xEE, 0x19, 0xCC, 0x39, 0xCC, 0x39, 0x8C,
  0x30, 0x1C, 0x30, 0x1C, 0x70, 0x18, 0x70, 0x18, 0x60, 0x38, 0xE0, 0x38,
  0x0E, 0x06, 0x1C, 0x1C, 0x78, 0x38, 0xF8, 0x61, 0xB0, 0xC3, 0x63, 0x8E,
  0xE7, 0x1C, 0xCC, 0x31, 0x98, 0x63, 0x71, 0xC6, 0xE3, 0x87, 0x86, 0x0F,
  0x0C, 0x1E, 0x18, 0x3C, 0x70, 0x70, 0xE0, 0xE0, 0x01, 0xC0, 0x3F, 0x83,
  0xFC, 0x38, 0x73, 0x83, 0x9C, 0x1D, 0xC0, 0xEE, 0x07, 0x60, 0x3F, 0x01,
  0xF8, 0x0D, 0xC0, 0xEE, 0x07, 0x70, 0x73, 0x83, 0x9E, 0x38, 0x7F, 0x81,
  0xF8, 0x00, 0x00, 0xC0, 0x3F, 0xE0, 0xFF, 0xC3, 0x87, 0x0C, 0x1C, 0x70,
  0x71, 0xC1, 0xC7, 0x07, 0x18, 0x38, 0xFF, 0xE3, 0xFE, 0x0F, 0xE0, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x3F, 0x83, 0xFC, 0x38, 0x73, 0x83, 0x9C, 0x1D, 0xC0, 0xEE, 0x07, 0x60,
  0x3F, 0x01, 0xF8, 0x0D, 0xC0, 0xEE, 0x07, 0x70, 0x73, 0x83, 0x9E, 0x38,
  0x7F, 0x81, 0xF8, 0x07, 0x00, 0x38, 0x00, 0xFC, 0x03, 0xC0, 0x02, 0x00,
  0x01, 0x80, 0x3F, 0xC0, 0xFF, 0x83, 0x0F, 0x1C, 0x1C, 0x70, 0x71, 0xC1,
  0xC6, 0x0E, 0x38, 0x78, 0xFF, 0xC3, 0xFC, 0x0C, 0x70, 0x71, 0xC1, 0xC3,
  0x87, 0x0E, 0x18, 0x38, 0xE0, 0x63, 0x81, 0xC0, 0x00, 0xF0, 0x1F, 0xF0,
  0xFF, 0xC3, 0x82, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x18, 0x38,
  0xFF, 0xE1, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x83, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x1C, 0xE0, 0x73,
  0x81, 0x8E, 0x0E, 0x38, 0x38, 0xC0, 0xE7, 0x03, 0x1C, 0x1C, 0x70, 0x71,
  0x81, 0xCE, 0x07, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x8F, 0x1C, 0x1F, 0xE0,
  0x3F, 0x00, 0xE0, 0x3F, 0x03, 0xB8, 0x1D, 0xC1, 0xCE, 0x0E, 0x70, 0x63,
  0x87, 0x1C, 0x30, 0xE3, 0x87, 0x18, 0x39, 0xC1, 0xCC, 0x0E, 0xE0, 0x7E,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x00, 0x1C, 0x07, 0x1C, 0x06, 0x18, 0x06,
  0x18, 0x0E, 0x38, 0x0C, 0x38, 0x0C, 0x31, 0x8C, 0x33, 0x9C, 0x33, 0x98,
  0x76, 0x98, 0x7C, 0x98, 0x6C, 0xB0, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0xE0,
  0x70, 0xE0, 0xE0, 0xE0, 0x07, 0x07, 0x83, 0x83, 0x80, 0xE3, 0x80, 0x73,
  0x80, 0x3B, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0xE7, 0x00, 0xE1, 0x80, 0xE0, 0xE0,
  0xF0, 0x70, 0xF0, 0x38, 0x00, 0xE0, 0x3F, 0x03, 0xB8, 0x1C, 0xC1, 0xC7,
  0x1C, 0x38, 0xC1, 0xCE, 0x06, 0xE0, 0x3E, 0x01, 0xE0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x00, 0x0F, 0xFE, 0x1F,
  0xFC, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x04, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0xE7, 0x39,
  0xCE, 0x73, 0x8C, 0x63, 0x1C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x63, 0x18,
  0xE7, 0x38, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0x80, 0x78, 0x0F, 0xC1,
  0xDC, 0x1C, 0xC3, 0x8E, 0x70, 0xEE, 0x06, 0xC0, 0x70, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x67, 0x9E, 0x70, 0x80, 0x07, 0xF1, 0xFF, 0x3C, 0x77, 0x07,
  0x70, 0x6E, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0C, 0xE1, 0xC7, 0xFC,
  0x7E, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x7F, 0xC3, 0xFE, 0x1C, 0x38, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x98,
  0x1D, 0xC1, 0xCE, 0x1E, 0x71, 0xE3, 0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFF,
  0x3C, 0x17, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xF0, 0x47, 0xFC, 0x3F, 0xC0, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x7F, 0x87, 0xFC, 0x3C, 0x71, 0xE1, 0xC7, 0x07,
  0x38, 0x18, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xF1, 0xC1, 0xFF,
  0x83, 0xEE, 0x00, 0x0F, 0xE1, 0xFF, 0x38, 0x77, 0x03, 0x70, 0x7E, 0x0F,
  0xFF, 0xEF, 0xF0, 0xE0, 0x0E, 0x00, 0xF0, 0x47, 0xFC, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x3C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xE0, 0x00, 0x01, 0xFE, 0x0F, 0xFC, 0x3C, 0x30, 0x70, 0xE1, 0xC1, 0xC3,
  0x03, 0x8E, 0x06, 0x1C, 0x1C, 0x38, 0x38, 0x78, 0xF0, 0x7F, 0xC0, 0x7F,
  0x80, 0x07, 0x00, 0x0E, 0x10, 0x38, 0x3F, 0xE0, 0xFF, 0x80, 0x38, 0x00,
  0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x7F, 0x83,
  0xFE, 0x1C, 0x71, 0xC1, 0xCE, 0x0C, 0x70, 0x63, 0x87, 0x38, 0x39, 0xC1,
  0xCE, 0x0C, 0x70, 0xE3, 0x07, 0x38, 0x38, 0x07, 0x07, 0x81, 0xC0, 0x40,
  0x00, 0x01, 0xF8, 0xFC, 0x8E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60,
  0x30, 0x1C, 0x8F, 0xC3, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x41, 0xC1, 0xFE, 0x0F, 0xF0, 0x07, 0x00, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0xE7, 0x0E,
  0x39, 0xE1, 0xDE, 0x0D, 0xC0, 0xFC, 0x07, 0xE0, 0x3B, 0x81, 0x8E, 0x1C,
  0x70, 0xE1, 0xC7, 0x0E, 0x38, 0x38, 0xFE, 0xFC, 0x1C, 0x1C, 0x18, 0x38,
  0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE2, 0xFE,
  0x7F, 0x1F, 0x78, 0xFF, 0xF3, 0x99, 0xCC, 0x67, 0x33, 0x99, 0xCC, 0x67,
  0x33, 0x98, 0xCE, 0x64, 0x31, 0x80, 0xCE, 0x07, 0x30, 0x1C, 0xC0, 0x60,
  0x1F, 0xF0, 0xFF, 0x87, 0x1E, 0x38, 0x71, 0x83, 0x9C, 0x1C, 0xE0, 0xC7,
  0x0E, 0x30, 0x73, 0x83, 0x9C, 0x18, 0xE1, 0xCE, 0x0E, 0x00, 0x0F, 0xC1,
  0xFE, 0x38, 0x77, 0x07, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xEE,
  0x0E, 0xF3, 0xC7, 0xF8, 0x3F, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0xE1, 0xC3,
  0x07, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC6, 0x07, 0x38, 0x38, 0xE1, 0xE3,
  0x8F, 0x0F, 0xF8, 0x7F, 0x81, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x07, 0xF8, 0xFF, 0xCF, 0x1C, 0xF0, 0xE7, 0x07, 0x30, 0x3B,
  0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x3C, 0x70, 0xFF, 0x83, 0xFC, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x0F, 0xF8, 0xFF, 0x87,
  0x04, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x0F, 0xF1, 0xFF, 0x3C, 0x23, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xC0, 0x0C, 0x41, 0xCF, 0xFC,
  0xFF, 0x00, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x7F, 0xF7, 0xFE, 0x9C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x38,
  0x43, 0xF8, 0x1F, 0x80, 0x38, 0x39, 0xC3, 0x8C, 0x1C, 0xE0, 0xE7, 0x06,
  0x38, 0x71, 0x83, 0x9C, 0x1C, 0xE0, 0xC7, 0x06, 0x3C, 0xF0, 0xFF, 0x87,
  0xEE, 0x00, 0xE0, 0x7E, 0x07, 0x60, 0xE6, 0x0E, 0x61, 0xC7, 0x1C, 0x73,
  0x87, 0x30, 0x77, 0x07, 0xE0, 0x3E, 0x03, 0xC0, 0x38, 0x00, 0x70, 0x1D,
  0x80, 0x76, 0x01, 0x98, 0xC6, 0xE7, 0x3B, 0x9C, 0xCE, 0xF3, 0x33, 0xD8,
  0xDB, 0x63, 0xCF, 0x8F, 0x1C, 0x38, 0x70, 0xE1, 0x80, 0x1E, 0x0E, 0x1C,
  0x38, 0x1C, 0xE0, 0x3B, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xE0, 0x1D, 0xC0, 0x71, 0xC1, 0xC3, 0x8F, 0x03, 0x80, 0x0E, 0x07,
  0x06, 0x07, 0x07, 0x0E, 0x07, 0x0E, 0x07, 0x0C, 0x07, 0x1C, 0x07, 0x18,
  0x07, 0x38, 0x03, 0x30, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x0F, 0xF8,
  0xFF, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1E, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x38, 0x0F, 0xC0,
  0xFE, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x01, 0xF0, 0x0F, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFC, 0x07, 0xE0, 0x0E,
  0x00, 0x03, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C,
  0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x60, 0xE0,
  0xE0, 0xE0, 0x03, 0x80, 0x3F, 0x01, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xF0, 0x07, 0x80,
  0x7C, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x03, 0x83, 0xF8, 0x1F, 0xC0, 0xE0, 0x00, 0x18, 0x23, 0xF1, 0xDF, 0xFD,
  0x8F, 0xC4, 0x1C, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 7, 17, 14, 4, -17 },
  { 16, 9, 7, 14, 5, -19 },
  { 24, 15, 17, 14, 0, -17 },
  { 56, 13, 22, 14, 1, -19 },
  { 92, 17, 18, 14, -1, -18 },
  { 131, 13, 18, 14, 0, -18 },
  { 161, 4, 8, 14, 7, -19 },
  { 165, 11, 25, 14, 3, -20 },
  { 200, 11, 25, 14, 0, -20 },
  { 235, 11, 10, 14, 3, -17 },
  { 249, 12, 13, 14, 1, -14 },
  { 269, 6, 8, 14, 2, -4 },
  { 275, 8, 2, 14, 3, -8 },
  { 277, 4, 4, 14, 4, -4 },
  { 279, 16, 25, 14, -1, -20 },
  { 329, 13, 18, 14, 1, -18 },
  { 359, 11, 17, 14, 1, -17 },
  { 383, 13, 18, 14, 1, -18 },
  { 413, 13, 18, 14, 0, -18 },
  { 443, 14, 17, 14, 0, -17 },
  { 473, 14, 17, 14, 0, -17 },
  { 503, 13, 17, 14, 1, -17 },
  { 531, 13, 17, 14, 3, -17 },
  { 559, 13, 18, 14, 1, -18 },
  { 589, 13, 18, 14, 1, -18 },
  { 619, 6, 13, 14, 4, -13 },
  { 629, 8, 17, 14, 2, -13 },
  { 646, 13, 12, 14, 1, -13 },
  { 666, 14, 8, 14, 0, -11 },
  { 680, 12, 12, 14, 1, -13 },
  { 698, 11, 18, 14, 3, -18 },
  { 723, 14, 22, 14, 1, -18 },
  { 762, 13, 17, 14, -1, -17 },
  { 790, 14, 18, 14, 0, -18 },
  { 822, 14, 18, 14, 1, -18 },
  { 854, 14, 18, 14, 0, -18 },
  { 886, 14, 17, 14, 1, -17 },
  { 916, 14, 17, 14, 1, -17 },
  { 946, 14, 18, 14, 1, -18 },
  { 978, 15, 17, 14, 0, -17 },
  { 1010, 14, 17, 14, 1, -17 },
  { 1040, 15, 17, 14, 0, -17 },
  { 1072, 16, 17, 14, 0, -17 },
  { 1106, 11, 17, 14, 0, -17 },
  { 1130, 16, 17, 14, -1, -17 },
  { 1164, 15, 17, 14, 0, -17 },
  { 1196, 13, 18, 14, 1, -18 },
  { 1226, 14, 18, 14, 0, -18 },
  { 1258, 13, 23, 14, 1, -18 },
  { 1296, 14, 18, 14, 0, -18 },
  { 1328, 14, 18, 14, 0, -18 },
  { 1360, 13, 17, 14, 3, -17 },
  { 1388, 14, 17, 14, 1, -17 },
  { 1418, 13, 17, 14, 3, -17 },
  { 1446, 16, 17, 14, 0, -17 },
  { 1480, 17, 17, 14, -1, -17 },
  { 1517, 13, 17, 14, 3, -17 },
  { 1545, 15, 17, 14, 0, -17 },
  { 1577, 13, 25, 14, 2, -20 },
  { 1618, 5, 25, 14, 5, -20 },
  { 1634, 13, 25, 14, 0, -20 },
  { 1675, 12, 9, 14, 2, -17 },
  { 1689, 13, 3, 14, -2, 2 },
  { 1694, 5, 5, 14, 6, -19 },
  { 1698, 12, 13, 14, 1, -13 },
  { 1718, 13, 19, 14, 0, -19 },
  { 1749, 12, 13, 14, 1, -13 },
  { 1769, 14, 19, 14, 1, -19 },
  { 1803, 12, 13, 14, 1, -13 },
  { 1823, 17, 24, 14, -1, -19 },
  { 1874, 15, 18, 14, -1, -13 },
  { 1908, 13, 19, 14, 0, -19 },
  { 1939, 9, 19, 14, 2, -19 },
  { 1961, 14, 24, 14, -1, -19 },
  { 2003, 13, 19, 14, 1, -19 },
  { 2034, 8, 19, 14, 4, -19 },
  { 2053, 14, 13, 14, 0, -13 },
  { 2076, 13, 13, 14, 0, -13 },
  { 2098, 12, 13, 14, 1, -13 },
  { 2118, 14, 18, 14, -1, -13 },
  { 2150, 13, 18, 14, 1, -13 },
  { 2180, 13, 13, 14, 1, -13 },
  { 2202, 12, 13, 14, 1, -13 },
  { 2222, 12, 17, 14, 2, -17 },
  { 2248, 13, 13, 14, 1, -13 },
  { 2270, 12, 13, 14, 2, -13 },
  { 2290, 14, 13, 14, 1, -13 },
  { 2313, 15, 13, 14, -1, -13 },
  { 2338, 16, 18, 14, -2, -13 },
  { 2374, 13, 13, 14, 0, -13 },
  { 2396, 13, 25, 14, 2, -20 },
  { 2437, 8, 25, 14, 3, -20 },
  { 2462, 13, 25, 14, -1, -20 },
  { 2503, 13, 5, 14, 1, -10 },
};

const GFXfont UbuntuSansMono_MediumItalic25pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic25pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic25pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC25PT7B_H_
