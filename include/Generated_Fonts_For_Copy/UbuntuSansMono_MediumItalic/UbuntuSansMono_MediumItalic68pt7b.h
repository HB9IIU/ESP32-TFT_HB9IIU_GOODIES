#ifndef _UBUNTUSANSMONO_MEDIUMITALIC68PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xE0,
  0x00, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFF, 0x3F, 0xC0,
  0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x81,
  0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0x01,
  0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0xF8, 0x00, 0x18, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x01, 0x80, 0x00,
  0x3F, 0xC0, 0x3E, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xC0, 0x00,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0xF8, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0x00, 0x1F,
  0x81, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8,
  0x3E, 0x1F, 0x80, 0x00, 0x03, 0xE1, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xCF,
  0xC7, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC7, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x03, 0x00, 0x00, 0x00, 0x01, 0xF8, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xC7, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xF1, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x87, 0xE7, 0xE0,
  0x00, 0x00, 0xFC, 0x3F, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0xF8, 0x3E, 0x00,
  0x00, 0x1F, 0x87, 0xC0, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x7C, 0x0F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x3E, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC0,
  0x0F, 0x81, 0xF0, 0x00, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x00, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF,
  0x01, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0x03, 0xFD, 0xFE, 0x0F, 0xC0, 0xFE,
  0x1F, 0xE1, 0xF8, 0x3F, 0x81, 0xFC, 0x7F, 0x0F, 0xE0, 0x3F, 0xCF, 0xC1,
  0xFC, 0x03, 0xFB, 0xF8, 0x7F, 0x00, 0x3F, 0xFE, 0x0F, 0xE0, 0x07, 0xFF,
  0xC1, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0x00, 0x0F, 0xFE, 0x0F, 0xE0, 0x00,
  0xFF, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0x81,
  0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xCF,
  0xE0, 0x3F, 0xFF, 0xE1, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0x80, 0x3F, 0xFC,
  0x07, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x1F, 0xE1,
  0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x87,
  0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07,
  0xC0, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x02, 0x00, 0xFC, 0x00,
  0x0E, 0x03, 0xF0, 0x1C, 0x3E, 0x07, 0xC1, 0xF9, 0xFE, 0x1F, 0x1F, 0xE7,
  0xFE, 0x7C, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xBF,
  0x80, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x87, 0xFC,
  0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x7E, 0x00,
  0x1E, 0x01, 0xF0, 0x00, 0x30, 0x03, 0x00, 0x00, 0x40, 0x08, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x80, 0x03, 0x01, 0xFC, 0x3F, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xE3, 0xFC, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0x07,
  0xE0, 0x7F, 0x3F, 0xC3, 0xF8, 0x1F, 0xCF, 0xE0, 0xFF, 0x07, 0xF3, 0xF8,
  0x7F, 0xC3, 0xFD, 0xFE, 0x1F, 0xF0, 0xFE, 0x7F, 0x87, 0xFC, 0x3F, 0x9F,
  0xC1, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x87, 0xF9, 0xFC, 0x0F, 0xC1, 0xFE,
  0x7F, 0x00, 0xC0, 0x7F, 0x3F, 0xC0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00,
  0x7F, 0x8F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0x3F, 0x80, 0x1F, 0xF1, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xC0, 0xFF,
  0x00, 0x10, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x3E, 0x00,
  0x0F, 0xF0, 0x01, 0x80, 0x00, 0xFF, 0x00, 0x10, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xE0, 0xFF, 0xE0, 0x00, 0xE0, 0x03, 0xFE, 0x00, 0x08, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x30, 0x00, 0x07,
  0xFE, 0x03, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFD, 0xFC, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x01, 0xFE, 0x3F,
  0x80, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x0C, 0x00, 0x03, 0xFF, 0x00, 0x3C, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0xFC, 0x00, 0x1F, 0xEF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x1F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x3F,
  0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC,
  0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFB, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xC0, 0x0F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xE0, 0x3F, 0xF0, 0x70,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0xFE, 0x0F, 0xE0, 0x0F, 0xFF, 0xF8, 0x3F,
  0x00, 0x7F, 0xFF, 0xE1, 0xFC, 0x07, 0xFF, 0xFF, 0x87, 0xE0, 0x3F, 0xFF,
  0xFE, 0x3F, 0x81, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xFC, 0x1F, 0xC3, 0xF0,
  0x3F, 0xC0, 0x7F, 0x0F, 0xC0, 0xFE, 0x01, 0xFC, 0x7F, 0x07, 0xF0, 0x0F,
  0xE1, 0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0x83,
  0xF8, 0x03, 0xF8, 0x7E, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x3F, 0x00, 0x7F,
  0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0xFC, 0x1F,
  0xC0, 0x1F, 0x83, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xC1, 0xFC, 0x03, 0xF8,
  0x3F, 0x03, 0xF0, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xC0, 0xFF, 0x87, 0xF0, 0x3F, 0x81, 0xFF, 0xFF, 0xC0,
  0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xE0, 0x1F,
  0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x20, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xC0,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x0F, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x01,
  0xFF, 0x80, 0x7F, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F,
  0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x03,
  0xFF, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFD, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x78, 0x00,
  0xFF, 0xC0, 0x00, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x60, 0x01, 0xFF, 0x80, 0x1F, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x03, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x1F, 0xE0, 0x01, 0xFF, 0x80, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xF0, 0x01,
  0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xFC, 0x03, 0xFC, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x7F, 0x80, 0x0F, 0xFE,
  0x00, 0x3C, 0x00, 0xFF, 0xC0, 0x00, 0x40, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x80, 0x00,
  0xFF, 0x80, 0x07, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00,
  0x00, 0x07, 0xF7, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x01, 0xF7, 0xC0, 0x7F, 0xF8, 0x00, 0xFD, 0xF0, 0x1F, 0x7E, 0x00, 0x3F,
  0x7C, 0x0F, 0xDF, 0x00, 0x0F, 0xDF, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC1,
  0xFB, 0xF0, 0x01, 0xF9, 0xF0, 0x7C, 0xFC, 0x00, 0x7E, 0x7C, 0x3E, 0x3F,
  0x00, 0x1F, 0x8F, 0x8F, 0x8F, 0xC0, 0x0F, 0xC3, 0xE7, 0xC7, 0xE0, 0x03,
  0xF0, 0xF9, 0xF1, 0xF8, 0x00, 0xFC, 0x3E, 0xF8, 0x7E, 0x00, 0x7F, 0x0F,
  0xBE, 0x1F, 0x80, 0x1F, 0x83, 0xFF, 0x07, 0xE0, 0x07, 0xE0, 0xFF, 0xC3,
  0xF8, 0x03, 0xF8, 0x3F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xF8, 0x3F, 0x00,
  0x3F, 0x03, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x03,
  0xFE, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xEF, 0xC0, 0x0F, 0xC0, 0x07, 0xE7, 0xE0,
  0x0F, 0xE0, 0x03, 0xF3, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0xFC, 0x03, 0xF8,
  0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x00, 0xFE, 0x3F, 0x01, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x83, 0xF0,
  0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE0, 0x3E, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0x87, 0xF0, 0x03, 0xF8,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x07, 0xE3, 0xF8, 0x01, 0xFC, 0x01, 0xF1,
  0xFC, 0x00, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xBF, 0x80, 0x1F, 0xC0,
  0x07, 0xDF, 0xC0, 0x0F, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0xF8, 0x01,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7E, 0x00,
  0x07, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x07, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFE,
  0x1F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0xFF, 0x00,
  0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x01, 0xFE, 0x7F,
  0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xF9, 0xFE, 0x00,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x07, 0xF8,
  0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F,
  0x80, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xF8, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x07, 0xFE, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x00,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x0F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0x83, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x38, 0x00, 0x7F, 0x80, 0x00, 0x20, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x08, 0x00, 0x00, 0x7F, 0x80, 0x38, 0x00, 0x03,
  0xFE, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00,
  0x03, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x01, 0xFE, 0x3F,
  0x80, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x00, 0x7E, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFF, 0x03, 0xF0, 0x03, 0xF0, 0x7F, 0xC0, 0xFC, 0x00, 0xFC, 0x1F,
  0xF0, 0x7F, 0x00, 0x3F, 0x0F, 0xFC, 0x1F, 0x80, 0x1F, 0xC3, 0xFF, 0x07,
  0xE0, 0x07, 0xE1, 0xFF, 0xC1, 0xF8, 0x01, 0xF8, 0x7D, 0xF0, 0xFC, 0x00,
  0x7E, 0x3F, 0x3C, 0x3F, 0x00, 0x1F, 0x8F, 0x8F, 0x8F, 0xC0, 0x07, 0xC7,
  0xC3, 0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0xF9, 0xF8, 0x00, 0xFC, 0xF8, 0x3E,
  0x7E, 0x00, 0x3F, 0x3E, 0x0F, 0x9F, 0x80, 0x0F, 0xDF, 0x03, 0xE7, 0xC0,
  0x03, 0xEF, 0xC0, 0xFB, 0xF0, 0x00, 0xFB, 0xE0, 0x3E, 0xFC, 0x00, 0x7F,
  0xF8, 0x0F, 0xBE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x00,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x3F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x07, 0xF3, 0xFE, 0x00, 0x03, 0xFB, 0xFE, 0x00, 0x01, 0xFE, 0x7E, 0x00,
  0x00, 0x7F, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0x00, 0x00, 0x18, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x18, 0x00, 0x78, 0x01,
  0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x07, 0xF8, 0x07, 0xE0, 0x07, 0x80, 0x06, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xF8, 0x0F, 0xE0, 0x1F, 0xFC, 0x01, 0xFC, 0x07, 0xFE, 0x00, 0x3F,
  0x80, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFC, 0x0F, 0xF8, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xE0,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xC7, 0xF0, 0x01, 0xFF, 0xE0, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xC0,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xE0, 0x1F, 0xFC, 0x00, 0x08, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x20, 0x1F, 0xFC, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xBF, 0x80, 0x03, 0xFF, 0xF8, 0xFE, 0x00, 0x07, 0xFF, 0xC3,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x0F,
  0xFC, 0xFF, 0x00, 0x7F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x02, 0x03, 0xFF, 0x00, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x08, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x80, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x10, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xEF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03,
  0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x03, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xC0, 0x01, 0xFE,
  0x00, 0x03, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x07, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0xFF,
  0xC0, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xDF,
  0xE0, 0x00, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00,
  0x7F, 0x8F, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1C, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x01,
  0xFF, 0xF9, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xC1, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x1F, 0xC1,
  0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03,
  0xF8, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xF8, 0x3F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03,
  0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F,
  0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x03, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x01,
  0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x01, 0xFF,
  0x80, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00,
  0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x7F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x3F,
  0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFE, 0x7F, 0x00, 0x00, 0x7C, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x04, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0x00, 0x78, 0x01, 0xFE, 0x00, 0x04, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x01, 0x80, 0x00, 0x7F, 0x81, 0xF0, 0x00,
  0xFF, 0x80, 0xFF, 0xEF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x01,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFD, 0xFC, 0x01, 0xFF, 0xFE, 0x3F, 0x80, 0x1F, 0xFE, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00,
  0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80,
  0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x80,
  0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80,
  0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xCF,
  0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x07,
  0xE1, 0xFC, 0x03, 0xE0, 0x1F, 0x87, 0xF0, 0x1F, 0x80, 0xFE, 0x1F, 0xC0,
  0xFE, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x0F, 0xC1, 0xF8, 0x1F, 0xE0, 0x7F,
  0x07, 0xE0, 0x7F, 0xC1, 0xF8, 0x1F, 0x83, 0xFF, 0x07, 0xE0, 0x7E, 0x0F,
  0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0xF0, 0xFC, 0x07, 0xE1, 0xF7, 0xC3, 0xF0,
  0x3F, 0x8F, 0xDF, 0x1F, 0x80, 0xFC, 0x3E, 0x7C, 0x7E, 0x03, 0xF1, 0xF9,
  0xF1, 0xF8, 0x0F, 0xC7, 0xC7, 0xCF, 0xC0, 0x3F, 0x3F, 0x1F, 0x3F, 0x00,
  0xFD, 0xF8, 0x7C, 0xFC, 0x03, 0xF7, 0xC1, 0xF7, 0xE0, 0x0F, 0xFF, 0x07,
  0xDF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00,
  0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x03,
  0xFB, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x04, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x02, 0x00, 0x7F,
  0xF0, 0x00, 0xFC, 0x1F, 0xFF, 0x80, 0x3F, 0x87, 0xFF, 0xF8, 0x07, 0xE1,
  0xFF, 0xFF, 0xC1, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE3, 0xF8, 0x1F, 0xFF, 0xF8, 0x7E, 0x01, 0xFF, 0xFE, 0x1F, 0xC0, 0x0F,
  0xFF, 0x81, 0xF0, 0x00, 0xFF, 0xE0, 0x04, 0x00, 0x07, 0xF0, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 20, 48, 38, 10, -47 },
  { 121, 24, 20, 38, 13, -52 },
  { 181, 40, 47, 38, 0, -47 },
  { 416, 36, 60, 38, 2, -53 },
  { 686, 46, 49, 38, -3, -48 },
  { 968, 35, 49, 38, 1, -48 },
  { 1183, 12, 22, 38, 19, -52 },
  { 1216, 29, 67, 38, 8, -54 },
  { 1459, 29, 67, 38, 1, -54 },
  { 1702, 30, 29, 38, 7, -47 },
  { 1811, 33, 34, 38, 3, -37 },
  { 1952, 17, 22, 38, 5, -11 },
  { 1999, 21, 7, 38, 9, -23 },
  { 2018, 12, 13, 38, 10, -12 },
  { 2038, 44, 66, 38, -4, -53 },
  { 2401, 34, 49, 38, 3, -48 },
  { 2610, 29, 47, 38, 3, -47 },
  { 2781, 36, 48, 38, 1, -48 },
  { 2997, 36, 49, 38, 1, -48 },
  { 3218, 36, 47, 38, 1, -47 },
  { 3430, 38, 48, 38, 1, -47 },
  { 3658, 35, 48, 38, 4, -47 },
  { 3868, 35, 47, 38, 7, -47 },
  { 4074, 35, 49, 38, 3, -48 },
  { 4289, 36, 48, 38, 2, -48 },
  { 4505, 18, 37, 38, 10, -36 },
  { 4589, 23, 47, 38, 5, -36 },
  { 4725, 34, 31, 38, 3, -35 },
  { 4857, 37, 20, 38, 1, -30 },
  { 4950, 35, 31, 38, 1, -35 },
  { 5086, 28, 49, 38, 9, -48 },
  { 5258, 38, 58, 38, 2, -48 },
  { 5534, 37, 47, 38, -4, -47 },
  { 5752, 37, 48, 38, 0, -48 },
  { 5974, 37, 49, 38, 4, -48 },
  { 6201, 37, 48, 38, 0, -48 },
  { 6423, 38, 47, 38, 2, -47 },
  { 6647, 39, 47, 38, 2, -47 },
  { 6877, 37, 49, 38, 3, -48 },
  { 7104, 41, 47, 38, 0, -47 },
  { 7345, 38, 47, 38, 1, -47 },
  { 7569, 38, 48, 38, 1, -47 },
  { 7797, 42, 47, 38, 0, -47 },
  { 8044, 29, 47, 38, 1, -47 },
  { 8215, 42, 47, 38, -2, -47 },
  { 8462, 41, 47, 38, 0, -47 },
  { 8703, 35, 49, 38, 3, -48 },
  { 8918, 38, 48, 38, 1, -48 },
  { 9146, 35, 61, 38, 3, -48 },
  { 9413, 37, 48, 38, 0, -48 },
  { 9635, 38, 49, 38, 1, -48 },
  { 9868, 34, 47, 38, 8, -47 },
  { 10068, 38, 48, 38, 3, -47 },
  { 10296, 37, 47, 38, 7, -47 },
  { 10514, 42, 47, 38, 1, -47 },
  { 10761, 46, 47, 38, -2, -47 },
  { 11032, 36, 47, 38, 8, -47 },
  { 11244, 41, 47, 38, 0, -47 },
  { 11485, 36, 66, 38, 4, -53 },
  { 11782, 13, 66, 38, 13, -53 },
  { 11890, 35, 66, 38, -1, -53 },
  { 12179, 33, 26, 38, 4, -47 },
  { 12287, 35, 7, 38, -5, 6 },
  { 12318, 15, 14, 38, 16, -53 },
  { 12345, 35, 37, 38, 2, -36 },
  { 12507, 35, 54, 38, 1, -53 },
  { 12744, 34, 37, 38, 3, -36 },
  { 12902, 38, 54, 38, 3, -53 },
  { 13159, 33, 37, 38, 3, -36 },
  { 13312, 47, 66, 38, -4, -53 },
  { 13700, 40, 49, 38, -2, -36 },
  { 13945, 34, 53, 38, 0, -53 },
  { 14171, 24, 53, 38, 7, -53 },
  { 14330, 38, 66, 38, -2, -53 },
  { 14644, 37, 53, 38, 2, -53 },
  { 14890, 21, 53, 38, 10, -52 },
  { 15030, 38, 36, 38, -1, -36 },
  { 15201, 34, 36, 38, 1, -36 },
  { 15354, 33, 37, 38, 3, -36 },
  { 15507, 38, 49, 38, -2, -36 },
  { 15740, 34, 49, 38, 3, -36 },
  { 15949, 34, 36, 38, 3, -36 },
  { 16102, 33, 37, 38, 2, -36 },
  { 16255, 30, 47, 38, 7, -46 },
  { 16432, 34, 37, 38, 3, -36 },
  { 16590, 32, 36, 38, 6, -36 },
  { 16734, 38, 36, 38, 3, -36 },
  { 16905, 41, 36, 38, -2, -36 },
  { 17090, 43, 49, 38, -5, -36 },
  { 17354, 36, 36, 38, 1, -36 },
  { 17516, 37, 66, 38, 4, -53 },
  { 17822, 23, 66, 38, 8, -53 },
  { 18012, 37, 66, 38, -3, -53 },
  { 18318, 35, 12, 38, 2, -26 },
};

const GFXfont UbuntuSansMono_MediumItalic68pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic68pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic68pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC68PT7B_H_
