#ifndef _UBUNTUSANSMONO_MEDIUMITALIC47PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xFC, 0x0F, 0xE0,
  0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0x7C, 0x00, 0x80, 0x00, 0x3E, 0x1F, 0x9F,
  0x0F, 0x8F, 0x87, 0xCF, 0xC3, 0xE7, 0xC1, 0xF3, 0xE1, 0xF1, 0xF0, 0xF8,
  0xF0, 0x7C, 0x78, 0x3C, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x0F, 0x03,
  0x87, 0x03, 0xC0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x7C,
  0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0x83, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x1F,
  0x00, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x78, 0x00, 0x1E, 0x0F,
  0x80, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x78, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x03, 0x80, 0xFC, 0x00, 0x80, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x81, 0x80, 0x0F, 0xC0, 0xF0, 0x1F, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0xFF, 0x00, 0x1E, 0x01, 0xFF, 0x80, 0x3C, 0x01, 0xE7, 0x80, 0x78,
  0x03, 0xC3, 0x80, 0xF8, 0x03, 0xC3, 0x81, 0xF0, 0x03, 0x83, 0x81, 0xE0,
  0x07, 0x87, 0x83, 0xC0, 0x07, 0x87, 0x87, 0x80, 0x07, 0x87, 0x8F, 0x00,
  0x07, 0x87, 0x1E, 0x00, 0x07, 0x8F, 0x3E, 0x00, 0x07, 0xDE, 0x3C, 0x00,
  0x03, 0xFE, 0x78, 0x00, 0x03, 0xFC, 0xF0, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC6, 0x00, 0x00, 0x07, 0x9F, 0xC0,
  0x00, 0x0F, 0x3F, 0xC0, 0x00, 0x1E, 0x7F, 0xE0, 0x00, 0x3C, 0x79, 0xE0,
  0x00, 0x78, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0xE0, 0x01, 0xF1, 0xE1, 0xE0,
  0x01, 0xE1, 0xE1, 0xE0, 0x03, 0xC1, 0xE1, 0xE0, 0x07, 0x81, 0xE1, 0xC0,
  0x0F, 0x01, 0xE3, 0xC0, 0x1E, 0x01, 0xE3, 0xC0, 0x3E, 0x01, 0xFF, 0x80,
  0x3C, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC,
  0x01, 0xF0, 0x7C, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C,
  0x03, 0xC0, 0x78, 0x03, 0xC0, 0xF8, 0x03, 0xE1, 0xF0, 0x03, 0xE3, 0xE0,
  0x03, 0xE7, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x1F, 0x0F, 0xFC, 0x1E, 0x1F, 0xFE, 0x3E, 0x3F, 0x3E, 0x3C,
  0x3C, 0x1F, 0x3C, 0x7C, 0x1F, 0xFC, 0xF8, 0x0F, 0xF8, 0xF8, 0x07, 0xF8,
  0xF8, 0x07, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xF0,
  0xFC, 0x1F, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0xF8, 0x3F, 0xF8, 0xF8,
  0x1F, 0xF0, 0x7C, 0x1F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C,
  0x7C, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x04,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x30, 0x78, 0x11, 0xE1, 0xC3, 0xCF, 0xCE, 0x7E, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0xC0,
  0x01, 0xEF, 0x00, 0x1F, 0x7C, 0x01, 0xF3, 0xF0, 0x1F, 0x8F, 0xC1, 0xF8,
  0x7E, 0x03, 0xC1, 0xE0, 0x0C, 0x04, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xC0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x01, 0xF0, 0x1E, 0x07, 0xC1, 0xFC, 0xFF, 0x87, 0xE0, 0x7C,
  0x04, 0x00, 0x3F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x1C,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x7E, 0x07, 0xF0,
  0x3E, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80,
  0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x3E,
  0x1F, 0x7E, 0x3E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E,
  0x3E, 0x7C, 0x7C, 0x3E, 0xFC, 0x10, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x03,
  0xF0, 0xFC, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xC0,
  0x7C, 0x7C, 0x07, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x3F, 0xC7, 0xF0, 0x0E, 0x00, 0xFC, 0x06, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xF0, 0x7F, 0x00,
  0x80, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x40, 0x01, 0xF8, 0x70, 0x07, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03,
  0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x00,
  0x3E, 0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x10, 0x00, 0xFE,
  0x03, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x7F, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0xFE, 0x03, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x7C, 0x07, 0xE0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x1F,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7E, 0x07, 0xF0, 0xFC,
  0x03, 0xFB, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x1F, 0xCF, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x7C, 0x00, 0xF8,
  0xFC, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xFC, 0x07, 0xF0, 0x7F, 0xBF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x3F, 0x83, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x1F,
  0x80, 0x7F, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x3F, 0xF7, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x7F,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x01, 0x80, 0x00,
  0x3C, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x7E, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0xFF, 0x80, 0x7E,
  0x00, 0x7C, 0x00, 0x40, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0E, 0x07, 0xE0, 0x80, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xC0,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x00, 0xF0, 0x3E, 0x00, 0x1F, 0x07,
  0xC0, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3C, 0x03, 0xFF, 0x0F, 0x81, 0xFF,
  0xE1, 0xE0, 0xFF, 0xFC, 0x7C, 0x3F, 0xFF, 0x8F, 0x07, 0xE3, 0xE1, 0xE1,
  0xF8, 0x7C, 0x7C, 0x3E, 0x0F, 0x8F, 0x8F, 0x81, 0xF1, 0xE1, 0xF0, 0x3C,
  0x3C, 0x3C, 0x0F, 0x87, 0x8F, 0x81, 0xF0, 0xF1, 0xF0, 0x3E, 0x3E, 0x3E,
  0x07, 0x87, 0xC7, 0xC1, 0xF0, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF8, 0xF0, 0x7C, 0x3F, 0xFE, 0x07, 0x83, 0xFF, 0xC0, 0xF0, 0x3F,
  0xF8, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x20, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x0F,
  0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0x80, 0x3E, 0x01, 0xE0, 0x0F, 0x80,
  0x78, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x07, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xCF, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x01, 0xFC, 0xFF, 0x80, 0x7C, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F,
  0x00, 0x3E, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xF8, 0x0F,
  0xE0, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0,
  0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7C, 0x07, 0xFC, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xE1, 0xF0, 0x3F, 0x80, 0x10, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x08, 0x07, 0xF0, 0x1C, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x3E,
  0x03, 0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x00,
  0x3F, 0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x3E,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x03,
  0xF0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x07, 0xC0,
  0x1F, 0x81, 0xF0, 0x1F, 0xE0, 0x7C, 0x1F, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0x0F, 0x00, 0xFE,
  0x00, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x02, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x03, 0xE0,
  0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x01, 0xF8, 0x07,
  0xC0, 0x7F, 0x01, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x01,
  0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0,
  0x1F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x7C,
  0x00, 0x7C, 0x03, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x01, 0xF0, 0x01,
  0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x01,
  0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0,
  0x3E, 0x00, 0x3E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x03,
  0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0xC0, 0x1F, 0x80, 0x7C, 0x0F, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03,
  0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0x3F, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0x80,
  0x7C, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7E,
  0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xFC,
  0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0x03, 0xF8, 0x07, 0xF8, 0x1F,
  0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0E, 0xF0, 0x0E, 0xF0, 0xF7, 0x80,
  0xF3, 0x87, 0x78, 0x07, 0x9C, 0x7B, 0xC0, 0x3C, 0xE7, 0x9E, 0x03, 0xE7,
  0x38, 0xF0, 0x1E, 0x3B, 0xCF, 0x80, 0xF1, 0xDC, 0x78, 0x0F, 0x8F, 0xE3,
  0xC0, 0x78, 0x7E, 0x1E, 0x03, 0xC3, 0xF0, 0xF0, 0x3E, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x7C, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0xC0,
  0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0x80, 0x7E, 0x00, 0x7C, 0x03, 0xF0,
  0x03, 0xE0, 0x1F, 0xC0, 0x1F, 0x01, 0xFE, 0x00, 0xF0, 0x0F, 0xF0, 0x0F,
  0x80, 0x7F, 0xC0, 0x7C, 0x03, 0xDE, 0x03, 0xE0, 0x3E, 0xF0, 0x1E, 0x01,
  0xF7, 0x80, 0xF0, 0x0F, 0xBE, 0x0F, 0x80, 0x78, 0xF0, 0x7C, 0x03, 0xC7,
  0x83, 0xE0, 0x3E, 0x3C, 0x1E, 0x01, 0xF0, 0xF1, 0xF0, 0x0F, 0x07, 0x8F,
  0x80, 0x78, 0x3C, 0x7C, 0x07, 0xC1, 0xE3, 0xC0, 0x3E, 0x0F, 0x3E, 0x01,
  0xF0, 0x3D, 0xF0, 0x0F, 0x01, 0xEF, 0x80, 0xF8, 0x0F, 0x78, 0x07, 0xC0,
  0x7F, 0xC0, 0x3E, 0x01, 0xFE, 0x01, 0xE0, 0x0F, 0xF0, 0x1F, 0x00, 0x7F,
  0x00, 0xF8, 0x03, 0xF8, 0x07, 0xC0, 0x1F, 0xC0, 0x3C, 0x00, 0x7E, 0x03,
  0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03,
  0xF8, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x1F,
  0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8,
  0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x7E,
  0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xF8, 0x07,
  0xE0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x83,
  0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x3E, 0x01, 0xFC, 0x1F, 0x83, 0xFE,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x7E, 0x07, 0xE0, 0x3F, 0x07,
  0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F,
  0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xFC,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xFC,
  0x03, 0xF0, 0xFC, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x01, 0xFC, 0xFF, 0x80, 0x7C, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x1F,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x03, 0xF0,
  0x3E, 0x03, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xC1, 0xF8, 0x01, 0xF0,
  0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E,
  0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x0F, 0xE0, 0x78, 0x03, 0xF0, 0x01, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x18, 0x00, 0x7E, 0x03, 0xC0, 0x3F,
  0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x07,
  0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C,
  0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00,
  0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x3F,
  0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xDF, 0x80, 0x07,
  0xEF, 0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xF0, 0x01, 0xF1, 0xF8, 0x00,
  0xF8, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x0F, 0x80,
  0x3E, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F,
  0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x07, 0xBC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x78,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x7C, 0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x81, 0xF0, 0xF0, 0x78, 0x0F, 0x0F, 0x83, 0xC0, 0x78,
  0x7C, 0x3E, 0x07, 0xC7, 0xE1, 0xE0, 0x3E, 0x3F, 0x0F, 0x01, 0xE3, 0xF8,
  0x78, 0x0F, 0x1D, 0xE7, 0xC0, 0x79, 0xEF, 0x3C, 0x03, 0xCE, 0x79, 0xE0,
  0x3C, 0xF3, 0xCF, 0x01, 0xE7, 0x1E, 0xF0, 0x0F, 0x78, 0xF7, 0x80, 0x7F,
  0x83, 0xBC, 0x03, 0xBC, 0x1D, 0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0x7C, 0x00,
  0x00, 0x7E, 0x7C, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0x00,
  0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xCF, 0x80, 0x0F, 0xC3,
  0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xE0,
  0x3E, 0x03, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF0,
  0x01, 0xF1, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF1, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x8F,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xFC, 0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0xF8, 0x03, 0xF1, 0xF0,
  0x0F, 0xC3, 0xE0, 0x1F, 0x07, 0xE0, 0x7E, 0x07, 0xC1, 0xF8, 0x0F, 0x87,
  0xE0, 0x1F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0x70,
  0x00, 0x70, 0x40, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x10, 0x0E, 0x07,
  0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x01, 0x80, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0x87, 0xE3,
  0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x1F, 0x80, 0x3E, 0x7E, 0x00, 0xFC, 0xF8,
  0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x9F, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07,
  0xC3, 0xE0, 0x0F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFE, 0xF8, 0x1F, 0xF1, 0xF0, 0x02, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xEF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x07, 0xF8, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0x7C, 0x07, 0xF0,
  0x7C, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xC3, 0xC3, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x0E, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x7E, 0x01,
  0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x1F,
  0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x3F,
  0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x0F, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0xF8, 0x00, 0xFF,
  0x8F, 0x80, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0x0F, 0xE3, 0xF8, 0x0F, 0xC7,
  0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0x7E, 0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF0,
  0x07, 0xF7, 0xC0, 0x7F, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x06, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xE0, 0x40, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xF0, 0x7C, 0x03, 0xF8, 0x0F,
  0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0x80, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0,
  0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x1F, 0x80,
  0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xDF, 0x00, 0x03, 0xC7,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x06, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xEF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F,
  0x80, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3F,
  0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7E,
  0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xFC,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC1, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0x80, 0x7E, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0xC0,
  0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xC0, 0xFC,
  0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0x9F,
  0x80, 0x03, 0xEF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0xFC, 0x7C, 0x00,
  0x3E, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x1F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x03, 0xF0,
  0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xF9, 0xFF, 0xF3, 0xFF, 0xC7,
  0xFF, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x02, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF8,
  0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7C, 0x7E, 0x7E, 0x0F, 0x87, 0x87,
  0xC1, 0xE1, 0xF0, 0xF8, 0x3C, 0x3E, 0x1E, 0x0F, 0x87, 0x83, 0xC1, 0xF0,
  0xF0, 0xF8, 0x3C, 0x1E, 0x1F, 0x07, 0x87, 0xC3, 0xC1, 0xF0, 0xF8, 0x78,
  0x3E, 0x1E, 0x1F, 0x07, 0x83, 0xC3, 0xE0, 0xF0, 0xF8, 0x78, 0x3E, 0x00,
  0x0F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x83,
  0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x83, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xBF, 0xE0, 0xF8, 0x0F, 0xC3, 0xF0,
  0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x00,
  0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F,
  0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF8, 0x03, 0xE3,
  0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7C,
  0x01, 0xF8, 0xF8, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xBF, 0xC3, 0xF8, 0x1F, 0x87, 0xE0,
  0x1F, 0x1F, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF0, 0x01,
  0xFB, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F,
  0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x3F, 0x8F, 0xE0, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xF8, 0x3F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0x03, 0xE0,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x07,
  0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0x7C, 0x07,
  0xF0, 0x1F, 0x07, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xB8, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFC, 0x7E, 0x0F, 0xE0, 0x3E, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7C, 0x3F,
  0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0xFC,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0x7E,
  0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x01, 0x87, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x83, 0xC0, 0x7C,
  0x00, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC1, 0x00, 0x0F, 0x83, 0x80, 0x3F, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x38, 0x3F, 0xFF, 0x81,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x40, 0x00, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07,
  0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x80, 0x7E, 0x3E, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE3, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xFC, 0x03, 0xF1, 0xF8,
  0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x3F, 0x07, 0xE1, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFE, 0xF8, 0x1F, 0xF1, 0xF0, 0x02, 0x00,
  0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x07,
  0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8,
  0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x03, 0xF0, 0x7E, 0x07,
  0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x3E,
  0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7D, 0xF0,
  0x00, 0x1E, 0x7C, 0x00, 0x07, 0x9F, 0x00, 0x03, 0xE7, 0xC1, 0xE0, 0xF1,
  0xE0, 0xF8, 0x3C, 0x78, 0x3E, 0x1F, 0x1E, 0x1F, 0x87, 0x87, 0x87, 0xE1,
  0xE1, 0xE3, 0xF8, 0xF8, 0xF8, 0xFE, 0x3C, 0x3E, 0x7B, 0x8F, 0x0F, 0x1C,
  0xE7, 0x83, 0xCF, 0x39, 0xE0, 0xF3, 0x8E, 0x78, 0x3D, 0xE3, 0xBC, 0x0F,
  0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x03, 0xF8,
  0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x7E, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0x9F, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC0, 0xF8,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x07,
  0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0,
  0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x04, 0x07, 0xFC, 0x07, 0xC7, 0xFF,
  0x07, 0xC7, 0xFF, 0xE7, 0xC3, 0xFF, 0xFF, 0xE3, 0xE1, 0xFF, 0xE3, 0xE0,
  0x3F, 0xE0, 0x60, 0x0F, 0xE0,
};

const GFXglyph UbuntuSansMono_MediumItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 13, 34, 26, 7, -33 },
  { 57, 17, 14, 26, 9, -36 },
  { 87, 28, 33, 26, 0, -33 },
  { 203, 25, 41, 26, 1, -36 },
  { 332, 32, 34, 26, -2, -33 },
  { 468, 24, 33, 26, 1, -33 },
  { 567, 8, 15, 26, 13, -36 },
  { 582, 21, 46, 26, 5, -37 },
  { 703, 20, 46, 26, 1, -37 },
  { 818, 21, 20, 26, 5, -33 },
  { 871, 23, 23, 26, 2, -25 },
  { 938, 12, 16, 26, 3, -8 },
  { 962, 14, 5, 26, 6, -16 },
  { 971, 8, 9, 26, 7, -8 },
  { 980, 31, 46, 26, -3, -37 },
  { 1159, 24, 34, 26, 2, -33 },
  { 1261, 20, 33, 26, 2, -33 },
  { 1344, 25, 33, 26, 1, -33 },
  { 1448, 24, 34, 26, 1, -33 },
  { 1550, 26, 33, 26, 0, -33 },
  { 1658, 27, 34, 26, 0, -33 },
  { 1773, 24, 34, 26, 3, -33 },
  { 1875, 24, 33, 26, 5, -33 },
  { 1974, 24, 34, 26, 2, -33 },
  { 2076, 25, 33, 26, 1, -33 },
  { 2180, 12, 26, 26, 7, -25 },
  { 2219, 16, 33, 26, 3, -25 },
  { 2285, 24, 21, 26, 2, -24 },
  { 2348, 25, 14, 26, 1, -21 },
  { 2392, 24, 21, 26, 1, -24 },
  { 2455, 20, 34, 26, 6, -33 },
  { 2540, 27, 40, 26, 1, -33 },
  { 2675, 26, 33, 26, -3, -33 },
  { 2783, 26, 33, 26, 0, -33 },
  { 2891, 25, 34, 26, 3, -33 },
  { 2998, 26, 33, 26, 0, -33 },
  { 3106, 27, 33, 26, 1, -33 },
  { 3218, 27, 33, 26, 1, -33 },
  { 3330, 26, 34, 26, 2, -33 },
  { 3441, 29, 33, 26, 0, -33 },
  { 3561, 26, 33, 26, 1, -33 },
  { 3669, 26, 34, 26, 1, -33 },
  { 3780, 29, 33, 26, 0, -33 },
  { 3900, 20, 33, 26, 1, -33 },
  { 3983, 29, 33, 26, -1, -33 },
  { 4103, 29, 33, 26, 0, -33 },
  { 4223, 24, 34, 26, 2, -33 },
  { 4325, 26, 33, 26, 1, -33 },
  { 4433, 24, 42, 26, 2, -33 },
  { 4559, 26, 33, 26, 0, -33 },
  { 4667, 27, 34, 26, 0, -33 },
  { 4782, 24, 33, 26, 5, -33 },
  { 4881, 26, 34, 26, 2, -33 },
  { 4992, 25, 33, 26, 5, -33 },
  { 5096, 29, 33, 26, 1, -33 },
  { 5216, 32, 33, 26, -2, -33 },
  { 5348, 25, 33, 26, 6, -33 },
  { 5452, 28, 33, 26, 0, -33 },
  { 5568, 24, 46, 26, 3, -37 },
  { 5706, 9, 46, 26, 9, -37 },
  { 5758, 25, 46, 26, -1, -37 },
  { 5902, 23, 19, 26, 3, -33 },
  { 5957, 25, 5, 26, -4, 4 },
  { 5973, 10, 9, 26, 11, -36 },
  { 5985, 23, 26, 26, 2, -25 },
  { 6060, 24, 38, 26, 1, -37 },
  { 6174, 23, 26, 26, 2, -25 },
  { 6249, 27, 38, 26, 2, -37 },
  { 6378, 23, 26, 26, 2, -25 },
  { 6453, 31, 45, 26, -2, -36 },
  { 6628, 27, 34, 26, -1, -25 },
  { 6743, 24, 37, 26, 0, -37 },
  { 6854, 16, 36, 26, 5, -36 },
  { 6926, 26, 45, 26, -1, -36 },
  { 7073, 26, 37, 26, 1, -37 },
  { 7194, 15, 37, 26, 7, -36 },
  { 7264, 27, 25, 26, -1, -25 },
  { 7349, 23, 25, 26, 1, -25 },
  { 7421, 23, 26, 26, 2, -25 },
  { 7496, 26, 34, 26, -1, -25 },
  { 7607, 24, 34, 26, 2, -25 },
  { 7709, 24, 25, 26, 2, -25 },
  { 7784, 23, 26, 26, 1, -25 },
  { 7859, 20, 33, 26, 5, -32 },
  { 7942, 23, 26, 26, 2, -25 },
  { 8017, 23, 25, 26, 4, -25 },
  { 8089, 26, 25, 26, 2, -25 },
  { 8171, 28, 25, 26, -1, -25 },
  { 8259, 30, 34, 26, -3, -25 },
  { 8387, 24, 25, 26, 1, -25 },
  { 8462, 25, 46, 26, 3, -37 },
  { 8606, 17, 46, 26, 5, -37 },
  { 8704, 25, 46, 26, -2, -37 },
  { 8848, 25, 8, 26, 1, -18 },
};

const GFXfont UbuntuSansMono_MediumItalic47pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic47pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic47pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC47PT7B_H_
