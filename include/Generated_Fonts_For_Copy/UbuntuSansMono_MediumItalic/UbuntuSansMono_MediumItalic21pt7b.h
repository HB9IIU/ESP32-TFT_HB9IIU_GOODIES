#ifndef _UBUNTUSANSMONO_MEDIUMITALIC21PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x71, 0xC6, 0x18, 0xE3, 0x8C, 0x30, 0xC0, 0x00, 0xE3, 0xCE,
  0x00, 0x66, 0xCF, 0x9E, 0x3C, 0xD9, 0x80, 0x03, 0x30, 0x33, 0x06, 0x30,
  0x66, 0x3F, 0xF7, 0xFF, 0x0C, 0xC1, 0x98, 0x19, 0x87, 0xFE, 0xFF, 0xE6,
  0x30, 0x66, 0x06, 0x60, 0xCE, 0x00, 0x03, 0x80, 0x60, 0x3F, 0x0F, 0xF3,
  0x84, 0x60, 0x0C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0E, 0x00, 0xC0, 0x19,
  0x87, 0x3F, 0xC1, 0xE0, 0x18, 0x06, 0x00, 0x0E, 0x0C, 0x7C, 0x21, 0xB1,
  0x84, 0xCC, 0x33, 0x60, 0xDB, 0x01, 0xD8, 0x00, 0x40, 0x03, 0x70, 0x1B,
  0xC0, 0xD9, 0x06, 0x64, 0x31, 0x31, 0x86, 0xCE, 0x1E, 0x00, 0x03, 0x81,
  0xF8, 0x73, 0x0C, 0x61, 0x8C, 0x33, 0x07, 0xC0, 0xE3, 0x3E, 0x6C, 0xF9,
  0x8F, 0x71, 0xCE, 0x38, 0xFF, 0x9F, 0x30, 0x6F, 0xFD, 0xA0, 0x00, 0x80,
  0x60, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x10,
  0x00, 0x02, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x38, 0x18, 0x1C, 0x1C, 0x0C, 0x0E, 0x1E, 0x1C, 0x04,
  0x00, 0x0C, 0x03, 0x08, 0xC9, 0xB6, 0xFF, 0xC3, 0x01, 0xE1, 0xCC, 0x33,
  0x00, 0x06, 0x01, 0x80, 0x60, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x60, 0x18,
  0x06, 0x00, 0x13, 0xDE, 0xF3, 0x3B, 0x80, 0xFF, 0xF0, 0x2F, 0xFE, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x00, 0x07, 0x83, 0xF8, 0xE3,
  0x18, 0x67, 0x0E, 0xC1, 0xDB, 0xB7, 0x76, 0xCC, 0xD8, 0x3B, 0x06, 0x61,
  0xCE, 0x31, 0xFE, 0x1F, 0x00, 0x01, 0x81, 0xC3, 0xC7, 0xE3, 0x30, 0x38,
  0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC7, 0xFF, 0xFC, 0x07, 0xC1,
  0xFE, 0x1C, 0x61, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x3C, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0x83, 0xFC,
  0x23, 0x80, 0x30, 0x06, 0x01, 0xC1, 0xF0, 0x7C, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x64, 0x1C, 0xFF, 0x3F, 0xC0, 0x00, 0x60, 0x1C, 0x07, 0x81, 0xF0,
  0x6C, 0x19, 0x86, 0x31, 0x86, 0x71, 0xCC, 0x33, 0xFF, 0x80, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x07, 0xF0, 0x7F, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x1F, 0x01, 0xF8, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x41, 0xC7, 0xF8,
  0xFF, 0x00, 0x00, 0x60, 0x7C, 0x3E, 0x0E, 0x03, 0x80, 0xE0, 0x1B, 0xC3,
  0xFC, 0xE1, 0xDC, 0x1B, 0x03, 0x60, 0xEE, 0x18, 0xFE, 0x0F, 0x80, 0x7F,
  0xEF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x03,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x00, 0x07, 0x83, 0xF8, 0xE3,
  0x98, 0x33, 0x0E, 0x61, 0x8E, 0x60, 0xF8, 0x77, 0x8C, 0x33, 0x06, 0x60,
  0xCC, 0x19, 0xFE, 0x1F, 0x80, 0x0F, 0x03, 0xF8, 0xE3, 0x38, 0x76, 0x0E,
  0xC1, 0xD8, 0x3B, 0xDE, 0x3F, 0xC0, 0x38, 0x06, 0x01, 0x80, 0xF1, 0xF8,
  0x3C, 0x00, 0x10, 0xF3, 0xCE, 0x00, 0x00, 0x08, 0xF3, 0xCE, 0x00, 0x08,
  0x3C, 0x78, 0xE0, 0x00, 0x00, 0x08, 0x78, 0xF1, 0xE1, 0x87, 0x1C, 0x00,
  0x00, 0x40, 0x70, 0xFC, 0xF8, 0xF0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0x40, 0x3F, 0xF3, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x10, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x03, 0xC3, 0xE7, 0xF0, 0x70, 0x10, 0x00,
  0x3E, 0x7F, 0x43, 0x03, 0x03, 0x06, 0x1C, 0x38, 0x30, 0x60, 0x00, 0x00,
  0xE0, 0xE0, 0xE0, 0x07, 0xC1, 0xFC, 0x61, 0x98, 0x36, 0x06, 0xC7, 0xF3,
  0xFE, 0x67, 0xDC, 0xDB, 0x1B, 0x63, 0x6C, 0x6C, 0xF9, 0x9F, 0x30, 0x07,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0xC0, 0x38, 0x0F, 0x81, 0xB0, 0x66, 0x0C,
  0xC3, 0x18, 0x63, 0x18, 0x63, 0xFC, 0xFF, 0x98, 0x36, 0x06, 0xC0, 0xF0,
  0x18, 0x0F, 0x81, 0xFE, 0x18, 0xE1, 0x87, 0x18, 0x63, 0x86, 0x3F, 0xC3,
  0xF8, 0x31, 0xC7, 0x0E, 0x60, 0xE6, 0x0E, 0x61, 0xCF, 0xF8, 0xFF, 0x00,
  0x03, 0xC0, 0xFF, 0x1C, 0x23, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x87, 0xF8, 0x3F, 0x00, 0x0F,
  0x03, 0xF8, 0x67, 0x8C, 0x33, 0x86, 0x60, 0xCC, 0x19, 0x83, 0x70, 0x6E,
  0x1D, 0x83, 0x30, 0xEE, 0x39, 0xFE, 0x3F, 0x80, 0x1F, 0xE3, 0xFC, 0x60,
  0x1C, 0x03, 0x00, 0x60, 0x0F, 0xE3, 0xFC, 0x70, 0x0C, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF1, 0xFE, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x07, 0xF8, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x00, 0x03, 0xC1, 0xFC, 0x70, 0x9C, 0x07, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0xC1, 0xD8, 0x3B, 0x06, 0x70, 0xCE, 0x18, 0xFF, 0x0F,
  0xC0, 0x1C, 0x38, 0xC1, 0xC6, 0x0C, 0x30, 0x63, 0x87, 0x18, 0x38, 0xFF,
  0x87, 0xFC, 0x70, 0x63, 0x87, 0x18, 0x30, 0xC1, 0x8E, 0x0C, 0x70, 0xE3,
  0x06, 0x00, 0x0F, 0xF0, 0xFF, 0x13, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x07, 0xF8, 0xFF,
  0x80, 0x07, 0xF0, 0x7F, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x43, 0x8F, 0xF0, 0x7E, 0x00,
  0x0C, 0x38, 0xE3, 0x86, 0x18, 0x31, 0x81, 0x98, 0x1D, 0x80, 0xD8, 0x07,
  0x80, 0x3E, 0x03, 0xB8, 0x18, 0xC0, 0xC7, 0x06, 0x18, 0x70, 0xE3, 0x03,
  0x00, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18,
  0x1C, 0x0C, 0x06, 0x03, 0xFF, 0xFE, 0x06, 0x18, 0x70, 0xC3, 0x8E, 0x14,
  0x71, 0xA7, 0x8D, 0x2C, 0x6B, 0x62, 0x76, 0x33, 0x31, 0x99, 0x8C, 0x0C,
  0xC0, 0xE6, 0x06, 0x30, 0x33, 0x81, 0x80, 0x1C, 0x18, 0xE1, 0xC7, 0x0C,
  0x38, 0x63, 0xE3, 0x1B, 0x38, 0xD9, 0x86, 0x6C, 0x73, 0x63, 0x1B, 0x18,
  0xF0, 0xC3, 0x86, 0x1C, 0x60, 0xE3, 0x06, 0x00, 0x07, 0x83, 0xF8, 0xE3,
  0x18, 0x77, 0x0E, 0xC1, 0xD8, 0x3F, 0x07, 0xC0, 0xD8, 0x1B, 0x07, 0x60,
  0xCE, 0x38, 0xFE, 0x1F, 0x80, 0x0F, 0x81, 0xFE, 0x1C, 0xF1, 0x87, 0x18,
  0x31, 0x87, 0x38, 0x63, 0x1E, 0x3F, 0xC3, 0xE0, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x00, 0x07, 0x83, 0xF8, 0xE3, 0x18, 0x77, 0x0E, 0xC1,
  0xD8, 0x3F, 0x07, 0xC0, 0xD8, 0x1B, 0x07, 0x60, 0xCE, 0x39, 0xFE, 0x1F,
  0x81, 0xC0, 0x18, 0x03, 0xE0, 0x18, 0x00, 0x0F, 0x81, 0xFE, 0x18, 0xE1,
  0x87, 0x18, 0x73, 0x86, 0x30, 0xE3, 0xFC, 0x3F, 0x87, 0x30, 0x63, 0x86,
  0x18, 0x61, 0x8E, 0x1C, 0xC1, 0xC0, 0x03, 0xE0, 0xFF, 0x1C, 0x21, 0x80,
  0x18, 0x01, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1C, 0x00, 0xC0, 0x0C,
  0x41, 0xCF, 0xF8, 0x7F, 0x00, 0x7F, 0xEF, 0xFE, 0x38, 0x06, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60,
  0x1C, 0x00, 0x38, 0x73, 0x06, 0x30, 0x63, 0x06, 0x70, 0xE6, 0x0C, 0x60,
  0xC6, 0x0C, 0xE1, 0xCC, 0x1C, 0xC1, 0x8C, 0x18, 0xC3, 0x8F, 0xF0, 0x7E,
  0x00, 0xE0, 0x7E, 0x06, 0xE0, 0xEE, 0x0C, 0xE1, 0xCE, 0x18, 0x63, 0x86,
  0x30, 0x67, 0x06, 0x60, 0x6C, 0x06, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x00,
  0x18, 0x18, 0xC0, 0xCE, 0x06, 0x60, 0x63, 0x03, 0x18, 0x18, 0xDC, 0xCC,
  0xEC, 0x6F, 0x63, 0x5B, 0x1E, 0xD0, 0xA3, 0x87, 0x1C, 0x30, 0xC3, 0x86,
  0x00, 0x0E, 0x0C, 0x38, 0x70, 0x63, 0x81, 0xCC, 0x03, 0x60, 0x0F, 0x80,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1B, 0x00, 0xCC, 0x07, 0x30, 0x38, 0xE1,
  0xC1, 0x8E, 0x06, 0x00, 0xC0, 0xF8, 0x1B, 0x06, 0x61, 0xCE, 0x30, 0xCC,
  0x1B, 0x83, 0xE0, 0x78, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x7F, 0xE3,
  0xFE, 0x00, 0x07, 0xE0, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0xF8, 0x7E, 0x00, 0xEE, 0xEE, 0x66, 0x66, 0x66, 0x66,
  0x77, 0x77, 0x33, 0x33, 0x0F, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x70, 0x0C, 0x01, 0x83, 0xF0, 0x7E, 0x00, 0x03, 0x01, 0xC0, 0xF8,
  0x36, 0x19, 0x8E, 0x77, 0x0F, 0x83, 0x20, 0x80, 0x7F, 0xFF, 0xFC, 0x47,
  0x0E, 0x20, 0x0F, 0xCF, 0xF7, 0x0D, 0x87, 0xE1, 0xB0, 0x6C, 0x1B, 0x0E,
  0xC3, 0xBF, 0xE7, 0xD8, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x3F,
  0x87, 0xF1, 0xC7, 0x30, 0x66, 0x0C, 0xC3, 0xB8, 0x76, 0x0C, 0xC3, 0x9F,
  0xE7, 0xF0, 0x0F, 0xCF, 0xF7, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00,
  0xE0, 0x1F, 0xC3, 0xF8, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0xFC, 0x3F, 0xC7, 0x0C, 0x61, 0xCE, 0x18, 0xC1, 0x8C, 0x18, 0xC3, 0x8C,
  0x38, 0xFF, 0x87, 0xD8, 0x1F, 0x8F, 0xF7, 0x0D, 0x83, 0xC1, 0xFF, 0xEF,
  0xC3, 0x00, 0xE0, 0x1F, 0xC3, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x0F, 0x80, 0x3C, 0x00, 0x03, 0xF8, 0x7F, 0x87, 0x0C, 0x30, 0x63,
  0x87, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x3F, 0xE0, 0xFE, 0x00, 0x30, 0x03,
  0x84, 0x38, 0x3F, 0xC3, 0xF8, 0x00, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x3F, 0x0F, 0xF1, 0xC6, 0x30, 0xE6, 0x19, 0xC3, 0x38, 0x66, 0x1C,
  0xC3, 0x18, 0x67, 0x1C, 0x0E, 0x3C, 0x30, 0x00, 0x1F, 0xBF, 0x0C, 0x18,
  0x30, 0xE1, 0x83, 0x06, 0x0F, 0x8F, 0x00, 0x70, 0x07, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x84, 0x70, 0xFE, 0x07, 0xC0,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x87, 0x18, 0xE1, 0x9C,
  0x3B, 0x03, 0xE0, 0x3E, 0x03, 0x70, 0x73, 0x06, 0x38, 0x61, 0x8E, 0x1C,
  0xFD, 0xF8, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xE1, 0x83, 0x06, 0x0C,
  0x1F, 0xBF, 0x3F, 0xE7, 0xFC, 0xCD, 0x9B, 0x36, 0x66, 0xCC, 0xD9, 0x9B,
  0x06, 0xC0, 0xD8, 0x1B, 0x07, 0x00, 0x1F, 0xC3, 0xF8, 0xE3, 0x9C, 0x73,
  0x0E, 0x61, 0x9C, 0x33, 0x86, 0x61, 0xCC, 0x33, 0x86, 0x00, 0x1F, 0x8F,
  0xF7, 0x1D, 0x83, 0xE0, 0xF0, 0x3C, 0x1F, 0x06, 0xE3, 0xBF, 0xC7, 0xE0,
  0x0F, 0xE0, 0xFE, 0x1C, 0x71, 0x83, 0x18, 0x31, 0x87, 0x38, 0x73, 0x06,
  0x31, 0xE3, 0xFC, 0x7F, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x00, 0x0F,
  0xE7, 0xF9, 0xC3, 0x30, 0xEE, 0x1D, 0x83, 0x30, 0x66, 0x1C, 0xE3, 0x9F,
  0xE1, 0xFC, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x1F, 0xE7, 0xF8, 0xC0,
  0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x00,
  0x1F, 0xCF, 0xE3, 0x00, 0xC0, 0x3C, 0x07, 0xC0, 0x70, 0x0E, 0x83, 0xBF,
  0xCF, 0xE0, 0x1C, 0x0E, 0x06, 0x1F, 0xFF, 0xF9, 0xC0, 0xC0, 0x60, 0x70,
  0x38, 0x18, 0x0C, 0x07, 0xF1, 0xF8, 0x30, 0xDC, 0x36, 0x1D, 0x87, 0x61,
  0xB8, 0x6C, 0x3B, 0x0E, 0xE3, 0x3F, 0xE7, 0xD8, 0xC1, 0xF0, 0x6E, 0x3B,
  0x8C, 0xE3, 0x39, 0x86, 0xE1, 0xB0, 0x78, 0x1E, 0x07, 0x00, 0x60, 0x76,
  0x06, 0xC0, 0x6C, 0xE6, 0xCE, 0xCD, 0xEC, 0xD6, 0x8F, 0x78, 0xE7, 0x8E,
  0x70, 0xC3, 0x00, 0x1C, 0x38, 0x63, 0x83, 0xB8, 0x0D, 0x80, 0x78, 0x01,
  0x80, 0x1E, 0x01, 0xB0, 0x19, 0xC1, 0xC6, 0x3C, 0x38, 0x0E, 0x1C, 0x38,
  0x60, 0xE1, 0x83, 0x8E, 0x06, 0x30, 0x19, 0xC0, 0x66, 0x01, 0xB8, 0x07,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x1F, 0xE3, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x30,
  0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xF0, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xF8, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3E, 0x01, 0xE0, 0x07, 0x06,
  0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30,
  0x30, 0x70, 0x70, 0x60, 0x60, 0xE0, 0x07, 0xC1, 0x38, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x1C, 0x07, 0x81, 0x80, 0x30,
  0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC3, 0xF0, 0x7C, 0x00, 0x78, 0x7F,
  0xBC, 0xF9, 0x0C,
};

const GFXglyph UbuntuSansMono_MediumItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 15, 12, 3, -15 },
  { 13, 7, 6, 12, 4, -16 },
  { 19, 12, 15, 12, 0, -15 },
  { 42, 11, 18, 12, 1, -16 },
  { 67, 14, 15, 12, -1, -15 },
  { 94, 11, 15, 12, 0, -15 },
  { 115, 3, 7, 12, 6, -16 },
  { 118, 10, 21, 12, 2, -17 },
  { 145, 9, 21, 12, 0, -17 },
  { 169, 10, 9, 12, 2, -15 },
  { 181, 10, 10, 12, 1, -11 },
  { 194, 5, 7, 12, 2, -4 },
  { 199, 6, 2, 12, 3, -7 },
  { 201, 4, 4, 12, 3, -4 },
  { 203, 13, 20, 12, -1, -16 },
  { 236, 11, 15, 12, 1, -15 },
  { 257, 9, 15, 12, 1, -15 },
  { 274, 12, 15, 12, 0, -15 },
  { 297, 11, 15, 12, 0, -15 },
  { 318, 11, 15, 12, 0, -15 },
  { 339, 12, 15, 12, 0, -15 },
  { 362, 11, 15, 12, 1, -15 },
  { 383, 11, 15, 12, 2, -15 },
  { 404, 11, 15, 12, 1, -15 },
  { 425, 11, 15, 12, 1, -15 },
  { 446, 6, 11, 12, 3, -11 },
  { 455, 7, 14, 12, 2, -11 },
  { 468, 10, 10, 12, 1, -11 },
  { 481, 12, 6, 12, 0, -9 },
  { 490, 11, 10, 12, 0, -11 },
  { 504, 8, 15, 12, 3, -15 },
  { 519, 11, 18, 12, 1, -15 },
  { 544, 11, 15, 12, -1, -15 },
  { 565, 12, 15, 12, 0, -15 },
  { 588, 12, 15, 12, 1, -15 },
  { 611, 11, 15, 12, 0, -15 },
  { 632, 11, 15, 12, 1, -15 },
  { 653, 12, 15, 12, 1, -15 },
  { 676, 11, 15, 12, 1, -15 },
  { 697, 13, 15, 12, 0, -15 },
  { 722, 12, 15, 12, 0, -15 },
  { 745, 12, 15, 12, 0, -15 },
  { 768, 13, 15, 12, 0, -15 },
  { 793, 9, 15, 12, 0, -15 },
  { 810, 13, 15, 12, -1, -15 },
  { 835, 13, 15, 12, 0, -15 },
  { 860, 11, 15, 12, 1, -15 },
  { 881, 12, 15, 12, 0, -15 },
  { 904, 11, 19, 12, 1, -15 },
  { 931, 12, 15, 12, 0, -15 },
  { 954, 12, 15, 12, 0, -15 },
  { 977, 11, 15, 12, 2, -15 },
  { 998, 12, 15, 12, 1, -15 },
  { 1021, 12, 15, 12, 2, -15 },
  { 1044, 13, 15, 12, 0, -15 },
  { 1069, 14, 15, 12, -1, -15 },
  { 1096, 11, 15, 12, 3, -15 },
  { 1117, 13, 15, 12, 0, -15 },
  { 1142, 11, 20, 12, 1, -16 },
  { 1170, 4, 20, 12, 4, -16 },
  { 1180, 11, 20, 12, 0, -16 },
  { 1208, 10, 9, 12, 1, -15 },
  { 1220, 11, 2, 12, -2, 2 },
  { 1223, 5, 4, 12, 5, -16 },
  { 1226, 10, 11, 12, 1, -11 },
  { 1240, 11, 16, 12, 0, -16 },
  { 1262, 10, 11, 12, 1, -11 },
  { 1276, 12, 16, 12, 1, -16 },
  { 1300, 10, 11, 12, 1, -11 },
  { 1314, 14, 20, 12, -1, -16 },
  { 1349, 13, 15, 12, -1, -11 },
  { 1374, 11, 16, 12, 0, -16 },
  { 1396, 7, 16, 12, 2, -16 },
  { 1410, 12, 20, 12, -1, -16 },
  { 1440, 12, 16, 12, 0, -16 },
  { 1464, 7, 16, 12, 3, -16 },
  { 1478, 11, 11, 12, 0, -11 },
  { 1494, 11, 11, 12, 0, -11 },
  { 1510, 10, 11, 12, 1, -11 },
  { 1524, 12, 15, 12, -1, -11 },
  { 1547, 11, 15, 12, 1, -11 },
  { 1568, 11, 11, 12, 1, -11 },
  { 1584, 10, 11, 12, 1, -11 },
  { 1598, 9, 14, 12, 2, -14 },
  { 1614, 10, 11, 12, 1, -11 },
  { 1628, 10, 11, 12, 2, -11 },
  { 1642, 12, 11, 12, 1, -11 },
  { 1659, 13, 11, 12, -1, -11 },
  { 1677, 14, 15, 12, -2, -11 },
  { 1704, 11, 11, 12, 0, -11 },
  { 1720, 12, 20, 12, 1, -16 },
  { 1750, 8, 20, 12, 2, -16 },
  { 1770, 11, 20, 12, -1, -16 },
  { 1798, 10, 4, 12, 1, -8 },
};

const GFXfont UbuntuSansMono_MediumItalic21pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic21pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC21PT7B_H_
