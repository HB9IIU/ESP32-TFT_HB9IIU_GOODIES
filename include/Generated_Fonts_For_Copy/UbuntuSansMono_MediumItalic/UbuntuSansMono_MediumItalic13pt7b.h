#ifndef _UBUNTUSANSMONO_MEDIUMITALIC13PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x66, 0x44, 0x0C, 0xC0, 0xDB, 0xAA, 0x0B, 0x12, 0x7F, 0x34,
  0x24, 0x68, 0xFE, 0x58, 0x90, 0x04, 0x18, 0xF9, 0x03, 0x03, 0x03, 0x02,
  0x4D, 0xF0, 0x80, 0x31, 0x52, 0x54, 0x78, 0x10, 0x3E, 0x2A, 0x4A, 0x8C,
  0x1C, 0x48, 0x91, 0x43, 0x2B, 0xB3, 0x66, 0x74, 0xFA, 0x19, 0x98, 0x8C,
  0x42, 0x10, 0x84, 0x30, 0x80, 0x10, 0x20, 0xC3, 0x0C, 0x30, 0xC2, 0x18,
  0xC6, 0x30, 0x11, 0x5F, 0xCC, 0x68, 0x10, 0xC3, 0x3F, 0x21, 0x80, 0x6C,
  0xE0, 0xF0, 0xF0, 0x01, 0x81, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x20,
  0x30, 0x10, 0x18, 0x18, 0x00, 0x3D, 0x9C, 0x65, 0xB6, 0x38, 0xA6, 0xF0,
  0x19, 0xD6, 0x21, 0x18, 0xC4, 0xF8, 0x3E, 0x44, 0x08, 0x30, 0xC6, 0x18,
  0x20, 0xFC, 0x3E, 0x4C, 0x18, 0x61, 0xC0, 0x81, 0x46, 0xF8, 0x06, 0x1C,
  0x51, 0x26, 0x49, 0xBF, 0x84, 0x08, 0x1F, 0x10, 0x30, 0x30, 0x3C, 0x04,
  0x04, 0x8C, 0xF8, 0x1E, 0x61, 0x86, 0x8F, 0x91, 0xA3, 0x44, 0xF0, 0x7E,
  0x08, 0x30, 0xC3, 0x04, 0x18, 0x20, 0xC0, 0x1E, 0x64, 0x89, 0xB3, 0x8C,
  0x91, 0x62, 0x78, 0x3E, 0x45, 0x8B, 0x13, 0xE2, 0xC3, 0x0C, 0xF0, 0x6C,
  0x01, 0xB0, 0x33, 0x00, 0x06, 0x62, 0xC0, 0x04, 0x7F, 0x30, 0x70, 0x60,
  0x7E, 0x00, 0x07, 0xF0, 0x40, 0xE0, 0x30, 0x73, 0x98, 0x00, 0x78, 0x46,
  0x66, 0x20, 0x18, 0xC0, 0x1E, 0x33, 0x63, 0x4E, 0x52, 0xD2, 0xD6, 0xDC,
  0x40, 0x60, 0x38, 0x06, 0x1C, 0x28, 0x91, 0x24, 0x4F, 0xA1, 0xC2, 0x3E,
  0x44, 0x8B, 0x37, 0xC8, 0xD1, 0xE6, 0xF8, 0x3E, 0xC5, 0x06, 0x08, 0x10,
  0x20, 0x64, 0x78, 0x3C, 0x4D, 0x8B, 0x14, 0x28, 0xD1, 0x66, 0xF0, 0x3F,
  0x30, 0x20, 0x20, 0x7C, 0x60, 0x40, 0x40, 0xFC, 0x3F, 0x30, 0x20, 0x20,
  0x7C, 0x60, 0x40, 0x40, 0xC0, 0x3E, 0xCB, 0x04, 0x08, 0xD1, 0xA2, 0x64,
  0xF8, 0x33, 0x23, 0x62, 0x62, 0x7E, 0x46, 0x44, 0xC4, 0x8C, 0x3F, 0x08,
  0x08, 0x18, 0x18, 0x10, 0x10, 0x30, 0xFC, 0x1F, 0x02, 0x02, 0x06, 0x04,
  0x04, 0x04, 0x4C, 0xF8, 0x33, 0x26, 0x2C, 0x78, 0x70, 0x58, 0x48, 0xCC,
  0xC4, 0x30, 0x82, 0x08, 0x61, 0x04, 0x10, 0xFC, 0x33, 0x32, 0x36, 0x5A,
  0x5A, 0x52, 0xC6, 0x84, 0x84, 0x33, 0x33, 0x32, 0x72, 0x4A, 0x4E, 0x4C,
  0xCC, 0x8C, 0x3D, 0x9C, 0x61, 0x86, 0x38, 0xA6, 0xF0, 0x3E, 0x44, 0x8B,
  0x16, 0xEF, 0x10, 0x20, 0xC0, 0x3D, 0x9C, 0x61, 0x86, 0x38, 0xA6, 0xF1,
  0x03, 0x00, 0x3C, 0x4C, 0x8B, 0x37, 0xCF, 0x12, 0x66, 0xC4, 0x1E, 0x44,
  0x81, 0x81, 0xC1, 0x81, 0x46, 0xF8, 0xFC, 0x82, 0x18, 0x61, 0x04, 0x30,
  0xC0, 0x66, 0x8B, 0x16, 0x28, 0xD1, 0xA2, 0x4C, 0xF0, 0xC3, 0x8F, 0x12,
  0x64, 0x8B, 0x14, 0x38, 0x60, 0x21, 0x61, 0x63, 0x5A, 0x5A, 0x6A, 0x6C,
  0xCC, 0xCC, 0x33, 0x32, 0x14, 0x1C, 0x18, 0x38, 0x2C, 0x44, 0xC4, 0x86,
  0x39, 0xB4, 0x61, 0x84, 0x10, 0xC0, 0x3F, 0x02, 0x04, 0x08, 0x18, 0x30,
  0x60, 0x40, 0xFC, 0x1E, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x20, 0x40, 0x83,
  0x07, 0x80, 0xAA, 0xAF, 0xFD, 0x1E, 0x08, 0x30, 0x60, 0x81, 0x02, 0x0C,
  0x10, 0x20, 0x47, 0x80, 0x18, 0xE6, 0x93, 0x84, 0xFE, 0xCC, 0x80, 0x1E,
  0x6D, 0x1A, 0x2C, 0x49, 0x9F, 0x00, 0x30, 0x60, 0x81, 0xE6, 0x6C, 0xD1,
  0xA2, 0x4D, 0xF0, 0x3D, 0x9C, 0x20, 0x82, 0x2F, 0x80, 0x06, 0x0C, 0x11,
  0xE6, 0xD9, 0xA2, 0x44, 0x99, 0xF0, 0x39, 0x38, 0xFE, 0x82, 0x0F, 0x80,
  0x03, 0x82, 0x03, 0x03, 0xE0, 0x80, 0x40, 0x20, 0x30, 0x18, 0x08, 0x04,
  0x1E, 0x00, 0x1E, 0x6D, 0x9A, 0x24, 0x4F, 0x8F, 0x04, 0xF8, 0x30, 0x60,
  0x81, 0xE6, 0x4C, 0xD1, 0x22, 0xCD, 0x98, 0x31, 0x81, 0xE3, 0x10, 0x8C,
  0x61, 0xC0, 0x06, 0x0C, 0x01, 0xE0, 0x41, 0x83, 0x04, 0x08, 0x30, 0x67,
  0x80, 0x10, 0x30, 0x30, 0x23, 0x2C, 0x78, 0x70, 0x58, 0x4C, 0xCC, 0xF2,
  0x66, 0x44, 0x4C, 0xCF, 0x76, 0xB5, 0x6A, 0xBC, 0x50, 0xA1, 0x00, 0x3C,
  0x4D, 0x9B, 0x24, 0x48, 0xB3, 0x00, 0x39, 0x38, 0xE3, 0x8A, 0x6F, 0x00,
  0x3C, 0xCD, 0x9A, 0x34, 0x49, 0xBE, 0x40, 0x80, 0x3D, 0xBC, 0xE2, 0x8A,
  0x6F, 0x84, 0x10, 0x7D, 0x94, 0x30, 0xC2, 0x08, 0x00, 0x1E, 0x44, 0x81,
  0xC0, 0xC9, 0xBE, 0x00, 0x30, 0xCF, 0xC8, 0x61, 0x84, 0x10, 0x78, 0x47,
  0x3C, 0xA2, 0x8A, 0x6F, 0x80, 0xC7, 0x3C, 0x96, 0x51, 0xC6, 0x00, 0x87,
  0x0A, 0xD5, 0xAD, 0x9B, 0x24, 0x00, 0x62, 0x48, 0xF0, 0xC3, 0x8D, 0xB3,
  0x00, 0x31, 0x33, 0x12, 0x12, 0x16, 0x1C, 0x18, 0x18, 0xF0, 0x3E, 0x08,
  0x20, 0x82, 0x0C, 0x3F, 0x00, 0x1E, 0x20, 0x41, 0x82, 0x0C, 0x30, 0x30,
  0x40, 0x81, 0x03, 0x80, 0x33, 0x22, 0x66, 0x44, 0xCC, 0x88, 0x1C, 0x0C,
  0x18, 0x20, 0x40, 0xC1, 0x84, 0x08, 0x30, 0x67, 0x80, 0x73, 0xB8,
};

const GFXglyph UbuntuSansMono_MediumItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 9, 7, 2, -9 },
  { 6, 4, 4, 7, 3, -10 },
  { 8, 8, 9, 7, 0, -9 },
  { 17, 7, 11, 7, 0, -10 },
  { 27, 8, 9, 7, 0, -9 },
  { 36, 7, 9, 7, 0, -9 },
  { 44, 2, 4, 7, 4, -10 },
  { 45, 5, 12, 7, 2, -10 },
  { 53, 6, 12, 7, 0, -10 },
  { 62, 6, 5, 7, 1, -9 },
  { 66, 6, 6, 7, 1, -7 },
  { 71, 3, 4, 7, 1, -2 },
  { 73, 4, 1, 7, 2, -4 },
  { 74, 2, 2, 7, 2, -2 },
  { 75, 9, 12, 7, -1, -10 },
  { 89, 6, 9, 7, 1, -9 },
  { 96, 5, 9, 7, 1, -9 },
  { 102, 7, 9, 7, 0, -9 },
  { 110, 7, 9, 7, 0, -9 },
  { 118, 7, 9, 7, 0, -9 },
  { 126, 8, 9, 7, 0, -9 },
  { 135, 7, 9, 7, 1, -9 },
  { 143, 7, 9, 7, 1, -9 },
  { 151, 7, 9, 7, 0, -9 },
  { 159, 7, 9, 7, 0, -9 },
  { 167, 3, 7, 7, 2, -7 },
  { 170, 4, 9, 7, 1, -7 },
  { 175, 6, 6, 7, 1, -7 },
  { 180, 7, 4, 7, 0, -6 },
  { 184, 7, 6, 7, 0, -7 },
  { 190, 5, 9, 7, 2, -9 },
  { 196, 8, 11, 7, 0, -9 },
  { 207, 7, 9, 7, -1, -9 },
  { 215, 7, 9, 7, 0, -9 },
  { 223, 7, 9, 7, 1, -9 },
  { 231, 7, 9, 7, 0, -9 },
  { 239, 8, 9, 7, 0, -9 },
  { 248, 8, 9, 7, 0, -9 },
  { 257, 7, 9, 7, 1, -9 },
  { 265, 8, 9, 7, 0, -9 },
  { 274, 8, 9, 7, 0, -9 },
  { 283, 8, 9, 7, 0, -9 },
  { 292, 8, 9, 7, 0, -9 },
  { 301, 6, 9, 7, 0, -9 },
  { 308, 8, 9, 7, 0, -9 },
  { 317, 8, 9, 7, 0, -9 },
  { 326, 6, 9, 7, 1, -9 },
  { 333, 7, 9, 7, 0, -9 },
  { 341, 6, 11, 7, 1, -9 },
  { 350, 7, 9, 7, 0, -9 },
  { 358, 7, 9, 7, 0, -9 },
  { 366, 6, 9, 7, 2, -9 },
  { 373, 7, 9, 7, 1, -9 },
  { 381, 7, 9, 7, 1, -9 },
  { 389, 8, 9, 7, 0, -9 },
  { 398, 8, 9, 7, 0, -9 },
  { 407, 6, 9, 7, 2, -9 },
  { 414, 8, 9, 7, 0, -9 },
  { 423, 7, 12, 7, 1, -10 },
  { 434, 2, 12, 7, 3, -10 },
  { 437, 7, 12, 7, 0, -10 },
  { 448, 6, 5, 7, 1, -9 },
  { 452, 7, 1, 7, -1, 1 },
  { 453, 3, 3, 7, 3, -10 },
  { 455, 7, 7, 7, 0, -7 },
  { 462, 7, 10, 7, 0, -10 },
  { 471, 6, 7, 7, 1, -7 },
  { 477, 7, 10, 7, 1, -10 },
  { 486, 6, 7, 7, 1, -7 },
  { 492, 9, 12, 7, -1, -10 },
  { 506, 7, 9, 7, 0, -7 },
  { 514, 7, 10, 7, 0, -10 },
  { 523, 5, 10, 7, 1, -10 },
  { 530, 7, 12, 7, 0, -10 },
  { 541, 8, 10, 7, 0, -10 },
  { 551, 4, 10, 7, 2, -10 },
  { 556, 7, 7, 7, 0, -7 },
  { 563, 7, 7, 7, 0, -7 },
  { 570, 6, 7, 7, 1, -7 },
  { 576, 7, 9, 7, 0, -7 },
  { 584, 6, 9, 7, 1, -7 },
  { 591, 6, 7, 7, 1, -7 },
  { 597, 7, 7, 7, 0, -7 },
  { 604, 6, 9, 7, 1, -9 },
  { 611, 6, 7, 7, 1, -7 },
  { 617, 6, 7, 7, 1, -7 },
  { 623, 7, 7, 7, 1, -7 },
  { 630, 7, 7, 7, 0, -7 },
  { 637, 8, 9, 7, -1, -7 },
  { 646, 7, 7, 7, 0, -7 },
  { 653, 7, 12, 7, 1, -10 },
  { 664, 4, 12, 7, 2, -10 },
  { 670, 7, 12, 7, -1, -10 },
  { 681, 7, 2, 7, 0, -5 },
};

const GFXfont UbuntuSansMono_MediumItalic13pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic13pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic13pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC13PT7B_H_
