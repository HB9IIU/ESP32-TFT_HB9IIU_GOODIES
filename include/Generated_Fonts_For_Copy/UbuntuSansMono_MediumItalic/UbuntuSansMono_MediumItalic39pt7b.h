#ifndef _UBUNTUSANSMONO_MEDIUMITALIC39PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xE0, 0x10, 0x00, 0x7C, 0x7B, 0xC3, 0xDE, 0x1E, 0xF1, 0xFF, 0x8F,
  0x78, 0x7B, 0xC3, 0xDE, 0x1C, 0xE0, 0xE7, 0x07, 0x30, 0x71, 0x83, 0x80,
  0x00, 0x1E, 0x1E, 0x00, 0x38, 0x38, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0,
  0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1C, 0x1C, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x87, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x70, 0x70, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F,
  0x08, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x81, 0xC1, 0xC0,
  0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00,
  0xE0, 0xE0, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xC0, 0x20, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x20, 0x07, 0x83,
  0xC0, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x7E, 0x00, 0xF0, 0x3F, 0x80, 0x78, 0x1C, 0xF0,
  0x3C, 0x07, 0x1C, 0x1E, 0x03, 0x87, 0x07, 0x00, 0xE1, 0xC3, 0x80, 0x38,
  0xE1, 0xC0, 0x0E, 0x38, 0xE0, 0x03, 0x8E, 0x78, 0x00, 0xE7, 0x3C, 0x00,
  0x3F, 0xDE, 0x00, 0x0F, 0xE7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xF8, 0x00, 0x3C, 0xFF, 0x00, 0x0E,
  0x71, 0xC0, 0x07, 0x1C, 0x70, 0x03, 0x8E, 0x1C, 0x01, 0xE3, 0x87, 0x00,
  0xF0, 0xE1, 0xC0, 0x78, 0x38, 0xE0, 0x1C, 0x0E, 0x38, 0x0E, 0x03, 0x9C,
  0x07, 0x00, 0xFF, 0x03, 0x80, 0x1F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x0F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3C, 0x3C, 0x0F,
  0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x07, 0x80, 0xF1, 0xE0, 0x1E,
  0x7C, 0x03, 0xDF, 0x00, 0x3F, 0xC0, 0x07, 0xE1, 0x03, 0xF8, 0x38, 0xFF,
  0x8F, 0x3E, 0xF1, 0xEF, 0x0F, 0x39, 0xE1, 0xFF, 0x78, 0x1F, 0xCF, 0x03,
  0xF9, 0xE0, 0x3E, 0x3C, 0x07, 0xC7, 0x81, 0xF8, 0xF8, 0x7F, 0x9F, 0xFF,
  0xF1, 0xFF, 0x9E, 0x1F, 0xE1, 0xE0, 0x3E, 0x79, 0xF3, 0xE7, 0xCF, 0x1E,
  0x3C, 0x71, 0xE3, 0xC7, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x06, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x60, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x06, 0x1C,
  0x33, 0xCE, 0x7D, 0xFB, 0x7F, 0xFF, 0xFF, 0x1F, 0xFE, 0x01, 0xF0, 0x01,
  0xFC, 0x01, 0xEF, 0x01, 0xF3, 0xC1, 0xF1, 0xF0, 0x78, 0x78, 0x18, 0x30,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x81, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x02, 0x03,
  0xE1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xF8, 0x1E, 0x07, 0x87, 0xCF, 0xE3,
  0xF0, 0xF0, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xEF, 0xFE, 0x10, 0xFB, 0xFF,
  0xFF, 0xFF, 0xBE, 0x10, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF,
  0xE0, 0x7C, 0x3E, 0x1F, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x0F, 0x3E, 0x01,
  0xE7, 0x80, 0x3C, 0xF0, 0x07, 0xBE, 0x30, 0xF7, 0x8F, 0x1E, 0xF3, 0xE3,
  0xFE, 0x7C, 0x7F, 0x8F, 0x9F, 0xF0, 0xE3, 0xDE, 0x00, 0x7B, 0xC0, 0x1F,
  0x78, 0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0xC1, 0xF0,
  0xFC, 0x7E, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x20, 0x00,
  0x00, 0x07, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFE, 0x1F, 0xFE,
  0x0F, 0xDE, 0x0F, 0x3E, 0x0C, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xC3, 0xF0, 0x30, 0x0F, 0x02, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x1C, 0x1F, 0x80, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x84, 0x00, 0xF8, 0x78, 0x1F, 0xC3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x00,
  0xF0, 0x78, 0x0F, 0x07, 0xC0, 0x78, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x0F,
  0x07, 0x80, 0xF8, 0x3C, 0x07, 0x83, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x08,
  0x01, 0xF0, 0x3C, 0x1F, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x7F, 0xFE,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xF0, 0x1F, 0x1F, 0x00, 0x78, 0xF8,
  0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x7C,
  0x7C, 0x03, 0xC1, 0xE0, 0x3E, 0x0F, 0x83, 0xE0, 0x3F, 0xFE, 0x01, 0xFF,
  0xE0, 0x03, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xE0, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1E, 0x01, 0xE1, 0xF0, 0x0F,
  0x0F, 0x00, 0xF8, 0x7C, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x87, 0xC0, 0x3E,
  0x7C, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0x0F, 0x81,
  0xF0, 0x3E, 0x1F, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x7C, 0x01,
  0xE3, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x7C, 0x1F, 0x83, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7C, 0x1F, 0x07, 0xC0, 0x78,
  0x3C, 0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80,
  0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x80, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x06, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x03, 0x03,
  0xE1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xF8, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x01, 0xF0, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xF8,
  0x08, 0x00, 0x00, 0x60, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x07, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xF8,
  0x03, 0xC0, 0x1E, 0x03, 0xE0, 0xFE, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x40, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x80, 0x0C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x01,
  0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0,
  0x07, 0xE0, 0x00, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xFC,
  0x1F, 0xFE, 0x1F, 0xFF, 0x18, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x10, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xE0, 0x78, 0x1F, 0x00, 0xF0, 0xF8,
  0x03, 0xC3, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x1F, 0xF3, 0xC1, 0xFF,
  0x8F, 0x0F, 0xFE, 0x78, 0x7E, 0xF9, 0xE3, 0xE1, 0xE7, 0x8F, 0x0F, 0x1C,
  0x78, 0x3C, 0x71, 0xE0, 0xF3, 0xC7, 0x83, 0xCF, 0x1E, 0x0E, 0x3C, 0x78,
  0x78, 0xF1, 0xE1, 0xE3, 0xC7, 0x87, 0x8F, 0x1F, 0x1C, 0x3C, 0x3F, 0xF0,
  0xF0, 0xFF, 0xC3, 0xC0, 0xFF, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xFD, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xF3, 0xC0, 0x07,
  0x9E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0,
  0x1E, 0x07, 0x00, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x07, 0x80,
  0x78, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xE0, 0x07, 0x8F,
  0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03,
  0xFE, 0x00, 0x1E, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07,
  0x87, 0xF0, 0x7C, 0x07, 0x83, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F,
  0x07, 0x80, 0x78, 0x7C, 0x07, 0x83, 0xC0, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xC0, 0x7C, 0x1E, 0x01, 0xF1,
  0xF0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xC0, 0x1F, 0x3E, 0x01,
  0xF1, 0xE0, 0x1F, 0x8F, 0x8F, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF,
  0xF0, 0x7F, 0x0F, 0x03, 0xE0, 0x08, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x20, 0x7F, 0x0F, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xDF, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x7C, 0x1E,
  0x03, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E,
  0x3E, 0x00, 0xF1, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xE7, 0xC0,
  0x1F, 0x3E, 0x00, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x7C, 0x78, 0x07, 0xC7,
  0xC0, 0x7C, 0x3C, 0x07, 0xE1, 0xE0, 0x7E, 0x0F, 0xBF, 0xE0, 0xFF, 0xFE,
  0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0x07, 0x07, 0xE0, 0x10, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x3E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x7C, 0x07,
  0xC3, 0xE0, 0x3E, 0x1F, 0x81, 0xE0, 0x7F, 0x1F, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x03,
  0xC0, 0x1E, 0x03, 0xC0, 0x1E, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x3E, 0x07,
  0x80, 0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x7C, 0x0F,
  0x00, 0x78, 0x0F, 0x00, 0x78, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3E, 0x00, 0xF0, 0x3E, 0x01, 0xF0, 0x3C,
  0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0x78,
  0x03, 0xE0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0xF8, 0x07, 0xC0, 0xF0,
  0x07, 0xC0, 0xF0, 0x07, 0x80, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x06, 0x01, 0xF0, 0x1E,
  0x1F, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x03, 0xC0,
  0xF8, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0x87, 0xC0, 0x07, 0x8F,
  0x80, 0x0F, 0x9F, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0x7C,
  0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1F,
  0x00, 0x3C, 0x0F, 0x00, 0x7C, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0xC0, 0x78, 0x03, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x3E, 0x03, 0xB0, 0x7E, 0x03, 0xB8,
  0x7E, 0x03, 0xB8, 0xEE, 0x07, 0xB9, 0xCE, 0x07, 0x39, 0xDE, 0x07, 0x3B,
  0x9E, 0x0F, 0x3B, 0x9C, 0x0F, 0x3F, 0x1C, 0x0E, 0x3F, 0x3C, 0x1E, 0x3E,
  0x3C, 0x1E, 0x3E, 0x3C, 0x1E, 0x3C, 0x38, 0x1C, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x1E, 0x03, 0xE0,
  0x1E, 0x07, 0xF0, 0x1E, 0x07, 0xF0, 0x1C, 0x07, 0xF0, 0x3C, 0x07, 0x78,
  0x3C, 0x0F, 0x78, 0x3C, 0x0F, 0x38, 0x38, 0x0F, 0x38, 0x78, 0x0E, 0x3C,
  0x78, 0x1E, 0x3C, 0x78, 0x1E, 0x1C, 0x78, 0x1E, 0x1C, 0xF0, 0x1C, 0x1C,
  0xF0, 0x3C, 0x1E, 0xF0, 0x3C, 0x0E, 0xF0, 0x3C, 0x0F, 0xE0, 0x3C, 0x0F,
  0xE0, 0x78, 0x0F, 0xE0, 0x78, 0x0F, 0xE0, 0x78, 0x07, 0xC0, 0x78, 0x07,
  0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xC3, 0xE0, 0xF8,
  0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x0F, 0x7C,
  0x00, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00, 0x7C,
  0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x81, 0xF0, 0xFC, 0x7E,
  0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xF8, 0xFF, 0x03, 0xC0,
  0x7C, 0x0F, 0x00, 0xF0, 0x7C, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C,
  0x1E, 0x00, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x3E, 0x0F, 0x01, 0xF8, 0x3C,
  0x7F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE,
  0x07, 0xC3, 0xE0, 0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x0F, 0x3E, 0x00,
  0xF3, 0xC0, 0x0F, 0x7C, 0x00, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0,
  0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x0F,
  0x81, 0xF0, 0xFC, 0x7E, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0xFF, 0xFC, 0x07, 0x87, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x3C, 0x1E, 0x01,
  0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xC0, 0x3E, 0x1E,
  0x03, 0xE0, 0xF0, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0xC0, 0x78, 0x1E, 0x03, 0xC0,
  0xF8, 0x3E, 0x03, 0xC1, 0xF0, 0x1E, 0x0F, 0x00, 0xF8, 0x78, 0x03, 0xC7,
  0xC0, 0x1E, 0x3E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xF0, 0x38, 0x0F, 0x00, 0x20, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x08, 0x01, 0xF0, 0x7C,
  0x1F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x01, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xE0,
  0xF0, 0x07, 0x87, 0xC0, 0x3E, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0,
  0x0F, 0x0F, 0x80, 0x7C, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x1E,
  0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x3E,
  0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x03,
  0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3C, 0x0F, 0x81, 0xF0, 0x3F, 0x1F, 0x80,
  0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xBE, 0x00, 0x3D, 0xF0, 0x03, 0xEF, 0x80, 0x1E,
  0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0x78, 0x07, 0x83, 0xC0,
  0x7C, 0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x3C, 0x1E, 0x01,
  0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0x3C,
  0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x1C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1C, 0x00,
  0x38, 0x3C, 0x00, 0x78, 0x3C, 0x78, 0x78, 0x3C, 0x78, 0x70, 0x38, 0xF8,
  0x70, 0x38, 0xF8, 0xF0, 0x79, 0xD8, 0xF0, 0x79, 0xDC, 0xE0, 0x7B, 0x9C,
  0xE0, 0x73, 0x9D, 0xE0, 0x77, 0x1D, 0xC0, 0x77, 0x1D, 0xC0, 0xFE, 0x1F,
  0xC0, 0xEE, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x1F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0xF8, 0x3E, 0x00,
  0x1E, 0x1F, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0x3D, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0xC3, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x07,
  0x80, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x00, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF8, 0x07, 0xC7,
  0x80, 0xF8, 0x78, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x03, 0xC3, 0xC0,
  0x3C, 0x78, 0x03, 0xCF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x02, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7C,
  0xF9, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xE7, 0xCF,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x9F, 0x3E, 0x7C, 0x78,
  0xF1, 0xE3, 0xC0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xF7, 0xC0, 0x7C, 0xF0, 0x3E,
  0x3C, 0x1F, 0x0F, 0x8F, 0x81, 0xE3, 0xC0, 0x79, 0xF0, 0x1F, 0xF8, 0x03,
  0xFC, 0x00, 0xF2, 0x00, 0x30, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x30, 0x1C, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1C, 0x04,
  0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xC1,
  0xE1, 0xF0, 0x1E, 0x3E, 0x03, 0xE3, 0xC0, 0x3E, 0x7C, 0x03, 0xC7, 0x80,
  0x3C, 0x78, 0x07, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x80, 0x78, 0xF8,
  0x07, 0x8F, 0x80, 0xF8, 0x78, 0x0F, 0x87, 0xC3, 0xF8, 0x7F, 0xFF, 0x83,
  0xFF, 0xF8, 0x1F, 0xE7, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF3, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x3F, 0x07, 0xC7, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C,
  0xF8, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0xDF, 0x00, 0xF3,
  0xC0, 0x3E, 0x78, 0x0F, 0x8F, 0x03, 0xF3, 0xE1, 0xFC, 0x7F, 0xFF, 0x0F,
  0xFF, 0x81, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFC,
  0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xF8, 0x04, 0x7E, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0xC3, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0xFF,
  0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7E, 0x0F, 0x03,
  0xF0, 0x3C, 0x0F, 0x00, 0xF0, 0x7C, 0x07, 0xC1, 0xE0, 0x1F, 0x0F, 0x80,
  0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3E, 0x0F, 0x00, 0xF0,
  0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0xC7, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF0, 0x3E, 0x7C, 0x07, 0xDF, 0x00,
  0xFB, 0xC0, 0x1E, 0xF8, 0x07, 0xDE, 0x03, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF,
  0x0F, 0xFF, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0xC1, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xEE, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x3F, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x1E, 0x07, 0xC0,
  0x3C, 0x0F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xC0, 0xF0, 0x07,
  0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x3E, 0x07, 0x80, 0x78, 0x0F, 0x81, 0xF0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0x9E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x20, 0x07, 0xC0, 0x7C,
  0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7D, 0xF0,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xF8, 0x3E, 0x0F, 0x01,
  0xE0, 0xF0, 0x1F, 0x0F, 0x01, 0xE1, 0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0,
  0x1E, 0x1E, 0x03, 0xE3, 0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3C,
  0x07, 0xC7, 0xC0, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x0F, 0x8F,
  0x80, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0xFF,
  0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xFD, 0xC3, 0xFF, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x40, 0x3C, 0x03, 0xCF, 0xE0,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x10, 0x78, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x87, 0xE0, 0x3C, 0x3F, 0x00,
  0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xF3, 0xE0, 0x03, 0xC7, 0xC0,
  0x1F, 0x0F, 0x00, 0x7C, 0x3E, 0x01, 0xE0, 0x7C, 0x07, 0x81, 0xF0, 0x1E,
  0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xC0, 0x1F, 0x00, 0xFF, 0xEF, 0xFC, 0xFF,
  0xCF, 0xFC, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C,
  0x77, 0xFF, 0x7F, 0xF3, 0xFE, 0x01, 0xE0, 0xE0, 0x7F, 0xDF, 0x83, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1C, 0x38, 0x79, 0xE3, 0xC3, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0x87, 0x0F, 0x3C, 0x00, 0x71, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x70,
  0x01, 0xE7, 0x80, 0x0E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8E, 0x00, 0x3C,
  0x00, 0x00, 0x7E, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF0,
  0x7E, 0x3E, 0x07, 0xC7, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xC0,
  0x7C, 0xF8, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x9F, 0x01,
  0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xF3, 0xE0, 0x3C, 0x78, 0x07,
  0x8F, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xFF,
  0x1F, 0x07, 0xCF, 0x80, 0xF7, 0xC0, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00,
  0xFB, 0xC0, 0x3C, 0xF8, 0x1F, 0x3F, 0x1F, 0x87, 0xFF, 0xC1, 0xFF, 0xE0,
  0x1F, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x3C, 0x1E, 0x01, 0xE0,
  0xF0, 0x0F, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00,
  0xF0, 0xF0, 0x0F, 0x8F, 0x80, 0x78, 0x78, 0x07, 0xC3, 0xC0, 0x7C, 0x1E,
  0x07, 0xE1, 0xF3, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFC,
  0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xF8, 0x3E, 0x7E, 0x07, 0x8F, 0x80, 0xF3,
  0xE0, 0x1E, 0x78, 0x07, 0xDF, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0xF9, 0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF8, 0x1F, 0x1F,
  0x8F, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0,
  0xF8, 0x04, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0x78, 0x04, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x20, 0x0F, 0x8F, 0x07, 0xE1, 0xFF,
  0xFC, 0x7F, 0xFF, 0x03, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x00, 0x20, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7E, 0x38,
  0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x1E, 0x01, 0xE7, 0xC0, 0x7C,
  0xF8, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x9F, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xF3, 0xE0, 0x3C, 0x7C, 0x07, 0x8F,
  0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0xC7, 0xC1, 0xF8, 0xFC, 0x7F, 0x0F,
  0xFF, 0xE1, 0xFF, 0xBC, 0x1F, 0xE7, 0x80, 0xF0, 0x07, 0xFC, 0x01, 0xEF,
  0x00, 0xFB, 0xC0, 0x3E, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x81, 0xE3, 0xE0,
  0xF8, 0xF8, 0x3C, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xC0, 0x79, 0xF0,
  0x1E, 0x78, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0x80, 0x07,
  0x9C, 0x00, 0x1C, 0x70, 0x70, 0xF3, 0xC3, 0xC3, 0xCF, 0x0F, 0x0E, 0x3C,
  0x7C, 0x78, 0xF1, 0xF1, 0xE3, 0xCF, 0xC7, 0x0E, 0x3F, 0x3C, 0x39, 0xDC,
  0xE0, 0xEF, 0x73, 0x83, 0xB8, 0xFE, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xC0,
  0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x03, 0xC0, 0x38, 0x0F, 0x00, 0x07,
  0xC0, 0x3E, 0x07, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x0F, 0x80, 0x1F,
  0x1E, 0x00, 0x1E, 0x78, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x7D, 0xF0, 0x01, 0xF1, 0xE0, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0xC0,
  0x7C, 0x07, 0x81, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x0F,
  0x80, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01,
  0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0,
  0x7C, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1E, 0x00, 0x07,
  0x9F, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xCF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x1F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x80,
  0x61, 0xFE, 0x0F, 0x3F, 0xF0, 0xF7, 0xFF, 0xFE, 0x78, 0xFF, 0xCF, 0x03,
  0xF8, 0x20, 0x1F, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 11, 28, 22, 6, -27 },
  { 40, 13, 12, 22, 8, -30 },
  { 60, 23, 27, 22, 0, -27 },
  { 138, 21, 34, 22, 1, -30 },
  { 228, 26, 29, 22, -1, -28 },
  { 323, 19, 28, 22, 1, -28 },
  { 390, 7, 13, 22, 11, -30 },
  { 402, 16, 38, 22, 5, -31 },
  { 478, 16, 38, 22, 1, -31 },
  { 554, 17, 16, 22, 4, -27 },
  { 588, 19, 19, 22, 2, -21 },
  { 634, 10, 13, 22, 3, -7 },
  { 651, 12, 4, 22, 5, -13 },
  { 657, 7, 8, 22, 6, -7 },
  { 664, 25, 38, 22, -2, -31 },
  { 783, 19, 29, 22, 2, -28 },
  { 852, 16, 27, 22, 2, -27 },
  { 906, 20, 28, 22, 1, -28 },
  { 976, 21, 29, 22, 0, -28 },
  { 1053, 21, 27, 22, 0, -27 },
  { 1124, 23, 28, 22, 0, -27 },
  { 1205, 21, 28, 22, 2, -27 },
  { 1279, 20, 27, 22, 4, -27 },
  { 1347, 21, 29, 22, 1, -28 },
  { 1424, 21, 28, 22, 1, -28 },
  { 1498, 10, 22, 22, 6, -21 },
  { 1526, 13, 27, 22, 3, -21 },
  { 1570, 19, 18, 22, 2, -20 },
  { 1613, 21, 12, 22, 1, -17 },
  { 1645, 19, 18, 22, 1, -20 },
  { 1688, 16, 29, 22, 5, -28 },
  { 1746, 22, 34, 22, 1, -28 },
  { 1840, 21, 27, 22, -2, -27 },
  { 1911, 21, 27, 22, 0, -27 },
  { 1982, 21, 29, 22, 2, -28 },
  { 2059, 21, 27, 22, 0, -27 },
  { 2130, 22, 27, 22, 1, -27 },
  { 2205, 23, 27, 22, 1, -27 },
  { 2283, 21, 29, 22, 2, -28 },
  { 2360, 24, 27, 22, 0, -27 },
  { 2441, 22, 27, 22, 1, -27 },
  { 2516, 22, 28, 22, 1, -27 },
  { 2593, 24, 27, 22, 0, -27 },
  { 2674, 16, 27, 22, 1, -27 },
  { 2728, 24, 27, 22, -1, -27 },
  { 2809, 24, 27, 22, 0, -27 },
  { 2890, 20, 29, 22, 2, -28 },
  { 2963, 22, 27, 22, 0, -27 },
  { 3038, 20, 35, 22, 2, -28 },
  { 3126, 21, 27, 22, 0, -27 },
  { 3197, 22, 29, 22, 0, -28 },
  { 3277, 19, 27, 22, 5, -27 },
  { 3342, 22, 28, 22, 2, -27 },
  { 3419, 21, 27, 22, 4, -27 },
  { 3490, 24, 27, 22, 1, -27 },
  { 3571, 26, 27, 22, -1, -27 },
  { 3659, 20, 27, 22, 5, -27 },
  { 3727, 23, 27, 22, 0, -27 },
  { 3805, 21, 38, 22, 2, -31 },
  { 3905, 7, 38, 22, 8, -31 },
  { 3939, 21, 38, 22, -1, -31 },
  { 4039, 18, 15, 22, 3, -27 },
  { 4073, 20, 4, 22, -3, 3 },
  { 4083, 9, 8, 22, 9, -30 },
  { 4092, 20, 21, 22, 1, -21 },
  { 4145, 19, 31, 22, 1, -30 },
  { 4219, 19, 21, 22, 2, -21 },
  { 4269, 22, 30, 22, 2, -30 },
  { 4352, 19, 22, 22, 2, -21 },
  { 4405, 26, 37, 22, -2, -30 },
  { 4526, 23, 28, 22, -1, -21 },
  { 4607, 20, 30, 22, 0, -30 },
  { 4682, 14, 30, 22, 4, -30 },
  { 4735, 21, 37, 22, -1, -30 },
  { 4833, 22, 30, 22, 1, -30 },
  { 4916, 12, 30, 22, 6, -30 },
  { 4961, 21, 21, 22, 0, -21 },
  { 5017, 19, 21, 22, 1, -21 },
  { 5067, 18, 22, 22, 2, -21 },
  { 5117, 21, 28, 22, -1, -21 },
  { 5191, 19, 28, 22, 2, -21 },
  { 5258, 19, 21, 22, 2, -21 },
  { 5308, 19, 22, 22, 1, -21 },
  { 5361, 17, 27, 22, 4, -27 },
  { 5419, 19, 20, 22, 2, -20 },
  { 5467, 18, 20, 22, 4, -20 },
  { 5512, 22, 20, 22, 2, -20 },
  { 5567, 23, 20, 22, -1, -20 },
  { 5625, 25, 27, 22, -3, -20 },
  { 5710, 20, 20, 22, 1, -20 },
  { 5760, 21, 38, 22, 2, -31 },
  { 5860, 13, 38, 22, 5, -31 },
  { 5922, 21, 38, 22, -2, -31 },
  { 6022, 20, 7, 22, 1, -15 },
};

const GFXfont UbuntuSansMono_MediumItalic39pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic39pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic39pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC39PT7B_H_
