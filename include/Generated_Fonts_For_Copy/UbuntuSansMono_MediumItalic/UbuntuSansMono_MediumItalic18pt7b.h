#ifndef _UBUNTUSANSMONO_MEDIUMITALIC18PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x67, 0x31, 0x8C, 0x06, 0x39, 0x80, 0x66, 0xCD, 0xB2,
  0x64, 0xD9, 0x00, 0x06, 0x61, 0x98, 0x32, 0x3F, 0xF1, 0x98, 0x26, 0x0C,
  0xC7, 0xFE, 0xFF, 0x8C, 0x81, 0x30, 0x66, 0x00, 0x03, 0x00, 0xC0, 0xF8,
  0x7F, 0x18, 0x0C, 0x01, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x19, 0x0C, 0xFF,
  0x0F, 0x01, 0x80, 0x60, 0x0C, 0x01, 0xE3, 0x16, 0x63, 0x6C, 0x34, 0x83,
  0xD0, 0x12, 0x00, 0x7C, 0x0D, 0x61, 0xB6, 0x32, 0x42, 0x24, 0xC3, 0x80,
  0x07, 0x07, 0xC6, 0x62, 0x31, 0x30, 0xF0, 0x72, 0x7B, 0x67, 0xE3, 0xB0,
  0xDD, 0xE7, 0x98, 0x6D, 0xED, 0x80, 0x03, 0x07, 0x0C, 0x18, 0x30, 0x30,
  0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x70, 0x30, 0x04,
  0x0E, 0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x0C,
  0x1C, 0x38, 0x70, 0xC0, 0x18, 0x99, 0xF7, 0x7E, 0x3C, 0x6E, 0x24, 0x0C,
  0x0C, 0x0C, 0x08, 0xFF, 0xFF, 0x18, 0x10, 0x30, 0x39, 0xCE, 0x27, 0x60,
  0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x0E, 0x0F, 0x8C, 0x6C, 0x36, 0x1E,
  0x4F, 0x77, 0xB6, 0xC3, 0x61, 0xB1, 0x9D, 0xC7, 0x80, 0x07, 0x1E, 0x3E,
  0x26, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0xFE, 0xFE, 0x07, 0x07, 0xE1,
  0x0C, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x01, 0xFC,
  0xFF, 0x00, 0x07, 0x07, 0xE1, 0x1C, 0x03, 0x01, 0x80, 0xE0, 0xE0, 0x0C,
  0x01, 0x80, 0x60, 0x39, 0x9C, 0xFE, 0x00, 0x01, 0xC0, 0xE0, 0x78, 0x36,
  0x19, 0x8C, 0xC6, 0x33, 0xFE, 0xFF, 0x81, 0x80, 0x60, 0x18, 0x0F, 0xC2,
  0x01, 0x80, 0x60, 0x1C, 0x0F, 0xC0, 0x38, 0x06, 0x01, 0x80, 0xC6, 0xF3,
  0xF8, 0x00, 0x87, 0xC7, 0x06, 0x06, 0x03, 0x73, 0xFD, 0x86, 0xC3, 0x61,
  0xB0, 0xDC, 0xC7, 0xC0, 0x7F, 0x81, 0x81, 0x81, 0xC0, 0xC0, 0xC0, 0xC0,
  0x60, 0x60, 0x30, 0x30, 0x18, 0x00, 0x0E, 0x0F, 0xCC, 0x64, 0x36, 0x19,
  0x98, 0xF8, 0xCC, 0xC3, 0x61, 0xB0, 0xDD, 0xC7, 0xC0, 0x0E, 0x1F, 0x9C,
  0x6C, 0x36, 0x1B, 0x0D, 0xCE, 0x7E, 0x03, 0x03, 0x03, 0x9F, 0x0F, 0x00,
  0x37, 0x70, 0x00, 0xEE, 0xE0, 0x0C, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x38,
  0x47, 0x30, 0x01, 0x87, 0xDF, 0x1C, 0x0E, 0x01, 0xE0, 0x3C, 0x04, 0x3F,
  0xDF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x30, 0x1E, 0x03, 0xC0, 0x70, 0x79,
  0xF3, 0xC1, 0x80, 0x1C, 0x3F, 0x43, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x20,
  0x00, 0x60, 0xE0, 0x60, 0x07, 0x07, 0xE3, 0x09, 0x83, 0x47, 0xB3, 0xED,
  0x9A, 0x66, 0x91, 0x24, 0xC9, 0xB2, 0x7C, 0xC0, 0x30, 0x07, 0xC0, 0x70,
  0x03, 0x80, 0xE0, 0x68, 0x32, 0x0C, 0x86, 0x31, 0x8C, 0xFF, 0x3F, 0xD8,
  0x36, 0x0F, 0x03, 0x0F, 0x07, 0xE1, 0x8C, 0xC3, 0x30, 0xCC, 0xE3, 0xF1,
  0x8E, 0x61, 0x98, 0x66, 0x1B, 0xFC, 0xFE, 0x00, 0x07, 0x07, 0xF3, 0x89,
  0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0xF8, 0x7E,
  0x00, 0x0E, 0x07, 0xE3, 0x18, 0xC3, 0x30, 0xCC, 0x36, 0x0D, 0x87, 0x61,
  0x98, 0x6C, 0x33, 0xF8, 0xFC, 0x00, 0x3F, 0xCC, 0x03, 0x00, 0xC0, 0x60,
  0x1F, 0xC6, 0x01, 0x80, 0xC0, 0x30, 0x0F, 0xF3, 0xF8, 0x3F, 0xCC, 0x03,
  0x00, 0xC0, 0x60, 0x1F, 0xC6, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x07, 0x07, 0xF3, 0x89, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x0C, 0xC3, 0x30,
  0xCC, 0x33, 0xD8, 0x7E, 0x00, 0x18, 0x66, 0x18, 0xC3, 0x18, 0x63, 0x0C,
  0xFF, 0x98, 0x63, 0x0C, 0x61, 0x98, 0x33, 0x0C, 0x61, 0x80, 0x1F, 0xC1,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x07, 0xF3,
  0xFC, 0x0F, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x00, 0xCE, 0xE1, 0xF8, 0x18, 0xE3, 0x30, 0xCE, 0x1B, 0x83, 0xE0, 0x70,
  0x1B, 0x03, 0x30, 0x66, 0x0C, 0x63, 0x0C, 0x61, 0xC0, 0x18, 0x18, 0x18,
  0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x7F, 0xFF, 0x18, 0xE3, 0x18,
  0xE7, 0x1C, 0xA2, 0xAC, 0xDD, 0x9B, 0x33, 0x04, 0xC1, 0x98, 0x33, 0x06,
  0x40, 0xC0, 0x18, 0x67, 0x08, 0xF3, 0x1E, 0x63, 0x4C, 0x49, 0x99, 0xA3,
  0x3C, 0x63, 0x88, 0x73, 0x0C, 0x61, 0x80, 0x0E, 0x0F, 0x8C, 0x6C, 0x36,
  0x1E, 0x0F, 0x07, 0x83, 0xC3, 0x61, 0xB1, 0x9D, 0xC7, 0xC0, 0x0F, 0x07,
  0xF1, 0x8C, 0xC3, 0x30, 0xCC, 0x33, 0x18, 0xFC, 0x78, 0x18, 0x06, 0x01,
  0x80, 0xC0, 0x00, 0x0E, 0x0F, 0x8C, 0x6C, 0x36, 0x1E, 0x0F, 0x07, 0x83,
  0xC3, 0x61, 0xB1, 0x9D, 0xC7, 0xC1, 0x80, 0xE0, 0x3C, 0x0E, 0x07, 0xE1,
  0x9C, 0xC3, 0x30, 0xCC, 0x63, 0x79, 0xFC, 0x66, 0x19, 0x86, 0x33, 0x0C,
  0xC3, 0x80, 0x07, 0x87, 0xF1, 0x84, 0xC0, 0x30, 0x07, 0x01, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x39, 0x9C, 0xFE, 0x00, 0xFF, 0x8C, 0x06, 0x03, 0x01,
  0x81, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x00, 0x30, 0xD8, 0x66,
  0x19, 0x86, 0x61, 0xB0, 0xCC, 0x33, 0x0C, 0xC3, 0x31, 0x8E, 0xE1, 0xF0,
  0xC1, 0xF0, 0x6C, 0x33, 0x0C, 0xC6, 0x31, 0x8C, 0xC3, 0x30, 0xD8, 0x36,
  0x07, 0x01, 0x80, 0x30, 0x66, 0x0C, 0xC1, 0x90, 0x26, 0x6C, 0xDD, 0x9B,
  0xA2, 0xF4, 0x53, 0x8C, 0x63, 0x8C, 0x61, 0x80, 0x0C, 0x38, 0x63, 0x01,
  0xB0, 0x0F, 0x00, 0x78, 0x01, 0x80, 0x1C, 0x01, 0xB0, 0x19, 0x81, 0xCC,
  0x0C, 0x61, 0xC1, 0x80, 0xC1, 0xD0, 0xC6, 0x31, 0x98, 0x6C, 0x0B, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x1F, 0xE0, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFC, 0x7F, 0x80,
  0x0F, 0xC3, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C,
  0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xFC, 0x00, 0xDB, 0x6D,
  0xB6, 0xDB, 0x36, 0xDB, 0x60, 0x0F, 0x88, 0xC0, 0x40, 0x60, 0x30, 0x18,
  0x08, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0xF8,
  0x00, 0x0E, 0x0F, 0x06, 0xC6, 0x66, 0x36, 0x0C, 0x04, 0xFF, 0x80, 0x4E,
  0x31, 0x06, 0x1F, 0xDC, 0xDC, 0x6C, 0x36, 0x1B, 0x19, 0x8C, 0xEE, 0x3D,
  0x80, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0xE1, 0xFC, 0xC6, 0x63, 0x31, 0xB0,
  0xD8, 0x6C, 0x67, 0xF7, 0xE0, 0x07, 0x1F, 0xDC, 0x1C, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xFE, 0x3F, 0x00, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x07, 0x8F,
  0xE7, 0x31, 0x8C, 0xC3, 0x30, 0xCC, 0x63, 0x18, 0xEE, 0x1E, 0xC0, 0x0E,
  0x1F, 0x98, 0xF8, 0x2C, 0x77, 0xF3, 0x01, 0x80, 0xF6, 0x3F, 0x00, 0x00,
  0xF0, 0x1F, 0x03, 0x00, 0x30, 0x03, 0x01, 0xFE, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x0B, 0x80, 0xF0,
  0x00, 0x03, 0x87, 0xF3, 0x8C, 0xC6, 0x61, 0x98, 0x66, 0x19, 0x8C, 0x7F,
  0x04, 0xC0, 0x72, 0x38, 0xFC, 0x00, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x61,
  0xFC, 0xC6, 0x63, 0x61, 0xB0, 0xD8, 0xCC, 0x6C, 0x36, 0x18, 0x18, 0x71,
  0x80, 0x03, 0xE3, 0x0C, 0x30, 0xC6, 0x18, 0x7C, 0xF0, 0x00, 0xC0, 0x30,
  0x0C, 0x00, 0x00, 0x03, 0xF0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x61, 0x38, 0xFC, 0x00, 0x0C, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x0C, 0x73, 0x30, 0xD8, 0x3C, 0x0F, 0x06, 0x61, 0x98, 0x63, 0x38,
  0xE0, 0xFF, 0x8C, 0x63, 0x31, 0x8C, 0x66, 0x31, 0x8F, 0xBC, 0x09, 0x8F,
  0xF2, 0x4D, 0x93, 0x6C, 0x9B, 0x64, 0x1B, 0x06, 0xC1, 0x30, 0xC0, 0x06,
  0x1F, 0xCC, 0x66, 0x33, 0x1B, 0x0D, 0x86, 0xC6, 0x63, 0x61, 0x80, 0x0C,
  0x3F, 0x73, 0xE3, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0x7C, 0x07, 0x07, 0xF1,
  0x8C, 0x63, 0x18, 0xCC, 0x33, 0x0C, 0xC6, 0x3F, 0x9F, 0x86, 0x01, 0x80,
  0xE0, 0x00, 0x06, 0x1F, 0xDC, 0xEC, 0x6C, 0x36, 0x1B, 0x0D, 0x8C, 0xEE,
  0x3F, 0x01, 0x81, 0x80, 0xC0, 0x07, 0x1F, 0xCC, 0x2C, 0x06, 0x03, 0x01,
  0x81, 0x80, 0xC0, 0x60, 0x00, 0x0E, 0x3F, 0x31, 0x60, 0x38, 0x1E, 0x06,
  0x06, 0xCE, 0xFC, 0x18, 0x30, 0x30, 0xFF, 0x30, 0x60, 0x60, 0x60, 0x60,
  0x60, 0x7C, 0x7C, 0x61, 0xB1, 0x98, 0xD8, 0x6C, 0x36, 0x33, 0x19, 0xFC,
  0x7E, 0x00, 0xC3, 0xC6, 0xC6, 0xCC, 0xCC, 0xD8, 0xD8, 0x70, 0x60, 0xC0,
  0xF0, 0x2C, 0x9B, 0x76, 0xDD, 0x2B, 0xCE, 0xE3, 0x38, 0xC4, 0x00, 0x31,
  0xC6, 0x61, 0xB0, 0x38, 0x0C, 0x07, 0x83, 0x61, 0x8C, 0xC3, 0x00, 0x18,
  0x63, 0x18, 0x63, 0x0C, 0x61, 0x98, 0x1B, 0x03, 0xC0, 0x78, 0x0E, 0x01,
  0x82, 0x60, 0x78, 0x00, 0x1F, 0xC8, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03,
  0x01, 0xFC, 0xFF, 0x00, 0x07, 0xC1, 0x80, 0xC0, 0x30, 0x08, 0x06, 0x01,
  0x80, 0xE0, 0xE0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x80,
  0x3C, 0x00, 0x0C, 0x30, 0xC6, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x18, 0x61,
  0x86, 0x10, 0xC0, 0x0F, 0x00, 0xE0, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30,
  0x0C, 0x01, 0xC0, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x70, 0xF8,
  0x00, 0x71, 0xFF, 0xA3, 0xC0,
};

const GFXglyph UbuntuSansMono_MediumItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 12, 10, 3, -12 },
  { 9, 7, 6, 10, 3, -14 },
  { 15, 11, 12, 10, 0, -12 },
  { 32, 10, 16, 10, 0, -14 },
  { 52, 12, 13, 10, -1, -13 },
  { 72, 9, 13, 10, 0, -13 },
  { 87, 3, 6, 10, 5, -14 },
  { 90, 8, 17, 10, 2, -14 },
  { 107, 8, 17, 10, 0, -14 },
  { 124, 8, 7, 10, 2, -12 },
  { 131, 8, 9, 10, 1, -10 },
  { 140, 5, 6, 10, 1, -3 },
  { 144, 6, 2, 10, 2, -6 },
  { 146, 3, 3, 10, 3, -3 },
  { 148, 12, 17, 10, -1, -14 },
  { 174, 9, 13, 10, 1, -13 },
  { 189, 8, 12, 10, 1, -12 },
  { 201, 10, 13, 10, 0, -13 },
  { 218, 10, 13, 10, 0, -13 },
  { 235, 10, 12, 10, 0, -12 },
  { 250, 10, 12, 10, 0, -12 },
  { 265, 9, 13, 10, 1, -13 },
  { 280, 9, 12, 10, 2, -12 },
  { 294, 9, 13, 10, 1, -13 },
  { 309, 9, 13, 10, 1, -13 },
  { 324, 4, 9, 10, 3, -9 },
  { 329, 6, 12, 10, 1, -9 },
  { 338, 9, 8, 10, 1, -9 },
  { 347, 10, 5, 10, 0, -8 },
  { 354, 9, 8, 10, 0, -9 },
  { 363, 8, 13, 10, 2, -13 },
  { 376, 10, 16, 10, 1, -13 },
  { 396, 10, 12, 10, -1, -12 },
  { 411, 10, 13, 10, 0, -13 },
  { 428, 10, 13, 10, 1, -13 },
  { 445, 10, 13, 10, 0, -13 },
  { 462, 10, 12, 10, 1, -12 },
  { 477, 10, 12, 10, 1, -12 },
  { 492, 10, 13, 10, 1, -13 },
  { 509, 11, 12, 10, 0, -12 },
  { 526, 10, 12, 10, 0, -12 },
  { 541, 10, 12, 10, 0, -12 },
  { 556, 11, 12, 10, 0, -12 },
  { 573, 8, 12, 10, 0, -12 },
  { 585, 11, 12, 10, 0, -12 },
  { 602, 11, 12, 10, 0, -12 },
  { 619, 9, 13, 10, 1, -13 },
  { 634, 10, 13, 10, 0, -13 },
  { 651, 9, 16, 10, 1, -13 },
  { 669, 10, 13, 10, 0, -13 },
  { 686, 10, 13, 10, 0, -13 },
  { 703, 9, 12, 10, 2, -12 },
  { 717, 10, 12, 10, 1, -12 },
  { 732, 10, 12, 10, 2, -12 },
  { 747, 11, 12, 10, 0, -12 },
  { 764, 13, 12, 10, -1, -12 },
  { 784, 10, 12, 10, 2, -12 },
  { 799, 11, 12, 10, 0, -12 },
  { 816, 10, 17, 10, 1, -14 },
  { 838, 3, 17, 10, 4, -14 },
  { 845, 9, 17, 10, 0, -14 },
  { 865, 9, 7, 10, 1, -12 },
  { 873, 9, 1, 10, -1, 2 },
  { 875, 4, 4, 10, 4, -14 },
  { 877, 9, 10, 10, 1, -10 },
  { 889, 9, 14, 10, 0, -14 },
  { 905, 9, 10, 10, 1, -10 },
  { 917, 10, 14, 10, 1, -14 },
  { 935, 9, 10, 10, 1, -10 },
  { 947, 12, 17, 10, -1, -14 },
  { 973, 10, 13, 10, 0, -10 },
  { 990, 9, 14, 10, 0, -14 },
  { 1006, 6, 14, 10, 2, -14 },
  { 1017, 10, 17, 10, -1, -14 },
  { 1039, 10, 14, 10, 0, -14 },
  { 1057, 5, 14, 10, 3, -14 },
  { 1066, 10, 10, 10, 0, -10 },
  { 1079, 9, 10, 10, 0, -10 },
  { 1091, 8, 10, 10, 1, -10 },
  { 1101, 10, 13, 10, -1, -10 },
  { 1118, 9, 13, 10, 1, -10 },
  { 1133, 9, 10, 10, 1, -10 },
  { 1145, 8, 10, 10, 1, -10 },
  { 1155, 8, 12, 10, 2, -12 },
  { 1167, 9, 9, 10, 1, -9 },
  { 1178, 8, 9, 10, 2, -9 },
  { 1187, 10, 9, 10, 1, -9 },
  { 1199, 10, 9, 10, 0, -9 },
  { 1211, 11, 12, 10, -1, -9 },
  { 1228, 10, 9, 10, 0, -9 },
  { 1240, 10, 17, 10, 1, -14 },
  { 1262, 6, 17, 10, 2, -14 },
  { 1275, 10, 17, 10, -1, -14 },
  { 1297, 9, 3, 10, 1, -7 },
};

const GFXfont UbuntuSansMono_MediumItalic18pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic18pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic18pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC18PT7B_H_
