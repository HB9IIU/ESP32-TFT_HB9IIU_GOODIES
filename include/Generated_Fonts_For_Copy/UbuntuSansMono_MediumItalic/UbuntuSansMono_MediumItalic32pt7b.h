#ifndef _UBUNTUSANSMONO_MEDIUMITALIC32PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x07, 0x83, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x3E, 0x1F, 0x0F,
  0x87, 0x80, 0x78, 0xF7, 0x8E, 0x71, 0xE7, 0x1E, 0x71, 0xCE, 0x1C, 0xE1,
  0xCE, 0x18, 0xC1, 0x80, 0x00, 0x70, 0xE0, 0x0E, 0x38, 0x03, 0x87, 0x00,
  0x71, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x0F, 0xFF, 0xF9, 0xFF, 0xFE, 0x03,
  0x8E, 0x00, 0xE1, 0xC0, 0x1C, 0x78, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xF8, 0x38, 0x70, 0x07, 0x1E, 0x01, 0xE3,
  0x80, 0x38, 0x70, 0x07, 0x1C, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x1F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFC,
  0x1E, 0x02, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x03, 0x84, 0x03, 0xC3, 0xEF, 0xE3, 0xFF, 0xE0, 0xFF, 0xC0,
  0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x3F, 0x01, 0xC1, 0xF8, 0x1C, 0x1C, 0xC1, 0xC0, 0xC6, 0x1C, 0x0E, 0x30,
  0xC0, 0x71, 0x8E, 0x03, 0x9C, 0xE0, 0x1C, 0xCE, 0x00, 0xFE, 0xE0, 0x03,
  0xEE, 0x00, 0x00, 0x60, 0x00, 0x07, 0x30, 0x00, 0x77, 0xC0, 0x07, 0x7F,
  0x00, 0x73, 0x18, 0x07, 0x38, 0xC0, 0x71, 0xC6, 0x03, 0x0C, 0x70, 0x38,
  0x63, 0x83, 0x83, 0x18, 0x38, 0x1F, 0xC3, 0x80, 0x7C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0x1C, 0x0E, 0x1E, 0x0E, 0x1C,
  0x0E, 0x1C, 0x0E, 0x3C, 0x0E, 0x78, 0x0E, 0xF0, 0x07, 0xE0, 0x0F, 0x87,
  0x1F, 0x8E, 0x3B, 0xCE, 0x71, 0xEE, 0xE0, 0xFC, 0xE0, 0xFC, 0xE0, 0x78,
  0xE0, 0x78, 0xE0, 0xF8, 0xFF, 0xFC, 0xFF, 0xDC, 0x7F, 0x1C, 0x7B, 0xDE,
  0xE7, 0x3B, 0x9C, 0xE6, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x80, 0x00,
  0x00, 0x40, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x01, 0xC0, 0x02, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x03, 0x1C, 0x67, 0xBB, 0xCF, 0xFF, 0xBF, 0xFF, 0x81, 0xC0, 0x0E, 0xC0,
  0x3D, 0xE0, 0x7B, 0xC1, 0xE3, 0xC0, 0x86, 0x00, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x0F, 0x87, 0xE3, 0xE1, 0xF0, 0x38, 0x38,
  0x7C, 0xF8, 0x78, 0x00, 0x7F, 0xDF, 0xF7, 0xFB, 0xFE, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFB, 0xE0, 0xF0, 0x70, 0xF0, 0x38,
  0x70, 0x1E, 0x78, 0x0F, 0x38, 0x07, 0x9C, 0x63, 0x9E, 0x79, 0xCF, 0x3C,
  0xE7, 0x1C, 0xF3, 0x8E, 0x79, 0xC0, 0x39, 0xE0, 0x3C, 0xF0, 0x1E, 0x78,
  0x1E, 0x1C, 0x0F, 0x0F, 0x0F, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00,
  0x00, 0x38, 0x07, 0xC0, 0x7E, 0x0F, 0xE3, 0xFF, 0x0F, 0x78, 0x63, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE1, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8,
  0x00, 0x78, 0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xFB, 0xE0, 0xC0, 0x70, 0x40,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF,
  0xE0, 0x00, 0x38, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x79, 0xF0, 0x20, 0x78,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x88, 0x07, 0xC7, 0xFF, 0xC7, 0xFF, 0xC1,
  0xFF, 0x80, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0x38, 0x07, 0x3C, 0x07, 0x1E, 0x07, 0x8E, 0x07, 0x87, 0x07,
  0x87, 0x83, 0x83, 0xC3, 0x81, 0xC3, 0x80, 0xE5, 0xFF, 0xFD, 0xFF, 0xFE,
  0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x84, 0x03, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xE0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x79, 0xE0, 0x7F, 0xF8, 0xFF,
  0xFC, 0xF8, 0x3C, 0xF0, 0x1C, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xF0, 0x3C, 0xF0, 0x78, 0x7D, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0x3F,
  0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0xFF, 0x01, 0xFF, 0xC0, 0xF1, 0xF0, 0xF0, 0x78, 0x70, 0x1C, 0x78,
  0x1E, 0x3C, 0x0F, 0x0E, 0x07, 0x07, 0x8F, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x81, 0xE3, 0xE1, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F,
  0x3C, 0x07, 0x9E, 0x07, 0x87, 0xDF, 0xC3, 0xFF, 0xC0, 0x7F, 0x80, 0x00,
  0xF0, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xF3, 0xE1, 0xE0, 0x70, 0xE0, 0x3C,
  0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE3, 0xE7,
  0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xF0, 0x00,
  0x1F, 0x1F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0xF8, 0xF8, 0xF8, 0xF0, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x3F, 0x07,
  0xC0, 0xF8, 0x07, 0x01, 0xC0, 0xF8, 0x7C, 0x0F, 0x00, 0x00, 0x01, 0x00,
  0x07, 0x00, 0x1F, 0x00, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0x7C,
  0x00, 0x7C, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x18, 0x3F, 0xFF, 0x9F, 0xFF, 0x9F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE,
  0x00, 0x10, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x7E, 0x01, 0xFE, 0x0F, 0xF0, 0x7F,
  0x80, 0xFE, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x03, 0x81, 0xFF, 0x87, 0xFE,
  0x30, 0xF0, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x7F, 0xC0, 0x3F, 0xF8, 0x1E, 0x0E, 0x0F, 0x03, 0xC7, 0x80, 0x71, 0xC0,
  0x1C, 0xE0, 0x3F, 0x38, 0x7F, 0x9C, 0x3F, 0xE7, 0x1E, 0x39, 0xCF, 0x1E,
  0xE3, 0x87, 0x38, 0xE1, 0xCE, 0x78, 0x73, 0x9C, 0x3C, 0xE7, 0x0E, 0x39,
  0xE3, 0x8E, 0x3C, 0xE3, 0x8F, 0xF8, 0xE1, 0xFC, 0x3C, 0x08, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7B, 0x80,
  0x1C, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x38,
  0x38, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1C, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x39, 0xE0, 0x0F, 0x78, 0x03, 0xFC,
  0x00, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x3C, 0x0F, 0x0F,
  0x03, 0xC3, 0xC0, 0xF0, 0xE0, 0x38, 0x38, 0x1E, 0x1E, 0x0F, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0x0F, 0x0F, 0x01, 0xC3, 0x80, 0x70,
  0xE0, 0x1C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x03, 0xE1, 0xFF, 0xF0, 0xFF,
  0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0xFF, 0x81, 0xFF, 0xE1, 0xFD,
  0xE1, 0xF0, 0x10, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x01, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1,
  0xE1, 0xF0, 0xF0, 0x78, 0x70, 0x1C, 0x78, 0x0E, 0x3C, 0x07, 0x1E, 0x03,
  0x8E, 0x01, 0xC7, 0x00, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xC0, 0x3C, 0xE0,
  0x3C, 0xF0, 0x1E, 0x78, 0x1E, 0x38, 0x1F, 0x1C, 0x3F, 0x1F, 0xFF, 0x0F,
  0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xF0, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xFC, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3F,
  0xE0, 0x3F, 0xFC, 0x1F, 0xDE, 0x0F, 0x80, 0x87, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x0F, 0x1C, 0x03, 0x87, 0x00, 0xE3, 0xC0, 0x78, 0x70, 0x1E, 0x1C, 0x07,
  0x07, 0x81, 0xC1, 0xF0, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x07, 0x80, 0xE0, 0xE0, 0x1C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1C,
  0x1C, 0x03, 0x83, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0x83, 0xFF, 0xF0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xC0, 0x70, 0x70, 0x0E, 0x0E, 0x03, 0xC3,
  0xC0, 0x78, 0x78, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x78, 0x78, 0x0F, 0x0F,
  0x01, 0xC1, 0xC0, 0x38, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x03,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x06,
  0x0F, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x07, 0x81, 0xF0,
  0x78, 0x3C, 0x07, 0x07, 0xC0, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF1, 0xE0,
  0x0E, 0x3C, 0x00, 0xE7, 0x80, 0x1E, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3D, 0xE0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x03, 0x87,
  0x80, 0x78, 0x38, 0x07, 0x83, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0xF0,
  0x1E, 0x0F, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x80, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC1, 0xF0, 0x3C, 0x1E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x06, 0xE6,
  0xE0, 0xEE, 0xEE, 0x0E, 0xEC, 0xE0, 0xEF, 0xCC, 0x1C, 0xF9, 0xC1, 0xC7,
  0x9C, 0x1C, 0x71, 0xC3, 0xC7, 0x1C, 0x38, 0x03, 0xC3, 0x80, 0x38, 0x38,
  0x03, 0x87, 0x80, 0x38, 0x70, 0x07, 0x87, 0x00, 0x78, 0x70, 0x07, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0xE0, 0xF0, 0x1C, 0x1E, 0x03, 0x87, 0xE0, 0xF0,
  0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xB0, 0x70, 0xF7, 0x1E, 0x1C, 0xE3, 0x83,
  0x9C, 0x70, 0x71, 0x8E, 0x1E, 0x39, 0xC3, 0x87, 0x70, 0x70, 0xEE, 0x0E,
  0x0D, 0xC3, 0xC1, 0xB8, 0x70, 0x3F, 0x0E, 0x07, 0xC1, 0xC0, 0xF8, 0x78,
  0x0F, 0x0E, 0x01, 0xE1, 0xC0, 0x38, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x01,
  0xFF, 0xC0, 0xFB, 0xE0, 0xF0, 0x78, 0xF0, 0x3C, 0x70, 0x1E, 0x78, 0x0F,
  0x38, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEE, 0x00, 0xF7, 0x00, 0x73, 0x80,
  0x3B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x1E, 0x78, 0x0F, 0x1C, 0x0F, 0x0F,
  0x0F, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xFF, 0x01, 0xFF,
  0xE0, 0x7F, 0xFC, 0x1C, 0x0F, 0x07, 0x03, 0xC3, 0xC0, 0x70, 0xF0, 0x1C,
  0x38, 0x0F, 0x0E, 0x03, 0xC7, 0x81, 0xE1, 0xE1, 0xF8, 0x7F, 0xFC, 0x1F,
  0xFC, 0x0F, 0xFC, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0xFF, 0x01, 0xFF, 0xC0, 0xFB, 0xE0, 0xF0, 0x78, 0xF0, 0x3C, 0x70,
  0x1E, 0x78, 0x0F, 0x38, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEE, 0x00, 0xF7,
  0x00, 0x73, 0x80, 0x3B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x1E, 0x78, 0x0F,
  0x1C, 0x0F, 0x0F, 0x0F, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x06, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1C, 0x1E, 0x0F, 0x03, 0xC3,
  0xC0, 0xF0, 0xE0, 0x3C, 0x38, 0x0E, 0x1E, 0x07, 0x87, 0x83, 0xC1, 0xCF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0x87, 0x80, 0xE0, 0xE0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x01, 0xC1, 0xC0, 0x78, 0xF0, 0x1E, 0x3C,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0x9E, 0x07,
  0x80, 0x83, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE1, 0x80, 0x78, 0x7F,
  0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x0F, 0x01, 0xC3, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0E, 0x1E,
  0x03, 0x87, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x0E, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0E, 0x1C, 0x03, 0x87, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x1C, 0x3C, 0x0F, 0x07, 0x87, 0x81, 0xFF, 0xE0, 0x3F,
  0xF0, 0x07, 0xF8, 0x00, 0xE0, 0x07, 0xF0, 0x07, 0xB8, 0x03, 0x9C, 0x03,
  0xCE, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xE1, 0xC0, 0xF0, 0xE0, 0x70, 0x70,
  0x78, 0x38, 0x38, 0x1C, 0x3C, 0x0E, 0x1C, 0x07, 0x1E, 0x03, 0x8E, 0x01,
  0xEF, 0x00, 0xF7, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xE0,
  0x0E, 0x1E, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C,
  0x71, 0xC3, 0x8F, 0x1C, 0x39, 0xF3, 0x83, 0x9B, 0x38, 0x3B, 0xB3, 0x83,
  0xB3, 0x30, 0x37, 0x37, 0x07, 0x63, 0x70, 0x7E, 0x36, 0x07, 0xC3, 0xE0,
  0x7C, 0x3E, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0x03, 0xC0,
  0x78, 0x1E, 0x07, 0x80, 0x70, 0x3C, 0x03, 0xC3, 0xC0, 0x1E, 0x3C, 0x00,
  0x73, 0xC0, 0x03, 0xDC, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0x78, 0x00, 0xF1, 0xC0, 0x0F, 0x0E, 0x00, 0xF8, 0x78, 0x07, 0x83, 0xC0,
  0x78, 0x0E, 0x07, 0x80, 0x70, 0x78, 0x03, 0xC0, 0xE0, 0x07, 0xF8, 0x07,
  0xBC, 0x07, 0x9E, 0x03, 0xC7, 0x03, 0xC3, 0x83, 0xC1, 0xE1, 0xC0, 0xF1,
  0xE0, 0x39, 0xE0, 0x1C, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xF3, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x79, 0xE7, 0x9E, 0x79, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF1, 0xC7, 0x1C, 0x71, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x00,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x7B, 0x81, 0xE7, 0x87,
  0x87, 0x0E, 0x0E, 0x3C, 0x1E, 0xF0, 0x3F, 0xC0, 0x39, 0x00, 0x60, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0xC3, 0xC3, 0xC3, 0xE3, 0x82, 0x00,
  0x01, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x0F, 0x3C, 0x0E, 0x78, 0x0E,
  0x78, 0x1E, 0x70, 0x1E, 0xF0, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x7C, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0x9C, 0x01, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x3C, 0x0F,
  0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x1E,
  0x70, 0x1E, 0xF0, 0x3C, 0xF0, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80,
  0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x02, 0x3E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x04, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xFC,
  0x0F, 0x87, 0x83, 0xE0, 0xF0, 0x78, 0x1C, 0x1E, 0x03, 0x83, 0x80, 0xF0,
  0x70, 0x1E, 0x1E, 0x03, 0x83, 0xC0, 0x70, 0x78, 0x1E, 0x0F, 0x03, 0xC0,
  0xE0, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0x9C, 0x00, 0x01, 0xFC,
  0x07, 0xFE, 0x0F, 0xFF, 0x1E, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x70, 0x3E, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x04, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xE2, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x11, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xE1, 0xE0, 0xF8, 0x3C, 0x1E, 0x07,
  0x87, 0x80, 0xE0, 0xF0, 0x1C, 0x1C, 0x07, 0x83, 0x80, 0xF0, 0x70, 0x1C,
  0x0E, 0x03, 0x81, 0xE0, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x30, 0x3E, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFF, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0E, 0x3C, 0x0E, 0x38, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78,
  0x1C, 0x70, 0x3C, 0x70, 0x3C, 0xF0, 0x3C, 0x01, 0x80, 0x78, 0x1F, 0x03,
  0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0xF3, 0xFE, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0xF8, 0x7F, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x01, 0x87, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x03, 0xF0, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x07,
  0xC7, 0x83, 0xC1, 0xE1, 0xE0, 0x78, 0xF0, 0x1C, 0x78, 0x07, 0x3C, 0x03,
  0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0E, 0xF0, 0x07, 0x9E, 0x01, 0xE3,
  0xC0, 0x70, 0xF0, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0xE0, 0x3C,
  0x00, 0xFF, 0xBF, 0xCF, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E,
  0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x07,
  0x03, 0xC0, 0xF0, 0x3C, 0x17, 0xFD, 0xFF, 0x3F, 0xC0, 0x07, 0xCF, 0x0F,
  0xFF, 0xC7, 0xFF, 0xE3, 0x9E, 0x71, 0xCE, 0x39, 0xC7, 0x1C, 0xE3, 0x8E,
  0x71, 0xC7, 0x38, 0xE7, 0x38, 0xE3, 0x9C, 0x71, 0xCE, 0x00, 0xE7, 0x00,
  0xF7, 0x80, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x1E, 0x00, 0x07, 0xF8,
  0x3F, 0xF8, 0x7F, 0xF8, 0xE0, 0xF1, 0xC0, 0xE7, 0x81, 0xCF, 0x03, 0x9C,
  0x07, 0x38, 0x1E, 0xF0, 0x3D, 0xE0, 0x73, 0xC0, 0xE7, 0x03, 0xDE, 0x07,
  0xBC, 0x0E, 0x78, 0x1C, 0xE0, 0x78, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE,
  0x1E, 0x1E, 0x3C, 0x0F, 0x38, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x0F,
  0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0x78, 0x7C, 0x7F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1C,
  0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x38, 0x0F, 0x1E, 0x03,
  0xC7, 0x80, 0xE1, 0xE0, 0x78, 0x70, 0x1E, 0x3C, 0x0F, 0x0F, 0x0F, 0x83,
  0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFF,
  0xC3, 0xFF, 0xC3, 0xE1, 0xE3, 0xE0, 0xF1, 0xE0, 0x71, 0xE0, 0x38, 0xF0,
  0x3C, 0x70, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x1E, 0x07, 0x8F, 0x03, 0xC3,
  0xC1, 0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xFF, 0x1F,
  0xFE, 0x1F, 0xFE, 0x1E, 0x04, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x0F,
  0xFE, 0x0E, 0x02, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x40, 0x38, 0x7F,
  0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x01, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x01, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x81, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0x3C, 0x0E, 0x70, 0x3C,
  0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xCE, 0x07, 0x9C, 0x0F, 0x78, 0x1E, 0xF0,
  0x39, 0xC0, 0x73, 0x81, 0xE7, 0x03, 0xCE, 0x07, 0x1E, 0x1E, 0x3F, 0xFE,
  0x7F, 0xFC, 0x7F, 0x38, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x77, 0x81, 0xEF,
  0x03, 0x9E, 0x0F, 0x1C, 0x1C, 0x38, 0x78, 0x70, 0xE0, 0xE3, 0xC1, 0xC7,
  0x03, 0xDE, 0x07, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x00,
  0x38, 0x01, 0xDE, 0x00, 0x77, 0x00, 0x3D, 0xC0, 0x0E, 0x70, 0xC3, 0x9C,
  0x70, 0xE7, 0x1E, 0x71, 0xCF, 0x9C, 0x73, 0xE7, 0x19, 0xFB, 0x86, 0x6E,
  0xE3, 0xBB, 0xF0, 0xFC, 0x7C, 0x3E, 0x1E, 0x0F, 0x87, 0x83, 0xC1, 0xE0,
  0xE0, 0x70, 0x00, 0x0F, 0x01, 0xE0, 0xF0, 0x78, 0x1E, 0x0E, 0x01, 0xC3,
  0xC0, 0x3C, 0xF0, 0x03, 0xBC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xDE, 0x00, 0xF1, 0xC0, 0x3E, 0x3C,
  0x07, 0x87, 0x81, 0xE0, 0x78, 0xF8, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x78,
  0x0F, 0x07, 0x80, 0xE0, 0x78, 0x1E, 0x03, 0x81, 0xE0, 0x38, 0x1C, 0x03,
  0x83, 0xC0, 0x3C, 0x38, 0x03, 0xC7, 0x80, 0x3C, 0x70, 0x01, 0xCF, 0x00,
  0x1C, 0xE0, 0x01, 0xDE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x08, 0x7C, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x01, 0xF8, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x01, 0xE0,
  0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70,
  0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38,
  0x0F, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0x1F,
  0x03, 0x3F, 0xC7, 0x7F, 0xFE, 0xF1, 0xFE, 0xE0, 0xFC,
};

const GFXglyph UbuntuSansMono_MediumItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 9, 22, 18, 5, -22 },
  { 26, 12, 9, 18, 6, -24 },
  { 40, 19, 22, 18, 0, -22 },
  { 93, 17, 28, 18, 1, -25 },
  { 153, 21, 24, 18, -1, -23 },
  { 216, 16, 23, 18, 1, -23 },
  { 262, 5, 10, 18, 9, -24 },
  { 269, 14, 31, 18, 4, -25 },
  { 324, 14, 31, 18, 0, -25 },
  { 379, 15, 13, 18, 3, -22 },
  { 404, 16, 16, 18, 1, -17 },
  { 436, 9, 10, 18, 2, -5 },
  { 448, 10, 4, 18, 4, -11 },
  { 453, 5, 5, 18, 5, -5 },
  { 457, 21, 31, 18, -2, -25 },
  { 539, 17, 23, 18, 1, -23 },
  { 588, 13, 22, 18, 2, -22 },
  { 624, 17, 23, 18, 1, -23 },
  { 673, 17, 23, 18, 0, -23 },
  { 722, 17, 22, 18, 0, -22 },
  { 769, 18, 22, 18, 0, -22 },
  { 819, 16, 22, 18, 2, -22 },
  { 863, 17, 22, 18, 3, -22 },
  { 910, 17, 23, 18, 1, -23 },
  { 959, 17, 23, 18, 1, -23 },
  { 1008, 8, 16, 18, 5, -16 },
  { 1024, 11, 21, 18, 2, -16 },
  { 1053, 16, 15, 18, 1, -17 },
  { 1083, 17, 10, 18, 1, -14 },
  { 1105, 16, 15, 18, 1, -17 },
  { 1135, 13, 23, 18, 4, -23 },
  { 1173, 18, 28, 18, 1, -23 },
  { 1236, 18, 22, 18, -2, -22 },
  { 1286, 18, 22, 18, 0, -22 },
  { 1336, 17, 23, 18, 2, -23 },
  { 1385, 17, 22, 18, 0, -22 },
  { 1432, 18, 22, 18, 1, -22 },
  { 1482, 18, 22, 18, 1, -22 },
  { 1532, 18, 23, 18, 1, -23 },
  { 1584, 19, 22, 18, 0, -22 },
  { 1637, 18, 22, 18, 1, -22 },
  { 1687, 18, 22, 18, 1, -22 },
  { 1737, 20, 22, 18, 0, -22 },
  { 1792, 14, 22, 18, 0, -22 },
  { 1831, 20, 22, 18, -1, -22 },
  { 1886, 19, 22, 18, 0, -22 },
  { 1939, 17, 23, 18, 1, -23 },
  { 1988, 18, 22, 18, 0, -22 },
  { 2038, 17, 29, 18, 1, -23 },
  { 2100, 18, 22, 18, 0, -22 },
  { 2150, 18, 23, 18, 0, -23 },
  { 2202, 16, 22, 18, 4, -22 },
  { 2246, 18, 22, 18, 1, -22 },
  { 2296, 17, 22, 18, 4, -22 },
  { 2343, 20, 22, 18, 0, -22 },
  { 2398, 21, 22, 18, -1, -22 },
  { 2456, 17, 22, 18, 4, -22 },
  { 2503, 19, 22, 18, 0, -22 },
  { 2556, 17, 31, 18, 2, -25 },
  { 2622, 6, 31, 18, 6, -25 },
  { 2646, 17, 31, 18, -1, -25 },
  { 2712, 15, 12, 18, 2, -22 },
  { 2735, 16, 3, 18, -2, 3 },
  { 2741, 7, 7, 18, 8, -25 },
  { 2748, 16, 17, 18, 1, -17 },
  { 2782, 16, 25, 18, 1, -25 },
  { 2832, 16, 17, 18, 1, -17 },
  { 2866, 19, 25, 18, 1, -25 },
  { 2926, 16, 17, 18, 1, -17 },
  { 2960, 22, 31, 18, -2, -25 },
  { 3046, 19, 23, 18, -1, -17 },
  { 3101, 16, 25, 18, 0, -25 },
  { 3151, 11, 25, 18, 3, -25 },
  { 3186, 18, 31, 18, -1, -25 },
  { 3256, 18, 25, 18, 1, -25 },
  { 3313, 10, 25, 18, 5, -25 },
  { 3345, 17, 17, 18, 0, -17 },
  { 3382, 15, 17, 18, 1, -17 },
  { 3414, 16, 17, 18, 1, -17 },
  { 3448, 18, 23, 18, -1, -17 },
  { 3500, 17, 23, 18, 1, -17 },
  { 3549, 16, 17, 18, 2, -17 },
  { 3583, 16, 17, 18, 1, -17 },
  { 3617, 14, 22, 18, 3, -22 },
  { 3656, 15, 17, 18, 2, -17 },
  { 3688, 15, 17, 18, 3, -17 },
  { 3720, 18, 17, 18, 1, -17 },
  { 3759, 19, 17, 18, -1, -17 },
  { 3800, 20, 23, 18, -2, -17 },
  { 3858, 16, 17, 18, 1, -17 },
  { 3892, 17, 31, 18, 2, -25 },
  { 3958, 11, 31, 18, 4, -25 },
  { 4001, 17, 31, 18, -1, -25 },
  { 4067, 16, 5, 18, 1, -12 },
};

const GFXfont UbuntuSansMono_MediumItalic32pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic32pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC32PT7B_H_
