#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/UbuntuSansMono_MediumItalic
// Headers: 67

#include "UbuntuSansMono_MediumItalic6pt7b.h"
#include "UbuntuSansMono_MediumItalic7pt7b.h"
#include "UbuntuSansMono_MediumItalic8pt7b.h"
#include "UbuntuSansMono_MediumItalic9pt7b.h"
#include "UbuntuSansMono_MediumItalic10pt7b.h"
#include "UbuntuSansMono_MediumItalic11pt7b.h"
#include "UbuntuSansMono_MediumItalic12pt7b.h"
#include "UbuntuSansMono_MediumItalic13pt7b.h"
#include "UbuntuSansMono_MediumItalic14pt7b.h"
#include "UbuntuSansMono_MediumItalic15pt7b.h"
#include "UbuntuSansMono_MediumItalic16pt7b.h"
#include "UbuntuSansMono_MediumItalic17pt7b.h"
#include "UbuntuSansMono_MediumItalic18pt7b.h"
#include "UbuntuSansMono_MediumItalic19pt7b.h"
#include "UbuntuSansMono_MediumItalic20pt7b.h"
#include "UbuntuSansMono_MediumItalic21pt7b.h"
#include "UbuntuSansMono_MediumItalic22pt7b.h"
#include "UbuntuSansMono_MediumItalic23pt7b.h"
#include "UbuntuSansMono_MediumItalic24pt7b.h"
#include "UbuntuSansMono_MediumItalic25pt7b.h"
#include "UbuntuSansMono_MediumItalic26pt7b.h"
#include "UbuntuSansMono_MediumItalic27pt7b.h"
#include "UbuntuSansMono_MediumItalic28pt7b.h"
#include "UbuntuSansMono_MediumItalic29pt7b.h"
#include "UbuntuSansMono_MediumItalic30pt7b.h"
#include "UbuntuSansMono_MediumItalic31pt7b.h"
#include "UbuntuSansMono_MediumItalic32pt7b.h"
#include "UbuntuSansMono_MediumItalic33pt7b.h"
#include "UbuntuSansMono_MediumItalic34pt7b.h"
#include "UbuntuSansMono_MediumItalic35pt7b.h"
#include "UbuntuSansMono_MediumItalic36pt7b.h"
#include "UbuntuSansMono_MediumItalic37pt7b.h"
#include "UbuntuSansMono_MediumItalic38pt7b.h"
#include "UbuntuSansMono_MediumItalic39pt7b.h"
#include "UbuntuSansMono_MediumItalic40pt7b.h"
#include "UbuntuSansMono_MediumItalic41pt7b.h"
#include "UbuntuSansMono_MediumItalic42pt7b.h"
#include "UbuntuSansMono_MediumItalic43pt7b.h"
#include "UbuntuSansMono_MediumItalic44pt7b.h"
#include "UbuntuSansMono_MediumItalic45pt7b.h"
#include "UbuntuSansMono_MediumItalic46pt7b.h"
#include "UbuntuSansMono_MediumItalic47pt7b.h"
#include "UbuntuSansMono_MediumItalic48pt7b.h"
#include "UbuntuSansMono_MediumItalic49pt7b.h"
#include "UbuntuSansMono_MediumItalic50pt7b.h"
#include "UbuntuSansMono_MediumItalic51pt7b.h"
#include "UbuntuSansMono_MediumItalic52pt7b.h"
#include "UbuntuSansMono_MediumItalic53pt7b.h"
#include "UbuntuSansMono_MediumItalic54pt7b.h"
#include "UbuntuSansMono_MediumItalic55pt7b.h"
#include "UbuntuSansMono_MediumItalic56pt7b.h"
#include "UbuntuSansMono_MediumItalic57pt7b.h"
#include "UbuntuSansMono_MediumItalic58pt7b.h"
#include "UbuntuSansMono_MediumItalic59pt7b.h"
#include "UbuntuSansMono_MediumItalic60pt7b.h"
#include "UbuntuSansMono_MediumItalic61pt7b.h"
#include "UbuntuSansMono_MediumItalic62pt7b.h"
#include "UbuntuSansMono_MediumItalic63pt7b.h"
#include "UbuntuSansMono_MediumItalic64pt7b.h"
#include "UbuntuSansMono_MediumItalic65pt7b.h"
#include "UbuntuSansMono_MediumItalic66pt7b.h"
#include "UbuntuSansMono_MediumItalic67pt7b.h"
#include "UbuntuSansMono_MediumItalic68pt7b.h"
#include "UbuntuSansMono_MediumItalic69pt7b.h"
#include "UbuntuSansMono_MediumItalic70pt7b.h"
#include "UbuntuSansMono_MediumItalic71pt7b.h"
#include "UbuntuSansMono_MediumItalic72pt7b.h"
