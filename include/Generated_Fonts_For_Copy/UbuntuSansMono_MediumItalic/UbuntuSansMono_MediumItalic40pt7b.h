#ifndef _UBUNTUSANSMONO_MEDIUMITALIC40PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x3C, 0x02, 0x00, 0x7C, 0x7D, 0xE1, 0xE7, 0x87, 0x9E, 0x1E,
  0xF8, 0xFB, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xE0, 0xE3, 0x83, 0x8C, 0x0C,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x78, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x01, 0xE1,
  0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0x83, 0xC0, 0x07, 0x87,
  0x80, 0x07, 0x87, 0x80, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0x1E, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x70, 0x78, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xE0,
  0x30, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC1, 0x00, 0x3E, 0x1F, 0x0F, 0xE0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8, 0x01,
  0xC0, 0xFE, 0x00, 0xE0, 0x7B, 0xC0, 0x78, 0x1C, 0x70, 0x3C, 0x0F, 0x1C,
  0x1E, 0x03, 0x87, 0x07, 0x00, 0xE1, 0xC3, 0x80, 0x38, 0xF1, 0xC0, 0x0E,
  0x38, 0xF0, 0x03, 0x8E, 0x78, 0x00, 0xE7, 0x3C, 0x00, 0x3F, 0xDE, 0x00,
  0x07, 0xE7, 0x00, 0x00, 0x43, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF3,
  0xE0, 0x00, 0x79, 0xFC, 0x00, 0x3C, 0xFF, 0x00, 0x0E, 0x79, 0xC0, 0x07,
  0x1C, 0x70, 0x03, 0x87, 0x1C, 0x01, 0xE3, 0x87, 0x00, 0xF0, 0xE1, 0xC0,
  0x78, 0x38, 0x70, 0x3C, 0x0E, 0x38, 0x0E, 0x03, 0xDE, 0x07, 0x00, 0x7F,
  0x03, 0xC0, 0x1F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0x3C, 0x07, 0xC1, 0xC0, 0x78, 0x1C, 0x07,
  0x83, 0xC0, 0x78, 0x3C, 0x07, 0x87, 0x80, 0x78, 0xF8, 0x07, 0x9F, 0x00,
  0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x0F, 0x0F, 0xF0, 0xF1, 0xFF, 0x0E,
  0x3C, 0xF9, 0xE7, 0x87, 0x9E, 0x78, 0x3F, 0xCF, 0x03, 0xFC, 0xF0, 0x1F,
  0x8F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x03, 0xF8, 0xF8, 0x7F, 0x8F, 0xFF,
  0xFC, 0x7F, 0xF3, 0xC3, 0xFC, 0x3C, 0x3E, 0x7C, 0xF3, 0xE7, 0xCF, 0x9E,
  0x3C, 0x70, 0xE1, 0xC7, 0x00, 0x00, 0x01, 0x00, 0x01, 0x80, 0x03, 0xC0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x78, 0x00, 0x18, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x18, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x61, 0xE0, 0x9E, 0x38, 0xE7, 0xEC, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xC0, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0x3C,
  0x07, 0xCF, 0x83, 0xE1, 0xF0, 0x78, 0x78, 0x04, 0x08, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x03,
  0xE1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x0E, 0x07, 0x87, 0xCF, 0xE3,
  0xF0, 0xF0, 0x20, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x38,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0x7E, 0x0F, 0xC1, 0xF0, 0xF8,
  0x1F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x0F, 0x7C,
  0x00, 0xF7, 0xCF, 0x1F, 0x78, 0xF9, 0xF7, 0x9F, 0x9E, 0xF9, 0xF1, 0xEF,
  0x8F, 0x1E, 0xF0, 0x43, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x7C,
  0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x1F, 0x0F, 0x83, 0xF0, 0x7C, 0x7E,
  0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8,
  0x3F, 0xF8, 0x1F, 0x3C, 0x0E, 0x3E, 0x04, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x7F, 0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x00,
  0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x38, 0x0F,
  0x81, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xE7, 0xF0,
  0x08, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x84, 0x00, 0xFC, 0x78, 0x1F, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0,
  0x7F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0xC0, 0x1E, 0x1E,
  0x00, 0xF0, 0x78, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x1F, 0x07, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x10, 0x03, 0xE0, 0x7C, 0x3F, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xE0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x79, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFC, 0x3F, 0x0F, 0x00, 0x78, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00,
  0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x0F,
  0x01, 0xF0, 0x7E, 0x1F, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x18, 0x00, 0x00, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7E, 0x3F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0,
  0xF0, 0x0F, 0x1F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x83, 0xE0, 0xFC, 0x7C,
  0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xF3, 0xF0, 0x3E, 0x1F,
  0x87, 0xC0, 0x7C, 0xF8, 0x07, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00,
  0x7C, 0xF0, 0x07, 0xCF, 0x00, 0xF8, 0xF8, 0x3F, 0x8F, 0xFF, 0xF0, 0x7F,
  0xFE, 0x01, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF,
  0x00, 0xFF, 0xFC, 0x0F, 0xE7, 0xE0, 0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x7C,
  0x01, 0xE3, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E,
  0x3C, 0x00, 0xF1, 0xF0, 0x0F, 0x8F, 0xC1, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xFD, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0xFC,
  0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x03, 0x83, 0xF0,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xF8, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x81, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0x7C, 0x04,
  0x00, 0x00, 0x70, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07,
  0xC0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x01,
  0xC0, 0x1E, 0x03, 0xE0, 0xFE, 0x07, 0xE0, 0x3C, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0x00, 0x1F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFC,
  0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0x07,
  0xFF, 0xC3, 0xE7, 0xF1, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFC, 0x1F, 0x03, 0xE0, 0x3C, 0x1E,
  0x00, 0xF0, 0xF0, 0x01, 0xC3, 0xC0, 0x0F, 0x1E, 0x00, 0xBC, 0x78, 0x3F,
  0xF3, 0xC1, 0xFF, 0xCF, 0x0F, 0xFF, 0x78, 0x7C, 0x79, 0xE3, 0xE1, 0xE7,
  0x8F, 0x07, 0x9C, 0x78, 0x1E, 0xF1, 0xE0, 0xF3, 0xC7, 0x83, 0xCF, 0x1E,
  0x0F, 0x3C, 0x78, 0x3C, 0xF1, 0xE1, 0xE3, 0xC7, 0x87, 0x8F, 0x1F, 0x1E,
  0x3C, 0x3F, 0xF8, 0xF0, 0x7F, 0xC1, 0xC0, 0xFF, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0xE0, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x7B, 0xC0, 0x07, 0x8E, 0x00, 0x3C, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E,
  0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x78,
  0x0F, 0x03, 0xC0, 0x78, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00,
  0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xC0, 0x7C, 0x1F,
  0x01, 0xF0, 0x7C, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x7C, 0x1E, 0x01,
  0xE0, 0xF8, 0x0F, 0x83, 0xC1, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xFE, 0x07, 0x83, 0xF8, 0x1E, 0x01, 0xF0, 0x78, 0x03, 0xC3, 0xE0,
  0x0F, 0x0F, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x01, 0xF8, 0x7F, 0x7F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xE0, 0x10, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x40, 0x3F, 0x8F, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC1, 0xF8,
  0x1F, 0x03, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E,
  0x01, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3,
  0xC0, 0x1F, 0x0F, 0x00, 0x7C, 0x3C, 0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xC0,
  0xFC, 0x1E, 0x07, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x01, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xE0, 0x10, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00,
  0x7C, 0x3C, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x1E, 0x0F, 0x80, 0x78,
  0x1F, 0x03, 0xE0, 0x7F, 0x1F, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x0F, 0x03,
  0xC0, 0x1F, 0x03, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x07, 0xC0, 0x1E, 0x07,
  0x80, 0x3E, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x3C, 0x0F,
  0x00, 0x7C, 0x0F, 0x00, 0x7C, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x1E, 0x00, 0xF8, 0x3E, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x3C,
  0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x7C, 0x01, 0xE0, 0x7C,
  0x01, 0xE0, 0x78, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0xF8, 0x03, 0xC0, 0xF8,
  0x03, 0xC0, 0xF0, 0x07, 0xC0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x7F,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x02, 0x00,
  0xF8, 0x18, 0x07, 0xC0, 0x7C, 0x7F, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x81, 0xF0, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x07, 0x8F, 0x80, 0x07, 0xCF,
  0x80, 0x03, 0xEF, 0x80, 0x01, 0xEF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x0F,
  0x1F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xC0, 0xF0, 0x01,
  0xE0, 0x7C, 0x01, 0xF0, 0x1E, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x3C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0xF0,
  0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x1F,
  0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x0E, 0xE1, 0xDC, 0x07, 0x70, 0xFE, 0x03,
  0xB8, 0xEE, 0x03, 0xDC, 0x77, 0x01, 0xCE, 0x73, 0x80, 0xE7, 0x7B, 0xC0,
  0xF3, 0xB9, 0xE0, 0x79, 0xF8, 0xF0, 0x38, 0xFC, 0x70, 0x3C, 0x7C, 0x38,
  0x1E, 0x1E, 0x3C, 0x0F, 0x0E, 0x1E, 0x07, 0x00, 0x0F, 0x07, 0x80, 0x07,
  0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xE0, 0x0F, 0x03,
  0xF0, 0x0F, 0x07, 0xF0, 0x1E, 0x07, 0xF0, 0x1E, 0x07, 0xF0, 0x1E, 0x07,
  0xF8, 0x1E, 0x07, 0x78, 0x3C, 0x0F, 0x38, 0x3C, 0x0F, 0x3C, 0x3C, 0x0F,
  0x3C, 0x3C, 0x0F, 0x1C, 0x78, 0x1E, 0x1C, 0x78, 0x1E, 0x1C, 0x78, 0x1E,
  0x1E, 0x78, 0x1E, 0x1E, 0x70, 0x3C, 0x0E, 0xF0, 0x3C, 0x0E, 0xF0, 0x3C,
  0x0E, 0xF0, 0x3C, 0x0F, 0xF0, 0x78, 0x07, 0xE0, 0x78, 0x07, 0xE0, 0x78,
  0x07, 0xE0, 0x78, 0x07, 0xE0, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0xF0,
  0x03, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xEF,
  0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0x78, 0x7C, 0x03, 0xC7, 0xC0, 0x1E, 0x3E,
  0x00, 0xF9, 0xE0, 0x07, 0x9F, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F,
  0x7C, 0x00, 0x7B, 0xE0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xE7, 0x80,
  0x0F, 0x3C, 0x00, 0xF9, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0x78, 0x03, 0xC3,
  0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0x7C, 0x7E, 0x03, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x07,
  0xC0, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x7C,
  0x1E, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xE0, 0x3F, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xEF, 0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0x78, 0x7C, 0x03, 0xC7, 0xC0,
  0x1E, 0x3E, 0x00, 0xF9, 0xE0, 0x07, 0x9F, 0x00, 0x3C, 0xF0, 0x01, 0xE7,
  0x80, 0x0F, 0x7C, 0x00, 0x7B, 0xE0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x01,
  0xE7, 0x80, 0x0F, 0x3C, 0x00, 0xF9, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0x78,
  0x03, 0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0x7C, 0x7E, 0x03, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03,
  0xC0, 0xFC, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80,
  0x3C, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xC0, 0x3E, 0x0F, 0x01, 0xF0,
  0x3C, 0x3F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x78,
  0x78, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xC0, 0x3C, 0x0F, 0x80, 0xF0, 0x1E,
  0x07, 0xC0, 0x78, 0x1F, 0x01, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x0F,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x0F, 0xEF, 0xE0, 0x3E, 0x00, 0x80, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x10,
  0x03, 0xF0, 0x7C, 0x1F, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xE0, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3C, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xC3,
  0xC0, 0x1E, 0x1F, 0x00, 0x78, 0x7C, 0x03, 0xE1, 0xE0, 0x0F, 0x87, 0x80,
  0x3C, 0x3E, 0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x78,
  0x7C, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF8, 0xF8,
  0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0xF0, 0x07,
  0x83, 0xC0, 0x3E, 0x0F, 0x00, 0xF8, 0x3E, 0x07, 0xC0, 0xFC, 0x7F, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3C, 0xF8, 0x01,
  0xF3, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0xC1,
  0xE0, 0x1E, 0x07, 0x80, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x01, 0xE0,
  0x78, 0x07, 0x83, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x7C, 0x01, 0xE1, 0xE0,
  0x07, 0x8F, 0x80, 0x1E, 0x3C, 0x00, 0x79, 0xF0, 0x01, 0xE7, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x3C, 0x3C,
  0x38, 0x3C, 0x7C, 0x78, 0x3C, 0x7C, 0x78, 0x3C, 0xFC, 0x78, 0x38, 0xFC,
  0x70, 0x79, 0xDC, 0xF0, 0x79, 0xDC, 0xF0, 0x7B, 0x9C, 0xE0, 0x73, 0x9C,
  0xE0, 0x77, 0x1D, 0xE0, 0x77, 0x1D, 0xC0, 0xFE, 0x1D, 0xC0, 0xEE, 0x0D,
  0xC0, 0xFC, 0x0F, 0x80, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x7C,
  0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x3E, 0x3E, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x03, 0xC0, 0x7C,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x7D, 0xF0,
  0x07, 0xC7, 0x80, 0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0x3E, 0x0F, 0x01, 0xE0,
  0x7C, 0x1F, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x03, 0xEF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xDE,
  0x01, 0xF3, 0xC0, 0x3E, 0x7C, 0x0F, 0x87, 0x83, 0xE0, 0xF0, 0xF8, 0x1F,
  0x3E, 0x01, 0xE7, 0x80, 0x3D, 0xF0, 0x07, 0xDC, 0x00, 0x71, 0x00, 0x08,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x20, 0x70, 0xF8, 0xFC,
  0x7E, 0x1F, 0x0F, 0x06, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC,
  0x1F, 0xF3, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0xF8, 0x07, 0x87, 0x80,
  0x3C, 0x7C, 0x03, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x8F,
  0x80, 0x7C, 0x7C, 0x03, 0xC3, 0xE0, 0x1E, 0x1F, 0x00, 0xF0, 0x7C, 0x0F,
  0x83, 0xF1, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFE, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFE, 0x7E, 0x1F,
  0x01, 0xF1, 0xF0, 0x1F, 0x1E, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xF3,
  0xE0, 0x1F, 0x3C, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x07, 0xC7, 0x80, 0xFC, 0x78, 0x1F, 0x8F, 0x8F, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0x1C, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x01, 0x07, 0xF1, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xCF, 0x81, 0xF8, 0x1E, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xC1,
  0xF0, 0x0F, 0x0F, 0x80, 0x3C, 0x3E, 0x01, 0xF0, 0xF0, 0x07, 0x83, 0xC0,
  0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3C,
  0x0F, 0x81, 0xF0, 0x3F, 0x1F, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xDE, 0x01,
  0xFE, 0x78, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFF, 0x8F, 0xE3,
  0xF3, 0xF0, 0x1E, 0x7C, 0x03, 0xDF, 0x00, 0x7B, 0xC0, 0x1F, 0xF8, 0x07,
  0xDE, 0x07, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x0F, 0xFE, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x01, 0x0F, 0xC1, 0xE1, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xBF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xE1, 0xF0, 0x3F, 0x03, 0xC0, 0xF8,
  0x07, 0x81, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x78, 0x3E, 0x00,
  0xF0, 0x7C, 0x03, 0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x1E,
  0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0x9F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x20, 0x07, 0xC0, 0x78, 0x7F, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x80,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1E, 0x01,
  0xE1, 0xE0, 0x1E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xC3, 0xC0,
  0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x78, 0x07, 0x87, 0x80, 0x78, 0xF8,
  0x0F, 0x80, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0xFF,
  0xE3, 0xFF, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x01, 0x00, 0xF8, 0x07, 0x8F, 0xC0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x07, 0xC1, 0xE0, 0x3E, 0x0F, 0x83, 0xF0, 0x3E, 0x1F, 0x80,
  0xF0, 0xFC, 0x03, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x01, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xC7, 0xC0,
  0x0F, 0x1F, 0x00, 0x3C, 0x3E, 0x01, 0xF0, 0x78, 0x07, 0xC1, 0xF0, 0x1E,
  0x03, 0xE0, 0x78, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x00, 0xFF,
  0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0xE7, 0x7F, 0xF3, 0xFF, 0x1F, 0xF0, 0x07, 0xF9,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xCF, 0x9F, 0x1E, 0x1C, 0x3C,
  0x78, 0x70, 0xF1, 0xE3, 0xC3, 0x87, 0x8F, 0x1E, 0x1C, 0x3C, 0x78, 0xF0,
  0xE1, 0xE3, 0xC7, 0x87, 0x8F, 0x1E, 0x3C, 0x38, 0x78, 0xF1, 0xE0, 0x03,
  0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x38, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x8F,
  0x00, 0x1E, 0x3C, 0x00, 0x70, 0xE0, 0x03, 0xC0, 0x03, 0xFF, 0x80, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x03, 0xE1, 0xF0, 0x1E, 0x1F,
  0x01, 0xF1, 0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x3E, 0x03, 0xE3,
  0xE0, 0x3E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C,
  0x78, 0x07, 0x87, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF0, 0x0F,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xF0,
  0x3E, 0x7C, 0x07, 0xDF, 0x00, 0xFB, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x0F, 0xBC, 0x01,
  0xE7, 0x80, 0x7C, 0xF8, 0x1F, 0x1F, 0xDF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFC,
  0x01, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0xF8, 0x7E, 0x03, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C,
  0x07, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07,
  0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x07,
  0x80, 0xFC, 0x1E, 0x07, 0xE0, 0xFD, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0x3E, 0x1F, 0x81, 0xE3,
  0xE0, 0x3E, 0x3C, 0x03, 0xE7, 0xC0, 0x3C, 0x78, 0x03, 0xCF, 0x80, 0x7C,
  0xF8, 0x07, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x0F,
  0x8F, 0x00, 0xF0, 0xF8, 0x1F, 0x0F, 0xC7, 0xF0, 0x7F, 0xFF, 0x03, 0xFF,
  0xE0, 0x1F, 0xDE, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0x1E,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x20, 0x0F, 0x87, 0xC1, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x07, 0xFF,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0x01,
  0xF1, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xE3, 0xC0,
  0x3C, 0x3C, 0x03, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0x80, 0x78, 0x78,
  0x07, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0xF0, 0xF8, 0x1F, 0x0F, 0xEF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x3F, 0xC7, 0x80, 0xF0, 0x03, 0xDE, 0x00, 0xFB, 0xC0, 0x1F, 0x7C, 0x03,
  0xCF, 0x80, 0xF9, 0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0xC0, 0xF0, 0xF8, 0x3E,
  0x0F, 0x07, 0x81, 0xE1, 0xF0, 0x3C, 0x3C, 0x07, 0x8F, 0x80, 0xF1, 0xE0,
  0x1F, 0x78, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80,
  0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xC1, 0xC1, 0xCF, 0x0F, 0x0F,
  0x3C, 0x3C, 0x3C, 0xF1, 0xF0, 0xE3, 0xC7, 0xE7, 0x8F, 0x3B, 0x9E, 0x3C,
  0xEE, 0x70, 0xE7, 0x3B, 0xC3, 0x9C, 0xEE, 0x0E, 0xE3, 0xF8, 0x3F, 0x8F,
  0xE0, 0xFC, 0x3F, 0x03, 0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x3C, 0x0F, 0x80,
  0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x7C,
  0x01, 0xE0, 0xF8, 0x01, 0xF1, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0xFB, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80,
  0x07, 0xC7, 0xC0, 0x0F, 0x87, 0xC0, 0x1F, 0x03, 0xC0, 0x3E, 0x03, 0xE0,
  0x7C, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x1F, 0x00, 0x7C,
  0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x3C, 0x00,
  0x3C, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0x78, 0xF0,
  0x00, 0x1E, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x63, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x78, 0xFF, 0x83, 0x8F, 0xFE, 0x7C,
  0xFF, 0xFF, 0xC7, 0x87, 0xFE, 0x78, 0x1F, 0xE0, 0x40, 0x3C, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 11, 29, 22, 6, -28 },
  { 41, 14, 11, 22, 8, -30 },
  { 61, 24, 28, 22, 0, -28 },
  { 145, 21, 35, 22, 1, -31 },
  { 237, 26, 29, 22, -1, -28 },
  { 332, 20, 28, 22, 1, -28 },
  { 402, 7, 12, 22, 11, -30 },
  { 413, 17, 40, 22, 5, -32 },
  { 498, 17, 40, 22, 1, -32 },
  { 583, 18, 17, 22, 4, -28 },
  { 622, 19, 20, 22, 2, -22 },
  { 670, 10, 14, 22, 3, -7 },
  { 688, 11, 5, 22, 6, -14 },
  { 695, 7, 8, 22, 6, -7 },
  { 702, 26, 38, 22, -2, -31 },
  { 826, 20, 29, 22, 2, -28 },
  { 899, 17, 28, 22, 2, -28 },
  { 959, 21, 28, 22, 1, -28 },
  { 1033, 21, 29, 22, 0, -28 },
  { 1110, 22, 28, 22, 0, -28 },
  { 1187, 23, 29, 22, 0, -28 },
  { 1271, 21, 29, 22, 2, -28 },
  { 1348, 21, 28, 22, 4, -28 },
  { 1422, 20, 29, 22, 2, -28 },
  { 1495, 21, 28, 22, 1, -28 },
  { 1569, 10, 22, 22, 6, -21 },
  { 1597, 13, 28, 22, 3, -21 },
  { 1643, 20, 19, 22, 2, -21 },
  { 1691, 21, 12, 22, 1, -18 },
  { 1723, 20, 19, 22, 1, -21 },
  { 1771, 17, 29, 22, 5, -28 },
  { 1833, 22, 34, 22, 1, -28 },
  { 1927, 21, 28, 22, -2, -28 },
  { 2001, 22, 28, 22, 0, -28 },
  { 2078, 22, 29, 22, 2, -28 },
  { 2158, 22, 28, 22, 0, -28 },
  { 2235, 23, 28, 22, 1, -28 },
  { 2316, 23, 28, 22, 1, -28 },
  { 2397, 22, 29, 22, 2, -28 },
  { 2477, 24, 28, 22, 0, -28 },
  { 2561, 22, 28, 22, 1, -28 },
  { 2638, 22, 29, 22, 1, -28 },
  { 2718, 25, 28, 22, 0, -28 },
  { 2806, 17, 28, 22, 1, -28 },
  { 2866, 25, 28, 22, -1, -28 },
  { 2954, 24, 28, 22, 0, -28 },
  { 3038, 21, 29, 22, 2, -28 },
  { 3115, 23, 28, 22, 0, -28 },
  { 3196, 21, 35, 22, 2, -28 },
  { 3288, 22, 28, 22, 0, -28 },
  { 3365, 23, 29, 22, 0, -28 },
  { 3449, 20, 28, 22, 5, -28 },
  { 3519, 22, 29, 22, 2, -28 },
  { 3599, 22, 28, 22, 4, -28 },
  { 3676, 24, 28, 22, 1, -28 },
  { 3760, 27, 28, 22, -1, -28 },
  { 3855, 21, 28, 22, 5, -28 },
  { 3929, 24, 28, 22, 0, -28 },
  { 4013, 20, 38, 22, 3, -31 },
  { 4108, 8, 38, 22, 8, -31 },
  { 4146, 21, 38, 22, -1, -31 },
  { 4246, 19, 16, 22, 3, -28 },
  { 4284, 21, 3, 22, -3, 4 },
  { 4292, 8, 8, 22, 10, -31 },
  { 4300, 21, 21, 22, 1, -21 },
  { 4356, 20, 32, 22, 1, -31 },
  { 4436, 20, 21, 22, 2, -21 },
  { 4489, 22, 31, 22, 2, -31 },
  { 4575, 19, 22, 22, 2, -21 },
  { 4628, 27, 39, 22, -2, -31 },
  { 4760, 23, 29, 22, -1, -21 },
  { 4844, 20, 31, 22, 0, -31 },
  { 4922, 14, 31, 22, 4, -31 },
  { 4977, 22, 39, 22, -1, -31 },
  { 5085, 22, 31, 22, 1, -31 },
  { 5171, 12, 31, 22, 6, -31 },
  { 5218, 22, 21, 22, 0, -21 },
  { 5276, 20, 21, 22, 1, -21 },
  { 5329, 19, 22, 22, 2, -21 },
  { 5382, 22, 28, 22, -1, -21 },
  { 5459, 20, 28, 22, 2, -21 },
  { 5529, 20, 21, 22, 2, -21 },
  { 5582, 20, 22, 22, 1, -21 },
  { 5637, 18, 27, 22, 4, -27 },
  { 5698, 20, 21, 22, 2, -21 },
  { 5751, 19, 21, 22, 4, -21 },
  { 5801, 22, 21, 22, 2, -21 },
  { 5859, 24, 21, 22, -1, -21 },
  { 5922, 26, 29, 22, -3, -21 },
  { 6017, 21, 21, 22, 1, -21 },
  { 6073, 21, 38, 22, 3, -31 },
  { 6173, 13, 38, 22, 5, -31 },
  { 6235, 22, 38, 22, -2, -31 },
  { 6340, 21, 7, 22, 1, -15 },
};

const GFXfont UbuntuSansMono_MediumItalic40pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic40pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic40pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC40PT7B_H_
