#ifndef _UBUNTUSANSMONO_MEDIUMITALIC26PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x78, 0xF1, 0xC3, 0x87, 0x1C, 0x38, 0x70, 0xC1, 0x80,
  0x00, 0x1C, 0x78, 0xF1, 0xE0, 0x73, 0xB9, 0xD8, 0xFC, 0x6E, 0x37, 0x3B,
  0x19, 0x8C, 0x01, 0xC6, 0x03, 0x1C, 0x0E, 0x30, 0x1C, 0xE0, 0x31, 0xC7,
  0xFF, 0xCF, 0xFF, 0x87, 0x18, 0x0C, 0x70, 0x18, 0xC0, 0x73, 0x83, 0xFF,
  0xEF, 0xFF, 0x86, 0x38, 0x1C, 0x60, 0x39, 0xC0, 0x63, 0x01, 0xCE, 0x00,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x01, 0xFF, 0x0F, 0xF8, 0x78, 0x61, 0xC0,
  0x06, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1C, 0x40, 0xE3, 0xFF, 0x8F, 0xF8, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x00, 0x07, 0x81, 0xC3, 0x60, 0xC1, 0x98, 0x60,
  0x66, 0x38, 0x19, 0x9C, 0x06, 0x66, 0x01, 0xB3, 0x00, 0x7D, 0x80, 0x04,
  0xC0, 0x00, 0x76, 0x00, 0x3B, 0xC0, 0x0D, 0x98, 0x06, 0x66, 0x03, 0x31,
  0x81, 0x8C, 0x60, 0xC3, 0x30, 0x70, 0xFC, 0x38, 0x1E, 0x00, 0x03, 0xF0,
  0x1F, 0xC0, 0xE3, 0x83, 0x8E, 0x0C, 0x30, 0x31, 0xC0, 0xEE, 0x03, 0xF0,
  0x0F, 0x1C, 0x7C, 0x63, 0xB9, 0x9C, 0x7E, 0x61, 0xF3, 0x83, 0xCE, 0x0E,
  0x1C, 0x7C, 0x7F, 0xF0, 0xF8, 0xE0, 0x3B, 0x9C, 0xE7, 0x31, 0x9C, 0x00,
  0x20, 0x0C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x38, 0x07,
  0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0x00, 0x01,
  0x00, 0x18, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x80, 0x70,
  0x04, 0x00, 0x0E, 0x01, 0xC2, 0x38, 0x73, 0x7F, 0xFE, 0xFF, 0x83, 0x80,
  0xD8, 0x3B, 0x8E, 0x38, 0x44, 0x00, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xDF, 0xFE, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x00, 0x3C, 0x78, 0xF9, 0xE1, 0xC7, 0x3C, 0x70, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x7F, 0x87, 0x8E, 0x38, 0x73, 0x83, 0x9C, 0x1D, 0xC0, 0xEE, 0x67, 0x77,
  0xBB, 0x39, 0xF8, 0x8D, 0xC0, 0xEE, 0x07, 0x70, 0x73, 0x83, 0x8E, 0x78,
  0x7F, 0x81, 0xF8, 0x00, 0x00, 0x60, 0x3C, 0x1F, 0x8F, 0xE1, 0xFC, 0x33,
  0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x7F, 0xFF, 0xFC, 0x07, 0xF0, 0xFF, 0xC7, 0x0E, 0x20, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x07,
  0xF0, 0x3F, 0xE0, 0x43, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0xFC, 0x07, 0xC0, 0x1F, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x18, 0x3C, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x0F,
  0xC0, 0x76, 0x03, 0xB8, 0x1C, 0xE0, 0x63, 0x83, 0x0C, 0x1C, 0x70, 0xE1,
  0xC7, 0x07, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x1F, 0xE0, 0x03, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x30, 0xF8, 0x7F, 0xE1, 0xFF,
  0x00, 0x00, 0x7C, 0x07, 0xF0, 0x7F, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03,
  0x80, 0x1D, 0xF8, 0x7F, 0xF1, 0xC1, 0xC7, 0x07, 0x38, 0x0C, 0xE0, 0x33,
  0x81, 0xC7, 0x07, 0x1C, 0x38, 0x3F, 0xC0, 0x7E, 0x00, 0x7F, 0xFB, 0xFF,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xE3, 0x87, 0x07, 0x18, 0x1C,
  0x60, 0xE1, 0xC3, 0x87, 0xBC, 0x0F, 0xC0, 0x7F, 0x87, 0x8E, 0x1C, 0x1C,
  0xE0, 0x73, 0x81, 0xCE, 0x07, 0x3C, 0x38, 0x7F, 0xC0, 0xFE, 0x00, 0x07,
  0xE0, 0xFF, 0x87, 0x0E, 0x70, 0x73, 0x81, 0x98, 0x0D, 0xC0, 0x66, 0x07,
  0x3C, 0x79, 0xFF, 0xC3, 0xEE, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x03,
  0xF0, 0xFE, 0x07, 0xC0, 0x00, 0x1C, 0x7C, 0xF9, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xE3, 0xC7, 0x8F, 0x00, 0x07, 0x07, 0xC3, 0xE1, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x0F, 0x07, 0xC3, 0xC0, 0xE0, 0xE1, 0xE0, 0xE0,
  0x00, 0x00, 0x18, 0x07, 0xC1, 0xFC, 0x3F, 0x07, 0xE0, 0x78, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0x40, 0x7F, 0xFB, 0xFF,
  0xDF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x38, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x38, 0x0F, 0xC3, 0xF8, 0x7F,
  0x07, 0xC0, 0x30, 0x01, 0x00, 0x00, 0x3F, 0x9F, 0xF4, 0x1C, 0x07, 0x01,
  0xC0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x03, 0xC0, 0xF0, 0x38, 0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xE1, 0xC7, 0x03,
  0x38, 0x0C, 0xC1, 0xF7, 0x1F, 0xD8, 0xFF, 0xE7, 0x1B, 0x98, 0x6C, 0xE3,
  0xB3, 0x8E, 0xCE, 0x33, 0x38, 0xCC, 0xF7, 0x31, 0xFC, 0xE1, 0xE3, 0x80,
  0x07, 0x00, 0x1F, 0x20, 0x3F, 0x80, 0x3E, 0x00, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xB8, 0x0E, 0xE0, 0x71, 0x81, 0xC6, 0x0E, 0x18,
  0x38, 0x61, 0xC1, 0x87, 0xFE, 0x3F, 0xFC, 0xFF, 0xF7, 0x01, 0xDC, 0x07,
  0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xF0, 0x3F, 0xF0, 0xE3, 0xC3, 0x07, 0x1C,
  0x1C, 0x70, 0x71, 0xC3, 0xC7, 0xFE, 0x3F, 0xE0, 0xFF, 0xC3, 0x83, 0x8C,
  0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x07, 0x9C, 0x7C, 0xFF, 0xE3, 0xFE, 0x00,
  0x03, 0xFE, 0x0F, 0xF8, 0x3C, 0x30, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x30, 0x3F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0,
  0x3F, 0xE0, 0xC7, 0x87, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0x81, 0xCE, 0x07,
  0x38, 0x1C, 0xE0, 0x73, 0x81, 0xDC, 0x0E, 0x70, 0x39, 0xC1, 0xC7, 0x0F,
  0x38, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x83,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xFF, 0xE3,
  0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xF8, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x03, 0xFC, 0x1F, 0xF0, 0xF0, 0x87, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0xEE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81,
  0xC7, 0x0E, 0x1E, 0x38, 0x7F, 0xE0, 0xFF, 0x80, 0x0E, 0x07, 0x0E, 0x06,
  0x0C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0C, 0x18, 0x1C, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x38, 0x38, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38,
  0x70, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0x0F, 0xFC, 0x7F, 0xF0,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x10, 0x38, 0x38, 0xF0, 0xFF, 0xC0,
  0x7F, 0x00, 0x0E, 0x0F, 0x0E, 0x1E, 0x0E, 0x1C, 0x0C, 0x38, 0x1C, 0x70,
  0x1C, 0xE0, 0x1D, 0xC0, 0x1B, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x3B, 0x80,
  0x31, 0xC0, 0x71, 0xC0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0x70, 0xE0, 0x70,
  0xE0, 0x78, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x07, 0x01, 0x7F, 0xEF, 0xFE, 0x03, 0x07, 0x07, 0x07, 0x07, 0x8F, 0x07,
  0x8F, 0x0D, 0x9B, 0x0D, 0x9F, 0x0D, 0xB6, 0x1D, 0xB6, 0x19, 0xE6, 0x19,
  0xEE, 0x39, 0xCE, 0x38, 0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x70, 0x1C, 0x70,
  0x1C, 0x60, 0x18, 0xE0, 0x38, 0x0E, 0x07, 0x0E, 0x06, 0x0F, 0x06, 0x1F,
  0x0E, 0x1F, 0x0E, 0x1B, 0x0E, 0x1B, 0x8C, 0x39, 0x9C, 0x39, 0x9C, 0x39,
  0x9C, 0x31, 0xD8, 0x70, 0xD8, 0x70, 0xF8, 0x70, 0xF8, 0x60, 0xF0, 0x60,
  0xF0, 0xE0, 0x70, 0xE0, 0x70, 0x07, 0xF0, 0x3F, 0xE1, 0xE3, 0x87, 0x0E,
  0x38, 0x1C, 0xC0, 0x77, 0x01, 0xDC, 0x06, 0x60, 0x3B, 0x80, 0xEE, 0x03,
  0xB8, 0x0E, 0xE0, 0x73, 0x81, 0xCE, 0x0E, 0x1C, 0x70, 0x7F, 0xC0, 0xFC,
  0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x38, 0xF0, 0x70, 0x70, 0xC0, 0xE3, 0x81,
  0xC7, 0x03, 0x8E, 0x0E, 0x18, 0x3C, 0x7F, 0xF0, 0xFF, 0x81, 0xF0, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x07,
  0xF0, 0x3F, 0xE1, 0xE3, 0x87, 0x0E, 0x38, 0x1C, 0xC0, 0x77, 0x01, 0xDC,
  0x06, 0x60, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x73, 0x81, 0xCE,
  0x0E, 0x1C, 0x70, 0x7F, 0xC0, 0xFC, 0x01, 0xC0, 0x07, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x18, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0xE3, 0xC3, 0x07, 0x1C,
  0x1C, 0x70, 0x71, 0xC1, 0xC6, 0x0F, 0x38, 0xF8, 0xFF, 0xC3, 0xFC, 0x0E,
  0x70, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x1C, 0xE0, 0x73, 0x81, 0xC0,
  0x03, 0xFE, 0x0F, 0xF8, 0x3C, 0x30, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x30, 0x78, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x38, 0x38, 0xE0, 0x71, 0xC0, 0xE3,
  0x81, 0xC7, 0x07, 0x0C, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x61, 0xC1,
  0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x1C, 0x38, 0x38, 0x78, 0xF0, 0x7F, 0xC0,
  0x7F, 0x00, 0xE0, 0x1F, 0x80, 0xEE, 0x03, 0xB8, 0x1C, 0xE0, 0x73, 0x83,
  0x8E, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x0E, 0x38, 0x39, 0xC0, 0xE6,
  0x01, 0xB8, 0x06, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1C, 0x03,
  0x1C, 0x07, 0x1C, 0x07, 0x18, 0x06, 0x18, 0x06, 0x38, 0x0E, 0x38, 0x0E,
  0x39, 0x8C, 0x33, 0xCC, 0x33, 0xDC, 0x76, 0xD8, 0x76, 0xD8, 0x6C, 0xD8,
  0x7C, 0xF8, 0x78, 0xF0, 0x70, 0xF0, 0x70, 0xF0, 0xE0, 0xE0, 0x07, 0x03,
  0xC1, 0xC1, 0xE0, 0x38, 0x70, 0x0E, 0x38, 0x03, 0x9C, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1D,
  0xC0, 0x0F, 0x70, 0x03, 0x8E, 0x01, 0xC3, 0x80, 0xE0, 0xE0, 0x78, 0x38,
  0x3C, 0x07, 0x00, 0xE0, 0x1F, 0x80, 0xE6, 0x07, 0x1C, 0x1C, 0x70, 0xE1,
  0xC7, 0x07, 0x1C, 0x0C, 0xE0, 0x3F, 0x00, 0xF8, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0F,
  0xFF, 0x0F, 0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x07,
  0xF8, 0x3F, 0xC1, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x84,
  0x1F, 0xC0, 0xFE, 0x00, 0xE7, 0x39, 0xC6, 0x31, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x31, 0x8E, 0x73, 0x9C, 0xE7, 0x38, 0x03, 0xFC, 0x0F, 0xF0,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x1F, 0xC0, 0xFF, 0x00, 0x03, 0x80, 0x3C, 0x07, 0xC0, 0xEC, 0x1C, 0xE3,
  0x8E, 0x78, 0x67, 0x07, 0xE0, 0x74, 0x06, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0x80, 0x63, 0xC7, 0x8F, 0x08, 0x03, 0xF0, 0x7F, 0xC7, 0xFE, 0x70, 0x67,
  0x07, 0x38, 0x3B, 0x81, 0xDC, 0x0C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xE3,
  0xC7, 0xFE, 0x1F, 0x70, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xDE, 0x07, 0xFC, 0x1F, 0xF8, 0x70, 0xE1, 0xC1, 0xCE,
  0x07, 0x38, 0x18, 0xE0, 0xE3, 0x83, 0x9C, 0x1E, 0x70, 0x71, 0xC7, 0x87,
  0xFC, 0x3F, 0xE0, 0x03, 0xF0, 0x7F, 0xC7, 0xFC, 0x78, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xF0, 0xC7, 0xFE,
  0x1F, 0xF0, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x00, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x78, 0x71, 0xC1, 0xC3, 0x83,
  0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE1, 0xE3, 0xC1,
  0xFF, 0x81, 0xF3, 0x00, 0x03, 0xE0, 0x7F, 0x8F, 0xBE, 0x70, 0x77, 0x03,
  0xB8, 0x3B, 0x87, 0xDF, 0xFC, 0xFE, 0x07, 0x00, 0x38, 0x00, 0xE0, 0xC7,
  0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1E, 0x40, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x07,
  0xFC, 0x1F, 0xF8, 0x78, 0x71, 0xE0, 0xE3, 0x83, 0x86, 0x07, 0x1C, 0x0E,
  0x38, 0x1C, 0x70, 0x70, 0xF1, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x0E, 0x00,
  0x1C, 0x20, 0x70, 0x7F, 0xE1, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x77, 0x83, 0xFE, 0x1F, 0xF8,
  0xE1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x19, 0xC1, 0xCE, 0x0E, 0x70,
  0x73, 0x83, 0x98, 0x39, 0xC1, 0xC0, 0x0E, 0x07, 0x83, 0xC1, 0xC0, 0x00,
  0x03, 0xF9, 0xFC, 0xFC, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1E, 0x4F, 0xE3, 0xF0, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x08, 0x38, 0x1F, 0xE0,
  0x7F, 0xC0, 0x3E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC1, 0xC7, 0x0E, 0x38, 0xF0, 0xE7, 0x83, 0xBC, 0x0F,
  0xC0, 0x7E, 0x01, 0xFC, 0x07, 0x70, 0x1C, 0xE0, 0xE1, 0xC3, 0x87, 0x0E,
  0x0E, 0x38, 0x38, 0xFE, 0xFE, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38,
  0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xF1, 0x7F, 0x7F, 0x0F,
  0x38, 0x7F, 0xF3, 0xBD, 0xCE, 0x63, 0x31, 0x9C, 0xC6, 0x77, 0x39, 0xDC,
  0xC6, 0x73, 0x19, 0x80, 0xE6, 0x03, 0xB8, 0x0C, 0xE0, 0x33, 0x01, 0xC0,
  0x0F, 0xC3, 0xFF, 0x3F, 0xF3, 0x87, 0x38, 0x73, 0x07, 0x70, 0x77, 0x07,
  0x70, 0x76, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0x07, 0xC0, 0x7F,
  0x0F, 0xFC, 0x70, 0xE7, 0x03, 0xB8, 0x1F, 0x80, 0xFC, 0x0E, 0xE0, 0x77,
  0x03, 0xB8, 0x39, 0xE3, 0xC7, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xF0,
  0x3F, 0xF0, 0x70, 0xE0, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x0E, 0x1C,
  0x1C, 0x70, 0x78, 0xE1, 0xE1, 0xC7, 0x83, 0xFE, 0x0F, 0xF8, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x7F, 0xC7,
  0xFE, 0x78, 0x77, 0x87, 0x38, 0x39, 0x81, 0xDC, 0x0E, 0xE0, 0x67, 0x07,
  0x38, 0x39, 0xE3, 0xC7, 0xFC, 0x1F, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x03, 0xF8, 0xFF, 0xC7, 0xFC, 0x38, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x00, 0x03, 0xF8, 0x7F, 0x87, 0xFC, 0x30, 0x03, 0x80, 0x0E, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x00, 0x38, 0x83, 0xCF, 0xFC, 0x3F,
  0xC0, 0x02, 0x01, 0xC0, 0x70, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xF9, 0xC0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x84, 0x7F,
  0x87, 0xF0, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x60, 0xE7, 0x07, 0x38, 0x39,
  0xC1, 0xCE, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xE7, 0xC7, 0xFE, 0x1F,
  0x70, 0xE0, 0x3B, 0x03, 0x9C, 0x1C, 0xE1, 0xC7, 0x0E, 0x38, 0x61, 0xC7,
  0x0E, 0x70, 0x73, 0x83, 0xB8, 0x0D, 0xC0, 0x7C, 0x03, 0xC0, 0x1C, 0x00,
  0x70, 0x0E, 0xE0, 0x19, 0x80, 0x33, 0x18, 0xE6, 0x31, 0x9C, 0xE3, 0x39,
  0xCE, 0x76, 0xD8, 0xED, 0xB1, 0xB3, 0xC3, 0xE7, 0x87, 0x8F, 0x0E, 0x1C,
  0x1C, 0x38, 0x00, 0x0E, 0x07, 0x0E, 0x0E, 0x07, 0x1C, 0x07, 0x38, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0E,
  0x70, 0x1C, 0x70, 0x38, 0x38, 0xF0, 0x38, 0x07, 0x03, 0x83, 0x83, 0x81,
  0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x70, 0x0E, 0x38,
  0x03, 0x38, 0x01, 0xDC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x04, 0x7F, 0xE3, 0xFF,
  0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x3E, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x03, 0x81, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC0,
  0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x1F, 0x00,
  0x7C, 0x03, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x01, 0xF0, 0x3F, 0x80, 0xF8, 0x00, 0x3C, 0x1B,
  0xF9, 0xFF, 0xFD, 0x87, 0xC4, 0x0C, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 7, 18, 15, 4, -18 },
  { 17, 9, 8, 15, 5, -20 },
  { 26, 15, 18, 15, 0, -18 },
  { 60, 14, 23, 15, 1, -20 },
  { 101, 18, 18, 15, -1, -18 },
  { 142, 14, 18, 15, 0, -18 },
  { 174, 5, 8, 15, 7, -20 },
  { 179, 11, 26, 15, 3, -21 },
  { 215, 12, 26, 15, 0, -21 },
  { 254, 11, 11, 15, 3, -18 },
  { 270, 13, 13, 15, 1, -14 },
  { 292, 7, 8, 15, 2, -4 },
  { 299, 7, 3, 15, 4, -9 },
  { 302, 4, 4, 15, 4, -4 },
  { 304, 17, 25, 15, -2, -20 },
  { 358, 13, 18, 15, 1, -18 },
  { 388, 11, 18, 15, 1, -18 },
  { 413, 13, 18, 15, 1, -18 },
  { 443, 14, 18, 15, 0, -18 },
  { 475, 14, 18, 15, 0, -18 },
  { 507, 15, 18, 15, 0, -18 },
  { 541, 14, 18, 15, 1, -18 },
  { 573, 13, 18, 15, 3, -18 },
  { 603, 14, 18, 15, 1, -18 },
  { 635, 13, 18, 15, 1, -18 },
  { 665, 7, 13, 15, 4, -13 },
  { 677, 9, 17, 15, 2, -13 },
  { 697, 13, 12, 15, 1, -13 },
  { 717, 13, 8, 15, 1, -12 },
  { 730, 13, 12, 15, 1, -13 },
  { 750, 10, 18, 15, 4, -18 },
  { 773, 14, 22, 15, 1, -18 },
  { 812, 14, 18, 15, -1, -18 },
  { 844, 14, 18, 15, 0, -18 },
  { 876, 15, 18, 15, 1, -18 },
  { 910, 14, 18, 15, 0, -18 },
  { 942, 14, 18, 15, 1, -18 },
  { 974, 15, 18, 15, 1, -18 },
  { 1008, 14, 18, 15, 1, -18 },
  { 1040, 16, 18, 15, 0, -18 },
  { 1076, 14, 18, 15, 1, -18 },
  { 1108, 15, 18, 15, 0, -18 },
  { 1142, 16, 18, 15, 0, -18 },
  { 1178, 12, 18, 15, 0, -18 },
  { 1205, 16, 18, 15, -1, -18 },
  { 1241, 16, 18, 15, 0, -18 },
  { 1277, 14, 18, 15, 1, -18 },
  { 1309, 15, 18, 15, 0, -18 },
  { 1343, 14, 23, 15, 1, -18 },
  { 1384, 14, 18, 15, 0, -18 },
  { 1416, 15, 18, 15, 0, -18 },
  { 1450, 13, 18, 15, 3, -18 },
  { 1480, 15, 18, 15, 1, -18 },
  { 1514, 14, 18, 15, 3, -18 },
  { 1546, 16, 18, 15, 0, -18 },
  { 1582, 18, 18, 15, -1, -18 },
  { 1623, 14, 18, 15, 3, -18 },
  { 1655, 16, 18, 15, 0, -18 },
  { 1691, 13, 25, 15, 2, -20 },
  { 1732, 5, 25, 15, 5, -20 },
  { 1748, 14, 25, 15, -1, -20 },
  { 1792, 12, 10, 15, 2, -18 },
  { 1807, 14, 3, 15, -2, 2 },
  { 1813, 6, 5, 15, 6, -20 },
  { 1817, 13, 14, 15, 1, -14 },
  { 1840, 14, 20, 15, 0, -20 },
  { 1875, 13, 14, 15, 1, -14 },
  { 1898, 15, 20, 15, 1, -20 },
  { 1936, 13, 14, 15, 1, -14 },
  { 1959, 17, 25, 15, -1, -20 },
  { 2013, 15, 19, 15, -1, -14 },
  { 2049, 13, 20, 15, 0, -20 },
  { 2082, 9, 20, 15, 3, -20 },
  { 2105, 15, 25, 15, -1, -20 },
  { 2152, 14, 20, 15, 1, -20 },
  { 2187, 8, 20, 15, 4, -20 },
  { 2207, 14, 14, 15, 0, -14 },
  { 2232, 12, 14, 15, 1, -14 },
  { 2253, 13, 14, 15, 1, -14 },
  { 2276, 15, 19, 15, -1, -14 },
  { 2312, 13, 19, 15, 1, -14 },
  { 2343, 13, 14, 15, 1, -14 },
  { 2366, 13, 14, 15, 1, -14 },
  { 2389, 11, 18, 15, 3, -18 },
  { 2414, 13, 14, 15, 1, -14 },
  { 2437, 13, 14, 15, 2, -14 },
  { 2460, 15, 14, 15, 1, -14 },
  { 2487, 16, 14, 15, -1, -14 },
  { 2515, 17, 19, 15, -2, -14 },
  { 2556, 14, 14, 15, 0, -14 },
  { 2581, 14, 25, 15, 2, -20 },
  { 2625, 9, 25, 15, 3, -20 },
  { 2654, 14, 25, 15, -1, -20 },
  { 2698, 13, 5, 15, 1, -10 },
};

const GFXfont UbuntuSansMono_MediumItalic26pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic26pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic26pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC26PT7B_H_
