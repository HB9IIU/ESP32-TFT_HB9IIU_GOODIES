#ifndef _UBUNTUSANSMONO_MEDIUMITALIC71PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x9F, 0xE0, 0x3F,
  0xCF, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFC, 0x07,
  0xF9, 0xFE, 0x03, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0x80,
  0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0x87, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7C,
  0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0xF0, 0x00, 0x38, 0x00, 0xFF,
  0x80, 0x00, 0x20, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x10,
  0x00, 0x01, 0xFF, 0x00, 0x70, 0x00, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0,
  0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0xC0,
  0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0xF8, 0x0F, 0x81, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0x83, 0xF8, 0x00,
  0x00, 0xF8, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x7E, 0x1F, 0x80, 0x00,
  0x00, 0xFF, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x20, 0x00,
  0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0xFC, 0x3F, 0xBF, 0x80, 0x00, 0x01, 0xF8, 0x7E, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x7C, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0xFC, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0xF8, 0x0F, 0x80,
  0x00, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF0, 0x1F, 0x80,
  0x00, 0x7F, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x3F, 0x00,
  0x03, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x03, 0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x03, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0x01, 0xFF, 0xFC,
  0x07, 0xF0, 0x3F, 0xFF, 0xC0, 0x7E, 0x07, 0xF9, 0xFE, 0x0F, 0xE0, 0xFF,
  0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xC1, 0xFC, 0x07, 0xF9, 0xFC,
  0x3F, 0x80, 0x7F, 0x9F, 0x83, 0xF8, 0x03, 0xFF, 0xF8, 0x7F, 0x00, 0x1F,
  0xFF, 0x07, 0xF0, 0x01, 0xFF, 0xF0, 0x7F, 0x00, 0x0F, 0xFE, 0x0F, 0xF0,
  0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x1F,
  0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x7F, 0x01, 0xFF, 0xFF, 0x87, 0xF8,
  0x0F, 0xFF, 0xF0, 0x7F, 0x80, 0x7F, 0xF8, 0x03, 0xF8, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0xF1, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE3, 0xFE, 0x3F,
  0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0x7F,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x18, 0x07,
  0xE0, 0x0C, 0x7E, 0x0F, 0xC0, 0xF8, 0xFE, 0x0F, 0x87, 0xF9, 0xFF, 0x1F,
  0x3F, 0xF7, 0xFF, 0xBE, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFF, 0x1F, 0xE0,
  0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0,
  0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0xE0, 0x00,
  0x08, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFE, 0x07,
  0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xC0,
  0x01, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0x0F, 0x83, 0xFE, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xC7, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE,
  0x07, 0x80, 0xFF, 0x1F, 0xC0, 0xFC, 0x0F, 0xF3, 0xFC, 0x1F, 0xE0, 0xFF,
  0x3F, 0xC3, 0xFE, 0x0F, 0xE3, 0xFC, 0x3F, 0xE0, 0xFE, 0x3F, 0x83, 0xFE,
  0x1F, 0xE7, 0xF8, 0x3F, 0xE1, 0xFE, 0x7F, 0x83, 0xFC, 0x1F, 0xE7, 0xF8,
  0x3F, 0xC1, 0xFC, 0x7F, 0x81, 0xF8, 0x3F, 0xC7, 0xF0, 0x06, 0x03, 0xFC,
  0x7F, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x7F, 0x80, 0x0F, 0xF8,
  0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0x70, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x3E,
  0x00, 0x0F, 0xF8, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x04, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC3, 0xFF, 0xC0, 0x01, 0xF0,
  0x03, 0xFF, 0x00, 0x04, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x81, 0x00,
  0x00, 0x0F, 0xF8, 0x0E, 0x00, 0x01, 0xFF, 0xC0, 0x7C, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x38, 0x00, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x30, 0x00, 0x01, 0xFE, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03,
  0xFF, 0xCF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x07, 0xFE, 0xFF, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x07, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F,
  0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x87, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x7F, 0x80, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0x81, 0xFF, 0xC0, 0xE0,
  0x03, 0xFE, 0x04, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0E, 0xFE, 0x07, 0xF0,
  0x01, 0xFF, 0xFE, 0x0F, 0xE0, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x1F, 0xFF,
  0xFE, 0x1F, 0xC0, 0x3F, 0xFF, 0xFC, 0x1F, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F,
  0x80, 0xFF, 0xFF, 0xFC, 0x3F, 0x81, 0xFF, 0x01, 0xFC, 0x3F, 0x81, 0xFE,
  0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x03, 0xF8,
  0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x07,
  0xF0, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0,
  0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07,
  0xFE, 0x3F, 0x80, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC7, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0x80, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xFF, 0x01,
  0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x30, 0x01,
  0xFF, 0x00, 0x00, 0x20, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x20, 0x00, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xFF, 0xE0, 0x0F,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xE0, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xFE,
  0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0,
  0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x00, 0x30, 0x01, 0xFF,
  0x80, 0x00, 0x20, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x02, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x08, 0x00, 0x03, 0xFC, 0x00, 0x1C, 0x00, 0x07, 0xFC, 0x00, 0x1E,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xEF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFB, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x87, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xBE, 0x01, 0xF7,
  0xE0, 0x01, 0xFB, 0xE0, 0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x03, 0xEF, 0xC0,
  0x03, 0xF3, 0xE0, 0x7E, 0xFC, 0x00, 0x3F, 0x3E, 0x07, 0xCF, 0xC0, 0x03,
  0xF3, 0xE0, 0xFC, 0xFC, 0x00, 0x7F, 0x3E, 0x0F, 0x9F, 0xC0, 0x07, 0xE3,
  0xE1, 0xF9, 0xF8, 0x00, 0x7E, 0x3E, 0x1F, 0x1F, 0x80, 0x0F, 0xE3, 0xF3,
  0xE1, 0xF8, 0x00, 0xFE, 0x3F, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF7, 0xC3,
  0xF8, 0x00, 0xFC, 0x1F, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFF, 0x83, 0xF0,
  0x01, 0xFC, 0x1F, 0xF8, 0x3F, 0x00, 0x1F, 0x81, 0xFF, 0x07, 0xF0, 0x03,
  0xF8, 0x1F, 0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x03, 0xF8,
  0x1F, 0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F,
  0x80, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x01,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xEF, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x9F,
  0x80, 0x1F, 0xC0, 0x07, 0xF3, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x03, 0xF8,
  0x00, 0xFE, 0x1F, 0x80, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x1F, 0xC0, 0x07,
  0xF0, 0x3F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0xC0,
  0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x01, 0xF8,
  0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xE1, 0xFC,
  0x00, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xCF, 0xE0, 0x03,
  0xF8, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xEF, 0xE0, 0x03, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xBF, 0x80, 0x0F, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x01,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xF0,
  0x00, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x03,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xF8, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x0F,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x07, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFC, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE7, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x00, 0x10, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x20, 0x00,
  0x03, 0xFE, 0x00, 0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFE, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0xFE, 0x7F,
  0x80, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7F,
  0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0x81,
  0xFC, 0x00, 0xFE, 0x0F, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xFF, 0x83, 0xF8,
  0x00, 0xFC, 0x1F, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xEF, 0x83, 0xF0, 0x01,
  0xFC, 0x7E, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xCF, 0xC7, 0xF0, 0x01, 0xF8,
  0xFC, 0x7C, 0x7E, 0x00, 0x1F, 0x8F, 0x87, 0xC7, 0xE0, 0x01, 0xF9, 0xF8,
  0x7C, 0x7E, 0x00, 0x3F, 0x1F, 0x07, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x7C,
  0xFC, 0x00, 0x3F, 0x3E, 0x07, 0xCF, 0xC0, 0x03, 0xF7, 0xE0, 0x7C, 0xFC,
  0x00, 0x3F, 0x7C, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x7D, 0xF8, 0x00,
  0x7F, 0xF8, 0x07, 0xDF, 0x80, 0x07, 0xFF, 0x00, 0x7D, 0xF0, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xBF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x00, 0x3F, 0xE1, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x03, 0xFE, 0x3F,
  0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F,
  0xC7, 0x80, 0x00, 0x0F, 0x80, 0xC0, 0x00, 0x01, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x18, 0x00, 0x78, 0x01,
  0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFE, 0x03,
  0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xE0, 0x01, 0xFC, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xDF, 0xE0, 0x07, 0xFF, 0xF8, 0xFE, 0x00, 0x3F, 0xFE,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0xBF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0x0F,
  0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xC0,
  0x07, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1C, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x06, 0x03, 0xFF,
  0xC0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFD, 0xFC, 0x00, 0x0F,
  0xFF, 0xF1, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0xFF, 0xF0, 0x1F, 0xF8, 0x03,
  0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x01, 0xFC, 0x7F,
  0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x07, 0xFC,
  0x7F, 0x80, 0x03, 0xFF, 0x8F, 0xE0, 0x07, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x06, 0x03, 0xFF, 0x80, 0x07, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xFF,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xCF, 0xE0, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x07, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x3F,
  0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xC7, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xC0,
  0x0F, 0xFC, 0x00, 0x07, 0xF9, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x07,
  0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xC3, 0xFF, 0x00, 0x00,
  0x7F, 0x8F, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x03, 0xFD, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x3F, 0xC1,
  0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xF8,
  0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x02, 0x3F, 0xF0, 0x1C, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xF8, 0x03, 0xC0, 0x00, 0x1F, 0xFE, 0x0F, 0xF8, 0x00, 0x7F,
  0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x3F, 0xFD, 0xFF, 0x01,
  0xFC, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F,
  0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0xFE,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xCF,
  0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC,
  0x3F, 0xE0, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x81, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0x80,
  0x7F, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0xF0, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFB, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x03,
  0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xF0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x0F, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFD, 0xFE, 0x00, 0x00, 0x7E, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x78, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3C, 0x00, 0xFF, 0x00, 0x01,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x20, 0x00, 0x07, 0xF8, 0x07, 0x00, 0x01, 0xFF,
  0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x40, 0x3F, 0xF8, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xEF, 0xF0, 0x07, 0xFF, 0xF8, 0xFE, 0x00,
  0x7F, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x02, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x0F, 0xF9, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x7C, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x03,
  0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x7F,
  0x03, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xFE,
  0x0F, 0xE0, 0x7E, 0x07, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xFE, 0x1F, 0xC0,
  0x7E, 0x0F, 0xBE, 0x1F, 0x80, 0x7E, 0x1F, 0xBE, 0x1F, 0x80, 0x7E, 0x3F,
  0x3E, 0x3F, 0x80, 0xFE, 0x3F, 0x3E, 0x3F, 0x00, 0xFE, 0x7E, 0x3E, 0x3F,
  0x00, 0xFC, 0x7E, 0x3E, 0x7F, 0x00, 0xFC, 0xFC, 0x3E, 0x7E, 0x00, 0xFC,
  0xF8, 0x3E, 0x7E, 0x00, 0xFD, 0xF8, 0x3E, 0xFC, 0x00, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x07, 0xFB,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF1, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x08, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x79, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x02, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0x80, 0x1F, 0xFE,
  0x00, 0x1F, 0xC1, 0xFF, 0xFC, 0x00, 0xFC, 0x1F, 0xFF, 0xF0, 0x0F, 0xE1,
  0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0x00, 0xFF, 0xFF, 0x83, 0xF0,
  0x03, 0xFF, 0xF8, 0x3F, 0x00, 0x0F, 0xFF, 0x80, 0x38, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 20, 50, 40, 11, -49 },
  { 126, 25, 21, 40, 14, -54 },
  { 192, 42, 49, 40, 0, -49 },
  { 450, 38, 63, 40, 2, -55 },
  { 750, 48, 51, 40, -3, -50 },
  { 1056, 36, 51, 40, 1, -50 },
  { 1286, 12, 22, 40, 20, -54 },
  { 1319, 31, 69, 40, 8, -56 },
  { 1587, 31, 69, 40, 1, -56 },
  { 1855, 31, 30, 40, 8, -49 },
  { 1972, 34, 35, 40, 3, -38 },
  { 2121, 18, 24, 40, 5, -12 },
  { 2175, 21, 8, 40, 10, -24 },
  { 2196, 12, 13, 40, 11, -12 },
  { 2216, 46, 69, 40, -4, -56 },
  { 2613, 36, 51, 40, 3, -50 },
  { 2843, 31, 49, 40, 3, -49 },
  { 3033, 37, 50, 40, 2, -50 },
  { 3265, 37, 51, 40, 1, -50 },
  { 3501, 38, 49, 40, 1, -49 },
  { 3734, 40, 50, 40, 1, -49 },
  { 3984, 37, 51, 40, 4, -50 },
  { 4220, 37, 49, 40, 7, -49 },
  { 4447, 37, 51, 40, 3, -50 },
  { 4683, 38, 50, 40, 2, -50 },
  { 4921, 18, 38, 40, 11, -37 },
  { 5007, 24, 49, 40, 5, -37 },
  { 5154, 36, 33, 40, 3, -37 },
  { 5303, 38, 22, 40, 1, -32 },
  { 5408, 35, 33, 40, 2, -37 },
  { 5553, 29, 51, 40, 10, -50 },
  { 5738, 40, 61, 40, 2, -50 },
  { 6043, 39, 49, 40, -4, -49 },
  { 6282, 39, 51, 40, 0, -50 },
  { 6531, 39, 51, 40, 4, -50 },
  { 6780, 39, 51, 40, 0, -50 },
  { 7029, 40, 49, 40, 2, -49 },
  { 7274, 41, 49, 40, 2, -49 },
  { 7526, 39, 51, 40, 3, -50 },
  { 7775, 44, 49, 40, -1, -49 },
  { 8045, 40, 49, 40, 1, -49 },
  { 8290, 40, 50, 40, 1, -49 },
  { 8540, 44, 49, 40, 0, -49 },
  { 8810, 31, 49, 40, 1, -49 },
  { 9000, 44, 49, 40, -2, -49 },
  { 9270, 43, 49, 40, 0, -49 },
  { 9534, 37, 51, 40, 3, -50 },
  { 9770, 39, 50, 40, 1, -50 },
  { 10014, 37, 63, 40, 3, -50 },
  { 10306, 39, 50, 40, 0, -50 },
  { 10550, 39, 51, 40, 1, -50 },
  { 10799, 36, 49, 40, 8, -49 },
  { 11020, 40, 50, 40, 3, -49 },
  { 11270, 38, 49, 40, 8, -49 },
  { 11503, 44, 49, 40, 1, -49 },
  { 11773, 47, 49, 40, -2, -49 },
  { 12061, 37, 49, 40, 9, -49 },
  { 12288, 42, 49, 40, 0, -49 },
  { 12546, 36, 69, 40, 5, -56 },
  { 12857, 14, 69, 40, 14, -56 },
  { 12978, 37, 69, 40, -1, -56 },
  { 13298, 34, 27, 40, 5, -49 },
  { 13413, 37, 7, 40, -5, 6 },
  { 13446, 15, 15, 40, 17, -55 },
  { 13475, 36, 39, 40, 2, -38 },
  { 13651, 36, 56, 40, 1, -55 },
  { 13903, 35, 39, 40, 3, -38 },
  { 14074, 40, 56, 40, 3, -55 },
  { 14354, 35, 39, 40, 3, -38 },
  { 14525, 48, 68, 40, -4, -55 },
  { 14933, 41, 51, 40, -2, -38 },
  { 15195, 36, 55, 40, 0, -55 },
  { 15443, 25, 56, 40, 7, -55 },
  { 15618, 39, 68, 40, -2, -55 },
  { 15950, 39, 55, 40, 2, -55 },
  { 16219, 23, 56, 40, 10, -55 },
  { 16380, 40, 38, 40, -1, -38 },
  { 16570, 35, 38, 40, 1, -38 },
  { 16737, 34, 39, 40, 3, -38 },
  { 16903, 39, 51, 40, -2, -38 },
  { 17152, 36, 51, 40, 3, -38 },
  { 17382, 36, 38, 40, 3, -38 },
  { 17553, 35, 39, 40, 2, -38 },
  { 17724, 31, 49, 40, 7, -48 },
  { 17914, 35, 38, 40, 3, -37 },
  { 18081, 33, 37, 40, 7, -37 },
  { 18234, 40, 37, 40, 3, -37 },
  { 18419, 42, 37, 40, -2, -37 },
  { 18614, 45, 50, 40, -5, -37 },
  { 18896, 37, 37, 40, 1, -37 },
  { 19068, 39, 69, 40, 4, -56 },
  { 19405, 25, 69, 40, 8, -56 },
  { 19621, 38, 69, 40, -3, -56 },
  { 19949, 37, 13, 40, 2, -27 },
};

const GFXfont UbuntuSansMono_MediumItalic71pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic71pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic71pt7bGlyphs,
  0x20, 0x7E, 85
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC71PT7B_H_
