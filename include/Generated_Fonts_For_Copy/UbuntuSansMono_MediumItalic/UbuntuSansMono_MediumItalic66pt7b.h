#ifndef _UBUNTUSANSMONO_MEDIUMITALIC66PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00,
  0xFE, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x7F, 0x83, 0xFC, 0xFE,
  0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xCF, 0xF0, 0x3F, 0x9F, 0xC0,
  0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x0F,
  0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8,
  0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x1E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80,
  0xFE, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0x3F,
  0xE0, 0x00, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x02, 0x00, 0x00, 0xFF,
  0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x3E, 0x00,
  0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0xFC,
  0x00, 0x1F, 0x03, 0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x00,
  0x1F, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x00, 0x3E,
  0x03, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x07,
  0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0x8F,
  0xC0, 0x00, 0x01, 0xFB, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x1F, 0x80,
  0x00, 0x00, 0xFF, 0xE3, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xC7, 0xFF, 0x00, 0x00, 0x01, 0xF8,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xE1, 0xF0,
  0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x0F, 0x80, 0x00, 0x0F, 0xC3, 0xE0, 0xF8,
  0x00, 0x01, 0xF8, 0x7C, 0x0F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0xF8, 0x00,
  0x07, 0xE0, 0x7C, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0x81, 0xF8, 0x00, 0x3F, 0x00,
  0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x00, 0xFC, 0x00, 0xF8,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF8,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x81,
  0x00, 0x01, 0xFF, 0x80, 0x7F, 0x01, 0xFF, 0xF0, 0x1F, 0x80, 0xFF, 0xFC,
  0x07, 0xE0, 0x7F, 0xFF, 0x83, 0xF8, 0x3F, 0xCF, 0xE0, 0xFC, 0x1F, 0xC1,
  0xFC, 0x3F, 0x07, 0xE0, 0x7F, 0x9F, 0x83, 0xF8, 0x0F, 0xE7, 0xE1, 0xFC,
  0x01, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0xFC, 0x1F, 0x80, 0x0F, 0xFE, 0x0F,
  0xE0, 0x01, 0xFF, 0x83, 0xF8, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF,
  0xC0, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE7, 0xF0, 0x3F, 0xFF, 0xF1, 0xFC, 0x07, 0xFF,
  0xF0, 0x7F, 0x80, 0x7F, 0xF0, 0x0F, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x1F,
  0xE3, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xE1, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0x01, 0xF8, 0x0C, 0x3E, 0x0F, 0x81,
  0xF3, 0xFC, 0x7C, 0x3F, 0x9F, 0xF3, 0xE7, 0xFC, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x80,
  0x3F, 0xE1, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0x1F,
  0x01, 0xF8, 0x00, 0x70, 0x07, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xC0, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFF,
  0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0x7F, 0x81, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0x01, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x10, 0x0F, 0xE7,
  0xF8, 0x3E, 0x07, 0xF3, 0xF8, 0x3F, 0x83, 0xF9, 0xFC, 0x3F, 0xC1, 0xFD,
  0xFE, 0x1F, 0xE1, 0xFE, 0xFE, 0x0F, 0xF0, 0xFE, 0x7F, 0x07, 0xF8, 0x7F,
  0x3F, 0x83, 0xFC, 0x3F, 0x9F, 0xC1, 0xFC, 0x1F, 0xDF, 0xE0, 0x7C, 0x1F,
  0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFB, 0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0x83, 0xF8,
  0x01, 0xE0, 0x7F, 0x80, 0x08, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x01, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFC, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x07, 0x00, 0x03, 0xFC,
  0x00, 0x40, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x3F, 0xFC,
  0x00, 0x78, 0x01, 0xFF, 0x00, 0x08, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x80, 0x00, 0x1F, 0xF0, 0x38, 0x00, 0x1F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x80, 0x00, 0x3F, 0xE0, 0x07, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xC3, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFD, 0xFF, 0xE0,
  0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xE2, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xF8,
  0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0xC7, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC7, 0xFE,
  0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0xFF,
  0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F,
  0xFE, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xBF, 0x80, 0x01, 0xFF, 0xCF,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x81, 0xF8, 0x3F, 0xF8, 0x38, 0x01, 0xFF, 0x04, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0x80,
  0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x7F, 0xFE, 0x0F, 0xC0, 0x1F, 0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0xFF,
  0x87, 0xE0, 0x1F, 0xFF, 0xFC, 0x3F, 0x01, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F,
  0xFF, 0xFE, 0x1F, 0x81, 0xFE, 0x07, 0xF0, 0xFC, 0x0F, 0xE0, 0x3F, 0x8F,
  0xE0, 0xFE, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x7F, 0x00,
  0xFE, 0x1F, 0x83, 0xF8, 0x07, 0xF0, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xE1,
  0xFC, 0x01, 0xF8, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x7F, 0x00, 0xFE,
  0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0xFE,
  0x03, 0xF8, 0x3F, 0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x3F, 0x80, 0xFC, 0x0F,
  0xC1, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0xFF,
  0xF8, 0x1F, 0x80, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0x80, 0x3F, 0xFF, 0x00, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x40, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xF0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07,
  0xFC, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0xFF, 0x83, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x03, 0xFF, 0x03,
  0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x78, 0x00, 0xFF, 0x80, 0x01, 0x80,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x04, 0x00, 0x7F, 0xE0, 0x03, 0xC0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x7F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x81,
  0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x3F,
  0xE0, 0x3F, 0x80, 0x07, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0x80,
  0x3F, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7C, 0x00, 0xFF,
  0xC0, 0x01, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFF, 0xE7, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x04, 0x00, 0x07, 0xF8, 0x00, 0x70, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x0F,
  0xFC, 0x00, 0x3F, 0xE3, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80,
  0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x00, 0x03,
  0xF8, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x7F,
  0xC0, 0x00, 0x00, 0xFE, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x03, 0xEF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xEF, 0x81,
  0xF7, 0xC0, 0x03, 0xE7, 0xC0, 0xFB, 0xE0, 0x01, 0xF3, 0xE0, 0xF9, 0xF0,
  0x01, 0xF9, 0xF0, 0x7D, 0xF8, 0x00, 0xFC, 0xF8, 0x7C, 0xFC, 0x00, 0x7C,
  0x7C, 0x7C, 0x7E, 0x00, 0x7E, 0x3E, 0x3E, 0x3E, 0x00, 0x3F, 0x1F, 0x3E,
  0x3F, 0x00, 0x1F, 0x8F, 0x9F, 0x1F, 0x80, 0x1F, 0x87, 0xDF, 0x0F, 0xC0,
  0x0F, 0xC3, 0xEF, 0x87, 0xE0, 0x07, 0xE1, 0xFF, 0x83, 0xF0, 0x03, 0xF0,
  0x7F, 0xC3, 0xF0, 0x03, 0xF0, 0x3F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0xE0,
  0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x7F, 0x00,
  0x7E, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0xE0,
  0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFD, 0xF8, 0x01,
  0xF8, 0x00, 0xFD, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0xFC, 0x03, 0xF8, 0x01,
  0xFC, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x7C,
  0x07, 0xF0, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x7E, 0x07, 0xF0,
  0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x07, 0xF0,
  0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x0F,
  0xC0, 0x07, 0xE0, 0x1F, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0x1F, 0xC0, 0x0F,
  0xE0, 0x1F, 0x9F, 0xC0, 0x0F, 0xE0, 0x1F, 0x9F, 0x80, 0x0F, 0xC0, 0x1F,
  0x9F, 0x80, 0x0F, 0xC0, 0x0F, 0xBF, 0x80, 0x1F, 0xC0, 0x0F, 0xBF, 0x80,
  0x1F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0x80,
  0x07, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x03,
  0xFC, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x01, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x80,
  0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x7F,
  0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF3,
  0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x07, 0xFB, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC,
  0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F,
  0xC0, 0x1F, 0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80,
  0x7F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F,
  0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3C, 0x00, 0x7F, 0x80,
  0x00, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x03, 0x00, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0x0F,
  0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0x7F, 0xE3, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xF8,
  0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x03, 0xF8, 0x3F, 0x81,
  0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x1F, 0xE0, 0x7E, 0x00,
  0x7E, 0x0F, 0xF0, 0x3F, 0x00, 0x3F, 0x0F, 0xF8, 0x3F, 0x00, 0x3F, 0x07,
  0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xDE, 0x0F, 0xC0, 0x0F, 0xC3, 0xEF, 0x87,
  0xE0, 0x07, 0xE3, 0xE7, 0xC7, 0xE0, 0x03, 0xF1, 0xF3, 0xE3, 0xF0, 0x01,
  0xF1, 0xF1, 0xF1, 0xF8, 0x01, 0xF8, 0xF8, 0xF8, 0xF8, 0x00, 0xFC, 0xF8,
  0x7C, 0xFC, 0x00, 0x7E, 0xFC, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x1F, 0x3E,
  0x00, 0x1F, 0x7E, 0x0F, 0x9F, 0x00, 0x0F, 0xBE, 0x07, 0xDF, 0x80, 0x0F,
  0xFE, 0x01, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0xF7, 0xC0, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x1F,
  0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07,
  0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x07, 0xF0,
  0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01,
  0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x07, 0xF1, 0xFE, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8,
  0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFC,
  0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE,
  0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7E,
  0x0E, 0x00, 0x00, 0x78, 0x04, 0x00, 0x00, 0x40, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x08,
  0x00, 0x70, 0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x70, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFC, 0x07, 0xF0, 0x0F, 0xFC, 0x01, 0xFC, 0x07, 0xFC, 0x00, 0x7F,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xFC, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFB, 0xF8, 0x03, 0xFF, 0xF8, 0xFE, 0x00, 0x3F,
  0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03, 0xFC,
  0x3F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x1F, 0xC0, 0x03, 0xFE,
  0x0F, 0xE0, 0x03, 0xFE, 0x07, 0xF0, 0x03, 0xFF, 0x07, 0xF8, 0x07, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x70, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x04, 0x07, 0xFE, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x07, 0xFE, 0x00, 0x3F, 0xF1, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF7, 0xF0, 0x00, 0x7F, 0xFF,
  0x3F, 0x80, 0x01, 0xFF, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFF,
  0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x07, 0xFE,
  0xFF, 0x00, 0x1F, 0xFC, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xC0, 0x7F, 0xFC, 0x3F, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x81, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xF8,
  0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x7F, 0x00, 0x00,
  0x1F, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x18, 0x00, 0x0F,
  0xF8, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x0F, 0xFE,
  0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x03,
  0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x01, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x06, 0x00, 0x1F, 0xE0, 0x00,
  0x3E, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x10, 0x0F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xE0,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x03, 0xF8, 0x1F,
  0xF0, 0x00, 0x3F, 0x83, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x7F,
  0x9F, 0xF0, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0xC0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x1F, 0xC7, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE2, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0x9F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0x80, 0x03, 0xFF, 0xE3,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0xFF, 0x0F,
  0xE0, 0x3F, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x00,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F,
  0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00,
  0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xFC, 0x01,
  0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xBE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFC, 0x0F, 0xFC, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8,
  0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFE,
  0x03, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xEF,
  0xE0, 0x00, 0x0F, 0x87, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF7, 0xF8, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x3C, 0x01, 0xFE, 0x00, 0x04,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x10, 0x00, 0x0F, 0xF0, 0x3C, 0x00, 0x1F, 0xE0,
  0x3F, 0xC1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x02, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x18, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xFC,
  0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC7, 0xF0, 0x03, 0xFF, 0xC3, 0xF8, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x7F,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x3F,
  0x8F, 0xE0, 0x3F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F,
  0xC0, 0xFE, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0xFC, 0x0F, 0xF0, 0x3F, 0x07,
  0xE0, 0x7F, 0x83, 0xF8, 0x3F, 0x07, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0xE0,
  0xFC, 0x0F, 0xC3, 0xFF, 0x0F, 0xC0, 0xFC, 0x1F, 0xF8, 0x7E, 0x07, 0xE1,
  0xF7, 0xC3, 0xF0, 0x3F, 0x0F, 0xBE, 0x3F, 0x01, 0xF8, 0xF9, 0xF1, 0xF8,
  0x0F, 0xCF, 0xCF, 0x8F, 0xC0, 0x7E, 0x7C, 0x7C, 0xFC, 0x03, 0xF7, 0xE1,
  0xF7, 0xE0, 0x1F, 0xBE, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x07,
  0xDF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x00, 0x7F, 0xC3, 0xF8, 0x00, 0x00,
  0xFF, 0x83, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xC0, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x06, 0x00, 0xFF, 0xE0, 0x03, 0xF0, 0xFF, 0xFE, 0x01, 0xF8,
  0x7F, 0xFF, 0xC0, 0x7E, 0x1F, 0xFF, 0xFC, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC7, 0xF8, 0xFF, 0xFF, 0xE1, 0xF8, 0x0F, 0xFF, 0xF8, 0xFE, 0x01, 0xFF,
  0xFC, 0x3F, 0x00, 0x1F, 0xFC, 0x01, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x08, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 19, 47, 37, 10, -46 },
  { 113, 23, 19, 37, 13, -50 },
  { 168, 39, 46, 37, 0, -46 },
  { 393, 35, 58, 37, 2, -51 },
  { 647, 44, 48, 37, -2, -47 },
  { 911, 34, 48, 37, 1, -47 },
  { 1115, 11, 21, 37, 19, -50 },
  { 1144, 28, 64, 37, 8, -52 },
  { 1368, 29, 64, 37, 1, -52 },
  { 1600, 29, 28, 37, 7, -46 },
  { 1702, 32, 33, 37, 3, -36 },
  { 1834, 17, 22, 37, 5, -11 },
  { 1881, 20, 7, 37, 9, -22 },
  { 1899, 12, 12, 37, 10, -11 },
  { 1917, 43, 64, 37, -4, -52 },
  { 2261, 33, 48, 37, 3, -47 },
  { 2459, 28, 46, 37, 3, -46 },
  { 2620, 35, 47, 37, 1, -47 },
  { 2826, 34, 48, 37, 1, -47 },
  { 3030, 35, 46, 37, 1, -46 },
  { 3232, 37, 47, 37, 1, -46 },
  { 3450, 34, 47, 37, 4, -46 },
  { 3650, 34, 46, 37, 7, -46 },
  { 3846, 34, 48, 37, 3, -47 },
  { 4050, 35, 47, 37, 2, -47 },
  { 4256, 17, 35, 37, 10, -34 },
  { 4331, 22, 45, 37, 5, -34 },
  { 4455, 33, 30, 37, 3, -34 },
  { 4579, 35, 21, 37, 1, -30 },
  { 4671, 33, 30, 37, 1, -34 },
  { 4795, 27, 48, 37, 9, -47 },
  { 4957, 37, 57, 37, 2, -47 },
  { 5221, 36, 46, 37, -4, -46 },
  { 5428, 36, 46, 37, 0, -46 },
  { 5635, 36, 48, 37, 4, -47 },
  { 5851, 36, 46, 37, 0, -46 },
  { 6058, 37, 46, 37, 2, -46 },
  { 6271, 38, 46, 37, 2, -46 },
  { 6490, 36, 48, 37, 3, -47 },
  { 6706, 40, 46, 37, 0, -46 },
  { 6936, 37, 46, 37, 1, -46 },
  { 7149, 37, 47, 37, 1, -46 },
  { 7367, 41, 46, 37, 0, -46 },
  { 7603, 28, 46, 37, 1, -46 },
  { 7764, 41, 46, 37, -2, -46 },
  { 8000, 40, 46, 37, 0, -46 },
  { 8230, 34, 48, 37, 3, -47 },
  { 8434, 37, 46, 37, 1, -46 },
  { 8647, 34, 59, 37, 3, -47 },
  { 8898, 36, 46, 37, 0, -46 },
  { 9105, 36, 48, 37, 1, -47 },
  { 9321, 33, 46, 37, 8, -46 },
  { 9511, 37, 47, 37, 3, -46 },
  { 9729, 36, 46, 37, 7, -46 },
  { 9936, 41, 46, 37, 1, -46 },
  { 10172, 44, 46, 37, -2, -46 },
  { 10425, 35, 46, 37, 8, -46 },
  { 10627, 39, 46, 37, 0, -46 },
  { 10852, 35, 64, 37, 4, -52 },
  { 11132, 13, 64, 37, 13, -52 },
  { 11236, 34, 64, 37, -1, -52 },
  { 11508, 32, 26, 37, 4, -46 },
  { 11612, 35, 6, 37, -5, 6 },
  { 11639, 14, 13, 37, 16, -51 },
  { 11662, 34, 36, 37, 2, -35 },
  { 11815, 33, 52, 37, 1, -51 },
  { 12030, 33, 36, 37, 3, -35 },
  { 12179, 37, 52, 37, 3, -51 },
  { 12420, 32, 36, 37, 3, -35 },
  { 12564, 44, 63, 37, -3, -51 },
  { 12911, 39, 47, 37, -2, -35 },
  { 13141, 33, 51, 37, 0, -51 },
  { 13352, 24, 51, 37, 6, -51 },
  { 13505, 37, 63, 37, -2, -51 },
  { 13797, 36, 51, 37, 2, -51 },
  { 14027, 21, 52, 37, 9, -51 },
  { 14164, 37, 35, 37, -1, -35 },
  { 14326, 33, 35, 37, 1, -35 },
  { 14471, 32, 36, 37, 3, -35 },
  { 14615, 37, 47, 37, -2, -35 },
  { 14833, 33, 47, 37, 3, -35 },
  { 15027, 33, 35, 37, 3, -35 },
  { 15172, 32, 36, 37, 2, -35 },
  { 15316, 29, 46, 37, 7, -45 },
  { 15483, 33, 35, 37, 3, -34 },
  { 15628, 31, 34, 37, 6, -34 },
  { 15760, 37, 34, 37, 3, -34 },
  { 15918, 40, 34, 37, -2, -34 },
  { 16088, 42, 46, 37, -5, -34 },
  { 16330, 35, 34, 37, 1, -34 },
  { 16479, 36, 64, 37, 4, -52 },
  { 16767, 22, 64, 37, 8, -52 },
  { 16943, 36, 64, 37, -3, -52 },
  { 17231, 34, 12, 37, 2, -25 },
};

const GFXfont UbuntuSansMono_MediumItalic66pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic66pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic66pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC66PT7B_H_
