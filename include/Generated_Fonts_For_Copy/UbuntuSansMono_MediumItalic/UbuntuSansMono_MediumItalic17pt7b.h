#ifndef _UBUNTUSANSMONO_MEDIUMITALIC17PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x33, 0x66, 0x64, 0x0C, 0xCC, 0x6D, 0xB4, 0xF2, 0xC8, 0x06,
  0xC3, 0x30, 0xC9, 0xFF, 0x7F, 0xC4, 0xC3, 0x23, 0xFE, 0xFF, 0x99, 0x04,
  0xC3, 0x60, 0x03, 0x01, 0x07, 0xE3, 0x13, 0x01, 0x80, 0x70, 0x1E, 0x03,
  0x01, 0x90, 0xDF, 0xC3, 0xC0, 0x80, 0x40, 0x1C, 0x31, 0x66, 0x34, 0xC2,
  0x48, 0x3D, 0x01, 0xA0, 0x06, 0x80, 0xFC, 0x1A, 0x43, 0x24, 0x22, 0xCC,
  0x38, 0x0F, 0x0D, 0x84, 0x46, 0x61, 0x60, 0xE0, 0xE6, 0xDA, 0xC7, 0x63,
  0x3B, 0xCF, 0x60, 0x7B, 0x68, 0x06, 0x1C, 0x61, 0x83, 0x0C, 0x18, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03,
  0x03, 0x03, 0x02, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0xE0, 0x40, 0x18,
  0x23, 0x5F, 0xF3, 0x8D, 0x9B, 0x00, 0x0C, 0x08, 0x18, 0xFF, 0xFF, 0x10,
  0x30, 0x30, 0x31, 0xCC, 0x6E, 0x60, 0x7F, 0xC0, 0xDF, 0x00, 0x00, 0x60,
  0x18, 0x02, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x1E, 0x3F, 0x63, 0x61,
  0xC3, 0xDB, 0xDB, 0xC3, 0xC6, 0xC6, 0xCC, 0x78, 0x06, 0x1D, 0xF9, 0x60,
  0xC1, 0x83, 0x0C, 0x18, 0x33, 0xFF, 0xF0, 0x0F, 0x1F, 0xC4, 0x60, 0x30,
  0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x1F, 0xDF, 0xE0, 0x1F, 0x0F, 0xC0,
  0x60, 0x30, 0x30, 0x70, 0x7C, 0x06, 0x03, 0x01, 0x91, 0xDF, 0xC0, 0x01,
  0x81, 0xC1, 0xE1, 0xA1, 0xB1, 0x99, 0x8C, 0x86, 0xFF, 0x83, 0x01, 0x80,
  0xC0, 0x0F, 0xC3, 0xF1, 0x80, 0x60, 0x10, 0x0F, 0x80, 0x70, 0x0C, 0x03,
  0x00, 0xC4, 0xF3, 0xF0, 0x03, 0x87, 0xCE, 0x0E, 0x06, 0x07, 0xF3, 0x1D,
  0x86, 0xC3, 0x61, 0x3B, 0x8F, 0x80, 0x7F, 0xFF, 0x81, 0x81, 0x80, 0xC0,
  0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x00, 0x1E, 0x1F, 0x88, 0x6C,
  0x26, 0x31, 0xF1, 0xF9, 0x8C, 0xC2, 0x63, 0x33, 0x8F, 0x80, 0x1E, 0x3F,
  0x63, 0x61, 0x41, 0x63, 0x7F, 0x03, 0x06, 0x0C, 0xF8, 0xE0, 0x37, 0x70,
  0x00, 0xCE, 0xC0, 0x0C, 0x71, 0xC0, 0x00, 0x03, 0x0E, 0x30, 0xCE, 0x30,
  0x01, 0x07, 0x3E, 0xF0, 0xE0, 0x78, 0x1E, 0x06, 0x3F, 0xBF, 0xC0, 0x00,
  0x07, 0xFF, 0xF8, 0x20, 0x1C, 0x07, 0x80, 0xF0, 0x78, 0xF3, 0xC1, 0x80,
  0x7C, 0x7C, 0x18, 0x30, 0xC3, 0x0C, 0x30, 0x00, 0x83, 0x87, 0x00, 0x07,
  0x87, 0x73, 0x0C, 0xC3, 0x67, 0xDB, 0x24, 0x89, 0x66, 0x59, 0xB2, 0x44,
  0xF1, 0x80, 0x60, 0x0F, 0x80, 0xC0, 0x03, 0x81, 0xC1, 0xE1, 0xB0, 0xD8,
  0xCC, 0x66, 0x63, 0x3F, 0xB0, 0xD8, 0x78, 0x30, 0x1F, 0x0F, 0xCC, 0x66,
  0x33, 0x19, 0xF9, 0xFC, 0xC3, 0x61, 0xA1, 0xBB, 0xDF, 0x80, 0x0F, 0x8F,
  0xCC, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x19, 0x8F, 0xC0,
  0x1E, 0x1F, 0x8C, 0x66, 0x33, 0x1B, 0x0D, 0x86, 0xC3, 0x63, 0x63, 0xBF,
  0x9F, 0x80, 0x1F, 0xC7, 0xF1, 0x80, 0x40, 0x30, 0x0F, 0xC3, 0xF0, 0x80,
  0x60, 0x18, 0x07, 0xF3, 0xFC, 0x3F, 0x9F, 0xCC, 0x04, 0x06, 0x03, 0xF1,
  0xF8, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x0F, 0x9F, 0xCC, 0x0C, 0x0C,
  0x06, 0x03, 0x0D, 0x86, 0xC6, 0x63, 0x39, 0x8F, 0xC0, 0x18, 0xCC, 0x33,
  0x0C, 0xC3, 0x31, 0x9F, 0xE7, 0xF9, 0x86, 0x63, 0x30, 0xCC, 0x33, 0x0C,
  0x1F, 0xC7, 0xF0, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x06,
  0x07, 0xE3, 0xF8, 0x0F, 0xC3, 0xF0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x03, 0x00, 0xC6, 0xE3, 0xF0, 0x18, 0xE2, 0x30, 0xCE, 0x1B, 0x83,
  0xE0, 0x78, 0x1F, 0x03, 0x60, 0x66, 0x0C, 0xC3, 0x0C, 0x61, 0x80, 0x18,
  0x18, 0x10, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x7F, 0xFE, 0x18,
  0xC6, 0x33, 0x9C, 0xA7, 0x2A, 0x9B, 0xA6, 0xD9, 0x36, 0x41, 0xB0, 0x4C,
  0x12, 0x0C, 0x18, 0x4E, 0x33, 0x8C, 0xE3, 0x2C, 0x8B, 0x66, 0x59, 0x96,
  0x47, 0x11, 0xCC, 0x33, 0x0C, 0x1E, 0x1F, 0x98, 0xCC, 0x3C, 0x1E, 0x0B,
  0x0D, 0x86, 0xC3, 0x63, 0x33, 0x0F, 0x00, 0x1F, 0x07, 0xE3, 0x0C, 0xC3,
  0x30, 0xCC, 0x63, 0xF1, 0xF0, 0x60, 0x18, 0x04, 0x03, 0x00, 0x1E, 0x1F,
  0x98, 0xCC, 0x3C, 0x1E, 0x0B, 0x0D, 0x86, 0xC3, 0x63, 0x33, 0x0F, 0x03,
  0x01, 0xC0, 0x70, 0x1F, 0x0F, 0xCC, 0x66, 0x33, 0x19, 0x1D, 0xFC, 0xFC,
  0x66, 0x33, 0x30, 0xD8, 0x60, 0x0F, 0xC7, 0xE3, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xF0, 0x0C, 0x03, 0x00, 0xC6, 0x73, 0xF8, 0xFF, 0xFF, 0x86, 0x03,
  0x01, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x00, 0x31, 0xB0,
  0xD8, 0x6C, 0x26, 0x36, 0x1B, 0x0D, 0x86, 0xC6, 0x63, 0x33, 0x0F, 0x80,
  0xC1, 0xE1, 0xB0, 0xD8, 0x4C, 0x66, 0x23, 0x31, 0x90, 0xD8, 0x78, 0x3C,
  0x0C, 0x00, 0x30, 0x66, 0x08, 0xC3, 0x10, 0x66, 0x0C, 0xD9, 0x1B, 0x62,
  0xAC, 0x55, 0x0C, 0xE3, 0x9C, 0x63, 0x00, 0x1C, 0x30, 0xC6, 0x0C, 0xC0,
  0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x19, 0x03, 0x98, 0x31, 0x8E,
  0x18, 0xC1, 0xE1, 0xB0, 0xC8, 0xC6, 0xC3, 0x40, 0xE0, 0x60, 0x30, 0x30,
  0x18, 0x0C, 0x00, 0x1F, 0xC7, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xC0,
  0x60, 0x30, 0x18, 0x0F, 0xF3, 0xFC, 0x0F, 0x84, 0x06, 0x03, 0x01, 0x80,
  0x80, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0xF0,
  0xCC, 0x46, 0x66, 0x66, 0x66, 0x66, 0x66, 0x23, 0x1F, 0x81, 0x80, 0xC0,
  0x60, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0,
  0x61, 0xF0, 0x04, 0x0E, 0x1E, 0x32, 0x63, 0xE3, 0x42, 0xFF, 0x80, 0x4E,
  0x30, 0x1F, 0x7F, 0x63, 0xC2, 0xC6, 0x86, 0xC6, 0xCE, 0xFE, 0x18, 0x0C,
  0x06, 0x02, 0x03, 0xF1, 0xFC, 0xC6, 0x43, 0x61, 0xB0, 0x98, 0xCD, 0xCF,
  0xC0, 0x1F, 0x7F, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xE6, 0x7E, 0x01, 0x80,
  0xC0, 0x60, 0x21, 0xF3, 0xF9, 0x8D, 0x86, 0xC6, 0x63, 0x31, 0x99, 0xC7,
  0xE0, 0x1E, 0x77, 0x63, 0xC3, 0xFE, 0xF0, 0xC0, 0xE6, 0x7E, 0x01, 0xF0,
  0x3A, 0x03, 0x00, 0x60, 0x1F, 0xE1, 0xFC, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0xB8, 0x0F, 0x00, 0x0F, 0x8E,
  0xCC, 0x6C, 0x36, 0x13, 0x19, 0x8C, 0xFE, 0x12, 0x03, 0x33, 0x9F, 0x80,
  0x18, 0x0C, 0x06, 0x06, 0x03, 0xF1, 0xF8, 0xC6, 0xC2, 0x63, 0x31, 0x98,
  0xD8, 0x6C, 0x60, 0x18, 0xE1, 0x00, 0xF3, 0xC3, 0x0C, 0x21, 0x86, 0x1F,
  0x3C, 0x01, 0xC0, 0x70, 0x08, 0x00, 0x0F, 0x87, 0xE0, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x86, 0xE3, 0xF0, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x31, 0xCC, 0xC3, 0x60, 0xF0, 0x7C, 0x1B, 0x06, 0x61, 0x98,
  0xC3, 0x00, 0x7A, 0x61, 0x8C, 0x30, 0xC3, 0x08, 0x61, 0x86, 0x19, 0x7C,
  0x3F, 0x97, 0xDB, 0x2D, 0xB6, 0xDA, 0x4B, 0x05, 0x86, 0xC3, 0x00, 0x3F,
  0x1F, 0xCC, 0x66, 0x36, 0x13, 0x19, 0x8C, 0xC6, 0xC6, 0x00, 0x3E, 0x7F,
  0x63, 0xC3, 0xC3, 0xC3, 0xC6, 0xEC, 0x78, 0x1F, 0x87, 0x71, 0x8C, 0x43,
  0x30, 0xCC, 0x33, 0x18, 0xDC, 0x7E, 0x18, 0x06, 0x03, 0x80, 0x1F, 0x3F,
  0x63, 0xC3, 0xC6, 0xC6, 0xC6, 0xCE, 0x7C, 0x0C, 0x0C, 0x0C, 0x3F, 0x3F,
  0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0x1F, 0x3E, 0x60, 0x70, 0x3C,
  0x0E, 0x06, 0xCE, 0xFC, 0x08, 0x60, 0xC7, 0xFF, 0xEC, 0x18, 0x30, 0x61,
  0x81, 0xB3, 0xE0, 0x63, 0x63, 0x43, 0xC6, 0xC6, 0xC6, 0xC6, 0xCE, 0xFE,
  0xC3, 0xC6, 0xC6, 0xCC, 0xCC, 0xD8, 0xF0, 0xF0, 0x60, 0xC1, 0xE0, 0xF2,
  0x5B, 0x29, 0xB5, 0x53, 0xB9, 0x9C, 0xCC, 0x00, 0x31, 0xCC, 0x61, 0xB0,
  0x78, 0x0C, 0x07, 0x03, 0x61, 0x98, 0xC3, 0x00, 0x18, 0xE3, 0x18, 0x63,
  0x0C, 0xC1, 0x98, 0x32, 0x02, 0xC0, 0x70, 0x0E, 0x01, 0x82, 0xE0, 0x78,
  0x00, 0x1F, 0x9F, 0xC1, 0xC1, 0xC1, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0x00,
  0x07, 0x86, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x41, 0xE0, 0xE0, 0x18, 0x0C,
  0x04, 0x06, 0x03, 0x01, 0x80, 0x78, 0x0C, 0x21, 0x86, 0x18, 0x43, 0x0C,
  0x30, 0x86, 0x18, 0x61, 0x0C, 0x30, 0x0F, 0x00, 0x80, 0x40, 0x60, 0x30,
  0x18, 0x0C, 0x07, 0x03, 0x83, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x61, 0xF0,
  0x22, 0xFB, 0x9E, 0x04,
};

const GFXglyph UbuntuSansMono_MediumItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 6, 5, 10, 3, -13 },
  { 11, 10, 12, 10, 0, -12 },
  { 26, 9, 15, 10, 0, -13 },
  { 43, 12, 12, 10, -1, -12 },
  { 61, 9, 12, 10, 0, -12 },
  { 75, 3, 5, 10, 5, -13 },
  { 77, 7, 16, 10, 2, -13 },
  { 91, 8, 16, 10, 0, -13 },
  { 107, 7, 7, 10, 2, -12 },
  { 114, 8, 8, 10, 1, -9 },
  { 122, 5, 6, 10, 1, -3 },
  { 126, 5, 2, 10, 2, -6 },
  { 128, 3, 3, 10, 3, -3 },
  { 130, 11, 16, 10, -1, -13 },
  { 152, 8, 12, 10, 1, -12 },
  { 164, 7, 12, 10, 1, -12 },
  { 175, 9, 12, 10, 0, -12 },
  { 189, 9, 12, 10, 0, -12 },
  { 203, 9, 12, 10, 0, -12 },
  { 217, 10, 12, 10, 0, -12 },
  { 232, 9, 12, 10, 1, -12 },
  { 246, 9, 12, 10, 2, -12 },
  { 260, 9, 12, 10, 1, -12 },
  { 274, 8, 12, 10, 1, -12 },
  { 286, 4, 9, 10, 3, -9 },
  { 291, 6, 12, 10, 1, -9 },
  { 300, 8, 8, 10, 1, -9 },
  { 308, 9, 6, 10, 0, -8 },
  { 315, 9, 8, 10, 0, -9 },
  { 324, 7, 12, 10, 2, -12 },
  { 335, 10, 15, 10, 0, -12 },
  { 354, 9, 12, 10, -1, -12 },
  { 368, 9, 12, 10, 0, -12 },
  { 382, 9, 12, 10, 1, -12 },
  { 396, 9, 12, 10, 0, -12 },
  { 410, 10, 12, 10, 0, -12 },
  { 425, 9, 12, 10, 1, -12 },
  { 439, 9, 12, 10, 1, -12 },
  { 453, 10, 12, 10, 0, -12 },
  { 468, 10, 12, 10, 0, -12 },
  { 483, 10, 12, 10, 0, -12 },
  { 498, 11, 12, 10, 0, -12 },
  { 515, 8, 12, 10, 0, -12 },
  { 527, 10, 12, 10, 0, -12 },
  { 542, 10, 12, 10, 0, -12 },
  { 557, 9, 12, 10, 1, -12 },
  { 571, 10, 12, 10, 0, -12 },
  { 586, 9, 15, 10, 1, -12 },
  { 603, 9, 12, 10, 0, -12 },
  { 617, 10, 12, 10, 0, -12 },
  { 632, 9, 12, 10, 2, -12 },
  { 646, 9, 12, 10, 1, -12 },
  { 660, 9, 12, 10, 2, -12 },
  { 674, 11, 12, 10, 0, -12 },
  { 691, 12, 12, 10, -1, -12 },
  { 709, 9, 12, 10, 2, -12 },
  { 723, 10, 12, 10, 0, -12 },
  { 738, 9, 16, 10, 1, -13 },
  { 756, 4, 16, 10, 3, -13 },
  { 764, 9, 16, 10, 0, -13 },
  { 782, 8, 7, 10, 1, -12 },
  { 789, 9, 1, 10, -1, 2 },
  { 791, 4, 3, 10, 4, -13 },
  { 793, 8, 9, 10, 1, -9 },
  { 802, 9, 13, 10, 0, -13 },
  { 817, 8, 9, 10, 1, -9 },
  { 826, 9, 13, 10, 1, -13 },
  { 841, 8, 9, 10, 1, -9 },
  { 850, 12, 16, 10, -1, -13 },
  { 874, 9, 12, 10, 0, -9 },
  { 888, 9, 13, 10, 0, -13 },
  { 903, 6, 13, 10, 2, -13 },
  { 913, 10, 16, 10, -1, -13 },
  { 933, 10, 13, 10, 0, -13 },
  { 950, 6, 13, 10, 2, -13 },
  { 960, 9, 9, 10, 0, -9 },
  { 971, 9, 9, 10, 0, -9 },
  { 982, 8, 9, 10, 1, -9 },
  { 991, 10, 12, 10, -1, -9 },
  { 1006, 8, 12, 10, 1, -9 },
  { 1018, 8, 9, 10, 1, -9 },
  { 1027, 8, 9, 10, 1, -9 },
  { 1036, 7, 12, 10, 2, -12 },
  { 1047, 8, 9, 10, 1, -9 },
  { 1056, 8, 9, 10, 2, -9 },
  { 1065, 9, 9, 10, 1, -9 },
  { 1076, 10, 9, 10, 0, -9 },
  { 1088, 11, 12, 10, -1, -9 },
  { 1105, 9, 9, 10, 0, -9 },
  { 1116, 9, 16, 10, 1, -13 },
  { 1134, 6, 16, 10, 2, -13 },
  { 1146, 9, 16, 10, -1, -13 },
  { 1164, 8, 4, 10, 1, -7 },
};

const GFXfont UbuntuSansMono_MediumItalic17pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic17pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC17PT7B_H_
