#ifndef _UBUNTUSANSMONO_MEDIUMITALIC50PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x3E, 0x0F, 0x9F,
  0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xF7, 0xC1, 0xF3, 0xE0, 0xFB, 0xF0, 0xFD,
  0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03,
  0xC7, 0x01, 0xC3, 0x80, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x1F, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0x81,
  0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0x03, 0xE0, 0x87, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xF8, 0x1E, 0x01, 0xFC, 0x00, 0x40, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x81, 0x00, 0x03, 0xF0, 0x38, 0x00, 0xFC, 0x07, 0xF3, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x1F, 0xE0, 0x03, 0xE0, 0x0F, 0xFC, 0x00, 0xF0, 0x07,
  0xCF, 0x00, 0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x00, 0xF0, 0xF0, 0x1F, 0x00,
  0x3C, 0x3C, 0x0F, 0x80, 0x0F, 0x0F, 0x07, 0xC0, 0x07, 0x83, 0xC1, 0xE0,
  0x01, 0xE0, 0xF0, 0xF0, 0x00, 0x78, 0x38, 0x78, 0x00, 0x1E, 0x1E, 0x3C,
  0x00, 0x07, 0x8F, 0x9F, 0x00, 0x00, 0xFF, 0xCF, 0x80, 0x00, 0x3F, 0xE7,
  0xC0, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3E, 0x10, 0x00, 0x00, 0x1F, 0x3F, 0x80, 0x00,
  0x0F, 0x9F, 0xF0, 0x00, 0x03, 0xCF, 0xFC, 0x00, 0x01, 0xE3, 0xCF, 0x80,
  0x00, 0xF1, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x78, 0x00, 0x3E, 0x3C, 0x1E,
  0x00, 0x1F, 0x0F, 0x07, 0x80, 0x0F, 0x83, 0xC1, 0xC0, 0x03, 0xC0, 0xF0,
  0xF0, 0x01, 0xE0, 0x3C, 0x3C, 0x00, 0xF0, 0x0F, 0x0F, 0x00, 0x7C, 0x03,
  0xC7, 0x80, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x1F, 0xF0, 0x0F, 0x80,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xC3, 0xE0, 0x0F,
  0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x1F, 0x00,
  0x0F, 0xBF, 0x80, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x04,
  0x01, 0xFE, 0x07, 0xC1, 0xFF, 0x83, 0xE1, 0xFF, 0xE1, 0xE1, 0xF1, 0xF1,
  0xF1, 0xF0, 0xFC, 0xF9, 0xF0, 0x3E, 0xF8, 0xF8, 0x0F, 0xFC, 0xF8, 0x07,
  0xFC, 0x7C, 0x01, 0xFE, 0x3E, 0x00, 0xFE, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x3F, 0x87, 0xE0, 0x3F, 0xC3, 0xF8, 0x7F, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0x7C, 0x1F, 0xFE, 0x3F, 0x07, 0xFC, 0x0F, 0x80, 0x20, 0x00, 0x00,
  0x1F, 0x9F, 0x8F, 0xC7, 0xE3, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F,
  0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x81, 0xF0, 0x23, 0x87, 0x83, 0x9F, 0x8E, 0x3F, 0x7F, 0xBB,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x3E, 0xF8, 0x01, 0xFB, 0xF0, 0x0F, 0xC7, 0xE0, 0x7F,
  0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xE0, 0xF0, 0x03, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0xFF, 0x0F, 0xF1, 0xFF, 0x1F, 0xF0,
  0xFF, 0x0F, 0xF0, 0x7F, 0x01, 0xE0, 0x3E, 0x07, 0xC1, 0xFC, 0xFF, 0x8F,
  0xF0, 0xFC, 0x0F, 0x00, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xEF,
  0xFF, 0xC0, 0x04, 0x1F, 0x9F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7F,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFE, 0x7F,
  0x80, 0xFE, 0x07, 0xE0, 0x7F, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x0F, 0xC0,
  0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0x8F, 0xC3, 0x83, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0xFC, 0x3E,
  0x7E, 0x3F, 0x0F, 0x9F, 0x8F, 0xC7, 0xE7, 0xC3, 0xF1, 0xF9, 0xF0, 0xF8,
  0x7C, 0x7C, 0x1C, 0x1F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xE3, 0xF0,
  0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x07, 0xE0, 0x7C, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x07, 0xF0, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xCF, 0xC0, 0x3C, 0x3E, 0x00,
  0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFE, 0x7F, 0xC0, 0x7C,
  0x03, 0xF0, 0x0C, 0x00, 0xFC, 0x02, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0xF8, 0x7F, 0x80, 0x30, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x18, 0x00,
  0x7F, 0x07, 0x80, 0x7F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xEF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x07, 0xC0,
  0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF2, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x10, 0x00, 0x7F, 0x00, 0xF0, 0x1F, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x80, 0x03, 0xE7, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F, 0xC3, 0xF0, 0x01, 0xF0,
  0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x01,
  0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x7F, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x00,
  0x3E, 0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0x1F, 0xE0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x07,
  0xE1, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0x80,
  0x07, 0xE3, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F,
  0xE0, 0x3F, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0x81,
  0xF8, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x0F,
  0xC7, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x1F, 0x00,
  0x0F, 0xC7, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x1F,
  0xC0, 0x3F, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xBF, 0x00, 0x04, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x0B, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x40, 0x0F, 0xC0, 0x3F, 0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x03, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x0F, 0xC0,
  0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFC, 0x07, 0xF0,
  0x07, 0x00, 0x00, 0x08, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x81, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0x07, 0xF0, 0x80, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x01,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x0F, 0xFF, 0x1F, 0x03, 0xFF, 0xF1,
  0xF0, 0x7F, 0xFE, 0x3E, 0x0F, 0xFF, 0xE3, 0xE1, 0xFC, 0x3E, 0x3E, 0x1F,
  0x03, 0xE3, 0xC3, 0xF0, 0x7C, 0x7C, 0x3E, 0x07, 0xC7, 0xC3, 0xE0, 0x7C,
  0x7C, 0x7C, 0x07, 0xC7, 0x87, 0xC0, 0x7C, 0x78, 0x7C, 0x0F, 0x87, 0x87,
  0xC0, 0xF8, 0xF8, 0x7C, 0x0F, 0x8F, 0x87, 0xC0, 0xF8, 0xF8, 0x7C, 0x1F,
  0x0F, 0x87, 0xE1, 0xF0, 0x78, 0x3F, 0xFF, 0x07, 0x83, 0xFF, 0xF0, 0x7C,
  0x1F, 0xFE, 0x07, 0xC0, 0xFF, 0xE0, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC0, 0xF8,
  0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0x80, 0xFE, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3F,
  0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E,
  0x00, 0x7E, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0xF8, 0x0F, 0xF0, 0x0F, 0x80, 0x1F, 0x81, 0xF8, 0x00,
  0xF8, 0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x3E, 0x00,
  0x3F, 0x07, 0xE0, 0x0F, 0xF0, 0x7E, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFD, 0xFC, 0x07, 0xF8, 0x03, 0x01, 0xFC, 0x00, 0x20, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x60, 0x1F, 0xF0, 0x7C, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xE0, 0x7F, 0x80, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x0F,
  0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0xC1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE1, 0xF0,
  0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0xFC,
  0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x07,
  0xE0, 0x1F, 0xC0, 0xFC, 0x0F, 0xF8, 0x1F, 0x9F, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFC, 0xFC, 0x03, 0xF8, 0x03, 0x80, 0xFE, 0x00, 0x10, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7C,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0,
  0xFE, 0x01, 0xF0, 0x0F, 0xF0, 0x7E, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0xC0,
  0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0x80,
  0x07, 0xC0, 0x3E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03,
  0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x20, 0x01, 0xF8, 0x03, 0x80, 0x3F, 0x00,
  0x7E, 0x0F, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x7F, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0x1F, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0xFD, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7D,
  0xFC, 0x00, 0x00, 0xF9, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0xFF,
  0x00, 0x7F, 0x81, 0xDE, 0x01, 0xEF, 0x07, 0xF8, 0x03, 0xDE, 0x1E, 0xF0,
  0x07, 0xBC, 0x3D, 0xE0, 0x1F, 0x78, 0xF3, 0xC0, 0x3C, 0xF1, 0xEF, 0x80,
  0x79, 0xE7, 0x9F, 0x01, 0xF1, 0xCF, 0x3C, 0x03, 0xE3, 0xBC, 0x78, 0x07,
  0x87, 0x70, 0xF0, 0x0F, 0x0F, 0xE3, 0xE0, 0x3E, 0x1F, 0x87, 0xC0, 0x7C,
  0x3F, 0x0F, 0x80, 0xF0, 0x7C, 0x1E, 0x03, 0xE0, 0xF8, 0x7C, 0x07, 0xC0,
  0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x07,
  0xC0, 0x7F, 0x00, 0x1F, 0x01, 0xFE, 0x00, 0xF8, 0x07, 0xF8, 0x03, 0xE0,
  0x1F, 0xE0, 0x0F, 0x80, 0xFF, 0x80, 0x3E, 0x03, 0xFF, 0x00, 0xF8, 0x0F,
  0xBC, 0x07, 0xC0, 0x3E, 0xF0, 0x1F, 0x01, 0xF3, 0xC0, 0x7C, 0x07, 0xCF,
  0x81, 0xF0, 0x1F, 0x1E, 0x0F, 0x80, 0x7C, 0x78, 0x3E, 0x01, 0xE1, 0xF0,
  0xF8, 0x0F, 0x87, 0xC3, 0xE0, 0x3E, 0x0F, 0x1F, 0x00, 0xF8, 0x3C, 0x7C,
  0x03, 0xC0, 0xF1, 0xF0, 0x1F, 0x03, 0xE7, 0xC0, 0x7C, 0x07, 0xBE, 0x01,
  0xF0, 0x1E, 0xF8, 0x07, 0xC0, 0x7B, 0xE0, 0x3E, 0x01, 0xEF, 0x80, 0xF8,
  0x07, 0xBC, 0x03, 0xE0, 0x0F, 0xF0, 0x0F, 0x80, 0x3F, 0xC0, 0x7C, 0x00,
  0xFF, 0x01, 0xF0, 0x03, 0xF8, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0xFE, 0x07, 0xE0, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x03, 0xF3, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x1F,
  0x80, 0xFE, 0x07, 0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x3F,
  0x00, 0x3E, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x03,
  0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0xFE, 0x07, 0xE0, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x03, 0xF3, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x1F,
  0x80, 0xFE, 0x07, 0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0xFE, 0x01, 0xF0, 0x07,
  0xE0, 0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xFC, 0x07, 0xC0, 0x7F, 0x80,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF0, 0x3F, 0x00,
  0x1F, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x3E, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0x87, 0xE0, 0x0F, 0xC0, 0x04,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0x80, 0x07, 0xE0,
  0x3E, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x1F, 0x80,
  0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF8,
  0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x03, 0xE0,
  0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3E,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC,
  0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0x80, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFD,
  0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x00,
  0x3F, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x0F,
  0x80, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x07, 0xE0,
  0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF1,
  0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF9, 0xF0, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8,
  0x1F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0xF0, 0x7C, 0x07, 0xC3,
  0xE0, 0xF8, 0x0F, 0x8F, 0xC1, 0xE0, 0x1E, 0x1F, 0x87, 0xC0, 0x7C, 0x7F,
  0x0F, 0x80, 0xF8, 0xFF, 0x1F, 0x01, 0xF3, 0xDE, 0x3C, 0x03, 0xC7, 0xBC,
  0xF8, 0x07, 0x9E, 0x79, 0xF0, 0x0F, 0x3C, 0xF3, 0xC0, 0x3E, 0xF1, 0xE7,
  0x80, 0x79, 0xE3, 0xDF, 0x00, 0xF7, 0x87, 0xBC, 0x01, 0xEE, 0x07, 0x78,
  0x03, 0xFC, 0x0E, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80,
  0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xF0, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0x3E,
  0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x1F,
  0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x80,
  0x07, 0xC7, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xF8, 0x7C, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF8, 0xFC,
  0x03, 0xF0, 0x7C, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E,
  0x3F, 0x80, 0x3E, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0x18, 0x00, 0x1C, 0x08, 0x00, 0x10, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x10,
  0x07, 0x01, 0xF0, 0x3F, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xC0,
  0x30, 0x02, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xC0, 0xF8, 0x3F, 0x80,
  0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xF0,
  0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E,
  0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3,
  0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0x7C,
  0x03, 0xFE, 0x3F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x1E, 0x00,
  0x1F, 0x7F, 0xC0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x03, 0xF8, 0x3F, 0x81, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01,
  0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x80,
  0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xE3, 0xF0,
  0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0x7E,
  0x01, 0xFC, 0x3E, 0x01, 0xFC, 0x1F, 0x07, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xE0, 0x30, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x81, 0xFF, 0x03, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0x0B, 0x40, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1E, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0xF8, 0x03, 0xF8, 0x07,
  0xC0, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x01,
  0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7E, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC3, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x7E, 0x00, 0x3F, 0xE1,
  0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0x81, 0xF8,
  0x7F, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x9F, 0x80, 0x0F, 0xCF, 0x80, 0x1F, 0xC7, 0xC0, 0x7F, 0xE7, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x41, 0xFE, 0x01, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x40, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0x81, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x7F,
  0x00, 0x7C, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01,
  0xF8, 0x1F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0,
  0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0xFC,
  0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFE, 0x0F,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xBE, 0x00, 0x01, 0xC3, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0x80, 0x0F,
  0xE0, 0x0F, 0x83, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x1E,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x03, 0xF8, 0x3F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7C,
  0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC,
  0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE0, 0x00, 0x1C,
  0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x10, 0x7F, 0xB8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x30, 0x07, 0xE0, 0x03, 0xE3, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x03, 0xE0,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0x7C, 0x3F, 0x80,
  0x07, 0xC7, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x03, 0xF0, 0x03, 0xE0, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x00, 0xFC, 0x07,
  0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x01, 0x3F, 0x07, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F,
  0xFE, 0x00, 0xC0, 0x00, 0x0E, 0x01, 0x00, 0x1F, 0xF9, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3C, 0x3F, 0x1F,
  0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x78,
  0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC3,
  0xE0, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x87, 0xC1, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x78, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x80, 0xFE,
  0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07,
  0xC1, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE1, 0xF8,
  0x03, 0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x1F, 0xC0, 0x3F,
  0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x1F,
  0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x8F, 0xF0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0xFF,
  0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF0, 0x1F,
  0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x07,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x01,
  0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x0F, 0x87, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xF7, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x81, 0xFE, 0x07, 0xE0, 0xFE, 0x01, 0xF0, 0x7F, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8,
  0x7E, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xC3, 0xF0, 0x01,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x83, 0xF0,
  0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x7F, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xBE,
  0x00, 0x03, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xF8,
  0x78, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF0,
  0x0C, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x60, 0x01,
  0xF8, 0x78, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x40, 0xFF, 0x0F, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x87,
  0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xE0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01,
  0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x3F, 0x83, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFE, 0xF8, 0x07, 0xFC, 0x7E, 0x00, 0x60, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0x9F,
  0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8,
  0x0F, 0xC1, 0xF0, 0x1F, 0x83, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x83,
  0xF0, 0x1F, 0x87, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x7E, 0x00, 0x7C, 0xF8,
  0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3C, 0x7C, 0x0F, 0x07,
  0xC7, 0xC1, 0xF0, 0x7C, 0x7C, 0x1F, 0x07, 0x87, 0xC3, 0xF0, 0xF8, 0x78,
  0x3F, 0x0F, 0x87, 0x87, 0xF0, 0xF0, 0x78, 0x7F, 0x1F, 0x07, 0x8F, 0xF1,
  0xF0, 0xF9, 0xE7, 0x1E, 0x0F, 0x9E, 0x73, 0xE0, 0xFB, 0xC7, 0xBC, 0x0F,
  0xBC, 0x7B, 0xC0, 0xF7, 0x87, 0xFC, 0x0F, 0x78, 0x7F, 0x80, 0xFF, 0x07,
  0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x0F,
  0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x07,
  0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F,
  0x8F, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x31, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x03,
  0x03, 0xFF, 0x00, 0xF1, 0xFF, 0xE0, 0x7C, 0x7F, 0xFE, 0x7E, 0x3F, 0xFF,
  0xFF, 0x9F, 0x07, 0xFF, 0xC7, 0xC0, 0xFF, 0xE3, 0xE0, 0x0F, 0xF0, 0x08,
  0x01, 0xF0, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 15, 36, 28, 7, -35 },
  { 69, 17, 15, 28, 10, -38 },
  { 101, 30, 35, 28, 0, -35 },
  { 233, 27, 44, 28, 1, -39 },
  { 382, 34, 36, 28, -2, -35 },
  { 535, 25, 36, 28, 1, -35 },
  { 648, 9, 16, 28, 14, -38 },
  { 666, 22, 48, 28, 6, -39 },
  { 798, 21, 48, 28, 1, -39 },
  { 924, 22, 22, 28, 5, -35 },
  { 985, 24, 25, 28, 2, -27 },
  { 1060, 12, 16, 28, 4, -8 },
  { 1084, 15, 5, 28, 7, -17 },
  { 1094, 9, 10, 28, 7, -9 },
  { 1106, 33, 48, 28, -3, -39 },
  { 1304, 26, 36, 28, 2, -35 },
  { 1421, 22, 35, 28, 2, -35 },
  { 1518, 26, 35, 28, 1, -35 },
  { 1632, 26, 36, 28, 1, -35 },
  { 1749, 27, 35, 28, 0, -35 },
  { 1868, 29, 36, 28, 0, -35 },
  { 1999, 26, 36, 28, 3, -35 },
  { 2116, 26, 35, 28, 5, -35 },
  { 2230, 26, 36, 28, 2, -35 },
  { 2347, 26, 35, 28, 2, -35 },
  { 2461, 14, 28, 28, 7, -27 },
  { 2510, 17, 35, 28, 4, -27 },
  { 2585, 25, 23, 28, 2, -26 },
  { 2657, 27, 15, 28, 1, -22 },
  { 2708, 25, 23, 28, 1, -26 },
  { 2780, 20, 36, 28, 7, -35 },
  { 2870, 28, 43, 28, 1, -35 },
  { 3021, 27, 35, 28, -3, -35 },
  { 3140, 28, 35, 28, 0, -35 },
  { 3263, 27, 36, 28, 3, -35 },
  { 3385, 27, 35, 28, 0, -35 },
  { 3504, 29, 35, 28, 1, -35 },
  { 3631, 28, 35, 28, 2, -35 },
  { 3754, 27, 36, 28, 2, -35 },
  { 3876, 30, 35, 28, 0, -35 },
  { 4008, 28, 35, 28, 1, -35 },
  { 4131, 28, 36, 28, 1, -35 },
  { 4257, 31, 35, 28, 0, -35 },
  { 4393, 21, 35, 28, 1, -35 },
  { 4485, 31, 35, 28, -1, -35 },
  { 4621, 30, 35, 28, 0, -35 },
  { 4753, 26, 36, 28, 2, -35 },
  { 4870, 28, 35, 28, 1, -35 },
  { 4993, 26, 44, 28, 2, -35 },
  { 5136, 28, 35, 28, 0, -35 },
  { 5259, 28, 36, 28, 0, -35 },
  { 5385, 25, 35, 28, 6, -35 },
  { 5495, 28, 36, 28, 2, -35 },
  { 5621, 27, 35, 28, 5, -35 },
  { 5740, 31, 35, 28, 1, -35 },
  { 5876, 34, 35, 28, -2, -35 },
  { 6025, 27, 35, 28, 6, -35 },
  { 6144, 30, 35, 28, 0, -35 },
  { 6276, 26, 48, 28, 3, -39 },
  { 6432, 9, 48, 28, 10, -39 },
  { 6486, 26, 48, 28, -1, -39 },
  { 6642, 24, 20, 28, 3, -35 },
  { 6702, 26, 5, 28, -4, 4 },
  { 6719, 11, 11, 28, 12, -39 },
  { 6735, 25, 28, 28, 2, -27 },
  { 6823, 25, 40, 28, 1, -39 },
  { 6948, 25, 28, 28, 2, -27 },
  { 7036, 29, 40, 28, 2, -39 },
  { 7181, 25, 28, 28, 2, -27 },
  { 7269, 34, 48, 28, -3, -39 },
  { 7473, 29, 36, 28, -1, -27 },
  { 7604, 25, 39, 28, 0, -39 },
  { 7726, 18, 39, 28, 5, -39 },
  { 7814, 28, 48, 28, -2, -39 },
  { 7982, 28, 39, 28, 1, -39 },
  { 8119, 16, 40, 28, 7, -39 },
  { 8199, 28, 27, 28, -1, -27 },
  { 8294, 25, 27, 28, 1, -27 },
  { 8379, 24, 28, 28, 2, -27 },
  { 8463, 28, 36, 28, -2, -27 },
  { 8589, 26, 36, 28, 2, -27 },
  { 8706, 25, 27, 28, 2, -27 },
  { 8791, 24, 28, 28, 2, -27 },
  { 8875, 22, 35, 28, 5, -34 },
  { 8972, 25, 27, 28, 2, -26 },
  { 9057, 23, 26, 28, 5, -26 },
  { 9132, 28, 26, 28, 2, -26 },
  { 9223, 29, 26, 28, -1, -26 },
  { 9318, 32, 35, 28, -4, -26 },
  { 9458, 26, 26, 28, 1, -26 },
  { 9543, 27, 48, 28, 3, -39 },
  { 9705, 17, 48, 28, 6, -39 },
  { 9807, 27, 48, 28, -2, -39 },
  { 9969, 26, 9, 28, 1, -19 },
};

const GFXfont UbuntuSansMono_MediumItalic50pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic50pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic50pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC50PT7B_H_
