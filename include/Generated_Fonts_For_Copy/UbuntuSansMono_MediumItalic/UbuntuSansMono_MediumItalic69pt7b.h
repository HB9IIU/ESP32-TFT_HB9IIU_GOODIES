#ifndef _UBUNTUSANSMONO_MEDIUMITALIC69PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF8,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0x87, 0xF0,
  0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0x7F, 0x03, 0xFC, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x1F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1,
  0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x7C, 0x01, 0xF0,
  0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x1F, 0xC0, 0x41, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0x80, 0x0F,
  0xF8, 0x00, 0x38, 0x00, 0xFF, 0x80, 0x00, 0x40, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x01, 0x80, 0x00, 0x3F, 0xE0, 0x1F, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xE7,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x00,
  0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE0, 0x00,
  0x7C, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x3E, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0xF8,
  0x3F, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x7C, 0x3F, 0x00, 0x00, 0x03, 0xF1,
  0xF8, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE3, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x87, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xF1,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC7, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0xFC, 0x3F, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0xFC,
  0x3F, 0x00, 0x00, 0x07, 0xE1, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x87, 0xE0,
  0x7C, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x0F,
  0xC0, 0x00, 0x7F, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x3E,
  0x00, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0x81, 0xF0,
  0x00, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x3F,
  0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x00, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x30, 0x00, 0x7F, 0xF0, 0x07, 0xE0, 0x1F, 0xFF, 0x01, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0x03, 0xFF, 0xFE, 0x07, 0xE0, 0xFF, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC3, 0xFC, 0x3F, 0x07, 0xF0, 0x3F, 0xCF, 0xE1, 0xFC, 0x03,
  0xF9, 0xF8, 0x3F, 0x80, 0x7F, 0xFF, 0x0F, 0xE0, 0x07, 0xFF, 0xC1, 0xFC,
  0x00, 0x7F, 0xF8, 0x3F, 0x80, 0x0F, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0xC1,
  0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xFF, 0x81, 0xFE, 0x01,
  0xFF, 0xF0, 0x3F, 0xFB, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xEF, 0xE0, 0x7F,
  0xFF, 0xF9, 0xFC, 0x07, 0xFF, 0xFE, 0x3F, 0xC0, 0x7F, 0xFF, 0x03, 0xF8,
  0x07, 0xFF, 0x80, 0x7F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xE3, 0xFC,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC,
  0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x1C, 0x03, 0xF0, 0x0C, 0x3E, 0x07, 0xC0,
  0x78, 0x7F, 0x0F, 0x83, 0xF1, 0xFF, 0x9F, 0x1F, 0xF3, 0xFF, 0xBE, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x3F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x04, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xC0, 0x07, 0x00, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0xFF, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFE, 0xFF, 0xF3, 0xFF, 0x9F, 0xF8, 0x7F, 0x81, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x03,
  0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x7F,
  0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x38, 0x0F, 0xF3, 0xFC, 0x1F, 0x81,
  0xFE, 0x7F, 0x87, 0xF8, 0x3F, 0x8F, 0xE0, 0xFF, 0x07, 0xF1, 0xFC, 0x3F,
  0xE0, 0xFE, 0x7F, 0x87, 0xFC, 0x1F, 0xCF, 0xF0, 0xFF, 0x87, 0xF9, 0xFC,
  0x1F, 0xF0, 0xFE, 0x3F, 0x81, 0xFC, 0x1F, 0xC7, 0xF0, 0x1F, 0x07, 0xF8,
  0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xF7, 0xF8, 0x01, 0xFF, 0x9F, 0xE0, 0x03, 0xF8, 0x7F,
  0x80, 0x0F, 0x81, 0xFC, 0x00, 0x38, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x1F,
  0xF0, 0x03, 0x80, 0x01, 0xFF, 0x00, 0x30, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x03,
  0xFF, 0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x03, 0x00, 0x00, 0x7F, 0xE0, 0x3E, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0xBF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x30, 0x00, 0x07, 0xFE, 0x00,
  0x7C, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x7C, 0x00, 0x01, 0xFC, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC7,
  0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F,
  0xC0, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFE, 0x07,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xE3, 0xFC, 0x00, 0x01, 0x80, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x03,
  0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF3, 0xFF, 0xC0, 0xF0, 0x03, 0xFE, 0x04, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x7F,
  0x80, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0x7F, 0x0F, 0xE0,
  0x03, 0xFF, 0xFC, 0x3F, 0x80, 0x3F, 0xFF, 0xF1, 0xFC, 0x03, 0xFF, 0xFF,
  0x87, 0xF0, 0x1F, 0xFF, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xF8, 0xFE, 0x07,
  0xFF, 0xBF, 0xE3, 0xF8, 0x1F, 0xE0, 0x3F, 0x0F, 0xC0, 0xFF, 0x01, 0xFC,
  0x3F, 0x03, 0xF8, 0x07, 0xF1, 0xFC, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x7F,
  0x00, 0x7F, 0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x7E, 0x0F, 0xE0, 0x0F, 0xE1,
  0xF8, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0xFE, 0x00, 0xFE, 0x3F, 0x83, 0xF8,
  0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x3F, 0x00, 0x7F, 0x0F,
  0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0,
  0x3F, 0x83, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F,
  0x83, 0xFE, 0x1F, 0xC0, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xFF,
  0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0x80, 0x7E,
  0x00, 0x7F, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x7F, 0x80, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x3F, 0x8F,
  0xF0, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x01,
  0xFF, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x03,
  0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7C,
  0x00, 0xFF, 0xE0, 0x00, 0xE0, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0x00, 0x0F, 0xFE, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xFE,
  0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07,
  0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0xFF,
  0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x03, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0xFC, 0x01, 0xFE, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x60, 0x03, 0xFE, 0x00, 0x00, 0x80, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x02, 0x00, 0x01, 0xFE, 0x00, 0x06,
  0x00, 0x07, 0xFC, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x7F,
  0xC0, 0x00, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00,
  0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xDF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x0F, 0xBE, 0x00, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x03,
  0xF7, 0xC0, 0x7D, 0xF8, 0x00, 0x7E, 0xFC, 0x0F, 0xBF, 0x00, 0x0F, 0xDF,
  0x83, 0xE7, 0xE0, 0x03, 0xF1, 0xF0, 0xFC, 0xFC, 0x00, 0x7E, 0x3E, 0x1F,
  0x1F, 0x00, 0x0F, 0xC7, 0xC7, 0xE7, 0xE0, 0x01, 0xF8, 0xF8, 0xF8, 0xFC,
  0x00, 0x7E, 0x1F, 0x3F, 0x1F, 0x80, 0x0F, 0xC3, 0xE7, 0xC3, 0xF0, 0x01,
  0xF8, 0x7D, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xBE, 0x1F, 0x80, 0x0F, 0xC1,
  0xFF, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xFC,
  0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0x83, 0xF8, 0x01, 0xF8, 0x1F, 0xE0, 0x7E,
  0x00, 0x3F, 0x03, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x01, 0xFB,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xBF, 0x00,
  0x3F, 0x80, 0x0F, 0xEF, 0xC0, 0x0F, 0xE0, 0x03, 0xF1, 0xF8, 0x07, 0xF0,
  0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x7F, 0x00, 0x1F,
  0xC7, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x3F,
  0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x83, 0xF0, 0x3F,
  0x80, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x87, 0xF0, 0x01,
  0xFC, 0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC0,
  0x3F, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xCF, 0xE0, 0x03, 0xF8, 0x03, 0xF3,
  0xF8, 0x00, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xDF, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x01, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xF3, 0xF8,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F,
  0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x1F, 0xE7, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F,
  0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x00, 0x60, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x10, 0x00,
  0x01, 0xFE, 0x00, 0xE0, 0x00, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x01, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0xC0,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x00, 0xFE, 0x07, 0xF0,
  0x3F, 0x80, 0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0xC0, 0xFC,
  0x00, 0x7E, 0x0F, 0xF8, 0x1F, 0x80, 0x0F, 0xC3, 0xFF, 0x87, 0xF0, 0x03,
  0xF8, 0x7D, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0xBE, 0x1F, 0x80, 0x0F, 0xC3,
  0xE7, 0xC3, 0xF0, 0x01, 0xF8, 0xFC, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0x1F,
  0x1F, 0x80, 0x07, 0xE7, 0xE3, 0xE3, 0xF0, 0x01, 0xF8, 0xF8, 0x7C, 0x7E,
  0x00, 0x3F, 0x3E, 0x0F, 0x9F, 0x80, 0x07, 0xE7, 0xC1, 0xF3, 0xF0, 0x00,
  0xFD, 0xF0, 0x3E, 0x7E, 0x00, 0x1F, 0x7E, 0x07, 0xCF, 0x80, 0x03, 0xEF,
  0x80, 0xFB, 0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xCF, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x7F,
  0x9F, 0xC0, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x8F, 0xF0, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x03, 0xFB, 0xFE, 0x00,
  0x00, 0xFF, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0x80, 0x00, 0x07, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18,
  0x00, 0x70, 0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFE, 0x03,
  0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0xE0, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF7, 0xF0, 0x03, 0xFF, 0xF8,
  0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xFD, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xFC, 0x0F, 0xE0, 0x07, 0xFF,
  0x03, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0C, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x07, 0xFF, 0x00, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xDF, 0xC0, 0x00, 0xFF, 0xFF, 0x3F, 0xC0,
  0x00, 0x7F, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFE, 0x1F, 0xF8, 0x1F, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0x0F, 0xFE, 0x3F,
  0xC0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x07, 0xFE, 0x00, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x10, 0x00, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x03, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x0F, 0xFC, 0x00,
  0x03, 0xF8, 0x7F, 0xE0, 0x00, 0x0F, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0x9F,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xF0, 0x00, 0x01,
  0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE1, 0xFF,
  0x00, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x13, 0xFE,
  0x03, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x03, 0xC0, 0x00, 0x3F, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0xFD, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0x8F, 0xFC, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F,
  0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x1F,
  0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF8,
  0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x07,
  0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFE,
  0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0xBF, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x3F,
  0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F, 0xFE, 0x00,
  0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFE, 0x07, 0xFF,
  0x00, 0x3F, 0x80, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03,
  0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFD, 0xFE, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x38, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x18, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x06,
  0x00, 0x01, 0xFE, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x20, 0x1F, 0xF8, 0x07, 0x80,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0x80,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF0,
  0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x3F, 0x80, 0x1F, 0xFE, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x07, 0xF0,
  0xFE, 0x01, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x0F,
  0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xC0, 0x7F, 0x81, 0xF8,
  0x1F, 0x81, 0xFF, 0x07, 0xF0, 0x3F, 0x03, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F,
  0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0xF8, 0x7F, 0x01, 0xF8, 0x7D, 0xF0, 0xFC,
  0x07, 0xF1, 0xFB, 0xE1, 0xF8, 0x0F, 0xC3, 0xE7, 0xC7, 0xE0, 0x1F, 0x8F,
  0xCF, 0x8F, 0xC0, 0x3F, 0x1F, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x3F, 0x7E,
  0x00, 0xFD, 0xF8, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x7F, 0xF0, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x9F,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x02, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x40, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x8F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x38, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x7F, 0xFE, 0x00,
  0x7E, 0x0F, 0xFF, 0xF8, 0x0F, 0xE1, 0xFF, 0xFF, 0xE1, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFC, 0xFF, 0xFF, 0xF8, 0x7F, 0x03, 0xFF, 0xFF, 0x07,
  0xE0, 0x0F, 0xFF, 0xE0, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xC0, 0x01, 0xFF,
  0x80, 0x04, 0x00, 0x07, 0xE0, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 20, 49, 39, 10, -48 },
  { 124, 25, 20, 39, 13, -52 },
  { 187, 41, 48, 39, 0, -48 },
  { 433, 37, 62, 39, 2, -54 },
  { 720, 47, 50, 39, -3, -49 },
  { 1014, 35, 50, 39, 1, -49 },
  { 1233, 11, 21, 39, 20, -52 },
  { 1262, 30, 67, 39, 8, -54 },
  { 1514, 30, 67, 39, 1, -54 },
  { 1766, 31, 29, 39, 7, -48 },
  { 1879, 33, 34, 39, 3, -37 },
  { 2020, 18, 23, 39, 5, -12 },
  { 2072, 20, 7, 39, 10, -23 },
  { 2090, 13, 13, 39, 10, -12 },
  { 2112, 45, 67, 39, -4, -54 },
  { 2489, 35, 50, 39, 3, -49 },
  { 2708, 30, 48, 39, 3, -48 },
  { 2888, 36, 49, 39, 2, -49 },
  { 3109, 36, 50, 39, 1, -49 },
  { 3334, 37, 48, 39, 1, -48 },
  { 3556, 39, 49, 39, 1, -48 },
  { 3795, 36, 49, 39, 4, -48 },
  { 4016, 36, 48, 39, 7, -48 },
  { 4232, 36, 50, 39, 3, -49 },
  { 4457, 36, 49, 39, 2, -49 },
  { 4678, 18, 37, 39, 10, -36 },
  { 4762, 23, 47, 39, 5, -36 },
  { 4898, 35, 32, 39, 3, -36 },
  { 5038, 37, 21, 39, 1, -31 },
  { 5136, 34, 32, 39, 2, -36 },
  { 5272, 29, 50, 39, 9, -49 },
  { 5454, 38, 59, 39, 2, -49 },
  { 5735, 38, 48, 39, -4, -48 },
  { 5963, 38, 48, 39, 0, -48 },
  { 6191, 37, 50, 39, 4, -49 },
  { 6423, 38, 48, 39, 0, -48 },
  { 6651, 39, 48, 39, 2, -48 },
  { 6885, 40, 48, 39, 2, -48 },
  { 7125, 38, 50, 39, 3, -49 },
  { 7363, 42, 48, 39, 0, -48 },
  { 7615, 39, 48, 39, 1, -48 },
  { 7849, 39, 49, 39, 1, -48 },
  { 8088, 43, 48, 39, 0, -48 },
  { 8346, 30, 48, 39, 1, -48 },
  { 8526, 43, 48, 39, -2, -48 },
  { 8784, 42, 48, 39, 0, -48 },
  { 9036, 36, 50, 39, 3, -49 },
  { 9261, 38, 48, 39, 1, -48 },
  { 9489, 36, 62, 39, 3, -49 },
  { 9768, 38, 48, 39, 0, -48 },
  { 9996, 38, 50, 39, 1, -49 },
  { 10234, 35, 48, 39, 8, -48 },
  { 10444, 39, 49, 39, 3, -48 },
  { 10683, 37, 48, 39, 8, -48 },
  { 10905, 43, 48, 39, 1, -48 },
  { 11163, 46, 48, 39, -2, -48 },
  { 11439, 37, 48, 39, 8, -48 },
  { 11661, 41, 48, 39, 0, -48 },
  { 11907, 36, 67, 39, 4, -54 },
  { 12209, 13, 67, 39, 14, -54 },
  { 12318, 36, 67, 39, -1, -54 },
  { 12620, 34, 27, 39, 4, -48 },
  { 12735, 36, 7, 39, -5, 6 },
  { 12767, 14, 14, 39, 17, -53 },
  { 12792, 35, 38, 39, 2, -37 },
  { 12959, 35, 55, 39, 1, -54 },
  { 13200, 34, 38, 39, 3, -37 },
  { 13362, 39, 55, 39, 3, -54 },
  { 13631, 34, 38, 39, 3, -37 },
  { 13793, 47, 67, 39, -4, -54 },
  { 14187, 40, 50, 39, -2, -37 },
  { 14437, 35, 54, 39, 0, -54 },
  { 14674, 24, 54, 39, 7, -54 },
  { 14836, 38, 67, 39, -2, -54 },
  { 15155, 38, 54, 39, 2, -54 },
  { 15412, 22, 54, 39, 10, -53 },
  { 15561, 39, 37, 39, -1, -37 },
  { 15742, 34, 37, 39, 1, -37 },
  { 15900, 33, 38, 39, 3, -37 },
  { 16057, 38, 50, 39, -2, -37 },
  { 16295, 35, 50, 39, 3, -37 },
  { 16514, 35, 37, 39, 3, -37 },
  { 16676, 34, 38, 39, 2, -37 },
  { 16838, 30, 48, 39, 7, -47 },
  { 17018, 34, 37, 39, 3, -36 },
  { 17176, 32, 36, 39, 7, -36 },
  { 17320, 39, 36, 39, 3, -36 },
  { 17496, 41, 36, 39, -2, -36 },
  { 17681, 44, 49, 39, -5, -36 },
  { 17951, 36, 36, 39, 1, -36 },
  { 18113, 38, 67, 39, 4, -54 },
  { 18432, 24, 67, 39, 8, -54 },
  { 18633, 37, 67, 39, -3, -54 },
  { 18943, 36, 13, 39, 2, -27 },
};

const GFXfont UbuntuSansMono_MediumItalic69pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic69pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic69pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC69PT7B_H_
