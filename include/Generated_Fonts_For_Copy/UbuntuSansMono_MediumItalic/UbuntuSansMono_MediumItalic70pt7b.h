#ifndef _UBUNTUSANSMONO_MEDIUMITALIC70PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0x80,
  0xFE, 0x3F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x01,
  0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xC0, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x1F,
  0xF0, 0x00, 0x08, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x20, 0x00, 0x03, 0xFC,
  0x01, 0x80, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0x81, 0xF8, 0x00,
  0x00, 0xF8, 0x0F, 0x83, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x83, 0xF0, 0x00,
  0x00, 0xF8, 0x1F, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x3F, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x3E, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x7E, 0x3F, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x8F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0xFF, 0x00,
  0x00, 0x01, 0xF8, 0x7E, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0xFC, 0x1F, 0x00,
  0x00, 0x07, 0xF0, 0xFC, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x00,
  0x00, 0x0F, 0xC1, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x1F, 0x00,
  0x00, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7F, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0xFE, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0x00,
  0x01, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0xFF, 0x00,
  0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x07, 0xD0, 0x07,
  0xFF, 0x00, 0x7E, 0x01, 0xFF, 0xF8, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFC, 0x1F, 0xE0, 0xFF,
  0x1F, 0xC1, 0xFC, 0x0F, 0xF1, 0xF8, 0x3F, 0x80, 0x7F, 0xBF, 0x83, 0xF8,
  0x03, 0xFB, 0xF0, 0x7F, 0x00, 0x3F, 0xFF, 0x07, 0xF0, 0x01, 0xFF, 0xE0,
  0x7F, 0x00, 0x0F, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x07,
  0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xF8, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0xFC,
  0xFF, 0x01, 0xFF, 0xFF, 0x87, 0xF0, 0x0F, 0xFF, 0xE0, 0x7F, 0x00, 0x7F,
  0xF8, 0x07, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xF1, 0xFE, 0x1F,
  0xE3, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0x7F,
  0x87, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x08,
  0x03, 0xF0, 0x04, 0x3C, 0x07, 0xE0, 0x38, 0x7E, 0x0F, 0xC1, 0xF8, 0xFF,
  0x1F, 0x8F, 0xF3, 0xFF, 0x9E, 0x7F, 0xE7, 0xFF, 0xBD, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x1F,
  0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x07,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC,
  0x07, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F,
  0xC0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x07, 0x80,
  0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0x9F, 0xF8, 0x7F, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0x00, 0xFE, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00,
  0xFE, 0x1F, 0xC0, 0xF8, 0x0F, 0xE3, 0xFC, 0x1F, 0xC0, 0xFE, 0x3F, 0xC3,
  0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0xE1, 0xFE, 0x3F, 0x83, 0xFE, 0x1F, 0xE7,
  0xF8, 0x7F, 0xE1, 0xFC, 0x7F, 0x87, 0xFC, 0x1F, 0xC7, 0xF8, 0x3F, 0xC3,
  0xFC, 0x7F, 0x03, 0xF8, 0x3F, 0xC7, 0xF0, 0x1F, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xF8, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x07, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFB, 0xFC, 0x01, 0xFF, 0xDF, 0xE0, 0x03, 0xFC,
  0x7F, 0x80, 0x0F, 0xC1, 0xFE, 0x00, 0x3C, 0x07, 0xF8, 0x00, 0xC0, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x07,
  0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x38,
  0x00, 0x0F, 0xF0, 0x02, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x0F, 0xFE, 0x00,
  0x0E, 0x00, 0x1F, 0xF0, 0x00, 0x40, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x0C, 0x00, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xBF, 0xC0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x60, 0x00, 0x0F, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x1F, 0xF8, 0x00, 0x1F, 0xEF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x8F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC,
  0x1F, 0xF0, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFC,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xDF, 0xF0, 0x00, 0x3F, 0xF8, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7C, 0x03, 0xFF,
  0x06, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0xFF, 0xFE, 0x1F, 0xC0, 0x0F, 0xFF, 0xF8, 0x3F,
  0x80, 0x7F, 0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0xFF, 0xE1, 0xFC, 0x07, 0xFF,
  0xFF, 0xC3, 0xF0, 0x1F, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0xE0, 0xFE, 0x1F,
  0xC0, 0xFF, 0x01, 0xFC, 0x3F, 0x03, 0xFC, 0x03, 0xF8, 0x7E, 0x07, 0xF0,
  0x0F, 0xE1, 0xFC, 0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0x83, 0xF8,
  0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFC, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x7F,
  0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC1, 0xFC, 0x03, 0xF8,
  0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xFC, 0x3F, 0x81, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0xFC,
  0x07, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFB, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xE0, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0xFE,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x81, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x40, 0x03, 0xFE, 0x00, 0x07, 0x00, 0x0F, 0xFE, 0x00,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xE0,
  0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x3F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFE,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0x80,
  0x0F, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xF8, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0x81, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xF0, 0x03, 0xFF,
  0x00, 0x00, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x00,
  0x1E, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x03,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xE1, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xEF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFB, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x01, 0xF7, 0xE0, 0x3E, 0xFC, 0x00, 0x7E, 0x7C, 0x0F, 0xDF, 0x80, 0x0F,
  0xCF, 0x81, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x7C, 0xFC, 0x00, 0x7F, 0x3E,
  0x0F, 0x9F, 0x80, 0x0F, 0xC7, 0xC3, 0xE3, 0xF0, 0x01, 0xF8, 0xF8, 0xFC,
  0x7E, 0x00, 0x3F, 0x1F, 0x1F, 0x1F, 0xC0, 0x0F, 0xE3, 0xE7, 0xE3, 0xF0,
  0x01, 0xF8, 0x7C, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xBF, 0x0F, 0xC0, 0x0F,
  0xE1, 0xF7, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0xF8, 0x7F, 0x00, 0x3F, 0x03,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x81, 0xF8, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0x00, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x81, 0xFC,
  0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xEF, 0xC0, 0x07, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x3F, 0x80, 0x07, 0xF3, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0xFE, 0x00, 0x3F, 0x8F, 0xC0, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x07,
  0xF0, 0x00, 0xFE, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x1F, 0xC0,
  0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0xFE, 0x00, 0x1F,
  0xC0, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x03,
  0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xE3,
  0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0,
  0x03, 0xF8, 0x03, 0xF1, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x0F,
  0xE0, 0x07, 0xEF, 0xE0, 0x03, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xBF, 0x80, 0x0F, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0xF0,
  0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x07,
  0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xF1,
  0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7,
  0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFC, 0xFF, 0x00,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xE0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x07,
  0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0x01, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFC, 0xFF,
  0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F,
  0x8F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xFC,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0x7F, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x3F,
  0x80, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x70, 0x00,
  0xFF, 0x80, 0x00, 0x20, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x20,
  0x00, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00,
  0x3F, 0xCF, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC,
  0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x00, 0x7E, 0x07, 0xF8, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFF, 0x03, 0xF0, 0x03, 0xF8, 0x3F, 0xE0, 0x7E, 0x00,
  0x7E, 0x07, 0xFC, 0x1F, 0xC0, 0x0F, 0xC1, 0xFF, 0x83, 0xF8, 0x01, 0xF8,
  0x7F, 0xF0, 0x7E, 0x00, 0x7F, 0x0F, 0xBE, 0x0F, 0xC0, 0x0F, 0xE3, 0xF7,
  0xC3, 0xF8, 0x01, 0xF8, 0x7C, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x9F, 0x0F,
  0xC0, 0x07, 0xE3, 0xE3, 0xE1, 0xF8, 0x00, 0xFC, 0xFC, 0x7C, 0x7E, 0x00,
  0x3F, 0x1F, 0x0F, 0x8F, 0xC0, 0x07, 0xE7, 0xE1, 0xF9, 0xF8, 0x00, 0xFC,
  0xF8, 0x1F, 0x3E, 0x00, 0x1F, 0xBF, 0x03, 0xEF, 0xC0, 0x03, 0xE7, 0xC0,
  0x7D, 0xF8, 0x00, 0x7D, 0xF0, 0x0F, 0xBF, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00, 0xFF, 0x1F, 0xC0,
  0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFF,
  0x87, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x00, 0xFF, 0x80, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFB, 0xF8,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x3F,
  0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x3F, 0x83, 0xFE, 0x00, 0x1F, 0xC3, 0xFE, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0x9F, 0x00, 0x00, 0x1F, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x08,
  0x00, 0x38, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xE0, 0x07, 0x80,
  0x06, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xE0, 0x3F, 0xF8,
  0x01, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xF0, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x9F, 0xE0, 0x03, 0xFF, 0xE0, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF1,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xE0,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x03, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0x80, 0x1F, 0xFC,
  0x07, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xC0, 0x3F, 0xFC, 0x00, 0x08,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x20,
  0x1F, 0xFE, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x3F, 0xC0,
  0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF1, 0xFC,
  0x00, 0x03, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x0F, 0xFC, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0x00, 0x1F, 0xFF, 0x3F,
  0xCF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x07, 0xFF, 0x00, 0x0F, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x08, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x20,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F,
  0xFC, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xBF, 0xC0, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x08, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF7, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x9F,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x07, 0xFC, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x02, 0x07, 0xFF, 0x06, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xC0, 0x01, 0xFF,
  0x00, 0x01, 0xE0, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0xE0, 0x00, 0x0F,
  0xE3, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0x9F, 0xF0, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x4F, 0xF8, 0x0F, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00,
  0xFF, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0x07, 0xFC, 0x3F, 0x80, 0xFE, 0x07, 0xE0, 0x7F, 0x01, 0xFC, 0x0F,
  0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x1F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8,
  0xFF, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07,
  0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0x7F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x07, 0xFC,
  0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xCF, 0xF0,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFC, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xC0, 0x3F, 0xF8, 0x03, 0xFC, 0x07,
  0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xDF, 0xE0, 0x00, 0x07, 0xC1,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x0C, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xF0, 0x03, 0xFC, 0x00, 0x0C,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x06, 0x00, 0x01, 0xFE, 0x03, 0xF0, 0x01,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x80, 0x3F,
  0xF0, 0x0F, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xEF, 0xE0, 0x07, 0xFF, 0xF1, 0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0,
  0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x7E, 0x01,
  0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0x3F,
  0x87, 0xF0, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x1F, 0x80,
  0xFF, 0x03, 0xF8, 0x3F, 0x03, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xFC, 0x1F,
  0xC0, 0xFC, 0x1F, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0xF0, 0x7E, 0x03, 0xF0,
  0xFF, 0xF1, 0xFC, 0x0F, 0xE3, 0xF7, 0xE3, 0xF0, 0x1F, 0xC7, 0xCF, 0xC7,
  0xE0, 0x3F, 0x1F, 0x9F, 0x9F, 0xC0, 0x7E, 0x3E, 0x1F, 0x3F, 0x00, 0xFC,
  0xFC, 0x3E, 0x7E, 0x01, 0xF9, 0xF0, 0x7D, 0xF8, 0x03, 0xF7, 0xE0, 0xFB,
  0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC7, 0xFC,
  0x00, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFB,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x20, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x20, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0x00,
  0x1F, 0xF8, 0x00, 0x3E, 0x07, 0xFF, 0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0x00,
  0x7E, 0x0F, 0xFF, 0xFC, 0x0F, 0xE1, 0xFF, 0xFF, 0xF3, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0x01, 0xFF, 0xFF, 0x07,
  0xE0, 0x0F, 0xFF, 0xF0, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 21, 50, 39, 10, -49 },
  { 133, 24, 20, 39, 14, -53 },
  { 193, 41, 49, 39, 0, -49 },
  { 445, 37, 62, 39, 2, -54 },
  { 732, 48, 51, 39, -3, -50 },
  { 1038, 36, 51, 39, 1, -50 },
  { 1268, 12, 22, 39, 20, -53 },
  { 1301, 31, 68, 39, 8, -55 },
  { 1565, 30, 68, 39, 1, -55 },
  { 1820, 31, 30, 39, 7, -49 },
  { 1937, 34, 35, 39, 3, -38 },
  { 2086, 18, 23, 39, 5, -12 },
  { 2138, 20, 8, 39, 10, -24 },
  { 2158, 13, 13, 39, 10, -12 },
  { 2180, 45, 68, 39, -4, -55 },
  { 2563, 36, 51, 39, 3, -50 },
  { 2793, 30, 49, 39, 3, -49 },
  { 2977, 36, 50, 39, 2, -50 },
  { 3202, 37, 51, 39, 1, -50 },
  { 3438, 37, 49, 39, 1, -49 },
  { 3665, 39, 50, 39, 1, -49 },
  { 3909, 36, 50, 39, 4, -49 },
  { 4134, 36, 49, 39, 7, -49 },
  { 4355, 36, 51, 39, 3, -50 },
  { 4585, 37, 50, 39, 2, -50 },
  { 4817, 19, 38, 39, 10, -37 },
  { 4908, 24, 48, 39, 5, -37 },
  { 5052, 35, 32, 39, 3, -36 },
  { 5192, 38, 21, 39, 1, -31 },
  { 5292, 35, 32, 39, 2, -36 },
  { 5432, 28, 51, 39, 10, -50 },
  { 5611, 39, 61, 39, 2, -50 },
  { 5909, 38, 49, 39, -4, -49 },
  { 6142, 39, 49, 39, 0, -49 },
  { 6381, 38, 51, 39, 4, -50 },
  { 6624, 38, 49, 39, 0, -49 },
  { 6857, 40, 49, 39, 2, -49 },
  { 7102, 40, 49, 39, 2, -49 },
  { 7347, 38, 51, 39, 3, -50 },
  { 7590, 43, 49, 39, 0, -49 },
  { 7854, 40, 49, 39, 1, -49 },
  { 8099, 40, 50, 39, 1, -49 },
  { 8349, 44, 49, 39, 0, -49 },
  { 8619, 30, 49, 39, 1, -49 },
  { 8803, 43, 49, 39, -2, -49 },
  { 9067, 43, 49, 39, 0, -49 },
  { 9331, 36, 51, 39, 3, -50 },
  { 9561, 39, 49, 39, 1, -49 },
  { 9800, 36, 63, 39, 3, -50 },
  { 10084, 39, 49, 39, 0, -49 },
  { 10323, 39, 51, 39, 1, -50 },
  { 10572, 36, 49, 39, 8, -49 },
  { 10793, 39, 50, 39, 3, -49 },
  { 11037, 37, 49, 39, 8, -49 },
  { 11264, 43, 49, 39, 1, -49 },
  { 11528, 47, 49, 39, -2, -49 },
  { 11816, 38, 49, 39, 8, -49 },
  { 12049, 42, 49, 39, 0, -49 },
  { 12307, 37, 68, 39, 4, -55 },
  { 12622, 13, 68, 39, 14, -55 },
  { 12733, 36, 68, 39, -1, -55 },
  { 13039, 33, 28, 39, 5, -49 },
  { 13155, 36, 7, 39, -5, 6 },
  { 13187, 15, 14, 39, 17, -54 },
  { 13214, 36, 38, 39, 2, -37 },
  { 13385, 36, 55, 39, 1, -54 },
  { 13633, 35, 38, 39, 3, -37 },
  { 13800, 40, 55, 39, 3, -54 },
  { 14075, 34, 38, 39, 3, -37 },
  { 14237, 48, 67, 39, -4, -54 },
  { 14639, 41, 50, 39, -2, -37 },
  { 14896, 35, 54, 39, 0, -54 },
  { 15133, 25, 54, 39, 7, -54 },
  { 15302, 39, 67, 39, -2, -54 },
  { 15629, 38, 54, 39, 2, -54 },
  { 15886, 22, 55, 39, 10, -54 },
  { 16038, 39, 37, 39, -1, -37 },
  { 16219, 35, 37, 39, 1, -37 },
  { 16381, 34, 38, 39, 3, -37 },
  { 16543, 39, 50, 39, -2, -37 },
  { 16787, 36, 50, 39, 3, -37 },
  { 17012, 35, 37, 39, 3, -37 },
  { 17174, 34, 38, 39, 2, -37 },
  { 17336, 31, 49, 39, 7, -48 },
  { 17526, 35, 38, 39, 3, -37 },
  { 17693, 33, 37, 39, 7, -37 },
  { 17846, 39, 37, 39, 3, -37 },
  { 18027, 42, 37, 39, -2, -37 },
  { 18222, 44, 50, 39, -5, -37 },
  { 18497, 37, 37, 39, 1, -37 },
  { 18669, 38, 68, 39, 4, -55 },
  { 18992, 24, 68, 39, 8, -55 },
  { 19196, 38, 68, 39, -3, -55 },
  { 19519, 36, 13, 39, 2, -27 },
};

const GFXfont UbuntuSansMono_MediumItalic70pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic70pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic70pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC70PT7B_H_
