#ifndef _UBUNTUSANSMONO_MEDIUMITALIC28PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x38,
  0x38, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF0, 0x79, 0xDC, 0x77, 0x1D,
  0xCE, 0x63, 0x98, 0xEE, 0x33, 0x0C, 0x00, 0xE3, 0x80, 0xE3, 0x80, 0x71,
  0x80, 0x71, 0xC0, 0x38, 0xE9, 0xFF, 0xF8, 0xFF, 0xFC, 0x0E, 0x30, 0x0E,
  0x38, 0x07, 0x18, 0x03, 0x1C, 0x0F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE0,
  0xE3, 0x00, 0xE3, 0x80, 0x71, 0x80, 0x31, 0xC0, 0x38, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x80, 0x7F, 0xE1, 0xFF, 0x87, 0x81,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE1, 0x83, 0xC7, 0xFF,
  0x0F, 0xFC, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x20, 0xF8, 0x18, 0x33, 0x06, 0x0E, 0x61, 0x81, 0x8C, 0x70, 0x31, 0x9C,
  0x06, 0x77, 0x00, 0xCC, 0xC0, 0x1F, 0x30, 0x01, 0xCC, 0x00, 0x03, 0x00,
  0x00, 0xEF, 0x00, 0x3B, 0xF0, 0x0E, 0x66, 0x01, 0x98, 0xC0, 0x63, 0x18,
  0x18, 0x67, 0x07, 0x0C, 0xC1, 0xC1, 0xF8, 0x70, 0x3E, 0x00, 0x00, 0xF0,
  0x07, 0xF0, 0x1F, 0xE0, 0x38, 0xE0, 0xE1, 0xC1, 0xC7, 0x03, 0x8E, 0x07,
  0x38, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x39, 0xFC, 0x63, 0x9D, 0xCE, 0x1F,
  0x1C, 0x3E, 0x70, 0x38, 0xF0, 0xF0, 0xE3, 0xF1, 0xFE, 0xE1, 0xF9, 0xE0,
  0x7B, 0x9C, 0xEE, 0x73, 0x98, 0x00, 0x30, 0x07, 0x00, 0xF0, 0x3E, 0x07,
  0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x08, 0x00, 0x00, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0x18, 0x00, 0x07, 0x00, 0x70, 0x46, 0x17, 0x67,
  0xFF, 0xF7, 0xFF, 0x0F, 0x01, 0xF8, 0x3D, 0xC7, 0x9E, 0x18, 0xC0, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x81, 0xFF, 0xF7, 0xFF, 0xBF,
  0xFE, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x0C, 0x3C, 0xF9, 0xF1, 0xE1, 0xC7, 0x7C, 0xF1, 0x00, 0xFF, 0xFF, 0xFE,
  0x33, 0xFF, 0xF7, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x1F,
  0xE0, 0xFF, 0xC3, 0x87, 0x1C, 0x1C, 0xF0, 0x73, 0x81, 0xDE, 0x07, 0x73,
  0x9D, 0xCE, 0x77, 0x39, 0xDC, 0xC7, 0xE0, 0x3B, 0x80, 0xEE, 0x07, 0xB8,
  0x1C, 0xF0, 0xF1, 0xC7, 0x87, 0xFC, 0x0F, 0xE0, 0x00, 0x70, 0x1F, 0x03,
  0xF1, 0xFE, 0x1E, 0xE1, 0x8E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x7F, 0xF7, 0xFF, 0xFF,
  0xE0, 0x01, 0xE0, 0x3F, 0xE1, 0xFF, 0xC3, 0x07, 0x08, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC,
  0x01, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x20, 0xF0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x03, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0xE3, 0xF1, 0xFF, 0xC7,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0xC0,
  0x73, 0x81, 0xC7, 0x07, 0x1C, 0x1C, 0x38, 0x30, 0x70, 0xE0, 0xE3, 0x83,
  0x97, 0xFF, 0xDF, 0xFF, 0x80, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x71, 0xF0,
  0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0x04, 0x03, 0xF0, 0x3F, 0xC3, 0xF0, 0x1F,
  0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0x77, 0xC3, 0xFF, 0x8F, 0xDF, 0x38,
  0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0xF3, 0xC7, 0x87,
  0xFC, 0x0F, 0xE0, 0x7F, 0xFD, 0xFF, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xF1, 0xC0, 0xE3, 0x81,
  0xC7, 0x07, 0x0E, 0x0E, 0x1E, 0x78, 0x1F, 0xE0, 0x7F, 0x81, 0xE7, 0x87,
  0x07, 0x8E, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x79, 0xE1, 0xE1, 0xFF,
  0x81, 0xFE, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xE0, 0xE3, 0xC1,
  0xC7, 0x01, 0xCE, 0x03, 0x9C, 0x0F, 0x38, 0x1C, 0x78, 0x38, 0xFF, 0xF0,
  0xFF, 0xE0, 0x23, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xE1, 0xFF,
  0x03, 0xFC, 0x07, 0xC0, 0x00, 0x0C, 0x3C, 0x79, 0xF1, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xC3, 0xCF, 0x9F, 0x1C, 0x00, 0x03, 0x03, 0xC1, 0xE1, 0xF0,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0xC3, 0xE1, 0xF0, 0x78,
  0x1C, 0x1C, 0x7C, 0x3C, 0x10, 0x00, 0x00, 0x0C, 0x01, 0xF0, 0x3F, 0xC3,
  0xF8, 0x7F, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x1C, 0x3F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x38, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x01, 0xE0, 0x0F, 0x81, 0xFE, 0x1F, 0xC3, 0xF8,
  0x0F, 0x80, 0x30, 0x00, 0x0F, 0x87, 0xF8, 0xFF, 0x90, 0x70, 0x0E, 0x01,
  0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x07, 0xF8,
  0x1F, 0xF8, 0x70, 0x71, 0xC0, 0x67, 0x00, 0xCE, 0x0F, 0xB8, 0xFF, 0x73,
  0xFE, 0xC7, 0x1F, 0x9C, 0x37, 0x38, 0xEE, 0x61, 0xDC, 0xC3, 0xB1, 0x86,
  0x63, 0x9C, 0xC7, 0xF9, 0xC7, 0xF3, 0x83, 0x87, 0x00, 0x07, 0x00, 0x0F,
  0x88, 0x0F, 0xF0, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x6E, 0x00, 0xEE, 0x01, 0xCE, 0x01, 0xCE, 0x03, 0x8E, 0x03, 0x8E, 0x07,
  0x0E, 0x07, 0x0E, 0x0E, 0x0E, 0x0F, 0xFE, 0x1F, 0xFE, 0x1C, 0x0F, 0x38,
  0x0F, 0x38, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0x01, 0xE0, 0x1F, 0xF8, 0x3F,
  0xF8, 0x70, 0xF0, 0xE0, 0xE1, 0xC1, 0xC7, 0x03, 0x8E, 0x0F, 0x1C, 0xFC,
  0x3F, 0xE0, 0xFF, 0xE1, 0xC1, 0xE3, 0x81, 0xC7, 0x03, 0x9C, 0x07, 0x38,
  0x0E, 0x70, 0x3C, 0xE3, 0xF3, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0xF8, 0x0F,
  0xFC, 0x3F, 0xF0, 0xF0, 0x23, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xF0, 0x01, 0xF9, 0xC1, 0xFF, 0x81, 0xFE, 0x00, 0x03,
  0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x71, 0xE0, 0xE1, 0xE3, 0x81, 0xC7, 0x03,
  0x8E, 0x07, 0x1C, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x81, 0xEF,
  0x03, 0x9C, 0x0F, 0x38, 0x3C, 0x70, 0xF1, 0xEF, 0xE3, 0xFF, 0x07, 0xF8,
  0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFE, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x78,
  0x21, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0xF7, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x3C, 0x0E, 0x78, 0x38, 0x70,
  0x70, 0xF8, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0x03, 0x87, 0x03, 0xC3,
  0x81, 0xC1, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x78, 0x70, 0x38, 0x38, 0x1C,
  0x3F, 0xFE, 0x1F, 0xFF, 0x0E, 0x07, 0x07, 0x03, 0x87, 0x81, 0xC3, 0x80,
  0xE1, 0xC0, 0xE0, 0xE0, 0x70, 0xF0, 0x38, 0x70, 0x1C, 0x38, 0x1C, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x80,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x20, 0x70, 0xE3, 0xE1, 0xFF, 0x81, 0xFE, 0x00,
  0x0F, 0x07, 0x87, 0x07, 0x83, 0x87, 0x81, 0xC7, 0x80, 0xE7, 0x80, 0xE7,
  0x80, 0x77, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0E, 0xF0, 0x07,
  0x38, 0x03, 0x9E, 0x03, 0x87, 0x01, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x78,
  0x78, 0x1C, 0x38, 0x0F, 0x00, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0, 0x03, 0x83,
  0xC1, 0xE0, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x8D, 0x83, 0xE7, 0xE0,
  0xD9, 0xB8, 0x76, 0xEC, 0x1C, 0xF3, 0x07, 0x39, 0xC1, 0x8E, 0x70, 0xE3,
  0x1C, 0x38, 0x06, 0x0E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E,
  0x1C, 0x03, 0x0E, 0x01, 0xC0, 0x0F, 0x03, 0x87, 0x81, 0xC3, 0xC0, 0xC1,
  0xF0, 0xE1, 0xF8, 0x70, 0xEC, 0x38, 0x76, 0x18, 0x33, 0x9C, 0x39, 0xCE,
  0x1C, 0x67, 0x0E, 0x33, 0x06, 0x1F, 0x87, 0x0F, 0xC3, 0x83, 0xE1, 0xC1,
  0xE0, 0xE0, 0xF0, 0x60, 0x78, 0x70, 0x3C, 0x38, 0x0E, 0x00, 0x01, 0xF0,
  0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xE1, 0xC1, 0xE7, 0x01, 0xCE, 0x03, 0xBC,
  0x07, 0x70, 0x0E, 0xE0, 0x39, 0xC0, 0x77, 0x00, 0xEE, 0x01, 0xDC, 0x07,
  0x38, 0x0E, 0x70, 0x3C, 0xF0, 0xF0, 0xF3, 0xC1, 0xFF, 0x01, 0xFC, 0x00,
  0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x0E, 0x1F, 0x0E, 0x07, 0x0E, 0x07,
  0x0E, 0x07, 0x1C, 0x07, 0x1C, 0x0E, 0x1C, 0x1E, 0x1F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xE0, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF0, 0xE1,
  0xC1, 0xE7, 0x01, 0xCE, 0x03, 0xBC, 0x07, 0x70, 0x0E, 0xE0, 0x39, 0xC0,
  0x77, 0x00, 0xEE, 0x01, 0xDC, 0x07, 0x38, 0x0E, 0x70, 0x3C, 0xF0, 0xF0,
  0xF3, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x70, 0xF0, 0xE0,
  0xE1, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x1E, 0x38, 0x78, 0xFF, 0xE1,
  0xFF, 0x83, 0xFE, 0x07, 0x1C, 0x1E, 0x3C, 0x38, 0x38, 0x70, 0x70, 0xE0,
  0x73, 0xC0, 0xE7, 0x01, 0xC0, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x0F,
  0x02, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x40, 0x38, 0x78, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x1C, 0x0E, 0x1C,
  0x0E, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x70,
  0x1C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x38, 0xE0, 0x78, 0xE0,
  0x70, 0xF0, 0xF0, 0x79, 0xE0, 0x7F, 0xE0, 0x3F, 0x80, 0xE0, 0x1F, 0xC0,
  0x3B, 0x80, 0xF7, 0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x38, 0x1C, 0x70, 0x70,
  0xE0, 0xE1, 0xC3, 0x81, 0x87, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0xE0, 0x1D,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0x87,
  0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x06, 0x01, 0xC3, 0x80,
  0x70, 0xE7, 0x1C, 0x39, 0xC6, 0x0C, 0xF3, 0x83, 0x3C, 0xE0, 0xDB, 0xB0,
  0x76, 0x6C, 0x1F, 0x1F, 0x06, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1C,
  0x1C, 0x0F, 0x07, 0x00, 0x07, 0x81, 0xE0, 0x70, 0x78, 0x0E, 0x1E, 0x01,
  0xE3, 0x80, 0x1C, 0xE0, 0x03, 0xB8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xDC, 0x00, 0x7B, 0x80, 0x1E,
  0x70, 0x03, 0x87, 0x00, 0xE0, 0xE0, 0x3C, 0x1C, 0x0F, 0x03, 0x83, 0xC0,
  0x78, 0x00, 0xF0, 0x1E, 0xE0, 0x39, 0xC0, 0xE3, 0x83, 0xC7, 0x07, 0x06,
  0x1C, 0x0E, 0x78, 0x1C, 0xE0, 0x3B, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x7F, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCF, 0x39, 0xCE,
  0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0xFF,
  0x03, 0xFE, 0x00, 0x01, 0xC0, 0x1F, 0x01, 0xF8, 0x1F, 0xC1, 0xE7, 0x0E,
  0x38, 0xE1, 0xCE, 0x07, 0xF0, 0x3B, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xF0, 0x41, 0x8F, 0x1E, 0x3C, 0x20, 0x01, 0xF8, 0x3F, 0xF1, 0xFF,
  0xCF, 0x0E, 0x78, 0x39, 0xC0, 0xEF, 0x03, 0xB8, 0x1C, 0xE0, 0x73, 0x81,
  0xCE, 0x07, 0x38, 0x3C, 0xFB, 0xF1, 0xFF, 0xC3, 0xF7, 0x00, 0x01, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x78, 0x0F, 0xF8, 0x3F, 0xF8, 0x70, 0x70, 0xE0, 0xF1, 0xC0, 0xE7, 0x03,
  0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0xF0, 0x71, 0xC1, 0xE3, 0x8F, 0x87,
  0xFE, 0x1F, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0xF1, 0xFF, 0x8F, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x7E, 0x71, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x01, 0xFC, 0x07,
  0xFC, 0x1F, 0xFC, 0x3C, 0x1C, 0x38, 0x38, 0x70, 0x38, 0x70, 0x38, 0xF0,
  0x38, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xF0, 0x70, 0x79, 0xF0, 0x7F,
  0xF0, 0x3F, 0x70, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x07, 0x78, 0x1D,
  0xC0, 0xF7, 0x07, 0xBF, 0xFC, 0xFF, 0xC3, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x7C, 0x71, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x07, 0xA0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x80, 0xFF, 0x81, 0xFF, 0xC1, 0xE0, 0xE0, 0xE0, 0xF0, 0xE0, 0x70,
  0x70, 0x38, 0x38, 0x1C, 0x38, 0x0E, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0xCF,
  0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x39,
  0xF8, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFC, 0x1F, 0xF8, 0x7F, 0xF1,
  0xC3, 0xC7, 0x07, 0x3C, 0x1C, 0xE0, 0x73, 0x83, 0xCE, 0x0E, 0x38, 0x39,
  0xC0, 0xE7, 0x07, 0x9C, 0x1C, 0x70, 0x73, 0x81, 0xC0, 0x03, 0x01, 0xE0,
  0xF8, 0x3C, 0x06, 0x00, 0x00, 0x03, 0xFC, 0xFE, 0x3F, 0x80, 0xE0, 0x78,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0x1F, 0xC3,
  0xF0, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xE0, 0x73, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x0F, 0x1C, 0x3C,
  0x38, 0xF0, 0xF3, 0xC1, 0xCF, 0x03, 0xBC, 0x07, 0xE0, 0x1F, 0xC0, 0x3B,
  0xC0, 0x73, 0xC0, 0xE3, 0x81, 0xC7, 0x87, 0x07, 0x0E, 0x0F, 0x1C, 0x0E,
  0x00, 0x7F, 0x7F, 0xBF, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E,
  0x0E, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x37,
  0xF9, 0xFC, 0x0F, 0x9C, 0x3F, 0xFC, 0x7F, 0xF9, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCC, 0x73, 0xB8, 0xC6, 0x73, 0x9C, 0xE0, 0x39, 0x80, 0x77, 0x00,
  0xCE, 0x01, 0x9C, 0x07, 0x30, 0x0E, 0x00, 0x07, 0xE0, 0xFF, 0x87, 0xFE,
  0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xEE, 0x07, 0x70, 0x3B, 0x83, 0x9C,
  0x1D, 0xE0, 0xEE, 0x07, 0x70, 0x73, 0x83, 0x80, 0x03, 0xE0, 0x3F, 0xC1,
  0xFF, 0x8F, 0x0E, 0x78, 0x3D, 0xC0, 0x77, 0x01, 0xFC, 0x0E, 0xE0, 0x3B,
  0x80, 0xEE, 0x07, 0xBC, 0x3C, 0x79, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x0E, 0x0E, 0x0E, 0x0F, 0x0E, 0x07, 0x1E,
  0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x1C, 0x38, 0x3C, 0x39,
  0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0xF1, 0xFF, 0xCF, 0x07, 0x38, 0x3D,
  0xC0, 0xE7, 0x03, 0xBC, 0x0E, 0xE0, 0x7B, 0x81, 0xCE, 0x07, 0x3C, 0x1C,
  0x79, 0xF1, 0xFF, 0x83, 0xFE, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xFC, 0x3F, 0xF1, 0xFF, 0xC7, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x71, 0xE3, 0xFF, 0x87, 0xF8, 0x00, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7C, 0xC3, 0xFC, 0x3F,
  0xC0, 0x1C, 0x1C, 0xE0, 0x73, 0x83, 0xCE, 0x0E, 0x38, 0x39, 0xC0, 0xE7,
  0x03, 0x9C, 0x1C, 0x70, 0x73, 0xC1, 0xCE, 0x07, 0x3C, 0x3C, 0x7B, 0xF1,
  0xFF, 0xC3, 0xF7, 0x00, 0xE0, 0x3F, 0x03, 0xB8, 0x1D, 0xC1, 0xEE, 0x0E,
  0x70, 0xF3, 0x87, 0x1C, 0x78, 0xE3, 0x83, 0xB8, 0x1D, 0xC0, 0xFC, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x00, 0x70, 0x07, 0x70, 0x07, 0x70, 0x06, 0x70,
  0x0E, 0x63, 0x8E, 0x63, 0x8C, 0x67, 0x9C, 0xE7, 0x98, 0xEF, 0x98, 0xED,
  0xB8, 0xF9, 0xB0, 0xF9, 0xF0, 0xF0, 0xE0, 0xF0, 0xE0, 0xE0, 0xC0, 0x0E,
  0x03, 0x87, 0x83, 0x81, 0xC3, 0x80, 0xF3, 0x80, 0x3B, 0xC0, 0x1F, 0xC0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xF8, 0x03, 0xDC, 0x01, 0xC7,
  0x01, 0xC3, 0x81, 0xC1, 0xE3, 0xC0, 0x70, 0x07, 0x03, 0xC1, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x1E, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0x78, 0xE0, 0x0E,
  0x38, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x13, 0xE0, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E,
  0x00, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x00, 0x00, 0x7E, 0x03, 0xFC, 0x07,
  0xF0, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x01, 0xC0,
  0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x00, 0x03, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x0F, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x1C,
  0x08, 0xFC, 0x77, 0xFF, 0xF8, 0xFE, 0xC1, 0xF0,
};

const GFXglyph UbuntuSansMono_MediumItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 8, 19, 16, 4, -19 },
  { 20, 10, 8, 16, 5, -21 },
  { 30, 17, 19, 16, 0, -19 },
  { 71, 15, 25, 16, 1, -22 },
  { 118, 19, 20, 16, -1, -20 },
  { 166, 15, 20, 16, 0, -20 },
  { 204, 5, 8, 16, 8, -21 },
  { 209, 12, 27, 16, 3, -22 },
  { 250, 13, 27, 16, 0, -22 },
  { 294, 12, 11, 16, 3, -19 },
  { 311, 14, 14, 16, 1, -15 },
  { 336, 7, 10, 16, 2, -5 },
  { 345, 8, 3, 16, 4, -9 },
  { 348, 5, 5, 16, 4, -5 },
  { 352, 19, 27, 16, -2, -22 },
  { 417, 14, 20, 16, 1, -20 },
  { 452, 12, 19, 16, 1, -19 },
  { 481, 14, 20, 16, 1, -20 },
  { 516, 15, 20, 16, 0, -20 },
  { 554, 15, 19, 16, 0, -19 },
  { 590, 16, 19, 16, 0, -19 },
  { 628, 14, 20, 16, 2, -20 },
  { 663, 14, 19, 16, 3, -19 },
  { 697, 15, 20, 16, 1, -20 },
  { 735, 15, 20, 16, 1, -20 },
  { 773, 7, 15, 16, 4, -15 },
  { 787, 9, 20, 16, 2, -15 },
  { 810, 14, 12, 16, 1, -14 },
  { 831, 14, 9, 16, 1, -13 },
  { 847, 14, 12, 16, 1, -14 },
  { 868, 11, 20, 16, 4, -20 },
  { 896, 15, 24, 16, 1, -20 },
  { 941, 16, 19, 16, -2, -19 },
  { 979, 15, 20, 16, 0, -20 },
  { 1017, 15, 20, 16, 2, -20 },
  { 1055, 15, 20, 16, 0, -20 },
  { 1093, 16, 19, 16, 1, -19 },
  { 1131, 16, 19, 16, 1, -19 },
  { 1169, 15, 20, 16, 1, -20 },
  { 1207, 17, 19, 16, 0, -19 },
  { 1248, 15, 19, 16, 1, -19 },
  { 1284, 15, 19, 16, 1, -19 },
  { 1320, 17, 19, 16, 0, -19 },
  { 1361, 12, 19, 16, 0, -19 },
  { 1390, 18, 19, 16, -1, -19 },
  { 1433, 17, 19, 16, 0, -19 },
  { 1474, 15, 20, 16, 1, -20 },
  { 1512, 16, 20, 16, 0, -20 },
  { 1552, 15, 25, 16, 1, -20 },
  { 1599, 15, 20, 16, 0, -20 },
  { 1637, 16, 20, 16, 0, -20 },
  { 1677, 14, 19, 16, 3, -19 },
  { 1711, 16, 19, 16, 1, -19 },
  { 1749, 15, 19, 16, 3, -19 },
  { 1785, 18, 19, 16, 0, -19 },
  { 1828, 19, 19, 16, -1, -19 },
  { 1874, 15, 19, 16, 3, -19 },
  { 1910, 17, 19, 16, 0, -19 },
  { 1951, 14, 27, 16, 2, -22 },
  { 1999, 5, 27, 16, 6, -22 },
  { 2016, 15, 27, 16, -1, -22 },
  { 2067, 13, 10, 16, 2, -19 },
  { 2084, 15, 3, 16, -2, 2 },
  { 2090, 6, 6, 16, 7, -22 },
  { 2095, 14, 15, 16, 1, -15 },
  { 2122, 15, 22, 16, 0, -22 },
  { 2164, 14, 15, 16, 1, -15 },
  { 2191, 16, 22, 16, 1, -22 },
  { 2235, 14, 15, 16, 1, -15 },
  { 2262, 19, 27, 16, -1, -22 },
  { 2327, 17, 20, 16, -1, -15 },
  { 2370, 14, 22, 16, 0, -22 },
  { 2409, 10, 22, 16, 3, -22 },
  { 2437, 16, 27, 16, -1, -22 },
  { 2491, 15, 22, 16, 1, -22 },
  { 2533, 9, 22, 16, 4, -22 },
  { 2558, 15, 15, 16, 0, -15 },
  { 2587, 13, 15, 16, 1, -15 },
  { 2612, 14, 15, 16, 1, -15 },
  { 2639, 16, 20, 16, -1, -15 },
  { 2679, 14, 20, 16, 1, -15 },
  { 2714, 14, 15, 16, 1, -15 },
  { 2741, 14, 15, 16, 1, -15 },
  { 2768, 12, 19, 16, 3, -19 },
  { 2797, 14, 15, 16, 1, -15 },
  { 2824, 13, 15, 16, 3, -15 },
  { 2849, 16, 15, 16, 1, -15 },
  { 2879, 17, 15, 16, -1, -15 },
  { 2911, 18, 20, 16, -2, -15 },
  { 2956, 14, 15, 16, 1, -15 },
  { 2983, 15, 27, 16, 2, -22 },
  { 3034, 10, 27, 16, 3, -22 },
  { 3068, 15, 27, 16, -1, -22 },
  { 3119, 14, 5, 16, 1, -11 },
};

const GFXfont UbuntuSansMono_MediumItalic28pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic28pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic28pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC28PT7B_H_
