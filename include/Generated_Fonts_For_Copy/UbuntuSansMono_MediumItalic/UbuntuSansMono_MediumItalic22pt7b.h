#ifndef _UBUNTUSANSMONO_MEDIUMITALIC22PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x38, 0x70, 0xE1, 0x83, 0x0E, 0x1C, 0x30, 0x60, 0x00, 0x07,
  0x1E, 0x38, 0x00, 0x73, 0x67, 0x66, 0x66, 0xC6, 0xC4, 0xC4, 0x03, 0x18,
  0x19, 0x81, 0x8C, 0x0C, 0xC3, 0xFF, 0xBF, 0xFC, 0x33, 0x03, 0x18, 0x19,
  0x87, 0xFF, 0xBF, 0xF8, 0xE6, 0x06, 0x30, 0x33, 0x03, 0x18, 0x00, 0x01,
  0x80, 0x30, 0x1E, 0x0F, 0xF3, 0xC6, 0x70, 0x0C, 0x01, 0xC0, 0x1E, 0x01,
  0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0xB9, 0xE7, 0xF8, 0x3C, 0x03, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x1E, 0x1C, 0x6C, 0x30, 0x98, 0xC1, 0x33, 0x06,
  0x6C, 0x07, 0xB0, 0x0E, 0xC0, 0x01, 0x00, 0x06, 0xE0, 0x1B, 0x60, 0x6C,
  0xC1, 0x99, 0x86, 0x32, 0x18, 0x6C, 0x70, 0x70, 0x01, 0x80, 0x7C, 0x0E,
  0xE1, 0xC6, 0x18, 0xC1, 0x8C, 0x1F, 0x80, 0xF0, 0x1E, 0x73, 0x66, 0x63,
  0x66, 0x3C, 0xE1, 0xCE, 0x3C, 0x7F, 0xC3, 0xCE, 0x77, 0x66, 0x6C, 0xC0,
  0x01, 0x81, 0xC3, 0xC3, 0x81, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x03, 0x00,
  0x02, 0x01, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xC0,
  0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x70, 0x18, 0x0E, 0x07, 0x03, 0x83,
  0xC0, 0x40, 0x00, 0x0C, 0x03, 0x06, 0xCF, 0xDF, 0x7F, 0x87, 0x83, 0xB1,
  0xCE, 0x11, 0x00, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x0F, 0xFF, 0xFF, 0xBF,
  0xF0, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x00, 0x33, 0xDE, 0x71, 0xBB, 0x90,
  0xFF, 0xF8, 0x6F, 0xFF, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x00, 0x03, 0x01, 0xF8, 0x7F, 0x9C, 0x33, 0x06,
  0xE0, 0xD9, 0x1B, 0x73, 0xEE, 0xFC, 0x9B, 0x03, 0x60, 0xEC, 0x19, 0xC7,
  0x1F, 0xC3, 0xF0, 0x01, 0x83, 0xC7, 0xE7, 0xF3, 0x30, 0x18, 0x1C, 0x0E,
  0x06, 0x03, 0x03, 0x81, 0xC0, 0xC7, 0xFF, 0xFE, 0x01, 0x80, 0xFE, 0x1F,
  0xF0, 0x87, 0x00, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x7F, 0xCF, 0xFC, 0x01, 0x80, 0xFE, 0x0E,
  0xF0, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x78, 0x0F, 0xC0, 0x0C, 0x00,
  0xE0, 0x0E, 0x00, 0xE4, 0x1C, 0x7F, 0xCF, 0xF0, 0x00, 0x70, 0x0F, 0x01,
  0xE0, 0x36, 0x06, 0x60, 0xCE, 0x18, 0xC3, 0x0C, 0x70, 0xC7, 0xFE, 0xFF,
  0xE0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x07, 0xF8, 0x3F, 0x83, 0x80,
  0x18, 0x00, 0xC0, 0x0E, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xC0, 0x07, 0x00,
  0x38, 0x01, 0xC4, 0x1C, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xF0, 0x7E, 0x0E,
  0x01, 0x80, 0x30, 0x07, 0x00, 0x7F, 0x87, 0xBC, 0xE0, 0xCE, 0x0C, 0xE0,
  0xCE, 0x0C, 0x61, 0xC7, 0xF8, 0x3F, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0xC0,
  0x18, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x00, 0x03, 0x01, 0xF8, 0x73, 0x9C, 0x33,
  0x06, 0x60, 0xCE, 0x30, 0xFC, 0x3F, 0x0E, 0x73, 0x87, 0x60, 0x6C, 0x1D,
  0xC3, 0xBF, 0xE3, 0xF8, 0x03, 0x03, 0xF8, 0xF7, 0x98, 0x37, 0x06, 0xE0,
  0xDC, 0x1B, 0x83, 0x3F, 0xE3, 0xF8, 0x07, 0x00, 0xC0, 0x38, 0x1E, 0x3F,
  0x07, 0x80, 0x18, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x63, 0xCF, 0x3C, 0x0C,
  0x3C, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x30, 0xF1, 0xE1, 0xC1, 0x8E, 0x38,
  0x40, 0x00, 0x60, 0x7C, 0x7E, 0x3E, 0x0F, 0x01, 0xE0, 0x0F, 0x80, 0x7E,
  0x03, 0x80, 0x10, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0xFF, 0xE0, 0x18, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0E, 0x07, 0xC7, 0xE7,
  0xE0, 0x70, 0x10, 0x00, 0x0C, 0x3F, 0x8D, 0xE0, 0x70, 0x38, 0x18, 0x1C,
  0x38, 0x38, 0x18, 0x1C, 0x00, 0x00, 0x07, 0x03, 0xC1, 0xC0, 0x01, 0x80,
  0xFE, 0x1C, 0x73, 0x83, 0x30, 0x36, 0x1F, 0x67, 0xFC, 0xE6, 0xCC, 0x6C,
  0xC6, 0xDC, 0xED, 0xCC, 0xDC, 0xCC, 0xFC, 0xC7, 0xCC, 0x00, 0xE0, 0x07,
  0xF0, 0x3F, 0x00, 0x00, 0xE0, 0x1E, 0x03, 0xE0, 0x36, 0x06, 0x60, 0x66,
  0x0C, 0x60, 0xC6, 0x18, 0x71, 0xFF, 0x3F, 0xF3, 0x07, 0x60, 0x76, 0x07,
  0xE0, 0x70, 0x0F, 0xE1, 0xFF, 0x18, 0x31, 0x83, 0x18, 0x73, 0x8E, 0x3F,
  0xC3, 0xFC, 0x30, 0xE7, 0x06, 0x70, 0x66, 0x0E, 0x61, 0xEF, 0xFC, 0xFF,
  0x00, 0x01, 0xC0, 0x7F, 0x1F, 0xF1, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x08, 0x7F, 0x83,
  0xF8, 0x1F, 0xC1, 0xFE, 0x18, 0x71, 0x87, 0x38, 0x33, 0x83, 0x30, 0x73,
  0x07, 0x70, 0x77, 0x06, 0x60, 0xE6, 0x1C, 0xE3, 0xCF, 0xF8, 0xFE, 0x00,
  0x1F, 0xF1, 0xFF, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x3F, 0xC7, 0xF8,
  0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F,
  0xF1, 0xFF, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x3F, 0xC3, 0xFC, 0x70,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x7F, 0x1F, 0xE3, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0xEE,
  0x0C, 0xC0, 0xCE, 0x1C, 0xE1, 0xCE, 0x18, 0x7F, 0x83, 0xF8, 0x1C, 0x18,
  0xE0, 0xC6, 0x0E, 0x30, 0x63, 0x83, 0x1C, 0x18, 0xFF, 0xC7, 0xFE, 0x70,
  0x63, 0x83, 0x18, 0x38, 0xC1, 0xCE, 0x0C, 0x70, 0x63, 0x07, 0x00, 0x0F,
  0xF8, 0x7F, 0x80, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x3F, 0xE3, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x84, 0x18, 0x7F, 0xC1, 0xFC,
  0x00, 0x0C, 0x3C, 0x71, 0xC1, 0x8E, 0x06, 0x70, 0x1B, 0x80, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x37, 0x01, 0xCC, 0x07, 0x38, 0x18, 0x60, 0x61, 0xC3,
  0x83, 0x0E, 0x0E, 0x00, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03,
  0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x1F, 0xFF, 0xF8, 0x06,
  0x1C, 0x38, 0x70, 0xE3, 0xC3, 0xCB, 0x1B, 0x78, 0x6D, 0x61, 0xBD, 0x86,
  0xE6, 0x33, 0x98, 0xC0, 0xC3, 0x03, 0x1C, 0x0C, 0x60, 0x31, 0x81, 0xCE,
  0x06, 0x00, 0x1C, 0x18, 0xE0, 0xC7, 0x86, 0x3C, 0x63, 0xE3, 0x19, 0x18,
  0xCC, 0xC6, 0x6E, 0x73, 0x63, 0x0B, 0x18, 0x78, 0xC3, 0xC6, 0x1C, 0x60,
  0xE3, 0x07, 0x00, 0x03, 0x01, 0xF8, 0x7F, 0x9C, 0x33, 0x06, 0xE0, 0xD8,
  0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0x60, 0x6C, 0x1D, 0xC7, 0x1F, 0xC3,
  0xF0, 0x0F, 0xE0, 0xFF, 0x87, 0x0C, 0x30, 0x71, 0x83, 0x0C, 0x18, 0xE1,
  0xC7, 0xFC, 0x3F, 0xC1, 0xE0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x00, 0x03, 0x01, 0xF8, 0x7F, 0x9C, 0x33, 0x06, 0xE0, 0xD8, 0x1F,
  0x03, 0xE0, 0x78, 0x1F, 0x03, 0x60, 0x6C, 0x1D, 0xC7, 0x1F, 0xC3, 0xF0,
  0x18, 0x03, 0x80, 0x7C, 0x03, 0x80, 0x0F, 0xE1, 0xFF, 0x18, 0x71, 0x83,
  0x18, 0x33, 0x87, 0x38, 0xE3, 0xFC, 0x3F, 0x87, 0x38, 0x71, 0x86, 0x18,
  0x61, 0xCE, 0x0C, 0xE0, 0xC0, 0x01, 0xC0, 0x3F, 0xC3, 0xDC, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x20, 0xE3, 0xFF, 0x0F, 0xE0, 0xFF, 0xFF, 0xF8, 0x30, 0x0E,
  0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x18, 0x00, 0x38, 0x33, 0x87, 0x30, 0x73, 0x06, 0x70, 0x67,
  0x0E, 0x60, 0xE6, 0x0C, 0xE0, 0xCE, 0x0C, 0xC1, 0xCC, 0x18, 0xE3, 0x8F,
  0xF0, 0x7E, 0x00, 0xE0, 0x7E, 0x06, 0xE0, 0xE6, 0x0C, 0x61, 0xC6, 0x18,
  0x63, 0x86, 0x30, 0x67, 0x06, 0x60, 0x6E, 0x06, 0xC0, 0x7C, 0x07, 0x80,
  0x70, 0x00, 0x18, 0x1C, 0x60, 0x63, 0x81, 0x8C, 0x06, 0x30, 0x38, 0xCC,
  0xC3, 0x73, 0x19, 0xCC, 0x6D, 0x61, 0xB5, 0x87, 0x96, 0x1C, 0x58, 0x71,
  0xC1, 0x87, 0x0E, 0x1C, 0x00, 0x0E, 0x0E, 0x0C, 0x38, 0x1C, 0xE0, 0x19,
  0x80, 0x36, 0x00, 0x7C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xC0, 0x0D, 0x80,
  0x3B, 0x80, 0xE3, 0x03, 0x86, 0x0E, 0x0C, 0x38, 0x1C, 0x00, 0xC0, 0xF8,
  0x1B, 0x07, 0x71, 0xC6, 0x30, 0xCC, 0x1B, 0x83, 0xE0, 0x38, 0x06, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xF0, 0x7E, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60,
  0x07, 0xE0, 0xFE, 0x00, 0xE7, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x9C, 0xE7,
  0x38, 0xC6, 0x31, 0x8C, 0x63, 0x80, 0x07, 0xE1, 0xFC, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x7E, 0x0F, 0xC0, 0x03,
  0x80, 0xF0, 0x3E, 0x0E, 0xE1, 0x8C, 0x61, 0x9C, 0x3F, 0x03, 0x7F, 0xFF,
  0xFE, 0x47, 0x1C, 0x30, 0x07, 0xC3, 0xFC, 0xF3, 0x38, 0x66, 0x0D, 0xC3,
  0xB0, 0x66, 0x0C, 0xC1, 0x9C, 0x73, 0xFE, 0x3E, 0xC0, 0x0E, 0x01, 0x80,
  0x30, 0x06, 0x01, 0xC0, 0x37, 0x07, 0xF8, 0xE7, 0x38, 0x67, 0x0C, 0xC1,
  0x98, 0x37, 0x0E, 0xE1, 0xD8, 0x73, 0xFC, 0xFF, 0x00, 0x07, 0xC3, 0xFC,
  0xF1, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x11, 0xFE,
  0x1F, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x3E, 0x1F,
  0xE3, 0xCE, 0x70, 0xC6, 0x0C, 0xE1, 0xCC, 0x1C, 0xC1, 0x8C, 0x18, 0xE3,
  0x8F, 0xF8, 0x7D, 0xC0, 0x07, 0x83, 0xF8, 0xE3, 0xB8, 0x76, 0x0D, 0xC7,
  0xBF, 0xE7, 0xC0, 0xC0, 0x1C, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7E, 0x01,
  0xF8, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x03, 0xFE, 0x07, 0xFC,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x07, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x3F, 0xC3, 0xCE, 0x38, 0x71, 0x83, 0x1C, 0x18, 0xE1,
  0xC7, 0x0E, 0x38, 0x61, 0xFF, 0x07, 0xF8, 0x01, 0xC0, 0x0C, 0x20, 0xE1,
  0xFE, 0x1F, 0xE0, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x37, 0x07,
  0xF1, 0xC7, 0x38, 0xE6, 0x0C, 0xC3, 0xB8, 0x77, 0x0C, 0xC1, 0x98, 0x73,
  0x0E, 0xE1, 0x80, 0x0E, 0x0E, 0x0E, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x1C,
  0x18, 0x18, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x1F, 0x00, 0x30, 0x03, 0xC0,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x10, 0xC0, 0xFE, 0x0F, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x03, 0x81, 0x30, 0xE3, 0x1C, 0x33, 0x87, 0xE0, 0x7C, 0x06,
  0xC0, 0x6E, 0x0E, 0x70, 0xE3, 0x0C, 0x38, 0xC1, 0xC0, 0x7D, 0xF8, 0x70,
  0xC1, 0x83, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x3F, 0x3E,
  0x0E, 0x63, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x36, 0x66, 0x66, 0x66, 0x66,
  0x60, 0x6C, 0x0E, 0xC0, 0xCC, 0x0C, 0x07, 0x83, 0xFC, 0x73, 0x9C, 0x33,
  0x86, 0x60, 0xCC, 0x39, 0x87, 0x70, 0xCC, 0x19, 0x87, 0x70, 0xE0, 0x07,
  0x03, 0xF8, 0xE7, 0x38, 0x66, 0x0F, 0xC1, 0xB0, 0x36, 0x06, 0xC1, 0xDC,
  0x73, 0xFC, 0x3F, 0x00, 0x03, 0xC0, 0x7F, 0x83, 0x1C, 0x38, 0x61, 0xC3,
  0x8C, 0x18, 0x60, 0xC7, 0x0E, 0x38, 0x71, 0x87, 0x0F, 0xF0, 0xFF, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0x03, 0xC3, 0xFC, 0xF3, 0xB8, 0x66,
  0x0D, 0xC1, 0xB8, 0x76, 0x0C, 0xC1, 0x9C, 0x73, 0xFE, 0x3F, 0xC0, 0x30,
  0x06, 0x01, 0xC0, 0x38, 0x07, 0xC3, 0xFC, 0xFF, 0x1C, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x00, 0x07, 0x87, 0xF3,
  0x8C, 0xC0, 0x38, 0x0F, 0x80, 0xF0, 0x0E, 0x01, 0xA0, 0xEF, 0xF3, 0xF8,
  0x0C, 0x03, 0x01, 0xC0, 0x70, 0xFF, 0xFF, 0xE3, 0x80, 0xE0, 0x30, 0x0C,
  0x07, 0x01, 0xC0, 0x70, 0x1F, 0xC3, 0xF0, 0x30, 0xEE, 0x19, 0xC3, 0x30,
  0xE6, 0x1D, 0xC3, 0x38, 0x67, 0x0C, 0xE3, 0x9F, 0xF1, 0xF6, 0x00, 0xE0,
  0xF8, 0x7E, 0x1B, 0x8E, 0xE3, 0x19, 0xC6, 0x61, 0xB0, 0x7C, 0x1E, 0x03,
  0x00, 0x60, 0x36, 0x03, 0xE6, 0x6C, 0xE6, 0xCE, 0x6D, 0xEC, 0xDE, 0xCF,
  0x28, 0xE3, 0x8E, 0x38, 0xC3, 0x00, 0x1C, 0x3C, 0x39, 0xC0, 0x6E, 0x01,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x03, 0xF0, 0x1C, 0xC0, 0xE3, 0x8F,
  0x06, 0x00, 0x0E, 0x0C, 0x38, 0x70, 0xE1, 0x81, 0x8E, 0x06, 0x30, 0x18,
  0xC0, 0x76, 0x01, 0xD8, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x01, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0xF1, 0xFE, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0xFC, 0xFF, 0x80, 0x01, 0xF0,
  0x3F, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x07,
  0x80, 0x70, 0x0B, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x03, 0xF0, 0x1E, 0x00, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x86,
  0x0C, 0x18, 0x70, 0xC1, 0x83, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x86, 0x0C,
  0x00, 0x07, 0xC0, 0x7E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x1C, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x0E, 0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x7F, 0xFB,
  0x1F, 0x00, 0x80,
};

const GFXglyph UbuntuSansMono_MediumItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 15, 12, 3, -15 },
  { 15, 8, 7, 12, 4, -17 },
  { 22, 13, 15, 12, 0, -15 },
  { 47, 11, 19, 12, 1, -17 },
  { 74, 15, 16, 12, -1, -16 },
  { 104, 12, 16, 12, 0, -16 },
  { 128, 4, 7, 12, 6, -17 },
  { 132, 9, 21, 12, 3, -17 },
  { 156, 10, 21, 12, 0, -17 },
  { 183, 10, 9, 12, 2, -15 },
  { 195, 11, 11, 12, 1, -12 },
  { 211, 5, 8, 12, 2, -4 },
  { 216, 7, 2, 12, 3, -7 },
  { 218, 4, 4, 12, 3, -4 },
  { 220, 14, 21, 12, -1, -17 },
  { 257, 11, 16, 12, 1, -16 },
  { 279, 9, 15, 12, 1, -15 },
  { 296, 12, 16, 12, 0, -16 },
  { 320, 12, 16, 12, 0, -16 },
  { 344, 12, 15, 12, 0, -15 },
  { 367, 13, 15, 12, 0, -15 },
  { 392, 12, 15, 12, 1, -15 },
  { 415, 12, 15, 12, 2, -15 },
  { 438, 11, 16, 12, 1, -16 },
  { 460, 11, 16, 12, 1, -16 },
  { 482, 6, 12, 12, 3, -12 },
  { 491, 7, 16, 12, 2, -12 },
  { 505, 11, 10, 12, 1, -11 },
  { 519, 12, 7, 12, 0, -10 },
  { 530, 11, 10, 12, 0, -11 },
  { 544, 9, 16, 12, 3, -16 },
  { 562, 12, 19, 12, 1, -16 },
  { 591, 12, 15, 12, -1, -15 },
  { 614, 12, 15, 12, 0, -15 },
  { 637, 12, 16, 12, 1, -16 },
  { 661, 12, 15, 12, 0, -15 },
  { 684, 12, 15, 12, 1, -15 },
  { 707, 12, 15, 12, 1, -15 },
  { 730, 12, 16, 12, 1, -16 },
  { 754, 13, 15, 12, 0, -15 },
  { 779, 13, 15, 12, 0, -15 },
  { 804, 13, 15, 12, 0, -15 },
  { 829, 14, 15, 12, 0, -15 },
  { 856, 10, 15, 12, 0, -15 },
  { 875, 14, 15, 12, -1, -15 },
  { 902, 13, 15, 12, 0, -15 },
  { 927, 11, 16, 12, 1, -16 },
  { 949, 13, 15, 12, 0, -15 },
  { 974, 11, 20, 12, 1, -16 },
  { 1002, 12, 15, 12, 0, -15 },
  { 1025, 13, 16, 12, 0, -16 },
  { 1051, 11, 15, 12, 3, -15 },
  { 1072, 12, 15, 12, 1, -15 },
  { 1095, 12, 15, 12, 2, -15 },
  { 1118, 14, 15, 12, 0, -15 },
  { 1145, 15, 15, 12, -1, -15 },
  { 1174, 11, 15, 12, 3, -15 },
  { 1195, 13, 15, 12, 0, -15 },
  { 1220, 12, 21, 12, 1, -17 },
  { 1252, 5, 21, 12, 4, -17 },
  { 1266, 11, 21, 12, 0, -17 },
  { 1295, 11, 8, 12, 1, -15 },
  { 1306, 12, 2, 12, -2, 2 },
  { 1309, 5, 4, 12, 5, -17 },
  { 1312, 11, 12, 12, 1, -12 },
  { 1329, 11, 17, 12, 0, -17 },
  { 1353, 11, 12, 12, 1, -12 },
  { 1370, 12, 17, 12, 1, -17 },
  { 1396, 11, 12, 12, 1, -12 },
  { 1413, 15, 21, 12, -1, -17 },
  { 1453, 13, 16, 12, -1, -12 },
  { 1479, 11, 17, 12, 0, -17 },
  { 1503, 8, 17, 12, 2, -17 },
  { 1520, 13, 21, 12, -1, -17 },
  { 1555, 12, 17, 12, 1, -17 },
  { 1581, 7, 17, 12, 3, -17 },
  { 1596, 12, 12, 12, 0, -12 },
  { 1614, 11, 12, 12, 0, -12 },
  { 1631, 11, 12, 12, 1, -12 },
  { 1648, 13, 16, 12, -1, -12 },
  { 1674, 11, 16, 12, 1, -12 },
  { 1696, 11, 12, 12, 1, -12 },
  { 1713, 10, 12, 12, 1, -12 },
  { 1728, 10, 15, 12, 2, -15 },
  { 1747, 11, 11, 12, 1, -11 },
  { 1763, 10, 11, 12, 2, -11 },
  { 1777, 12, 11, 12, 1, -11 },
  { 1794, 14, 11, 12, -1, -11 },
  { 1814, 14, 15, 12, -2, -11 },
  { 1841, 12, 11, 12, 0, -11 },
  { 1858, 12, 21, 12, 1, -17 },
  { 1890, 7, 21, 12, 3, -17 },
  { 1909, 12, 21, 12, -1, -17 },
  { 1941, 11, 4, 12, 1, -8 },
};

const GFXfont UbuntuSansMono_MediumItalic22pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic22pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC22PT7B_H_
