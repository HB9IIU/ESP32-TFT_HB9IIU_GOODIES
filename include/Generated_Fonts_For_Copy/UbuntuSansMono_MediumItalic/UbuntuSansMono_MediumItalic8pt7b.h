#ifndef _UBUNTUSANSMONO_MEDIUMITALIC8PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0xF0, 0x29, 0xBE, 0xAF, 0x50, 0x17, 0x43, 0x1E, 0x40,
  0x4D, 0xB4, 0x67, 0x58, 0x35, 0x67, 0xBF, 0xE0, 0x2A, 0x49, 0x22, 0x22,
  0x11, 0x22, 0x48, 0x5D, 0x50, 0x2F, 0x24, 0xE0, 0xC0, 0xC0, 0x18, 0x88,
  0x44, 0x22, 0x00, 0x35, 0x5B, 0x96, 0x17, 0x22, 0x2F, 0x35, 0x12, 0x4F,
  0x71, 0x13, 0x1E, 0x13, 0x59, 0xF2, 0x3A, 0x10, 0x61, 0x70, 0x19, 0x19,
  0x29, 0x38, 0xF2, 0x24, 0x88, 0x32, 0x54, 0xE9, 0x38, 0x35, 0x57, 0x1E,
  0x43, 0x43, 0x80, 0x3C, 0x61, 0x70, 0xF0, 0x61, 0x68, 0x64, 0xA1, 0x00,
  0x32, 0x5F, 0x6D, 0x59, 0x80, 0x13, 0x55, 0xF9, 0x35, 0x57, 0x9E, 0x3A,
  0x11, 0x08, 0x38, 0x65, 0x59, 0x9E, 0x3A, 0x10, 0xE4, 0x78, 0x3A, 0x10,
  0xE4, 0x40, 0x3A, 0x11, 0x29, 0x38, 0x4A, 0x55, 0x69, 0x48, 0x79, 0x08,
  0x42, 0x70, 0x38, 0x84, 0x21, 0x70, 0x4A, 0x98, 0xCA, 0x48, 0x44, 0x44,
  0x8F, 0x4A, 0xD5, 0x69, 0x48, 0x4A, 0x5D, 0x6B, 0x48, 0x32, 0x93, 0x29,
  0x30, 0x32, 0x52, 0xE8, 0x40, 0x32, 0x93, 0x29, 0x31, 0x06, 0x25, 0x56,
  0xA9, 0x3A, 0x10, 0x61, 0x70, 0xF4, 0x44, 0x48, 0x4A, 0x55, 0x29, 0x30,
  0x99, 0xAA, 0xCC, 0x4A, 0x5B, 0x6F, 0x48, 0x4A, 0x8C, 0x45, 0x48, 0x99,
  0xA4, 0x48, 0x78, 0x88, 0x44, 0x78, 0x74, 0x48, 0x88, 0xC0, 0xFE, 0x31,
  0x22, 0x22, 0xC0, 0x2E, 0xD0, 0xF8, 0xC0, 0x79, 0x9F, 0x44, 0x75, 0x9E,
  0x78, 0x87, 0x08, 0x5D, 0x29, 0x38, 0x79, 0xE7, 0x39, 0x5C, 0x44, 0x21,
  0x10, 0x79, 0x97, 0xA4, 0x44, 0x75, 0x9B, 0x43, 0x28, 0xC0, 0x10, 0x71,
  0x22, 0xA4, 0x62, 0x54, 0xCA, 0x48, 0xC9, 0x29, 0xC0, 0x7B, 0x99, 0x75,
  0x99, 0x79, 0x96, 0x75, 0x9E, 0x80, 0x79, 0x97, 0x20, 0x74, 0x48, 0x76,
  0x1E, 0x5E, 0x4E, 0x55, 0x97, 0xBA, 0xCC, 0x8D, 0xBD, 0x40, 0x59, 0x19,
  0x20, 0x2C, 0xA3, 0x0C, 0x23, 0x00, 0x72, 0x4F, 0x39, 0x09, 0x84, 0x21,
  0x80, 0x29, 0x25, 0x20, 0x72, 0x21, 0x24, 0xC0, 0xF0,
};

const GFXglyph UbuntuSansMono_MediumItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 6, 4, 1, -6 },
  { 3, 2, 2, 4, 2, -6 },
  { 4, 5, 6, 4, 0, -6 },
  { 8, 4, 7, 4, 0, -6 },
  { 12, 5, 6, 4, 0, -6 },
  { 16, 4, 6, 4, 0, -6 },
  { 19, 2, 2, 4, 2, -6 },
  { 20, 3, 8, 4, 1, -6 },
  { 23, 4, 8, 4, 0, -6 },
  { 27, 3, 4, 4, 1, -6 },
  { 29, 4, 4, 4, 0, -4 },
  { 31, 2, 2, 4, 1, -1 },
  { 32, 2, 1, 4, 1, -3 },
  { 33, 2, 1, 4, 1, -1 },
  { 34, 5, 7, 4, 0, -6 },
  { 39, 4, 6, 4, 0, -6 },
  { 42, 4, 6, 4, 0, -6 },
  { 45, 4, 6, 4, 0, -6 },
  { 48, 4, 6, 4, 0, -6 },
  { 51, 4, 6, 4, 0, -6 },
  { 54, 5, 6, 4, 0, -6 },
  { 58, 5, 6, 4, 0, -6 },
  { 62, 4, 6, 4, 1, -6 },
  { 65, 5, 6, 4, 0, -6 },
  { 69, 4, 6, 4, 0, -6 },
  { 72, 2, 4, 4, 1, -4 },
  { 73, 2, 5, 4, 1, -4 },
  { 75, 4, 4, 4, 0, -4 },
  { 77, 4, 3, 4, 0, -4 },
  { 79, 4, 4, 4, 0, -4 },
  { 81, 3, 6, 4, 1, -6 },
  { 84, 5, 7, 4, 0, -6 },
  { 89, 4, 6, 4, 0, -6 },
  { 92, 4, 6, 4, 0, -6 },
  { 95, 5, 6, 4, 0, -6 },
  { 99, 4, 6, 4, 0, -6 },
  { 102, 5, 6, 4, 0, -6 },
  { 106, 5, 6, 4, 0, -6 },
  { 110, 5, 6, 4, 0, -6 },
  { 114, 5, 6, 4, 0, -6 },
  { 118, 5, 6, 4, 0, -6 },
  { 122, 5, 6, 4, 0, -6 },
  { 126, 5, 6, 4, 0, -6 },
  { 130, 4, 6, 4, 0, -6 },
  { 133, 5, 6, 4, 0, -6 },
  { 137, 5, 6, 4, 0, -6 },
  { 141, 5, 6, 4, 0, -6 },
  { 145, 5, 6, 4, 0, -6 },
  { 149, 5, 8, 4, 0, -6 },
  { 154, 4, 6, 4, 0, -6 },
  { 157, 5, 6, 4, 0, -6 },
  { 161, 4, 6, 4, 1, -6 },
  { 164, 5, 6, 4, 0, -6 },
  { 168, 4, 6, 4, 1, -6 },
  { 171, 5, 6, 4, 0, -6 },
  { 175, 5, 6, 4, 0, -6 },
  { 179, 4, 6, 4, 1, -6 },
  { 182, 5, 6, 4, 0, -6 },
  { 186, 4, 7, 4, 1, -6 },
  { 190, 1, 7, 4, 2, -6 },
  { 191, 4, 7, 4, 0, -6 },
  { 195, 3, 4, 4, 1, -6 },
  { 197, 5, 1, 4, -1, 1 },
  { 198, 2, 1, 4, 2, -6 },
  { 199, 4, 4, 4, 0, -4 },
  { 201, 4, 6, 4, 0, -6 },
  { 204, 4, 4, 4, 0, -4 },
  { 206, 5, 6, 4, 0, -6 },
  { 210, 4, 4, 4, 0, -4 },
  { 212, 5, 8, 4, 0, -6 },
  { 217, 4, 6, 4, 0, -4 },
  { 220, 4, 6, 4, 0, -6 },
  { 223, 3, 6, 4, 1, -6 },
  { 226, 4, 8, 4, 0, -6 },
  { 230, 5, 6, 4, 0, -6 },
  { 234, 3, 6, 4, 1, -6 },
  { 237, 4, 4, 4, 0, -4 },
  { 239, 4, 4, 4, 0, -4 },
  { 241, 4, 4, 4, 0, -4 },
  { 243, 4, 5, 4, 0, -4 },
  { 246, 4, 5, 4, 0, -4 },
  { 249, 4, 4, 4, 0, -4 },
  { 251, 4, 4, 4, 0, -4 },
  { 253, 3, 5, 4, 1, -5 },
  { 255, 4, 4, 4, 0, -4 },
  { 257, 4, 4, 4, 1, -4 },
  { 259, 5, 4, 4, 0, -4 },
  { 262, 5, 4, 4, 0, -4 },
  { 265, 6, 6, 4, -1, -4 },
  { 270, 4, 4, 4, 0, -4 },
  { 272, 5, 7, 4, 0, -6 },
  { 277, 3, 7, 4, 1, -6 },
  { 280, 4, 7, 4, 0, -6 },
  { 284, 4, 1, 4, 0, -3 },
};

const GFXfont UbuntuSansMono_MediumItalic8pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic8pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic8pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC8PT7B_H_
