#ifndef _UBUNTUSANSMONO_MEDIUMITALIC15PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x62, 0x30, 0x00, 0xE6, 0x00, 0xDE, 0xE5, 0x20, 0x0D,
  0x84, 0x9F, 0xEF, 0xF3, 0x61, 0x23, 0xFC, 0x98, 0x48, 0x6C, 0x00, 0x06,
  0x06, 0x1F, 0x39, 0x30, 0x30, 0x1C, 0x0E, 0x02, 0x02, 0xFE, 0x38, 0x10,
  0x30, 0x08, 0x23, 0x98, 0x92, 0x12, 0x83, 0xA0, 0x28, 0x03, 0xE0, 0xD4,
  0x14, 0x84, 0x93, 0x1C, 0x00, 0x0C, 0x1E, 0x32, 0x36, 0x3C, 0x3A, 0x7B,
  0x4E, 0xC6, 0xCE, 0x7A, 0x6B, 0x60, 0x04, 0x31, 0x8C, 0x61, 0x0C, 0x30,
  0x82, 0x08, 0x30, 0xC1, 0x82, 0x00, 0x08, 0x30, 0x30, 0x20, 0x60, 0xC1,
  0x83, 0x04, 0x18, 0x60, 0xC3, 0x1C, 0x10, 0x00, 0x32, 0xDF, 0xCC, 0xF9,
  0x20, 0x18, 0x30, 0x47, 0xF3, 0x06, 0x08, 0x00, 0x27, 0x72, 0xE0, 0xFF,
  0x80, 0x5F, 0x80, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x40,
  0x30, 0x08, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0x0C, 0x7D,
  0x9A, 0x1D, 0x3B, 0xE5, 0xC3, 0x8D, 0xB3, 0xC0, 0x0C, 0xF6, 0x86, 0x18,
  0x61, 0x04, 0x33, 0xF0, 0x0E, 0x3F, 0x23, 0x03, 0x03, 0x06, 0x1C, 0x30,
  0x60, 0x40, 0xFE, 0x0C, 0x3F, 0x03, 0x03, 0x06, 0x1C, 0x06, 0x02, 0x02,
  0x46, 0xFC, 0x07, 0x0F, 0x1A, 0x12, 0x26, 0x46, 0xFF, 0x04, 0x0C, 0x0C,
  0x1F, 0x8C, 0x04, 0x06, 0x03, 0xC0, 0x30, 0x08, 0x0C, 0x4E, 0x7E, 0x00,
  0x1F, 0x38, 0x60, 0x40, 0xFC, 0xC6, 0x86, 0x86, 0xCC, 0x78, 0xFE, 0x08,
  0x30, 0xC3, 0x04, 0x18, 0x20, 0xC1, 0x00, 0x0C, 0x7D, 0x8B, 0x16, 0x67,
  0x9B, 0x42, 0x85, 0x9B, 0xE0, 0x0C, 0x1F, 0x33, 0x21, 0x61, 0x33, 0x3F,
  0x02, 0x06, 0x1C, 0xF0, 0x23, 0x70, 0x04, 0xEE, 0x10, 0xCE, 0x00, 0x11,
  0xCE, 0x27, 0x00, 0x02, 0x1D, 0xE6, 0x0E, 0x07, 0x03, 0x00, 0x7F, 0x7F,
  0x00, 0x7F, 0xFE, 0x20, 0x78, 0x1E, 0x03, 0x1E, 0x78, 0xC0, 0x39, 0xF0,
  0xC3, 0x18, 0xC6, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x0F, 0x8C, 0x64, 0x36,
  0xFA, 0xC9, 0x65, 0xA6, 0xDB, 0x6F, 0x10, 0x0C, 0x03, 0xC0, 0x07, 0x07,
  0x0F, 0x09, 0x11, 0x31, 0x3F, 0x61, 0x61, 0xC1, 0x04, 0x3F, 0x31, 0x21,
  0x23, 0x7C, 0x66, 0x63, 0x43, 0xC6, 0xFC, 0x0E, 0x3F, 0x60, 0x60, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC4, 0x7C, 0x08, 0x3E, 0x33, 0x23, 0x61, 0x63,
  0x63, 0x43, 0x46, 0xCC, 0xF8, 0x1F, 0x98, 0x0C, 0x06, 0x03, 0xE1, 0x01,
  0x80, 0xC0, 0x40, 0x7F, 0x00, 0x1F, 0x88, 0x0C, 0x06, 0x03, 0xE1, 0x01,
  0x80, 0xC0, 0x40, 0x60, 0x00, 0x0E, 0x3F, 0x60, 0x40, 0xC0, 0xC0, 0x86,
  0x84, 0xC4, 0xCC, 0x7C, 0x31, 0x98, 0xC8, 0x4C, 0x27, 0xF3, 0x19, 0x09,
  0x84, 0xC6, 0x63, 0x00, 0x3F, 0x86, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60,
  0x30, 0x12, 0x7E, 0x00, 0x1F, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x18,
  0x0C, 0x4C, 0x7E, 0x00, 0x31, 0x99, 0x89, 0x85, 0x87, 0x83, 0xC1, 0xB0,
  0x88, 0xC6, 0x63, 0x00, 0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x20, 0x43,
  0xF8, 0x31, 0x99, 0xCC, 0xCF, 0xA6, 0xD2, 0x49, 0x0D, 0x86, 0xC2, 0x43,
  0x00, 0x31, 0x9C, 0xCE, 0x45, 0x26, 0xB3, 0x79, 0x38, 0x8C, 0xC6, 0x63,
  0x00, 0x0C, 0x7D, 0x8A, 0x1C, 0x38, 0x61, 0xC3, 0x85, 0x99, 0xE0, 0x04,
  0x1F, 0x8C, 0x46, 0x32, 0x13, 0x19, 0xF8, 0xC0, 0x40, 0x20, 0x30, 0x00,
  0x0C, 0x7D, 0x8A, 0x1C, 0x38, 0x61, 0xC3, 0x85, 0x99, 0xE3, 0x03, 0x83,
  0x00, 0x08, 0x3F, 0x33, 0x21, 0x23, 0x66, 0x7C, 0x6C, 0x44, 0xC6, 0xC6,
  0x0E, 0x0F, 0xCC, 0x06, 0x03, 0x00, 0xE0, 0x38, 0x0C, 0x02, 0x23, 0x3F,
  0x00, 0xFE, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x41, 0x80, 0x63, 0x63,
  0x42, 0xC6, 0xC6, 0xC6, 0x84, 0x8C, 0xCC, 0xF8, 0x83, 0x86, 0x84, 0x8C,
  0x88, 0x98, 0xD0, 0xF0, 0xE0, 0xE0, 0x30, 0xC8, 0x66, 0x19, 0xA4, 0x4D,
  0x15, 0xC7, 0x71, 0x98, 0xE6, 0x31, 0x80, 0x18, 0xE1, 0xB0, 0x34, 0x03,
  0x80, 0x60, 0x1C, 0x06, 0x81, 0x98, 0x33, 0x1C, 0x20, 0xC7, 0xC6, 0xCC,
  0x58, 0x50, 0x70, 0x60, 0x60, 0x60, 0xC0, 0x3F, 0x81, 0x81, 0x80, 0x80,
  0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x7F, 0x00, 0x1F, 0x1E, 0x18, 0x10, 0x30,
  0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0xF8, 0xF0, 0xDB, 0x6D,
  0xB2, 0x49, 0x36, 0xD8, 0x1F, 0x1E, 0x06, 0x06, 0x04, 0x04, 0x0C, 0x0C,
  0x0C, 0x08, 0x18, 0x18, 0x18, 0xF0, 0xF0, 0x1C, 0x38, 0xD3, 0x3C, 0x60,
  0xFF, 0xFE, 0x99, 0x80, 0x3E, 0xEF, 0x1C, 0x28, 0xD1, 0xB3, 0x7E, 0x08,
  0x10, 0x30, 0x30, 0x3E, 0x37, 0x23, 0x63, 0x63, 0x46, 0x4E, 0xF8, 0x3E,
  0xE7, 0x06, 0x08, 0x10, 0x31, 0x3E, 0x01, 0x03, 0x03, 0x02, 0x3E, 0x76,
  0xC6, 0xC4, 0x84, 0x8C, 0xCC, 0xFC, 0x3C, 0xCF, 0x1C, 0x7F, 0x90, 0x31,
  0x3E, 0x01, 0xC0, 0xF0, 0x60, 0x18, 0x1F, 0x87, 0xE0, 0xC0, 0x30, 0x0C,
  0x02, 0x01, 0x80, 0x60, 0x18, 0x1C, 0x0E, 0x00, 0x0F, 0x3B, 0x63, 0x63,
  0x42, 0x46, 0x7E, 0x36, 0x04, 0xFC, 0xF0, 0x08, 0x10, 0x30, 0x30, 0x3E,
  0x36, 0x63, 0x62, 0x66, 0x46, 0xC6, 0xC4, 0x08, 0x61, 0x80, 0x7B, 0xC3,
  0x0C, 0x30, 0x83, 0x4F, 0x02, 0x07, 0x02, 0x00, 0x3E, 0x3E, 0x06, 0x06,
  0x04, 0x0C, 0x0C, 0x0C, 0x08, 0xF8, 0xF0, 0x08, 0x0C, 0x04, 0x06, 0x03,
  0x39, 0xB0, 0xB0, 0xF0, 0x78, 0x36, 0x11, 0x98, 0xC0, 0xF7, 0x8C, 0x62,
  0x31, 0x8C, 0x42, 0x12, 0xF0, 0x3F, 0x6D, 0x69, 0x4B, 0x5B, 0xC2, 0xC2,
  0x86, 0x3E, 0x37, 0x23, 0x63, 0x62, 0x66, 0x46, 0xC6, 0x3C, 0xDF, 0x1E,
  0x38, 0x70, 0xB3, 0x7C, 0x3E, 0x37, 0x23, 0x63, 0x63, 0x46, 0x4E, 0xF8,
  0xC0, 0xC0, 0x80, 0x3E, 0xEF, 0x1E, 0x38, 0x51, 0xB3, 0x7E, 0x08, 0x30,
  0x60, 0x3E, 0xFD, 0x82, 0x04, 0x18, 0x30, 0x60, 0x1F, 0x32, 0x30, 0x38,
  0x0E, 0x06, 0x46, 0xFC, 0x18, 0x21, 0xFF, 0xF3, 0x04, 0x18, 0x30, 0x64,
  0x78, 0x66, 0x8F, 0x1E, 0x2C, 0xD1, 0xB7, 0x7E, 0xC3, 0x8D, 0x12, 0x64,
  0x8F, 0x1C, 0x30, 0xC3, 0xC3, 0x92, 0xB2, 0xBE, 0xFC, 0xCC, 0x88, 0x61,
  0x99, 0x05, 0x83, 0x81, 0xC1, 0xE1, 0x91, 0x8C, 0x30, 0x88, 0xC4, 0x63,
  0x21, 0xB0, 0xD0, 0x78, 0x18, 0x18, 0x78, 0x38, 0x00, 0x3F, 0x3F, 0x06,
  0x0C, 0x18, 0x30, 0x62, 0xFC, 0x07, 0x0F, 0x18, 0x18, 0x10, 0x10, 0x30,
  0xC0, 0x60, 0x20, 0x60, 0x60, 0x40, 0x78, 0x38, 0x18, 0xC4, 0x63, 0x18,
  0x8C, 0x63, 0x10, 0x8C, 0x62, 0x00, 0x0E, 0x1F, 0x03, 0x02, 0x02, 0x06,
  0x06, 0x03, 0x06, 0x0C, 0x0C, 0x08, 0x08, 0x78, 0xF0, 0x31, 0x7F, 0xCE,
};

const GFXglyph UbuntuSansMono_MediumItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 10, 8, 2, -10 },
  { 8, 5, 4, 8, 3, -11 },
  { 11, 9, 10, 8, 0, -10 },
  { 23, 8, 14, 8, 0, -12 },
  { 37, 11, 11, 8, -1, -11 },
  { 53, 8, 11, 8, 0, -11 },
  { 64, 3, 4, 8, 4, -11 },
  { 66, 6, 15, 8, 2, -12 },
  { 78, 7, 15, 8, 0, -12 },
  { 92, 6, 6, 8, 2, -10 },
  { 97, 7, 7, 8, 1, -8 },
  { 104, 4, 5, 8, 1, -3 },
  { 107, 5, 2, 8, 2, -5 },
  { 109, 3, 3, 8, 2, -3 },
  { 111, 10, 15, 8, -1, -12 },
  { 130, 7, 11, 8, 1, -11 },
  { 140, 6, 10, 8, 1, -10 },
  { 148, 8, 11, 8, 0, -11 },
  { 159, 8, 11, 8, 0, -11 },
  { 170, 8, 10, 8, 0, -10 },
  { 180, 9, 10, 8, 0, -10 },
  { 192, 8, 10, 8, 1, -10 },
  { 202, 7, 10, 8, 2, -10 },
  { 211, 7, 11, 8, 1, -11 },
  { 221, 8, 11, 8, 0, -11 },
  { 232, 4, 8, 8, 2, -8 },
  { 236, 5, 10, 8, 1, -8 },
  { 243, 7, 7, 8, 1, -8 },
  { 250, 8, 5, 8, 0, -7 },
  { 255, 8, 7, 8, 0, -8 },
  { 262, 6, 11, 8, 2, -11 },
  { 271, 9, 13, 8, 0, -11 },
  { 286, 8, 10, 8, -1, -10 },
  { 296, 8, 11, 8, 0, -11 },
  { 307, 8, 11, 8, 1, -11 },
  { 318, 8, 11, 8, 0, -11 },
  { 329, 9, 10, 8, 0, -10 },
  { 341, 9, 10, 8, 0, -10 },
  { 353, 8, 11, 8, 1, -11 },
  { 364, 9, 10, 8, 0, -10 },
  { 376, 9, 10, 8, 0, -10 },
  { 388, 9, 10, 8, 0, -10 },
  { 400, 9, 10, 8, 0, -10 },
  { 412, 7, 10, 8, 0, -10 },
  { 421, 9, 10, 8, 0, -10 },
  { 433, 9, 10, 8, 0, -10 },
  { 445, 7, 11, 8, 1, -11 },
  { 455, 9, 11, 8, 0, -11 },
  { 468, 7, 14, 8, 1, -11 },
  { 481, 8, 11, 8, 0, -11 },
  { 492, 9, 11, 8, 0, -11 },
  { 505, 7, 10, 8, 2, -10 },
  { 514, 8, 10, 8, 1, -10 },
  { 524, 8, 10, 8, 2, -10 },
  { 534, 10, 10, 8, 0, -10 },
  { 547, 11, 10, 8, -1, -10 },
  { 561, 8, 10, 8, 2, -10 },
  { 571, 9, 10, 8, 0, -10 },
  { 583, 8, 15, 8, 1, -12 },
  { 598, 3, 15, 8, 3, -12 },
  { 604, 8, 15, 8, 0, -12 },
  { 619, 7, 5, 8, 1, -10 },
  { 624, 8, 2, 8, -1, 1 },
  { 626, 3, 3, 8, 4, -12 },
  { 628, 7, 8, 8, 1, -8 },
  { 635, 8, 12, 8, 0, -12 },
  { 647, 7, 8, 8, 1, -8 },
  { 654, 8, 12, 8, 1, -12 },
  { 666, 7, 8, 8, 1, -8 },
  { 673, 10, 15, 8, -1, -12 },
  { 692, 8, 11, 8, 0, -8 },
  { 703, 8, 12, 8, 0, -12 },
  { 715, 6, 12, 8, 1, -12 },
  { 724, 8, 15, 8, 0, -12 },
  { 739, 9, 12, 8, 0, -12 },
  { 753, 5, 12, 8, 2, -12 },
  { 761, 8, 8, 8, 0, -8 },
  { 769, 8, 8, 8, 0, -8 },
  { 777, 7, 8, 8, 1, -8 },
  { 784, 8, 11, 8, 0, -8 },
  { 795, 7, 11, 8, 1, -8 },
  { 805, 7, 8, 8, 1, -8 },
  { 812, 8, 8, 8, 0, -8 },
  { 820, 7, 10, 8, 1, -10 },
  { 829, 7, 8, 8, 1, -8 },
  { 836, 7, 8, 8, 1, -8 },
  { 843, 8, 8, 8, 1, -8 },
  { 851, 9, 8, 8, 0, -8 },
  { 860, 9, 11, 8, -1, -8 },
  { 873, 8, 8, 8, 0, -8 },
  { 881, 8, 15, 8, 1, -12 },
  { 896, 5, 15, 8, 2, -12 },
  { 906, 8, 15, 8, -1, -12 },
  { 921, 8, 3, 8, 0, -6 },
};

const GFXfont UbuntuSansMono_MediumItalic15pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic15pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC15PT7B_H_
