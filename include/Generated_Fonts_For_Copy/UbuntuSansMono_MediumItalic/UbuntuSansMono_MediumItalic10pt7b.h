#ifndef _UBUNTUSANSMONO_MEDIUMITALIC10PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0xB0, 0xB6, 0x80, 0x14, 0xA7, 0xD4, 0xF9, 0x4A, 0x00,
  0x08, 0x62, 0x58, 0x30, 0x28, 0x9C, 0x60, 0x65, 0xA7, 0x04, 0x39, 0x69,
  0x80, 0x3A, 0x54, 0xD9, 0xCB, 0xA0, 0xEA, 0x19, 0x98, 0x8C, 0x42, 0x10,
  0x42, 0x00, 0x21, 0x11, 0x11, 0x12, 0x48, 0x2F, 0x25, 0x10, 0xBE, 0x42,
  0x00, 0x76, 0xE0, 0x70, 0x02, 0x08, 0x30, 0x41, 0x82, 0x08, 0x10, 0x41,
  0x80, 0x39, 0xA4, 0xDE, 0xCB, 0x67, 0x00, 0x1B, 0x84, 0x21, 0x13, 0xE0,
  0x3A, 0x42, 0x22, 0x23, 0xE0, 0x38, 0x42, 0x60, 0x87, 0xC0, 0x08, 0xCA,
  0x9F, 0x88, 0x40, 0x3C, 0x82, 0x1C, 0x08, 0x2F, 0x00, 0x3A, 0x21, 0xE9,
  0x4B, 0x80, 0xF8, 0x8C, 0x44, 0x22, 0x00, 0x39, 0x96, 0x8C, 0x4A, 0x27,
  0x00, 0x39, 0x34, 0xDE, 0x08, 0x4E, 0x00, 0x2C, 0x05, 0x80, 0x2C, 0x05,
  0x94, 0x0B, 0xB0, 0x70, 0x7C, 0x0F, 0x80, 0x60, 0xC7, 0xC0, 0x71, 0x16,
  0x44, 0xC0, 0x3D, 0x15, 0xEA, 0xAA, 0xA9, 0x10, 0x30, 0x08, 0x51, 0x49,
  0x3D, 0x1C, 0x40, 0x39, 0x34, 0x9C, 0x4A, 0x2F, 0x00, 0x7A, 0x21, 0x08,
  0x43, 0xC0, 0x7A, 0x52, 0x94, 0xCF, 0xC0, 0x3C, 0x84, 0x1E, 0x41, 0x0F,
  0x80, 0x3C, 0x86, 0x1E, 0x41, 0x0C, 0x00, 0x3D, 0x84, 0x10, 0xC9, 0x27,
  0x80, 0x65, 0x14, 0x9E, 0x4A, 0x29, 0x80, 0x3C, 0x41, 0x0C, 0x20, 0x8F,
  0x00, 0x3C, 0x20, 0x82, 0x08, 0x4F, 0x00, 0x25, 0x25, 0x18, 0x52, 0x48,
  0x80, 0x26, 0x44, 0x4C, 0xF0, 0x25, 0xB7, 0x5E, 0x8A, 0x28, 0x80, 0x25,
  0x96, 0x56, 0x5A, 0x69, 0x80, 0x39, 0xB4, 0x52, 0xCB, 0x27, 0x00, 0x39,
  0x94, 0x56, 0x63, 0x08, 0x00, 0x39, 0xB4, 0x52, 0xCB, 0x27, 0x08, 0x10,
  0x39, 0x34, 0x9E, 0x52, 0x48, 0x80, 0x3D, 0x06, 0x0C, 0x08, 0x2F, 0x00,
  0xF9, 0x08, 0xC4, 0x21, 0x00, 0x65, 0x14, 0x92, 0x4B, 0x27, 0x00, 0x8C,
  0x65, 0x2A, 0x53, 0x00, 0x45, 0x14, 0x5E, 0xBB, 0x69, 0x00, 0x64, 0xA3,
  0x8C, 0x31, 0x68, 0x80, 0x8F, 0x65, 0x18, 0x41, 0x04, 0x00, 0x7C, 0x21,
  0x0C, 0x61, 0x0F, 0x80, 0x39, 0x10, 0x84, 0x23, 0x10, 0x87, 0x00, 0xAA,
  0xB5, 0x50, 0x38, 0x44, 0x21, 0x08, 0x84, 0x27, 0x00, 0x25, 0xD9, 0xF8,
  0x5C, 0x7A, 0x73, 0x37, 0x80, 0x21, 0x18, 0xF4, 0xA5, 0x7E, 0x3A, 0x31,
  0x87, 0x80, 0x04, 0x10, 0xCE, 0x4B, 0x2C, 0x9E, 0x7A, 0x7D, 0x87, 0x80,
  0x06, 0x10, 0x21, 0xF1, 0x02, 0x04, 0x08, 0x21, 0xC0, 0x3D, 0x24, 0xB2,
  0x70, 0x4E, 0x00, 0x21, 0x18, 0xF4, 0xA7, 0x72, 0x22, 0x0E, 0x44, 0x56,
  0x08, 0x40, 0xF1, 0x08, 0x42, 0x27, 0x00, 0x20, 0x82, 0x52, 0x51, 0x85,
  0x26, 0x6A, 0x24, 0x44, 0x47, 0x7A, 0xEB, 0x18, 0x80, 0x7A, 0x52, 0x99,
  0x00, 0x7A, 0x73, 0x97, 0x00, 0x7A, 0x53, 0xBF, 0x42, 0x00, 0x3D, 0x2C,
  0xB2, 0x70, 0x41, 0x00, 0x3A, 0x10, 0x8C, 0x00, 0x3B, 0x0C, 0x3F, 0x00,
  0x24, 0xF4, 0x4C, 0x70, 0x4A, 0x53, 0xB7, 0x80, 0x9C, 0xA9, 0x44, 0x00,
  0x45, 0x6B, 0xB6, 0xD0, 0x6C, 0xC3, 0x14, 0x98, 0x26, 0x48, 0xB0, 0xC1,
  0x06, 0x38, 0x00, 0x78, 0x88, 0x8F, 0x00, 0x19, 0x08, 0x84, 0x61, 0x10,
  0x83, 0x00, 0x32, 0x22, 0x64, 0x44, 0xC8, 0x30, 0x84, 0x21, 0x0C, 0x84,
  0x26, 0x00, 0x6C, 0xC0,
};

const GFXglyph UbuntuSansMono_MediumItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 7, 6, 1, -7 },
  { 4, 3, 3, 6, 2, -8 },
  { 6, 6, 7, 6, 0, -7 },
  { 12, 6, 9, 6, 0, -8 },
  { 19, 6, 7, 6, 0, -7 },
  { 25, 5, 7, 6, 0, -7 },
  { 30, 2, 4, 6, 3, -8 },
  { 31, 5, 10, 6, 1, -8 },
  { 38, 4, 10, 6, 0, -8 },
  { 43, 4, 4, 6, 1, -7 },
  { 45, 5, 5, 6, 0, -5 },
  { 49, 2, 4, 6, 1, -2 },
  { 50, 3, 1, 6, 1, -3 },
  { 51, 2, 2, 6, 1, -2 },
  { 52, 7, 10, 6, -1, -8 },
  { 61, 6, 7, 6, 0, -7 },
  { 67, 5, 7, 6, 0, -7 },
  { 72, 5, 7, 6, 0, -7 },
  { 77, 5, 7, 6, 0, -7 },
  { 82, 5, 7, 6, 0, -7 },
  { 87, 6, 7, 6, 0, -7 },
  { 93, 5, 7, 6, 1, -7 },
  { 98, 5, 7, 6, 1, -7 },
  { 103, 6, 7, 6, 0, -7 },
  { 109, 6, 7, 6, 0, -7 },
  { 115, 3, 6, 6, 1, -6 },
  { 118, 3, 8, 6, 1, -6 },
  { 121, 5, 4, 6, 0, -5 },
  { 124, 6, 3, 6, 0, -4 },
  { 127, 5, 4, 6, 0, -5 },
  { 130, 4, 7, 6, 1, -7 },
  { 134, 6, 9, 6, 0, -7 },
  { 141, 6, 7, 6, -1, -7 },
  { 147, 6, 7, 6, 0, -7 },
  { 153, 5, 7, 6, 1, -7 },
  { 158, 5, 7, 6, 0, -7 },
  { 163, 6, 7, 6, 0, -7 },
  { 169, 6, 7, 6, 0, -7 },
  { 175, 6, 7, 6, 0, -7 },
  { 181, 6, 7, 6, 0, -7 },
  { 187, 6, 7, 6, 0, -7 },
  { 193, 6, 7, 6, 0, -7 },
  { 199, 6, 7, 6, 0, -7 },
  { 205, 4, 7, 6, 0, -7 },
  { 209, 6, 7, 6, 0, -7 },
  { 215, 6, 7, 6, 0, -7 },
  { 221, 6, 7, 6, 0, -7 },
  { 227, 6, 7, 6, 0, -7 },
  { 233, 6, 9, 6, 0, -7 },
  { 240, 6, 7, 6, 0, -7 },
  { 246, 6, 7, 6, 0, -7 },
  { 252, 5, 7, 6, 1, -7 },
  { 257, 6, 7, 6, 0, -7 },
  { 263, 5, 7, 6, 1, -7 },
  { 268, 6, 7, 6, 0, -7 },
  { 274, 6, 7, 6, 0, -7 },
  { 280, 6, 7, 6, 1, -7 },
  { 286, 6, 7, 6, 0, -7 },
  { 292, 5, 10, 6, 1, -8 },
  { 299, 2, 10, 6, 2, -8 },
  { 302, 5, 10, 6, 0, -8 },
  { 309, 4, 4, 6, 1, -7 },
  { 311, 5, 1, 6, -1, 1 },
  { 312, 3, 2, 6, 2, -8 },
  { 313, 5, 5, 6, 0, -5 },
  { 317, 5, 8, 6, 0, -8 },
  { 322, 5, 5, 6, 0, -5 },
  { 326, 6, 8, 6, 0, -8 },
  { 332, 5, 5, 6, 0, -5 },
  { 336, 7, 10, 6, -1, -8 },
  { 345, 6, 7, 6, 0, -5 },
  { 351, 5, 8, 6, 0, -8 },
  { 356, 4, 8, 6, 1, -8 },
  { 360, 5, 10, 6, 0, -8 },
  { 367, 6, 8, 6, 0, -8 },
  { 373, 4, 8, 6, 1, -8 },
  { 377, 5, 5, 6, 0, -5 },
  { 381, 5, 5, 6, 0, -5 },
  { 385, 5, 5, 6, 0, -5 },
  { 389, 5, 7, 6, 0, -5 },
  { 394, 6, 7, 6, 0, -5 },
  { 400, 5, 5, 6, 0, -5 },
  { 404, 5, 5, 6, 0, -5 },
  { 408, 4, 7, 6, 1, -7 },
  { 412, 5, 5, 6, 0, -5 },
  { 416, 5, 5, 6, 1, -5 },
  { 420, 6, 5, 6, 0, -5 },
  { 424, 6, 5, 6, 0, -5 },
  { 428, 7, 7, 6, -1, -5 },
  { 435, 5, 5, 6, 0, -5 },
  { 439, 5, 10, 6, 1, -8 },
  { 446, 4, 10, 6, 1, -8 },
  { 451, 5, 10, 6, 0, -8 },
  { 458, 5, 2, 6, 0, -4 },
};

const GFXfont UbuntuSansMono_MediumItalic10pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic10pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC10PT7B_H_
