#ifndef _UBUNTUSANSMONO_MEDIUMITALIC54PT7B_H_
#define _UBUNTUSANSMONO_MEDIUMITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-MediumItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_MediumItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x00, 0x7E, 0x00, 0x18, 0x00, 0x1F, 0x87, 0xF3, 0xF0, 0x7E, 0x3F, 0x07,
  0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xC3, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0,
  0xFC, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0x80, 0xF0, 0x78,
  0x1F, 0x07, 0x81, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x03, 0xE0, 0x7C, 0x08, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x81, 0xF0,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFC, 0x01, 0xC0, 0x1F, 0xC0, 0x02,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x04, 0x00, 0x0F, 0xC0, 0x7C, 0x01, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x0F, 0xFE, 0x00,
  0x7C, 0x01, 0xF1, 0xE0, 0x0F, 0x80, 0x1E, 0x1F, 0x01, 0xF0, 0x03, 0xE1,
  0xE0, 0x1E, 0x00, 0x3C, 0x1E, 0x03, 0xE0, 0x03, 0xC1, 0xE0, 0x7C, 0x00,
  0x3C, 0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xE1, 0xF0, 0x00, 0x3C, 0x3E, 0x3E,
  0x00, 0x03, 0xC3, 0xC3, 0xC0, 0x00, 0x3C, 0x7C, 0x78, 0x00, 0x03, 0xEF,
  0x8F, 0x80, 0x00, 0x3F, 0xF9, 0xF0, 0x00, 0x01, 0xFF, 0x3E, 0x00, 0x00,
  0x0F, 0xC7, 0xC0, 0x00, 0x00, 0x20, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x3E, 0x7F, 0x80, 0x00, 0x07,
  0xCF, 0xFC, 0x00, 0x00, 0xF9, 0xFF, 0xC0, 0x00, 0x1F, 0x1F, 0x3E, 0x00,
  0x01, 0xE3, 0xE1, 0xE0, 0x00, 0x3E, 0x3C, 0x1E, 0x00, 0x07, 0xC3, 0xC1,
  0xE0, 0x00, 0xF8, 0x7C, 0x1E, 0x00, 0x1F, 0x07, 0x83, 0xE0, 0x03, 0xE0,
  0x78, 0x3C, 0x00, 0x7C, 0x07, 0x83, 0xC0, 0x07, 0x80, 0x78, 0x3C, 0x00,
  0xF8, 0x07, 0x87, 0x80, 0x1F, 0x00, 0x7C, 0xF8, 0x03, 0xE0, 0x07, 0xFF,
  0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xF3, 0xF8, 0x01, 0xF8, 0x1F, 0x00,
  0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x03,
  0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x07, 0xE0, 0x03,
  0xE1, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x0F, 0x81, 0xFF, 0x81, 0xF0, 0x7F,
  0xF0, 0x3E, 0x1F, 0xBF, 0x0F, 0x87, 0xE3, 0xF1, 0xF1, 0xF8, 0x7E, 0x7E,
  0x7E, 0x07, 0xEF, 0x8F, 0x80, 0x7F, 0xF3, 0xF0, 0x0F, 0xFC, 0x7E, 0x00,
  0xFF, 0x8F, 0xC0, 0x1F, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07,
  0xE0, 0x0F, 0xF0, 0xFE, 0x03, 0xFE, 0x1F, 0xE3, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xCF, 0x83, 0xFF, 0xE1, 0xF8, 0x1F, 0xF0, 0x3F, 0x00,
  0x20, 0x00, 0x00, 0x1F, 0x8F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0xFC,
  0x7E, 0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0xF0, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x70, 0x7C, 0x0C, 0x7C, 0x3C, 0x3C, 0x7E, 0x3C, 0xFE, 0xFF,
  0xBB, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00,
  0x7E, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x07, 0xEF, 0xC0, 0x0F,
  0xE7, 0xE0, 0x0F, 0xC7, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0x83, 0xF0, 0x07,
  0x81, 0xE0, 0x03, 0x01, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x1F,
  0xE0, 0x7F, 0x83, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFE, 0x07,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x0F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F,
  0xC0, 0xFC, 0x03, 0x80, 0x00, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x1F, 0x1F, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFB,
  0xFE, 0x7F, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0,
  0xFE, 0x03, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0x80,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF0, 0xF8, 0x3E,
  0x3F, 0x1F, 0xC3, 0xE3, 0xF1, 0xFC, 0x7E, 0x7E, 0x1F, 0xC7, 0xE7, 0xE1,
  0xFC, 0x7E, 0x7E, 0x1F, 0x87, 0xE7, 0xE1, 0xF0, 0xFC, 0x7E, 0x04, 0x0F,
  0xC7, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x07,
  0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x03,
  0xFD, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F,
  0xE7, 0xE0, 0x1F, 0x0F, 0xC0, 0x18, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7E, 0x07, 0xF8, 0x03, 0xC0, 0x0F, 0xC0, 0x18, 0x00,
  0x7F, 0x00, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0x80, 0xFF, 0x00,
  0x60, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x70, 0x00, 0xFF, 0x07, 0xF0, 0x7F,
  0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0,
  0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x0F,
  0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x1C, 0x00, 0x7F, 0x80, 0x7F, 0x1F,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF1, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xE0,
  0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x07,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x01, 0xFE, 0x7F, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x07, 0xF0,
  0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x8F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F,
  0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00,
  0x3F, 0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xCF, 0xC0, 0x01, 0xC1, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x03, 0xF0, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0x81, 0xFE, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0, 0x1C, 0x00, 0x00, 0x1F, 0x00,
  0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x38,
  0x07, 0xF0, 0x80, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xC7, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0x80,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x7F, 0xF8, 0x7C, 0x07,
  0xFF, 0xE3, 0xE0, 0x7F, 0xFF, 0x8F, 0x83, 0xFF, 0xFE, 0x7E, 0x0F, 0xF3,
  0xF1, 0xF0, 0x7E, 0x07, 0xC7, 0xC3, 0xF0, 0x3F, 0x1F, 0x0F, 0xC0, 0xFC,
  0xFC, 0x3E, 0x03, 0xE3, 0xE1, 0xF8, 0x0F, 0x8F, 0x87, 0xC0, 0x7E, 0x3E,
  0x1F, 0x01, 0xF8, 0xF8, 0x7C, 0x07, 0xC3, 0xE1, 0xF0, 0x1F, 0x0F, 0x87,
  0xC0, 0xFC, 0x3E, 0x1F, 0x03, 0xF0, 0xF8, 0x7C, 0x0F, 0x83, 0xE1, 0xF8,
  0x3E, 0x0F, 0x87, 0xF0, 0xF8, 0x3E, 0x0F, 0xFF, 0xE0, 0xF8, 0x3F, 0xFF,
  0x03, 0xE0, 0x7F, 0xFC, 0x0F, 0x80, 0x7F, 0xF0, 0x3F, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x3E,
  0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7C, 0x00, 0xFC, 0x07, 0xE0,
  0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x3F, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0xFC,
  0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7F, 0x00, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x81, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0x80, 0xF8, 0x0F, 0xF0, 0x00, 0x80, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x80,
  0x7F, 0x80, 0x1C, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x3F, 0xF0,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF8, 0x1F,
  0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F,
  0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x7E, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x1F,
  0x80, 0x1F, 0xC1, 0xF8, 0x01, 0xFE, 0x0F, 0xC0, 0x3F, 0xE0, 0x7E, 0x07,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x80,
  0xF0, 0x0F, 0xF0, 0x01, 0x80, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01,
  0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0x7E, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0xFC, 0x03, 0xFF, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0,
  0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x03, 0x00, 0x0F,
  0xC0, 0x0F, 0x00, 0xFF, 0x00, 0x7F, 0x9F, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07, 0xE0,
  0x3F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00,
  0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0x7F, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF8,
  0x07, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFF,
  0x03, 0xDE, 0x00, 0xF7, 0x81, 0xFF, 0x00, 0x7B, 0xC1, 0xEF, 0x80, 0x7D,
  0xE1, 0xF7, 0x80, 0x3E, 0xF0, 0xF3, 0xC0, 0x1E, 0x78, 0xFB, 0xE0, 0x1F,
  0x3C, 0x79, 0xF0, 0x0F, 0x9E, 0x78, 0xF8, 0x07, 0xCF, 0x3C, 0x7C, 0x07,
  0xC3, 0xBC, 0x7C, 0x03, 0xE1, 0xFE, 0x3E, 0x01, 0xF0, 0xFE, 0x1F, 0x01,
  0xF8, 0x7F, 0x0F, 0x80, 0xF8, 0x3F, 0x07, 0xC0, 0x7C, 0x1F, 0x87, 0xC0,
  0x3E, 0x0F, 0x83, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0x80, 0x3F,
  0x80, 0x07, 0xC0, 0x1F, 0xC0, 0x03, 0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x0F,
  0xF8, 0x01, 0xF0, 0x07, 0xFC, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x01,
  0xFF, 0x80, 0x7E, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0xF9, 0xF0, 0x1F, 0x00,
  0x7C, 0xF8, 0x0F, 0x80, 0x3E, 0x7C, 0x0F, 0xC0, 0x3F, 0x1E, 0x07, 0xE0,
  0x1F, 0x8F, 0x83, 0xE0, 0x0F, 0x87, 0xC1, 0xF0, 0x07, 0xC3, 0xE1, 0xF8,
  0x07, 0xE0, 0xF0, 0xFC, 0x03, 0xF0, 0x78, 0x7C, 0x01, 0xF0, 0x3E, 0x3E,
  0x00, 0xF8, 0x1F, 0x1F, 0x00, 0x7C, 0x07, 0x9F, 0x80, 0x7E, 0x03, 0xCF,
  0x80, 0x3E, 0x01, 0xE7, 0xC0, 0x1F, 0x00, 0xFB, 0xE0, 0x0F, 0x80, 0x7F,
  0xF0, 0x0F, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x0F, 0xF8, 0x03, 0xE0, 0x07,
  0xFC, 0x01, 0xF0, 0x03, 0xFE, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xF0, 0x7F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0x7F, 0x01, 0xF8,
  0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0xC0,
  0xFC, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFE,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03,
  0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00,
  0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xFE,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xF0,
  0x3F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0x7E,
  0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0,
  0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xE0,
  0x0F, 0x00, 0x3F, 0x80, 0x04, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x08, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x7F, 0x80, 0x7F, 0x87,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFE,
  0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0,
  0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07,
  0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00,
  0x7F, 0xCF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x7F, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0xC0,
  0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x1F, 0x07,
  0xC0, 0x7E, 0x1F, 0x83, 0xE0, 0x3E, 0x0F, 0xC1, 0xF0, 0x1F, 0x0F, 0xE1,
  0xF0, 0x0F, 0x87, 0xF0, 0xF8, 0x07, 0xC7, 0xF8, 0x7C, 0x07, 0xC3, 0xFC,
  0x3E, 0x03, 0xE3, 0xDE, 0x3E, 0x01, 0xF1, 0xEF, 0x1F, 0x00, 0xF9, 0xE7,
  0x8F, 0x80, 0x79, 0xF3, 0xC7, 0x80, 0x3C, 0xF0, 0xE7, 0xC0, 0x3E, 0xF8,
  0x7B, 0xE0, 0x1F, 0x78, 0x3D, 0xE0, 0x0F, 0xF8, 0x1E, 0xF0, 0x07, 0xBC,
  0x0F, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xF0, 0x7C, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0xC0, 0x3E, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07,
  0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF9, 0xF8, 0x00,
  0x1F, 0xBF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x10,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x01, 0xF9, 0xF8, 0x01,
  0xFC, 0xFC, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE3, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x10, 0x03,
  0x80, 0x3C, 0x07, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x1C, 0x00, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0x1F, 0x83,
  0xFC, 0x03, 0xF0, 0xFF, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0x87, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF0, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x1F, 0xE0,
  0x7F, 0x8F, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xBF, 0x00, 0xFF, 0xC3, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xF8,
  0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00,
  0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x07, 0xF0, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x87, 0xE0,
  0x3F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFE, 0x07, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x60, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0x80, 0x3F, 0xC0, 0x7E, 0x00, 0xFE,
  0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07,
  0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x3F, 0x00, 0x1F, 0xFC, 0x7E, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F,
  0x83, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE7, 0xE0,
  0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x07, 0xF8,
  0xFC, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x60, 0x3F, 0xF1, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x30, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x20, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x87, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0x80, 0x3F,
  0xC0, 0x3F, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xE0,
  0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8,
  0x03, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x7E, 0x00, 0x00, 0x40, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x60, 0x00, 0xFE, 0x00, 0xF0, 0x07, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xF9, 0xFF, 0x81,
  0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01,
  0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xE0,
  0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0,
  0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0x7E, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xF8,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x02, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0x0F,
  0xC0, 0x03, 0xC0, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0xFE,
  0x03, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0, 0x7F, 0x80, 0x3F, 0x03, 0xF8, 0x00,
  0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7E,
  0x3F, 0x80, 0x01, 0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7E, 0x7F, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F,
  0xC0, 0x7F, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0,
  0x07, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x13, 0xFF, 0xFC, 0xFF,
  0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0x0F,
  0x01, 0xC0, 0x03, 0xFF, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0x87, 0xE1, 0xF0, 0x3E, 0x1F, 0x87,
  0xC0, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x87,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xF8, 0xFF, 0x81, 0xFC, 0x07, 0xF0, 0x3F,
  0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F,
  0x87, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x3F, 0xE0, 0xFF, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00,
  0xFC, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x1F,
  0xCF, 0xE0, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xF8,
  0x1F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0x7E,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x80,
  0x3F, 0x80, 0xFC, 0x01, 0xFE, 0x03, 0xF0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7E, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xF0, 0x7E, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0x7F, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0xC7, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFD, 0xF8, 0x00,
  0x04, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x03, 0xC0, 0x3F, 0x00, 0x10,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x82, 0x00, 0x0F, 0xE0, 0xC0, 0x07, 0xF0, 0x7F, 0x0F, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x30, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x7F, 0x83,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xEF,
  0xC0, 0x7F, 0xE1, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x00,
  0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x3F, 0x00,
  0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xFC,
  0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x1F, 0x0F, 0x81, 0xE0, 0x7C, 0x3F, 0x07, 0xC0, 0xF8, 0x7C, 0x0F,
  0x81, 0xF0, 0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xE1, 0xFE,
  0x1F, 0x07, 0xC3, 0xFC, 0x7C, 0x0F, 0x8F, 0xF8, 0xF8, 0x1F, 0x1E, 0xF1,
  0xF0, 0x3C, 0x7D, 0xE7, 0xC0, 0x78, 0xF3, 0xCF, 0x80, 0xF3, 0xC7, 0x9E,
  0x03, 0xEF, 0x8F, 0x7C, 0x07, 0xDE, 0x1E, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0x80,
  0x7F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x1F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x20, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x87, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x01, 0x00,
  0xFF, 0x00, 0x3C, 0x7F, 0xF8, 0x0F, 0x9F, 0xFF, 0x83, 0xF3, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0x07, 0xFF, 0xE7, 0xC0, 0x7F, 0xF8, 0xF0,
  0x03, 0xFE, 0x02, 0x00, 0x3F, 0x00,
};

const GFXglyph UbuntuSansMono_MediumItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 16, 38, 30, 8, -37 },
  { 77, 20, 16, 30, 10, -41 },
  { 117, 32, 37, 30, 0, -37 },
  { 265, 29, 48, 30, 1, -42 },
  { 439, 36, 39, 30, -2, -38 },
  { 615, 27, 39, 30, 1, -38 },
  { 747, 9, 17, 30, 15, -41 },
  { 767, 24, 53, 30, 6, -43 },
  { 926, 23, 53, 30, 1, -43 },
  { 1079, 24, 22, 30, 6, -37 },
  { 1145, 26, 27, 30, 2, -29 },
  { 1233, 14, 18, 30, 4, -9 },
  { 1265, 16, 5, 30, 7, -18 },
  { 1275, 10, 10, 30, 8, -9 },
  { 1288, 35, 52, 30, -3, -42 },
  { 1516, 28, 39, 30, 2, -38 },
  { 1653, 23, 37, 30, 3, -37 },
  { 1760, 29, 38, 30, 1, -38 },
  { 1898, 28, 39, 30, 1, -38 },
  { 2035, 29, 37, 30, 0, -37 },
  { 2170, 30, 38, 30, 1, -37 },
  { 2313, 28, 39, 30, 3, -38 },
  { 2450, 28, 37, 30, 6, -37 },
  { 2580, 28, 39, 30, 2, -38 },
  { 2717, 28, 38, 30, 2, -38 },
  { 2850, 14, 29, 30, 8, -28 },
  { 2901, 18, 37, 30, 4, -28 },
  { 2985, 27, 25, 30, 2, -28 },
  { 3070, 29, 16, 30, 1, -24 },
  { 3128, 27, 25, 30, 1, -28 },
  { 3213, 22, 39, 30, 7, -38 },
  { 3321, 30, 46, 30, 2, -38 },
  { 3494, 29, 37, 30, -3, -37 },
  { 3629, 30, 38, 30, 0, -38 },
  { 3772, 29, 39, 30, 3, -38 },
  { 3914, 29, 38, 30, 0, -38 },
  { 4052, 30, 37, 30, 2, -37 },
  { 4191, 31, 37, 30, 2, -37 },
  { 4335, 29, 39, 30, 3, -38 },
  { 4477, 33, 37, 30, 0, -37 },
  { 4630, 30, 37, 30, 1, -37 },
  { 4769, 30, 38, 30, 1, -37 },
  { 4912, 34, 37, 30, 0, -37 },
  { 5070, 23, 37, 30, 1, -37 },
  { 5177, 33, 37, 30, -1, -37 },
  { 5330, 33, 37, 30, 0, -37 },
  { 5483, 28, 39, 30, 2, -38 },
  { 5620, 30, 38, 30, 1, -38 },
  { 5763, 28, 48, 30, 2, -38 },
  { 5931, 30, 38, 30, 0, -38 },
  { 6074, 31, 39, 30, 0, -38 },
  { 6226, 28, 37, 30, 6, -37 },
  { 6356, 31, 38, 30, 2, -37 },
  { 6504, 29, 37, 30, 6, -37 },
  { 6639, 33, 37, 30, 1, -37 },
  { 6792, 37, 37, 30, -2, -37 },
  { 6964, 28, 37, 30, 7, -37 },
  { 7094, 32, 37, 30, 0, -37 },
  { 7242, 29, 52, 30, 3, -42 },
  { 7431, 10, 52, 30, 11, -42 },
  { 7496, 28, 52, 30, -1, -42 },
  { 7678, 25, 21, 30, 4, -37 },
  { 7744, 28, 5, 30, -4, 5 },
  { 7762, 12, 11, 30, 13, -42 },
  { 7779, 27, 30, 30, 2, -29 },
  { 7881, 27, 43, 30, 1, -42 },
  { 8027, 27, 30, 30, 2, -29 },
  { 8129, 31, 43, 30, 2, -42 },
  { 8296, 27, 30, 30, 2, -29 },
  { 8398, 37, 52, 30, -3, -42 },
  { 8639, 31, 39, 30, -1, -29 },
  { 8791, 27, 42, 30, 0, -42 },
  { 8933, 19, 42, 30, 5, -42 },
  { 9033, 30, 52, 30, -2, -42 },
  { 9228, 30, 42, 30, 1, -42 },
  { 9386, 17, 43, 30, 8, -42 },
  { 9478, 30, 29, 30, -1, -29 },
  { 9587, 27, 29, 30, 1, -29 },
  { 9685, 26, 30, 30, 2, -29 },
  { 9783, 30, 39, 30, -2, -29 },
  { 9930, 28, 39, 30, 2, -29 },
  { 10067, 27, 29, 30, 3, -29 },
  { 10165, 26, 30, 30, 2, -29 },
  { 10263, 24, 38, 30, 5, -37 },
  { 10377, 26, 29, 30, 3, -28 },
  { 10472, 26, 28, 30, 5, -28 },
  { 10563, 31, 28, 30, 2, -28 },
  { 10672, 32, 28, 30, -1, -28 },
  { 10784, 34, 38, 30, -4, -28 },
  { 10946, 28, 28, 30, 1, -28 },
  { 11044, 30, 52, 30, 3, -42 },
  { 11239, 19, 52, 30, 6, -42 },
  { 11363, 29, 52, 30, -2, -42 },
  { 11552, 27, 10, 30, 2, -21 },
};

const GFXfont UbuntuSansMono_MediumItalic54pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_MediumItalic54pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_MediumItalic54pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _UBUNTUSANSMONO_MEDIUMITALIC54PT7B_H_
