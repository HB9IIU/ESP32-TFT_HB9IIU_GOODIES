#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT19PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight19pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x54, 0x30, 0x99, 0x99, 0x90, 0x11, 0x08, 0x84, 0x82,
  0x47, 0xF8, 0x90, 0x48, 0x44, 0x22, 0x7F, 0x89, 0x04, 0x82, 0x41, 0x20,
  0x10, 0xFA, 0x44, 0x89, 0x12, 0x18, 0x0C, 0x14, 0x24, 0x48, 0x99, 0xCC,
  0x04, 0x00, 0x61, 0x12, 0x22, 0x44, 0x49, 0x09, 0x21, 0x29, 0x25, 0x54,
  0xB2, 0x6A, 0x21, 0x44, 0x48, 0x89, 0x11, 0x24, 0x43, 0x80, 0x30, 0x48,
  0x48, 0x48, 0x48, 0x48, 0x30, 0x50, 0x91, 0x89, 0x86, 0x82, 0x86, 0x79,
  0xF8, 0x25, 0x29, 0x24, 0x92, 0x48, 0x92, 0x20, 0x91, 0x22, 0x49, 0x24,
  0x92, 0x92, 0x80, 0x22, 0x97, 0x8C, 0x49, 0x20, 0x10, 0x20, 0x40, 0x8F,
  0xE2, 0x04, 0x08, 0x10, 0x6A, 0xF0, 0xC0, 0x04, 0x10, 0x82, 0x08, 0x41,
  0x04, 0x20, 0x82, 0x10, 0x42, 0x00, 0x38, 0x8A, 0x14, 0x28, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x24, 0x47, 0x00, 0x2E, 0xD2, 0x49, 0x24, 0x92,
  0x40, 0x79, 0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x20, 0x82, 0x08,
  0x1F, 0xC0, 0x79, 0x08, 0x10, 0x20, 0x40, 0x9E, 0x04, 0x04, 0x04, 0x08,
  0x20, 0x5F, 0x00, 0x02, 0x06, 0x0A, 0x0A, 0x12, 0x12, 0x22, 0x22, 0x42,
  0x82, 0xFF, 0x02, 0x02, 0x02, 0x7D, 0x02, 0x04, 0x08, 0x10, 0x3E, 0x02,
  0x02, 0x04, 0x08, 0x20, 0x5F, 0x00, 0x1C, 0x41, 0x04, 0x08, 0x12, 0x3B,
  0x42, 0x83, 0x06, 0x0C, 0x14, 0x4F, 0x00, 0xFE, 0x04, 0x10, 0x20, 0x41,
  0x02, 0x08, 0x10, 0x20, 0x81, 0x02, 0x08, 0x00, 0x38, 0x8A, 0x14, 0x18,
  0x48, 0x8E, 0x34, 0x85, 0x06, 0x0C, 0x18, 0x4F, 0x00, 0x38, 0x8A, 0x14,
  0x28, 0x30, 0x61, 0xC3, 0x7A, 0x08, 0x10, 0x20, 0x9E, 0x00, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x6A, 0x02, 0x18, 0xC6, 0x08, 0x0C, 0x06, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x80, 0xC0, 0x60, 0x20, 0x63, 0x18, 0x40, 0x72,
  0x20, 0x41, 0x04, 0x21, 0x04, 0x20, 0x82, 0x00, 0x00, 0x80, 0x0F, 0x02,
  0x10, 0x81, 0x20, 0x18, 0x73, 0x12, 0x64, 0x4C, 0x89, 0x91, 0x32, 0x26,
  0x4C, 0xC6, 0x64, 0x00, 0x80, 0x08, 0x20, 0xF8, 0x08, 0x04, 0x06, 0x02,
  0x81, 0x41, 0x20, 0x88, 0x44, 0x3E, 0x21, 0x10, 0x48, 0x28, 0x14, 0x04,
  0xF1, 0x1A, 0x14, 0x28, 0x50, 0xBE, 0x46, 0x85, 0x06, 0x0C, 0x28, 0x5F,
  0x00, 0x1E, 0x21, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x40, 0x20, 0x1E, 0xF1, 0x12, 0x14, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x5F, 0x00, 0xFC, 0x21, 0x08, 0x43, 0xF0, 0x84, 0x21, 0x08,
  0x7C, 0xFC, 0x21, 0x08, 0x42, 0x1F, 0x84, 0x21, 0x08, 0x40, 0x0F, 0x18,
  0x50, 0x08, 0x08, 0x04, 0x02, 0x01, 0x0F, 0x80, 0xC0, 0x60, 0x28, 0x12,
  0x08, 0xFC, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x40, 0xE9, 0x24, 0x92, 0x49, 0x25, 0xC0, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x49, 0xE0, 0x85, 0x0A, 0x24, 0x89, 0x14, 0x30, 0x50, 0xA1,
  0x22, 0x24, 0x48, 0x50, 0xC0, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x7C, 0x80, 0x60, 0x18, 0x0F, 0x03, 0xC0, 0xF0, 0x5A, 0x16, 0x85,
  0xA2, 0x64, 0x99, 0x26, 0x51, 0x8C, 0x62, 0x10, 0x83, 0x06, 0x0E, 0x1A,
  0x34, 0x64, 0xC9, 0x8B, 0x16, 0x1C, 0x38, 0x30, 0x40, 0x1C, 0x11, 0x90,
  0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x28, 0x14, 0x11,
  0xF0, 0xF2, 0x28, 0x61, 0x86, 0x18, 0x7E, 0x82, 0x08, 0x20, 0x82, 0x00,
  0x1C, 0x11, 0x90, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x28, 0x14, 0x11, 0xF0, 0x10, 0x04, 0x01, 0x00, 0xF1, 0x12, 0x14, 0x28,
  0x50, 0xA2, 0x78, 0x91, 0x22, 0x24, 0x48, 0x50, 0xC0, 0x3D, 0x08, 0x20,
  0x82, 0x06, 0x06, 0x04, 0x10, 0x41, 0x07, 0xE0, 0xFE, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x41, 0x3E, 0x81,
  0x81, 0x81, 0x41, 0x42, 0x42, 0x22, 0x24, 0x24, 0x24, 0x14, 0x18, 0x18,
  0x08, 0x82, 0x06, 0x08, 0x24, 0x30, 0x90, 0xC2, 0x45, 0x09, 0x12, 0x24,
  0x49, 0x09, 0x24, 0x24, 0x90, 0xA2, 0x42, 0x86, 0x06, 0x18, 0x18, 0x60,
  0x41, 0x80, 0x82, 0x85, 0x09, 0x22, 0x43, 0x06, 0x0C, 0x18, 0x48, 0x92,
  0x24, 0x30, 0x40, 0x83, 0x05, 0x0A, 0x24, 0x45, 0x0A, 0x0C, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x00, 0xFC, 0x10, 0x82, 0x08, 0x41, 0x08, 0x21, 0x04,
  0x20, 0x83, 0xF0, 0xF2, 0x49, 0x24, 0x92, 0x49, 0x24, 0xE0, 0x81, 0x04,
  0x10, 0x20, 0x82, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0xE4, 0x92, 0x49,
  0x24, 0x92, 0x49, 0xE0, 0x08, 0x18, 0x14, 0x24, 0x22, 0x42, 0x41, 0x81,
  0xFF, 0x91, 0x80, 0x78, 0x10, 0x41, 0x3F, 0x18, 0x61, 0x8F, 0xD0, 0x81,
  0x02, 0x04, 0x0B, 0xD8, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x37, 0x80,
  0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x41, 0xE0, 0x02, 0x04, 0x08, 0x17,
  0xA8, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x6F, 0x40, 0x79, 0x18, 0x61,
  0xFE, 0x08, 0x20, 0x41, 0xF0, 0x19, 0x08, 0x42, 0x78, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x80, 0x7B, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x86, 0xF4,
  0x08, 0x10, 0x50, 0x9E, 0x00, 0x81, 0x02, 0x04, 0x0B, 0xD8, 0xA0, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0xCF, 0xFC, 0x50, 0x55, 0x55, 0x55,
  0x58, 0x82, 0x08, 0x20, 0x86, 0x29, 0x28, 0xA3, 0x49, 0x22, 0x8A, 0x10,
  0xFF, 0xFC, 0xB9, 0xD8, 0xC6, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C,
  0x21, 0x84, 0x30, 0x84, 0xBD, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x04, 0x79, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x44, 0xF0, 0xBD, 0x86,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC3, 0x7A, 0x04, 0x08, 0x10, 0x00, 0x7B,
  0x0E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x86, 0xF4, 0x08, 0x10, 0x20, 0x40,
  0xBE, 0x21, 0x08, 0x42, 0x10, 0x84, 0x00, 0x7C, 0x21, 0x06, 0x08, 0x21,
  0x0F, 0x80, 0x44, 0xF4, 0x44, 0x44, 0x44, 0x43, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x85, 0xF0, 0x83, 0x09, 0x12, 0x24, 0x89, 0x0A, 0x14, 0x30,
  0x20, 0x84, 0x30, 0x85, 0x29, 0x25, 0x24, 0xA4, 0x92, 0x8C, 0x61, 0x8C,
  0x31, 0x82, 0x10, 0x46, 0x88, 0xA1, 0x41, 0x02, 0x0A, 0x12, 0x45, 0x84,
  0x82, 0x89, 0x12, 0x24, 0x45, 0x0A, 0x14, 0x10, 0x20, 0x40, 0x82, 0x04,
  0x30, 0x00, 0xF8, 0x84, 0x42, 0x21, 0x10, 0x87, 0xC0, 0x19, 0x08, 0x42,
  0x10, 0x88, 0xC2, 0x08, 0x42, 0x10, 0x84, 0x18, 0xFF, 0xFF, 0xE0, 0x82,
  0x08, 0x42, 0x10, 0x84, 0x19, 0x08, 0x42, 0x10, 0x84, 0xC0, 0x61, 0x3C,
};

const GFXglyph NotoSans_Condensed_ExtraLight19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 14, 4, 1, -14 },
  { 5, 4, 5, 6, 1, -14 },
  { 8, 9, 14, 9, 0, -14 },
  { 24, 7, 15, 9, 1, -14 },
  { 38, 11, 14, 12, 1, -14 },
  { 58, 8, 14, 9, 1, -14 },
  { 72, 1, 5, 3, 1, -14 },
  { 73, 3, 17, 5, 1, -14 },
  { 80, 3, 17, 5, 1, -14 },
  { 87, 6, 6, 8, 1, -14 },
  { 92, 7, 9, 9, 1, -11 },
  { 100, 2, 4, 4, 1, -2 },
  { 101, 4, 1, 5, 1, -6 },
  { 102, 2, 1, 4, 1, -1 },
  { 103, 6, 14, 6, 0, -14 },
  { 114, 7, 14, 9, 1, -14 },
  { 127, 3, 14, 9, 2, -14 },
  { 133, 7, 14, 9, 1, -14 },
  { 146, 7, 14, 9, 1, -14 },
  { 159, 8, 14, 9, 0, -14 },
  { 173, 7, 14, 9, 1, -14 },
  { 186, 7, 14, 9, 1, -14 },
  { 199, 7, 14, 9, 1, -14 },
  { 212, 7, 14, 9, 1, -14 },
  { 225, 7, 14, 9, 1, -14 },
  { 238, 2, 10, 4, 1, -10 },
  { 241, 2, 12, 4, 1, -10 },
  { 244, 7, 8, 9, 1, -11 },
  { 251, 7, 5, 9, 1, -9 },
  { 256, 7, 8, 9, 1, -11 },
  { 263, 6, 14, 6, 0, -14 },
  { 274, 11, 16, 13, 1, -14 },
  { 296, 9, 14, 9, 0, -14 },
  { 312, 7, 14, 9, 2, -14 },
  { 325, 8, 14, 9, 1, -14 },
  { 339, 7, 14, 10, 2, -14 },
  { 352, 5, 14, 8, 2, -14 },
  { 361, 5, 14, 8, 2, -14 },
  { 370, 9, 14, 11, 1, -14 },
  { 386, 7, 14, 11, 2, -14 },
  { 399, 3, 14, 5, 1, -14 },
  { 405, 3, 17, 4, -1, -14 },
  { 412, 7, 14, 8, 2, -14 },
  { 425, 5, 14, 8, 2, -14 },
  { 434, 10, 14, 14, 2, -14 },
  { 452, 7, 14, 11, 2, -14 },
  { 465, 9, 14, 11, 1, -14 },
  { 481, 6, 14, 9, 2, -14 },
  { 492, 9, 17, 11, 1, -14 },
  { 512, 7, 14, 9, 2, -14 },
  { 525, 6, 14, 8, 1, -14 },
  { 536, 7, 14, 8, 0, -14 },
  { 549, 8, 14, 11, 1, -14 },
  { 563, 8, 14, 8, 0, -14 },
  { 577, 14, 14, 14, 0, -14 },
  { 602, 7, 14, 8, 0, -14 },
  { 615, 7, 14, 7, 0, -14 },
  { 628, 6, 14, 8, 1, -14 },
  { 639, 3, 17, 6, 2, -14 },
  { 646, 6, 14, 6, 0, -14 },
  { 657, 3, 17, 6, 1, -14 },
  { 664, 8, 8, 9, 0, -14 },
  { 672, 8, 1, 8, 0, 2 },
  { 673, 3, 3, 5, 1, -15 },
  { 675, 6, 10, 8, 1, -10 },
  { 683, 7, 14, 9, 1, -14 },
  { 696, 6, 10, 7, 1, -10 },
  { 704, 7, 14, 9, 1, -14 },
  { 717, 6, 10, 8, 1, -10 },
  { 725, 5, 15, 5, 0, -15 },
  { 735, 7, 15, 9, 1, -10 },
  { 749, 7, 14, 9, 1, -14 },
  { 762, 1, 14, 4, 1, -14 },
  { 764, 2, 19, 4, 0, -14 },
  { 769, 6, 14, 7, 1, -14 },
  { 780, 1, 14, 4, 1, -14 },
  { 782, 11, 10, 13, 1, -10 },
  { 796, 7, 10, 9, 1, -10 },
  { 805, 7, 10, 9, 1, -10 },
  { 814, 7, 14, 9, 1, -10 },
  { 827, 7, 14, 9, 1, -10 },
  { 840, 5, 10, 6, 1, -10 },
  { 847, 5, 10, 7, 1, -10 },
  { 854, 4, 12, 5, 0, -12 },
  { 860, 6, 10, 9, 1, -10 },
  { 868, 7, 10, 7, 0, -10 },
  { 877, 11, 10, 11, 0, -10 },
  { 891, 7, 10, 7, 0, -10 },
  { 900, 7, 15, 7, 0, -10 },
  { 914, 5, 10, 6, 1, -10 },
  { 921, 5, 17, 7, 1, -14 },
  { 932, 1, 19, 8, 4, -14 },
  { 935, 5, 17, 7, 1, -14 },
  { 946, 7, 2, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_ExtraLight19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight19pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT19PT7B_H_
