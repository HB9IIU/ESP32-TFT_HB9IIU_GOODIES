#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT67PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight67pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x06, 0xFF,
  0xFF, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xC0, 0x76, 0x03, 0xB0, 0x1D, 0x80,
  0xEC, 0x07, 0x60, 0x3B, 0x01, 0xD8, 0x0E, 0xC0, 0x76, 0x03, 0xB0, 0x1D,
  0x80, 0xEC, 0x07, 0x60, 0x38, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x03,
  0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0x80, 0x18,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00, 0xE0, 0x0C, 0x00,
  0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x0F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30,
  0x07, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x30, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x07, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x01, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x60, 0x0E, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x1E, 0x18, 0x3C, 0x38,
  0x18, 0x08, 0x70, 0x18, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x18, 0x00, 0xE0,
  0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x18, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x18, 0x00, 0x70,
  0x18, 0x00, 0x38, 0x18, 0x00, 0x3C, 0x18, 0x00, 0x1F, 0x18, 0x00, 0x07,
  0x98, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x19, 0xE0, 0x00, 0x18, 0x78, 0x00, 0x18, 0x3C, 0x00,
  0x18, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x06, 0x00, 0x18, 0x07, 0x00,
  0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00,
  0x18, 0x07, 0x00, 0x18, 0x06, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x0E, 0x00,
  0x18, 0x1C, 0xC0, 0x18, 0x78, 0xFC, 0x19, 0xF0, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x70, 0x01, 0xFF, 0x00, 0x01, 0x80, 0x06, 0x0E,
  0x00, 0x0E, 0x00, 0x30, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x03, 0x80, 0x18, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x01, 0x80, 0x18, 0x03, 0x00, 0x0E, 0x00, 0x60, 0x0C, 0x00,
  0x38, 0x01, 0x80, 0x60, 0x00, 0xE0, 0x06, 0x01, 0x80, 0x03, 0x80, 0x18,
  0x0E, 0x00, 0x0E, 0x00, 0x60, 0x30, 0x00, 0x38, 0x01, 0x80, 0xC0, 0x00,
  0xE0, 0x06, 0x06, 0x00, 0x03, 0x80, 0x18, 0x18, 0x00, 0x0E, 0x00, 0x60,
  0xE0, 0x00, 0x38, 0x01, 0x83, 0x00, 0x00, 0xE0, 0x06, 0x0C, 0x1F, 0x81,
  0x80, 0x18, 0x60, 0xFF, 0x06, 0x00, 0xE1, 0x87, 0x0E, 0x18, 0x03, 0x0E,
  0x38, 0x1C, 0x70, 0x0C, 0x30, 0xC0, 0x30, 0xC0, 0x70, 0xC3, 0x00, 0xE3,
  0x81, 0x86, 0x1C, 0x03, 0x86, 0x0E, 0x18, 0x60, 0x06, 0x1F, 0xF0, 0xE1,
  0x80, 0x18, 0x3F, 0x83, 0x06, 0x00, 0x60, 0x10, 0x0C, 0x18, 0x01, 0x80,
  0x00, 0x70, 0x60, 0x07, 0x00, 0x01, 0x81, 0x80, 0x1C, 0x00, 0x0E, 0x06,
  0x00, 0x70, 0x00, 0x30, 0x18, 0x01, 0xC0, 0x00, 0xC0, 0x60, 0x07, 0x00,
  0x07, 0x01, 0x80, 0x1C, 0x00, 0x18, 0x06, 0x00, 0x70, 0x00, 0xE0, 0x18,
  0x01, 0x80, 0x03, 0x00, 0x60, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x18, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x01, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x03, 0x81, 0xC0, 0x07,
  0x00, 0x07, 0x06, 0x00, 0x18, 0x00, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x03, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x60, 0x00, 0x30, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x03,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x38, 0x01, 0x80, 0x00, 0xE0,
  0x0E, 0x00, 0x01, 0x80, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x30, 0xC0, 0x1C, 0x00, 0xC7, 0x00,
  0x38, 0x07, 0x18, 0x00, 0x60, 0x1C, 0xE0, 0x01, 0xC0, 0x63, 0x80, 0x03,
  0x81, 0x8C, 0x00, 0x06, 0x0E, 0x30, 0x00, 0x1C, 0x30, 0xC0, 0x00, 0x38,
  0xC3, 0x00, 0x00, 0x77, 0x0C, 0x00, 0x01, 0xF8, 0x30, 0x00, 0x03, 0xE0,
  0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF8, 0x1C,
  0x00, 0x07, 0x70, 0x70, 0x00, 0x38, 0xE0, 0xE0, 0x01, 0xC3, 0x81, 0xE0,
  0x1E, 0x07, 0x03, 0xFF, 0xF0, 0x0E, 0x07, 0xFF, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x00, 0xFF, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x00, 0x30, 0x06,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00,
  0x30, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0xE0, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0C, 0x06, 0x03, 0xF8,
  0x30, 0xF9, 0xF9, 0xBF, 0x81, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x6E, 0x00, 0x07, 0x30, 0x00, 0x70, 0xC0, 0x03, 0x07, 0x00, 0x30,
  0x1C, 0x03, 0x80, 0x60, 0x38, 0x03, 0x80, 0x80, 0x08, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x71, 0xCE, 0x38, 0xE3, 0x8C, 0x71, 0xC6, 0x18,
  0xE3, 0x0C, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0xEF, 0xFF, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0x30, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x18, 0x00,
  0x1C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00,
  0x07, 0x60, 0x00, 0x06, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00,
  0x0C, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0E, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x81, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x3E, 0x03, 0xF0, 0x3D,
  0x83, 0x8C, 0x38, 0x63, 0x83, 0x78, 0x1F, 0x80, 0xC8, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x3E, 0x01, 0xE0, 0x78, 0x00,
  0xF0, 0x20, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x10, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0x03, 0xF0, 0x0F,
  0x0F, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x10, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x90, 0x00,
  0x0F, 0x3C, 0x00, 0x7C, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x33, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x30, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x18, 0x07, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x06, 0x00, 0x70,
  0x00, 0x70, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x18, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x0C, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x70, 0x06, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC1, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x07, 0x80, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1C, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x88, 0x00, 0x1E, 0x1E, 0x00, 0xF8, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xC0,
  0x20, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x0F,
  0xFC, 0x0C, 0x3F, 0xFC, 0x18, 0xE0, 0x3E, 0x33, 0x80, 0x1C, 0x6C, 0x00,
  0x1C, 0xD0, 0x00, 0x19, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x37, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xB8, 0x00, 0x06, 0x70,
  0x00, 0x1C, 0x60, 0x00, 0x38, 0xE0, 0x00, 0x60, 0xE0, 0x01, 0xC1, 0xC0,
  0x07, 0x01, 0xE0, 0x1C, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0x80, 0xF0, 0x1E, 0x00,
  0x38, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x0F, 0x00, 0x70, 0x07, 0x81,
  0xE0, 0x01, 0xE3, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xE7, 0x80, 0x07, 0x81, 0xE0, 0x0F, 0x00, 0xF0, 0x1C, 0x00,
  0x78, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x60, 0x00,
  0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x0F, 0x01, 0xE0, 0x1C, 0x00, 0xF0, 0x38, 0x00, 0x70, 0x38, 0x00,
  0x38, 0x70, 0x00, 0x18, 0x70, 0x00, 0x1C, 0x60, 0x00, 0x1C, 0xE0, 0x00,
  0x0C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x60, 0x00,
  0x0F, 0x70, 0x00, 0x1F, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x36, 0x3C, 0x00,
  0x66, 0x1E, 0x01, 0xE6, 0x0F, 0xFF, 0xC6, 0x03, 0xFF, 0x06, 0x00, 0x7C,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x20, 0x0F,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x6F, 0xFF,
  0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0xFF, 0xFF, 0x0C, 0x3C, 0x78, 0xF1, 0xE1, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x87, 0x1C, 0x38, 0x70, 0xE1,
  0x87, 0x0E, 0x18, 0x30, 0xE1, 0x83, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x07, 0xFE, 0x0F, 0xFF, 0xE1, 0xC0, 0x3C, 0x40,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00,
  0x60, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x01, 0x87, 0x00, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x1F, 0xF8, 0x07, 0x38, 0x00, 0xFF, 0xF0, 0x06, 0x70,
  0x03, 0xC0, 0x60, 0x0C, 0xC0, 0x0E, 0x00, 0xC0, 0x19, 0x80, 0x18, 0x01,
  0x80, 0x3F, 0x00, 0x70, 0x03, 0x00, 0x7E, 0x00, 0xC0, 0x06, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0C, 0x00,
  0x70, 0x03, 0xC0, 0x18, 0x00, 0xE0, 0x07, 0x80, 0x30, 0x01, 0xC0, 0x0F,
  0x00, 0x60, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x07, 0x00, 0x18, 0x01, 0xF0, 0x06, 0x00, 0x30, 0x03,
  0xE0, 0x0C, 0x00, 0x60, 0x07, 0xC0, 0x18, 0x01, 0xC0, 0x0D, 0x80, 0x30,
  0x03, 0xC0, 0x1B, 0x00, 0x70, 0x07, 0x80, 0x76, 0x00, 0xE0, 0x1B, 0x00,
  0xCE, 0x00, 0xE0, 0x36, 0x03, 0x9C, 0x01, 0xE0, 0xC6, 0x0E, 0x18, 0x01,
  0xFF, 0x0F, 0xF8, 0x30, 0x01, 0xFC, 0x0F, 0xE0, 0x70, 0x00, 0x40, 0x06,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x00, 0x33, 0x00, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00,
  0x1C, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x87, 0x00, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x70,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x01, 0x80, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x70, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x01, 0x81, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0xC0, 0x00, 0xF0, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0xF0, 0xC0, 0x07, 0xE0, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0x03, 0xF0, 0xC0, 0x00, 0x78, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x1E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x3C, 0xC0, 0x00, 0xF8, 0xC0, 0x07, 0xF0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x00, 0x40, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x10, 0x0F,
  0x80, 0x1C, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7C, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x60, 0x00,
  0xF8, 0x0C, 0x00, 0x07, 0x81, 0x80, 0x00, 0x78, 0x30, 0x00, 0x07, 0x86,
  0x00, 0x00, 0x70, 0xC0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x39, 0x80, 0x00, 0x07, 0x30, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x0E, 0x18, 0x00, 0x03, 0xC3, 0x00, 0x00,
  0xF0, 0x60, 0x00, 0x3C, 0x0C, 0x00, 0x1F, 0x01, 0x80, 0x7F, 0x80, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x00,
  0x01, 0xC0, 0x78, 0x00, 0x00, 0x81, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0E, 0xC0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x01, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x3F,
  0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x06, 0x00, 0xEF, 0xFC, 0xFF, 0x87, 0xE0, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0xE0, 0xC0, 0x01, 0xC0, 0xC0, 0x03, 0x80, 0xC0,
  0x03, 0x80, 0xC0, 0x07, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0xC0,
  0x1C, 0x00, 0xC0, 0x38, 0x00, 0xC0, 0x78, 0x00, 0xC0, 0x70, 0x00, 0xC0,
  0xE0, 0x00, 0xC1, 0xC0, 0x00, 0xC1, 0xC0, 0x00, 0xC3, 0x80, 0x00, 0xC7,
  0x80, 0x00, 0xCF, 0xC0, 0x00, 0xCF, 0xC0, 0x00, 0xDC, 0xE0, 0x00, 0xD8,
  0xE0, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0xC0,
  0x1C, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0xC0,
  0x07, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0xC0,
  0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0x70, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0xC0,
  0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xEC, 0x00, 0x00, 0x00, 0xFF, 0x70, 0x00, 0x00, 0x06, 0xFB, 0x80,
  0x00, 0x00, 0x77, 0xCC, 0x00, 0x00, 0x03, 0xBE, 0x70, 0x00, 0x00, 0x19,
  0xF3, 0x80, 0x00, 0x01, 0xCF, 0x8C, 0x00, 0x00, 0x0E, 0x7C, 0x70, 0x00,
  0x00, 0x63, 0xE3, 0x80, 0x00, 0x07, 0x1F, 0x0C, 0x00, 0x00, 0x38, 0xF8,
  0x70, 0x00, 0x01, 0x87, 0xC3, 0x80, 0x00, 0x1C, 0x3E, 0x0C, 0x00, 0x00,
  0xE1, 0xF0, 0x70, 0x00, 0x06, 0x0F, 0x83, 0x80, 0x00, 0x70, 0x7C, 0x0C,
  0x00, 0x03, 0x83, 0xE0, 0x70, 0x00, 0x18, 0x1F, 0x03, 0x80, 0x01, 0xC0,
  0xF8, 0x0C, 0x00, 0x0E, 0x07, 0xC0, 0x70, 0x00, 0x60, 0x3E, 0x03, 0x80,
  0x07, 0x01, 0xF0, 0x0C, 0x00, 0x38, 0x0F, 0x80, 0x60, 0x01, 0x80, 0x7C,
  0x03, 0x80, 0x1C, 0x03, 0xE0, 0x0C, 0x00, 0xE0, 0x1F, 0x00, 0x70, 0x06,
  0x00, 0xF8, 0x03, 0x80, 0x70, 0x07, 0xC0, 0x0C, 0x03, 0x80, 0x3E, 0x00,
  0x60, 0x18, 0x01, 0xF0, 0x03, 0x81, 0xC0, 0x0F, 0x80, 0x0C, 0x0E, 0x00,
  0x7C, 0x00, 0x60, 0x60, 0x03, 0xE0, 0x03, 0x87, 0x00, 0x1F, 0x00, 0x0C,
  0x38, 0x00, 0xF8, 0x00, 0x61, 0x80, 0x07, 0xC0, 0x03, 0x9C, 0x00, 0x3E,
  0x00, 0x0C, 0xE0, 0x01, 0xF0, 0x00, 0x66, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xB0, 0x00, 0x01, 0xF7, 0x00, 0x00, 0x3E, 0x60, 0x00, 0x07, 0xCE,
  0x00, 0x00, 0xF8, 0xC0, 0x00, 0x1F, 0x1C, 0x00, 0x03, 0xE1, 0x80, 0x00,
  0x7C, 0x38, 0x00, 0x0F, 0x83, 0x00, 0x01, 0xF0, 0x70, 0x00, 0x3E, 0x06,
  0x00, 0x07, 0xC0, 0xE0, 0x00, 0xF8, 0x0C, 0x00, 0x1F, 0x01, 0xC0, 0x03,
  0xE0, 0x18, 0x00, 0x7C, 0x03, 0x80, 0x0F, 0x80, 0x30, 0x01, 0xF0, 0x07,
  0x00, 0x3E, 0x00, 0x60, 0x07, 0xC0, 0x0E, 0x00, 0xF8, 0x00, 0xC0, 0x1F,
  0x00, 0x1C, 0x03, 0xE0, 0x01, 0x80, 0x7C, 0x00, 0x38, 0x0F, 0x80, 0x03,
  0x01, 0xF0, 0x00, 0x70, 0x3E, 0x00, 0x06, 0x07, 0xC0, 0x00, 0xE0, 0xF8,
  0x00, 0x0E, 0x1F, 0x00, 0x01, 0xC3, 0xE0, 0x00, 0x1C, 0x7C, 0x00, 0x03,
  0x8F, 0x80, 0x00, 0x39, 0xF0, 0x00, 0x07, 0x3E, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x00,
  0x01, 0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x00, 0x0E, 0x60, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xF0, 0x07, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x30, 0x00, 0xF8, 0xC0, 0x00, 0xF3,
  0x00, 0x01, 0xCC, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x1B, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x3B, 0x00, 0x01, 0xCC, 0x00,
  0x07, 0x30, 0x00, 0x38, 0xC0, 0x03, 0xC3, 0x03, 0xFE, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x00, 0x01, 0xE0, 0x0E, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0E, 0x60, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0x03, 0xE0, 0xC0, 0x00,
  0xF0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x38, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xE0, 0xC0, 0x03, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x07,
  0x00, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x01,
  0xC0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x00, 0x04,
  0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x7C, 0x01, 0xE1, 0xE0, 0x00,
  0x47, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x90, 0x00, 0x0F, 0x3C, 0x00,
  0x7C, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x06, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x1F, 0x00, 0x7C, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x03, 0x38, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x80, 0x30, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x70,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x01,
  0x80, 0x0E, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x70, 0x03, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x0C, 0x07, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x63, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x33, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0x9C, 0x00, 0x01, 0xB0, 0x00, 0x07, 0x38, 0x00, 0x07, 0x60, 0x00,
  0x0C, 0x30, 0x00, 0x0E, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x19, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x33, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x63, 0x00, 0x01,
  0x81, 0x80, 0x01, 0xC6, 0x00, 0x07, 0x03, 0x00, 0x03, 0x8E, 0x00, 0x0E,
  0x07, 0x00, 0x06, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x30,
  0x0C, 0x00, 0x38, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x70, 0x60, 0x01, 0xC0,
  0x38, 0x00, 0xC0, 0xE0, 0x03, 0x80, 0x70, 0x01, 0x81, 0xC0, 0x06, 0x00,
  0xE0, 0x03, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x1C, 0x07, 0x00, 0x70, 0x03, 0x80, 0x30, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x06, 0x01, 0xC0, 0x18, 0x07, 0x00, 0x0C,
  0x03, 0x80, 0x30, 0x0E, 0x00, 0x1C, 0x06, 0x00, 0x70, 0x1C, 0x00, 0x38,
  0x0C, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xE0, 0x00, 0x60,
  0x70, 0x01, 0x81, 0xC0, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x01, 0xC1,
  0x80, 0x07, 0x06, 0x00, 0x03, 0x83, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x0E,
  0x00, 0x0C, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x18, 0x70, 0x00, 0x0E, 0x30,
  0x00, 0x38, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x71, 0x80, 0x00, 0x18, 0xC0,
  0x00, 0x67, 0x00, 0x00, 0x33, 0x80, 0x00, 0xCE, 0x00, 0x00, 0x77, 0x00,
  0x01, 0x9C, 0x00, 0x00, 0xEC, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xD8, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x07,
  0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x03, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01,
  0xC0, 0x30, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x06, 0x00, 0x01, 0x83, 0x80,
  0x00, 0x70, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x98, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x06, 0x0E,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x1C,
  0x03, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x07, 0x00,
  0x70, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x70, 0x00, 0x38, 0x1C, 0x00,
  0x0E, 0x03, 0x00, 0x03, 0x00, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x03, 0x00, 0x0E, 0x01, 0xC0,
  0x01, 0x80, 0x60, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x03,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x07, 0x38, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x63, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x03, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x18, 0x0C, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x38, 0x03, 0x80, 0x06, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x30, 0x00, 0xE0, 0x0E, 0x00, 0x0C, 0x01,
  0x80, 0x01, 0xC0, 0x70, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x30, 0x60, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x1C,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x01,
  0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0x07, 0xC1, 0x80, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0x80, 0x31, 0xE0,
  0x03, 0x38, 0x00, 0x37, 0x00, 0x03, 0x60, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1B, 0x70, 0x03, 0xB3, 0x80, 0x73,
  0x3F, 0xFE, 0x30, 0xFF, 0xC3, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x7F, 0x00, 0xE1, 0xFF, 0xC0, 0xE7,
  0xC1, 0xE0, 0xE6, 0x00, 0x70, 0xEC, 0x00, 0x38, 0xF8, 0x00, 0x1C, 0xD8,
  0x00, 0x1C, 0xD0, 0x00, 0x0C, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0C, 0xF0, 0x00, 0x1C, 0xD8,
  0x00, 0x1C, 0xDC, 0x00, 0x38, 0xCE, 0x00, 0x70, 0xC7, 0x01, 0xF0, 0xC3,
  0xFF, 0xE0, 0xC1, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xC0, 0x1F,
  0xFF, 0x03, 0xF0, 0xF0, 0x78, 0x01, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x03, 0x03, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0xFF, 0x03, 0x03, 0xFF, 0xC3, 0x07, 0xC1, 0xE3, 0x0F,
  0x00, 0x73, 0x1E, 0x00, 0x33, 0x1C, 0x00, 0x1B, 0x38, 0x00, 0x0B, 0x38,
  0x00, 0x0F, 0x30, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x30, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x1B, 0x1C,
  0x00, 0x1B, 0x1E, 0x00, 0x33, 0x0F, 0x00, 0xE3, 0x07, 0xFF, 0xC3, 0x01,
  0xFF, 0x83, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x1F,
  0x0F, 0x80, 0x78, 0x07, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x07, 0x06, 0x00,
  0x06, 0x1C, 0x00, 0x0E, 0x30, 0x00, 0x1C, 0xE0, 0x00, 0x19, 0xC0, 0x00,
  0x33, 0x00, 0x00, 0x76, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x04, 0x0F, 0x00, 0x78, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x70, 0x20, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0xFF, 0xFC, 0x7F, 0xFE, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC3, 0x07,
  0xC1, 0xE3, 0x0F, 0x00, 0x73, 0x1E, 0x00, 0x3B, 0x1C, 0x00, 0x1B, 0x38,
  0x00, 0x0F, 0x38, 0x00, 0x0F, 0x30, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x0F, 0x30, 0x00, 0x0F, 0x38, 0x00, 0x0B, 0x38,
  0x00, 0x1B, 0x1C, 0x00, 0x33, 0x0E, 0x00, 0x77, 0x0F, 0x00, 0xE7, 0x07,
  0xFF, 0xC7, 0x01, 0xFF, 0x87, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x40, 0x00, 0x3C, 0x30, 0x00, 0x78, 0x3E, 0x03, 0xF0, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x0F, 0xE0, 0xE1,
  0xFF, 0xC7, 0x3E, 0x1F, 0x39, 0x80, 0x3D, 0xD8, 0x00, 0xEF, 0x80, 0x03,
  0xEC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x06, 0x4E, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x01, 0x00, 0xE0, 0x7C,
  0x0F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x01, 0xC8, 0xE3, 0xF8, 0xF8, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0xEE, 0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x00, 0x30, 0xE0, 0x07, 0x0E, 0x00,
  0xE0, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x00, 0xE0,
  0x60, 0x0E, 0x0E, 0x00, 0xE1, 0xC0, 0x0E, 0x38, 0x00, 0xE3, 0xC0, 0x0E,
  0x7C, 0x00, 0xCE, 0xE0, 0x0C, 0xC6, 0x00, 0xD8, 0x70, 0x0F, 0x83, 0x00,
  0xF0, 0x38, 0x0E, 0x01, 0x80, 0xE0, 0x1C, 0x0E, 0x00, 0xC0, 0xE0, 0x0E,
  0x0E, 0x00, 0x60, 0xE0, 0x07, 0x0E, 0x00, 0x30, 0xE0, 0x03, 0x8E, 0x00,
  0x18, 0xE0, 0x01, 0xCE, 0x00, 0x0C, 0xE0, 0x00, 0xEE, 0x00, 0x06, 0xE0,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x7F, 0x06, 0x1F, 0xF8, 0x0F, 0xFC, 0x31, 0xE1, 0xE0, 0xF0, 0xF1,
  0x9C, 0x03, 0x8E, 0x01, 0xCC, 0xC0, 0x0C, 0xE0, 0x07, 0x6C, 0x00, 0x76,
  0x00, 0x3B, 0x40, 0x01, 0xE0, 0x00, 0xDE, 0x00, 0x0F, 0x00, 0x07, 0xE0,
  0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x1C, 0x00,
  0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00,
  0x38, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x07,
  0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x1C,
  0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x03, 0xF0,
  0x00, 0x38, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x0E, 0x00,
  0x07, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00,
  0x1C, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x03,
  0xF0, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x0E,
  0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x01, 0xF8,
  0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7F, 0x06,
  0x0F, 0xFE, 0x31, 0xF0, 0xF9, 0x8C, 0x01, 0xEC, 0xC0, 0x07, 0x6C, 0x00,
  0x1F, 0x60, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0xF0, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0x0F, 0x01, 0xE0, 0x03, 0xC0,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x06,
  0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x60,
  0x00, 0x03, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x61, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x30, 0x38, 0x00, 0x38,
  0x0E, 0x00, 0x38, 0x03, 0xC0, 0x38, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0xC1, 0xFF, 0xC0, 0xC3, 0xC1,
  0xE0, 0xC7, 0x00, 0x70, 0xCC, 0x00, 0x38, 0xCC, 0x00, 0x1C, 0xD8, 0x00,
  0x1C, 0xD0, 0x00, 0x0C, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0, 0x00,
  0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00,
  0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0C, 0xD8, 0x00, 0x1C, 0xD8, 0x00,
  0x1C, 0xEC, 0x00, 0x38, 0xEE, 0x00, 0x70, 0xE7, 0x00, 0xF0, 0xE3, 0xFF,
  0xC0, 0xE1, 0xFF, 0x80, 0xE0, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC3, 0x07, 0xC1,
  0xE3, 0x0F, 0x00, 0x73, 0x0E, 0x00, 0x33, 0x1C, 0x00, 0x1B, 0x38, 0x00,
  0x0B, 0x38, 0x00, 0x0F, 0x30, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x0B, 0x38, 0x00,
  0x1B, 0x1C, 0x00, 0x33, 0x1E, 0x00, 0x77, 0x0F, 0x00, 0xE7, 0x07, 0xFF,
  0xC7, 0x01, 0xFF, 0x87, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0xFF, 0x83, 0xFB, 0x0F, 0xF6, 0x38, 0x0C,
  0xC0, 0x19, 0x80, 0x36, 0x00, 0x68, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x1F, 0x83, 0xE3, 0xC0, 0x06, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0xC0, 0x01, 0xCF, 0x00,
  0x3C, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0x00, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xB0, 0x00, 0x6D, 0xC0, 0x03, 0x6F, 0x00, 0x33, 0x3C, 0x07,
  0x18, 0xFF, 0xF0, 0xC3, 0xFF, 0x06, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x0E,
  0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x33, 0x80, 0x00, 0xE3, 0x00, 0x01, 0xC6,
  0x00, 0x03, 0x8E, 0x00, 0x06, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x38,
  0x00, 0x60, 0x70, 0x00, 0xC0, 0x60, 0x03, 0x80, 0xC0, 0x07, 0x01, 0xC0,
  0x0C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0xC0, 0x0E, 0x01,
  0x80, 0x0C, 0x07, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x18, 0x00, 0x70, 0x70,
  0x00, 0x60, 0xE0, 0x00, 0xC1, 0x80, 0x01, 0xC3, 0x00, 0x01, 0x8E, 0x00,
  0x03, 0x1C, 0x00, 0x07, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x0D, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x01, 0xF8,
  0x00, 0x1E, 0x00, 0x0E, 0xC0, 0x01, 0xF0, 0x00, 0x66, 0x00, 0x0D, 0x80,
  0x03, 0x38, 0x00, 0x6E, 0x00, 0x39, 0xC0, 0x03, 0x30, 0x01, 0xC6, 0x00,
  0x39, 0x80, 0x0C, 0x30, 0x01, 0xCC, 0x00, 0x61, 0xC0, 0x0C, 0x70, 0x03,
  0x0E, 0x00, 0x63, 0x80, 0x38, 0x30, 0x07, 0x0C, 0x01, 0xC1, 0x80, 0x38,
  0x60, 0x0C, 0x0E, 0x01, 0x83, 0x80, 0x60, 0x70, 0x0C, 0x1C, 0x07, 0x01,
  0x80, 0xE0, 0x60, 0x38, 0x0C, 0x07, 0x03, 0x01, 0x80, 0x70, 0x30, 0x1C,
  0x0C, 0x03, 0x81, 0x80, 0xE0, 0xE0, 0x0C, 0x1C, 0x03, 0x07, 0x00, 0x60,
  0xE0, 0x18, 0x30, 0x03, 0x86, 0x00, 0xE1, 0x80, 0x1C, 0x30, 0x07, 0x0C,
  0x00, 0x63, 0x80, 0x18, 0xE0, 0x03, 0x1C, 0x00, 0xC6, 0x00, 0x18, 0xC0,
  0x06, 0x30, 0x00, 0xE6, 0x00, 0x39, 0x80, 0x07, 0x30, 0x00, 0xDC, 0x00,
  0x1B, 0x80, 0x06, 0xE0, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x07, 0xC0, 0x01,
  0xB0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x30, 0xE0, 0x00, 0xE0, 0xE0, 0x03, 0x80, 0xC0, 0x07, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0xE0, 0x03, 0x01, 0xC0, 0x07, 0x07,
  0x00, 0x06, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x60, 0x00, 0x1D, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x71, 0xC0, 0x01, 0xC1, 0xC0, 0x03, 0x81, 0x80, 0x0E, 0x03, 0x80, 0x1C,
  0x03, 0x00, 0x70, 0x07, 0x00, 0xC0, 0x06, 0x03, 0x80, 0x0E, 0x06, 0x00,
  0x0C, 0x1C, 0x00, 0x1C, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0x38, 0x70, 0x00, 0x07, 0x70, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x0C, 0x00, 0x18, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00,
  0x30, 0x06, 0x00, 0x30, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00,
  0x60, 0x03, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xC0, 0x01, 0x80,
  0xC0, 0x01, 0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xC1, 0x80, 0x00, 0xC3,
  0x80, 0x00, 0xE3, 0x80, 0x00, 0x63, 0x00, 0x00, 0x63, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x36, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x87, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x0F, 0xC0, 0x1F, 0x80,
  0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0xFF, 0x00, 0x7E, 0x00, 0x20, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x17, 0xFF, 0xC0, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x07, 0xFF, 0xA0,
  0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraLight67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 48, 14, 5, -48 },
  { 25, 13, 17, 21, 4, -48 },
  { 53, 31, 48, 33, 1, -48 },
  { 239, 24, 55, 30, 3, -51 },
  { 404, 38, 50, 44, 3, -49 },
  { 642, 30, 50, 33, 3, -49 },
  { 830, 3, 17, 12, 4, -48 },
  { 837, 12, 59, 18, 3, -48 },
  { 926, 13, 59, 18, 2, -48 },
  { 1022, 21, 21, 28, 3, -51 },
  { 1078, 26, 31, 30, 2, -39 },
  { 1179, 6, 16, 13, 3, -7 },
  { 1191, 15, 2, 19, 2, -19 },
  { 1195, 4, 5, 13, 5, -5 },
  { 1198, 20, 48, 22, 1, -48 },
  { 1318, 24, 50, 30, 3, -49 },
  { 1468, 13, 48, 30, 5, -48 },
  { 1546, 24, 49, 30, 3, -49 },
  { 1693, 23, 50, 30, 3, -49 },
  { 1837, 29, 48, 30, 1, -48 },
  { 2011, 23, 49, 30, 4, -48 },
  { 2152, 23, 49, 30, 4, -48 },
  { 2293, 24, 48, 30, 3, -48 },
  { 2437, 24, 49, 30, 3, -48 },
  { 2584, 24, 50, 30, 3, -49 },
  { 2734, 4, 36, 14, 5, -36 },
  { 2752, 7, 45, 13, 2, -36 },
  { 2792, 26, 29, 30, 2, -38 },
  { 2887, 26, 17, 30, 2, -32 },
  { 2943, 26, 29, 30, 2, -38 },
  { 3038, 18, 49, 21, 1, -49 },
  { 3149, 39, 54, 47, 4, -48 },
  { 3413, 30, 48, 30, 0, -48 },
  { 3593, 24, 48, 33, 6, -48 },
  { 3737, 26, 50, 32, 4, -49 },
  { 3900, 27, 48, 37, 6, -48 },
  { 4062, 20, 48, 29, 6, -48 },
  { 4182, 20, 48, 27, 6, -48 },
  { 4302, 31, 50, 39, 4, -49 },
  { 4496, 26, 48, 38, 6, -48 },
  { 4652, 11, 48, 17, 3, -48 },
  { 4718, 12, 60, 14, -4, -48 },
  { 4808, 24, 48, 30, 6, -48 },
  { 4952, 19, 48, 27, 6, -48 },
  { 5066, 37, 48, 48, 6, -48 },
  { 5288, 27, 48, 39, 6, -48 },
  { 5450, 32, 50, 40, 4, -49 },
  { 5650, 22, 48, 31, 6, -48 },
  { 5782, 32, 60, 40, 4, -49 },
  { 6022, 24, 48, 31, 6, -48 },
  { 6166, 23, 50, 29, 3, -49 },
  { 6310, 26, 48, 27, 0, -48 },
  { 6466, 27, 49, 38, 5, -48 },
  { 6632, 29, 48, 29, 0, -48 },
  { 6806, 47, 48, 49, 1, -48 },
  { 7088, 26, 48, 27, 0, -48 },
  { 7244, 26, 48, 26, 0, -48 },
  { 7400, 23, 48, 27, 2, -48 },
  { 7538, 13, 59, 21, 6, -48 },
  { 7634, 20, 48, 22, 1, -48 },
  { 7754, 13, 59, 21, 2, -48 },
  { 7850, 27, 25, 30, 2, -48 },
  { 7935, 27, 2, 27, 0, 6 },
  { 7942, 10, 10, 16, 3, -51 },
  { 7955, 20, 37, 28, 3, -36 },
  { 8048, 24, 52, 32, 5, -51 },
  { 8204, 20, 37, 25, 3, -36 },
  { 8297, 24, 52, 32, 3, -51 },
  { 8453, 23, 37, 29, 3, -36 },
  { 8560, 17, 51, 16, 1, -51 },
  { 8669, 24, 52, 32, 3, -36 },
  { 8825, 21, 51, 31, 5, -51 },
  { 8959, 4, 49, 13, 5, -49 },
  { 8984, 10, 65, 13, -1, -49 },
  { 9066, 20, 51, 25, 5, -51 },
  { 9194, 3, 51, 13, 5, -51 },
  { 9214, 37, 36, 47, 5, -36 },
  { 9381, 21, 36, 31, 5, -36 },
  { 9476, 25, 37, 31, 3, -36 },
  { 9592, 24, 52, 32, 5, -36 },
  { 9748, 24, 52, 32, 3, -36 },
  { 9904, 15, 36, 20, 5, -36 },
  { 9972, 20, 37, 24, 2, -36 },
  { 10065, 15, 45, 17, 1, -44 },
  { 10150, 21, 36, 31, 5, -35 },
  { 10245, 23, 35, 23, 0, -35 },
  { 10346, 37, 35, 39, 1, -35 },
  { 10508, 23, 35, 25, 1, -35 },
  { 10609, 24, 51, 24, 0, -35 },
  { 10762, 18, 35, 22, 2, -35 },
  { 10841, 17, 59, 23, 3, -48 },
  { 10967, 3, 67, 29, 13, -51 },
  { 10993, 17, 59, 23, 3, -48 },
  { 11119, 26, 6, 30, 2, -27 },
};

const GFXfont NotoSans_Condensed_ExtraLight67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight67pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT67PT7B_H_
