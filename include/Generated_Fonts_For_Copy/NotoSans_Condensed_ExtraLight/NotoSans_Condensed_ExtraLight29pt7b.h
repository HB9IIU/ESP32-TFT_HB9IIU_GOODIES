#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT29PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF5, 0x55, 0x55, 0x03, 0xC0, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x0C, 0x20, 0x42, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x23, 0xFF, 0xE1,
  0x08, 0x10, 0x80, 0x84, 0x04, 0x20, 0x21, 0x01, 0x08, 0x7F, 0xF8, 0x42,
  0x04, 0x10, 0x21, 0x01, 0x08, 0x08, 0x40, 0x42, 0x02, 0x10, 0x00, 0x04,
  0x00, 0x80, 0xFE, 0x32, 0x24, 0x41, 0x08, 0x21, 0x04, 0x20, 0x44, 0x0C,
  0x80, 0xD0, 0x07, 0x00, 0x70, 0x09, 0x81, 0x10, 0x23, 0x04, 0x20, 0x8C,
  0x11, 0x42, 0x67, 0xF0, 0x08, 0x01, 0x00, 0x20, 0x38, 0x08, 0x22, 0x04,
  0x11, 0x04, 0x08, 0x42, 0x0C, 0x22, 0x04, 0x11, 0x02, 0x08, 0x81, 0x04,
  0x80, 0x82, 0x44, 0x21, 0x49, 0x91, 0x24, 0x48, 0x94, 0x23, 0x92, 0x10,
  0x09, 0x04, 0x08, 0x82, 0x04, 0x41, 0x02, 0x21, 0x82, 0x10, 0x81, 0x08,
  0x41, 0x02, 0x20, 0x80, 0xE0, 0x0E, 0x00, 0x88, 0x08, 0x40, 0x41, 0x02,
  0x08, 0x10, 0x40, 0x84, 0x02, 0x20, 0x12, 0x00, 0x60, 0x05, 0x00, 0x48,
  0x04, 0x21, 0x20, 0x8A, 0x06, 0x50, 0x12, 0x80, 0x64, 0x03, 0x10, 0x18,
  0xC3, 0x23, 0xF1, 0x80, 0xFF, 0x0C, 0x21, 0x0C, 0x20, 0x84, 0x10, 0x41,
  0x0C, 0x30, 0xC3, 0x0C, 0x10, 0x41, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08,
  0x30, 0x82, 0x08, 0x41, 0x08, 0x41, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x46, 0x21, 0x18, 0x8C, 0x44, 0x00, 0x0C, 0x04, 0x02, 0x1D, 0x31, 0xE0,
  0x60, 0x48, 0x66, 0x21, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x6D,
  0x25, 0x20, 0xFC, 0xF0, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x18, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0xC0, 0x80,
  0x80, 0x0F, 0x06, 0x30, 0x82, 0x30, 0x24, 0x04, 0x80, 0x90, 0x12, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x3C, 0x06, 0x80, 0xD0, 0x12, 0x02, 0x40,
  0x48, 0x08, 0x82, 0x18, 0xC1, 0xF0, 0x04, 0x33, 0x59, 0xC4, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x1E, 0x0C,
  0x30, 0x02, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x06, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x06, 0x00, 0x80,
  0x20, 0x0F, 0xFE, 0x3E, 0x18, 0x68, 0x0C, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x03, 0x00, 0x80, 0xC1, 0xE0, 0x06, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x0E, 0x02, 0x7F, 0x00, 0x00, 0x40, 0x06, 0x00, 0x50, 0x02,
  0x80, 0x24, 0x01, 0x20, 0x11, 0x00, 0x88, 0x08, 0x40, 0x42, 0x04, 0x10,
  0x60, 0x82, 0x04, 0x20, 0x21, 0x01, 0x1F, 0xFF, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x7F, 0x90, 0x0C, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x3F, 0x80, 0x18, 0x02, 0x00, 0x80, 0x30, 0x04,
  0x03, 0x00, 0x80, 0x20, 0x1A, 0x0C, 0xFE, 0x00, 0x0F, 0x8C, 0x02, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x8E, 0x28, 0xCC, 0x0A, 0x02, 0x80,
  0xE0, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x24, 0x09, 0x84, 0x3F, 0x00, 0xFF,
  0xE0, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x1F, 0x06, 0x11, 0x81, 0x20, 0x24, 0x04, 0x80,
  0x90, 0x11, 0x06, 0x31, 0x81, 0xC0, 0x38, 0x18, 0xC6, 0x0C, 0x80, 0xB0,
  0x1C, 0x01, 0x80, 0x38, 0x0D, 0x01, 0x30, 0x63, 0xF0, 0x1E, 0x08, 0x64,
  0x09, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x50, 0x14, 0x0C, 0x87,
  0x1E, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x7E, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x6C, 0x00, 0x00, 0x00, 0x06, 0xD2, 0x52, 0x00,
  0x00, 0x20, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x02, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x00, 0x79, 0x0C,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x04, 0x18, 0x60, 0x82, 0x04, 0x08, 0x10,
  0x00, 0x00, 0x01, 0x02, 0x00, 0x01, 0xE0, 0x07, 0x0C, 0x04, 0x03, 0x04,
  0x00, 0xC6, 0x00, 0x22, 0x00, 0x0B, 0x07, 0x85, 0x04, 0x42, 0x84, 0x21,
  0x42, 0x10, 0x62, 0x08, 0x31, 0x04, 0x18, 0x82, 0x0C, 0x41, 0x0A, 0x20,
  0x85, 0x08, 0xC2, 0x86, 0x52, 0x41, 0xC6, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x70, 0xC0, 0x07, 0x00, 0x02, 0x00, 0x18, 0x01,
  0x40, 0x0A, 0x00, 0x50, 0x04, 0x40, 0x22, 0x01, 0x10, 0x08, 0xC0, 0x82,
  0x04, 0x10, 0x20, 0x83, 0xFE, 0x10, 0x10, 0x80, 0x84, 0x06, 0x40, 0x12,
  0x00, 0x90, 0x05, 0x80, 0x18, 0x00, 0x80, 0xFE, 0x18, 0x33, 0x01, 0x60,
  0x2C, 0x07, 0x80, 0xF0, 0x16, 0x02, 0xC0, 0xD8, 0x73, 0xFE, 0x60, 0x6C,
  0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0x60, 0x6F, 0xF0,
  0x07, 0xC3, 0x04, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x08, 0x10, 0xFE, 0xFE, 0x0C, 0x38, 0xC0, 0xCC, 0x06, 0xC0,
  0x2C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x2C, 0x06, 0xC0, 0x4C, 0x18, 0xFE,
  0x00, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x3F, 0xF8, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F,
  0xF8, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x1F, 0xFC, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x00, 0x07, 0xE0, 0xC0, 0xCC, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x03, 0xF8, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x40, 0x0A, 0x00, 0x48, 0x02, 0x30, 0x10, 0xFF, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xFF, 0xFC, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x10, 0xF9, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x4F, 0x80, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0xC2, 0x0B, 0xC0, 0xC0, 0x78, 0x0B, 0x02, 0x60, 0x8C,
  0x31, 0x84, 0x31, 0x06, 0x60, 0xC8, 0x1B, 0x03, 0xA0, 0x76, 0x0C, 0x41,
  0x8C, 0x30, 0x86, 0x08, 0xC1, 0x18, 0x13, 0x03, 0x60, 0x2C, 0x06, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0F, 0xF8, 0xC0,
  0x01, 0xC0, 0x03, 0xA0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xD0, 0x05, 0xD0,
  0x05, 0xD0, 0x0D, 0xC8, 0x09, 0xC8, 0x09, 0xC8, 0x19, 0xC4, 0x11, 0xC4,
  0x11, 0xC4, 0x31, 0xC2, 0x21, 0xC2, 0x21, 0xC2, 0x61, 0xC1, 0x41, 0xC1,
  0x41, 0xC1, 0xC1, 0xC0, 0x81, 0xC0, 0x1C, 0x01, 0xA0, 0x1E, 0x01, 0xD0,
  0x1D, 0x01, 0xC8, 0x1C, 0x81, 0xC4, 0x1C, 0x41, 0xC2, 0x1C, 0x21, 0xC1,
  0x1C, 0x11, 0xC0, 0x9C, 0x09, 0xC0, 0x5C, 0x05, 0xC0, 0x3C, 0x03, 0xC0,
  0x10, 0x0F, 0x80, 0xC1, 0x82, 0x03, 0x10, 0x04, 0x40, 0x1A, 0x00, 0x28,
  0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xE0, 0x02, 0x80, 0x0A,
  0x00, 0x28, 0x00, 0xA0, 0x02, 0xC0, 0x19, 0x00, 0x46, 0x03, 0x0C, 0x18,
  0x1F, 0xC0, 0xFC, 0x31, 0xCC, 0x0B, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x2C, 0x1B, 0xFC, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0xC1, 0x82, 0x03, 0x10, 0x04,
  0x40, 0x1A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00,
  0xE0, 0x03, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0xC0, 0x19, 0x00,
  0x46, 0x03, 0x0C, 0x18, 0x1F, 0xC0, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0xC0, 0xFC, 0x18, 0xF3, 0x02, 0x60, 0x2C, 0x05, 0x80, 0xB0,
  0x16, 0x02, 0xC0, 0xD8, 0x13, 0x0C, 0x7E, 0x0C, 0x61, 0x84, 0x30, 0xC6,
  0x08, 0xC1, 0x98, 0x13, 0x03, 0x60, 0x2C, 0x06, 0x1F, 0x8C, 0x14, 0x01,
  0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0E, 0x06, 0xFF, 0x00, 0xFF,
  0xE0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0xC0, 0x14, 0x03, 0x40, 0x22, 0x06, 0x1F, 0x80,
  0x80, 0x0C, 0x00, 0x90, 0x04, 0x80, 0x24, 0x03, 0x30, 0x10, 0x80, 0x84,
  0x04, 0x20, 0x40, 0x82, 0x04, 0x10, 0x21, 0x81, 0x08, 0x04, 0x40, 0x22,
  0x01, 0x20, 0x0D, 0x00, 0x28, 0x01, 0x40, 0x0C, 0x00, 0x20, 0x00, 0xC0,
  0x20, 0x0A, 0x01, 0x00, 0xD0, 0x14, 0x04, 0x80, 0xA0, 0x24, 0x05, 0x01,
  0x10, 0x28, 0x18, 0x81, 0x40, 0x84, 0x11, 0x04, 0x20, 0x88, 0x21, 0x84,
  0x43, 0x04, 0x22, 0x10, 0x23, 0x18, 0x81, 0x10, 0x44, 0x0C, 0x82, 0x20,
  0x24, 0x12, 0x01, 0x20, 0x90, 0x0A, 0x02, 0x80, 0x50, 0x14, 0x01, 0x80,
  0xE0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x00, 0x40, 0x2C, 0x0C, 0x81, 0x10,
  0x21, 0x08, 0x21, 0x02, 0x40, 0x48, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xB0, 0x12, 0x04, 0x60, 0x84, 0x20, 0x84, 0x09, 0x81, 0x20, 0x1C, 0x02,
  0x80, 0x38, 0x05, 0x01, 0x20, 0x22, 0x0C, 0x41, 0x0C, 0x20, 0x88, 0x11,
  0x01, 0x60, 0x28, 0x07, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0xFF, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x00,
  0x40, 0x20, 0x08, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0xFF, 0xC0, 0xFE, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x83, 0xF0, 0x80, 0x80, 0x80, 0x40, 0x40, 0x60, 0x20, 0x20,
  0x10, 0x10, 0x10, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x02, 0x02, 0x02, 0x01,
  0x01, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x07, 0xF0, 0x04, 0x00, 0xC0,
  0x28, 0x04, 0x81, 0x10, 0x21, 0x08, 0x21, 0x02, 0x40, 0x48, 0x0E, 0x00,
  0x80, 0xFF, 0xF0, 0xC3, 0x08, 0x30, 0x0C, 0x39, 0x80, 0x60, 0x10, 0x08,
  0x04, 0x02, 0x0F, 0x30, 0xA0, 0x70, 0x30, 0x18, 0x0C, 0x0D, 0x0A, 0x7D,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x23, 0x04, 0x9C, 0xA0,
  0x98, 0x0B, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x1C, 0x02, 0x80, 0x50,
  0x0B, 0x01, 0x60, 0x6A, 0x19, 0x3E, 0x00, 0x06, 0x0E, 0xC8, 0x0C, 0x04,
  0x02, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x08, 0x04, 0x03, 0x00, 0xC0,
  0x3F, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x43, 0x08, 0xD9,
  0x20, 0xA8, 0x0D, 0x01, 0xA0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x40,
  0x28, 0x0D, 0x01, 0xA0, 0x32, 0x0A, 0x3E, 0x40, 0x0C, 0x06, 0xC2, 0x09,
  0x03, 0x40, 0x50, 0x14, 0x07, 0xFF, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x40,
  0x18, 0x03, 0x04, 0x7E, 0x0F, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFC,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x0E, 0x07, 0x34, 0x82, 0xA0, 0x34, 0x06, 0x80, 0xF0, 0x0E,
  0x01, 0xC0, 0x38, 0x05, 0x01, 0xA0, 0x34, 0x06, 0x80, 0xC8, 0x28, 0xF9,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x83, 0x0F, 0xC0, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x11, 0x36, 0xA0, 0xE0, 0x70, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0xF0,
  0x0A, 0xAA, 0xAA, 0xAA, 0x80, 0x18, 0xC0, 0x00, 0x00, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x85, 0xC0, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x02, 0x82, 0x42, 0x21, 0x11,
  0x09, 0x05, 0xC2, 0xA1, 0x98, 0x84, 0x43, 0x20, 0x90, 0x68, 0x14, 0x0C,
  0xFF, 0xFF, 0xFC, 0x0C, 0x08, 0xB7, 0x36, 0xA1, 0x43, 0xC1, 0x81, 0xC0,
  0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80,
  0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x80, 0x81, 0x04,
  0x4D, 0xA8, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x06, 0x03, 0x30, 0x83, 0x20, 0x24, 0x06,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x05, 0x00, 0xA0, 0x14, 0x04, 0xC0,
  0x88, 0x20, 0xF8, 0x0C, 0x13, 0x72, 0x82, 0x60, 0x2C, 0x05, 0x00, 0xA0,
  0x14, 0x02, 0x80, 0x70, 0x0A, 0x01, 0x60, 0x2C, 0x05, 0x81, 0xA8, 0x24,
  0xF8, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x00, 0x04,
  0x03, 0x64, 0x82, 0xA0, 0x34, 0x06, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xA0, 0x34, 0x06, 0xC1, 0x48, 0x28, 0xF9, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x0F, 0x3A, 0x86, 0x0C, 0x18,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x1C, 0x73, 0x40,
  0x80, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x02, 0x01, 0x01, 0x01, 0x01, 0x83,
  0xFE, 0x20, 0x40, 0x81, 0x0F, 0xE4, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x60, 0x78, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x1A, 0x1C, 0xFA, 0x80,
  0x50, 0x34, 0x09, 0x02, 0x60, 0x88, 0x42, 0x10, 0x84, 0x13, 0x04, 0x81,
  0x20, 0x68, 0x0C, 0x03, 0x00, 0xC0, 0xC0, 0x81, 0xA0, 0x60, 0x90, 0x50,
  0x48, 0x28, 0x26, 0x14, 0x21, 0x09, 0x10, 0x88, 0x88, 0x44, 0x44, 0x32,
  0x24, 0x09, 0x0A, 0x05, 0x05, 0x02, 0x82, 0x81, 0x41, 0x40, 0x60, 0xC0,
  0x20, 0x20, 0x81, 0xA0, 0x98, 0xC4, 0x43, 0x60, 0xA0, 0x60, 0x10, 0x14,
  0x1A, 0x08, 0x8C, 0x44, 0x16, 0x0A, 0x02, 0xC0, 0x50, 0x14, 0x0C, 0x82,
  0x20, 0x88, 0x22, 0x10, 0x44, 0x11, 0x04, 0x80, 0xA0, 0x28, 0x0A, 0x03,
  0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x38, 0x00, 0xFF,
  0x02, 0x06, 0x04, 0x0C, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40,
  0x80, 0xFF, 0x01, 0x0C, 0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0xE0, 0x60, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x08, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x30, 0x18, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x07, 0x06, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x10, 0x70, 0xC0, 0x10, 0x1D,
  0x86, 0x0F, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLight29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 21, 6, 2, -21 },
  { 7, 5, 8, 9, 2, -21 },
  { 12, 13, 21, 14, 1, -21 },
  { 47, 11, 24, 13, 1, -22 },
  { 80, 17, 21, 19, 1, -21 },
  { 125, 13, 21, 14, 1, -21 },
  { 160, 1, 8, 5, 2, -21 },
  { 161, 6, 26, 8, 1, -21 },
  { 181, 5, 26, 8, 1, -21 },
  { 198, 9, 9, 12, 1, -22 },
  { 209, 11, 13, 13, 1, -17 },
  { 227, 3, 7, 6, 1, -3 },
  { 230, 6, 1, 8, 1, -8 },
  { 231, 2, 2, 6, 2, -2 },
  { 232, 8, 21, 10, 1, -21 },
  { 253, 11, 21, 13, 1, -21 },
  { 282, 6, 21, 13, 2, -21 },
  { 298, 11, 21, 13, 1, -21 },
  { 327, 10, 21, 13, 1, -21 },
  { 354, 13, 21, 13, 0, -21 },
  { 389, 10, 21, 13, 2, -21 },
  { 416, 10, 21, 13, 2, -21 },
  { 443, 11, 21, 13, 1, -21 },
  { 472, 11, 21, 13, 1, -21 },
  { 501, 10, 21, 13, 1, -21 },
  { 528, 2, 15, 6, 2, -15 },
  { 532, 3, 19, 6, 1, -15 },
  { 540, 11, 13, 13, 1, -17 },
  { 558, 11, 7, 13, 1, -14 },
  { 568, 11, 13, 13, 1, -17 },
  { 586, 7, 21, 9, 1, -21 },
  { 605, 17, 24, 20, 2, -21 },
  { 656, 13, 21, 13, 0, -21 },
  { 691, 11, 21, 14, 2, -21 },
  { 720, 11, 21, 14, 2, -21 },
  { 749, 12, 21, 16, 2, -21 },
  { 781, 9, 21, 13, 2, -21 },
  { 805, 9, 21, 12, 2, -21 },
  { 829, 13, 21, 17, 2, -21 },
  { 864, 12, 21, 16, 2, -21 },
  { 896, 5, 21, 7, 1, -21 },
  { 910, 6, 26, 6, -2, -21 },
  { 930, 11, 21, 13, 2, -21 },
  { 959, 9, 21, 11, 2, -21 },
  { 983, 16, 21, 21, 2, -21 },
  { 1025, 12, 21, 17, 2, -21 },
  { 1057, 14, 21, 17, 2, -21 },
  { 1094, 10, 21, 13, 2, -21 },
  { 1121, 14, 26, 17, 2, -21 },
  { 1167, 11, 21, 14, 2, -21 },
  { 1196, 10, 21, 13, 1, -21 },
  { 1223, 11, 21, 11, 0, -21 },
  { 1252, 12, 21, 16, 2, -21 },
  { 1284, 13, 21, 13, 0, -21 },
  { 1319, 21, 21, 21, 0, -21 },
  { 1375, 11, 21, 12, 0, -21 },
  { 1404, 11, 21, 11, 0, -21 },
  { 1433, 10, 21, 12, 1, -21 },
  { 1460, 6, 26, 9, 2, -21 },
  { 1480, 8, 21, 10, 1, -21 },
  { 1501, 6, 26, 9, 1, -21 },
  { 1521, 11, 11, 13, 1, -21 },
  { 1537, 12, 1, 12, 0, 3 },
  { 1539, 5, 4, 7, 1, -22 },
  { 1542, 9, 16, 12, 1, -16 },
  { 1560, 11, 22, 14, 2, -22 },
  { 1591, 9, 16, 11, 1, -16 },
  { 1609, 11, 22, 14, 1, -22 },
  { 1640, 10, 16, 13, 1, -16 },
  { 1660, 8, 22, 7, 0, -22 },
  { 1682, 11, 23, 14, 1, -16 },
  { 1714, 9, 22, 14, 2, -22 },
  { 1739, 2, 21, 6, 2, -21 },
  { 1745, 5, 28, 6, -1, -21 },
  { 1763, 9, 22, 11, 2, -22 },
  { 1788, 1, 22, 5, 2, -22 },
  { 1791, 16, 16, 20, 2, -16 },
  { 1823, 9, 16, 14, 2, -16 },
  { 1841, 11, 16, 13, 1, -16 },
  { 1863, 11, 23, 14, 2, -16 },
  { 1895, 11, 23, 14, 1, -16 },
  { 1927, 7, 16, 9, 2, -16 },
  { 1941, 8, 16, 10, 1, -16 },
  { 1957, 7, 19, 7, 0, -19 },
  { 1974, 9, 15, 14, 2, -15 },
  { 1991, 10, 15, 10, 0, -15 },
  { 2010, 17, 15, 17, 0, -15 },
  { 2042, 9, 15, 11, 1, -15 },
  { 2059, 10, 22, 11, 0, -15 },
  { 2087, 8, 15, 9, 1, -15 },
  { 2102, 8, 26, 10, 1, -21 },
  { 2128, 1, 29, 12, 6, -22 },
  { 2132, 8, 26, 10, 1, -21 },
  { 2158, 11, 3, 13, 1, -12 },
};

const GFXfont NotoSans_Condensed_ExtraLight29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight29pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT29PT7B_H_
