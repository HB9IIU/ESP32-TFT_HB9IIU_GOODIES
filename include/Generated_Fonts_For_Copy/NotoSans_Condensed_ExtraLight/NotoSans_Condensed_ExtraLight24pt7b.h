#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT24PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF9, 0x80, 0x99, 0x99, 0x99, 0x08, 0x41, 0x10, 0x22, 0x04,
  0x40, 0x88, 0xFF, 0xC2, 0x20, 0x84, 0x10, 0x82, 0x20, 0x44, 0x7F, 0xF1,
  0x10, 0x22, 0x08, 0x41, 0x08, 0x22, 0x00, 0x08, 0x1F, 0x12, 0x51, 0x08,
  0x84, 0x42, 0x20, 0x90, 0x38, 0x06, 0x02, 0x81, 0x20, 0x88, 0x44, 0x22,
  0x12, 0xFE, 0x04, 0x02, 0x00, 0x78, 0x61, 0x21, 0x08, 0x84, 0x21, 0x20,
  0x84, 0x82, 0x12, 0x08, 0x53, 0x22, 0x52, 0x4A, 0x89, 0xEA, 0x20, 0x28,
  0x41, 0x21, 0x04, 0x84, 0x22, 0x10, 0x88, 0x82, 0x12, 0x10, 0x70, 0x3C,
  0x04, 0x41, 0x08, 0x21, 0x02, 0x20, 0x44, 0x09, 0x00, 0xC0, 0x28, 0x09,
  0x0A, 0x11, 0x41, 0x28, 0x19, 0x03, 0x20, 0x62, 0x1A, 0x7C, 0x60, 0xFC,
  0x19, 0x08, 0x84, 0x22, 0x10, 0x84, 0x21, 0x08, 0x41, 0x08, 0x41, 0x08,
  0x21, 0x80, 0x84, 0x22, 0x21, 0x11, 0x11, 0x11, 0x11, 0x11, 0x22, 0x44,
  0x80, 0x10, 0x10, 0xD3, 0x3C, 0x18, 0x24, 0x46, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x87, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x55, 0xA0, 0xF8,
  0xC0, 0x01, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x40, 0x40, 0xC0, 0x3E, 0x31, 0x10, 0x48, 0x28, 0x14,
  0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x12, 0x09, 0x04, 0x44,
  0x3C, 0x00, 0x19, 0x53, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x7E, 0x41, 0x00, 0x40, 0x20, 0x10, 0x08, 0x04, 0x04, 0x02, 0x02,
  0x03, 0x01, 0x01, 0x01, 0x01, 0x00, 0x80, 0xFF, 0x80, 0x7E, 0x83, 0x01,
  0x01, 0x01, 0x01, 0x02, 0x0C, 0x3C, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x03, 0xFE, 0x01, 0x00, 0x60, 0x0C, 0x02, 0x80, 0x50, 0x12, 0x04, 0x40,
  0x88, 0x21, 0x04, 0x21, 0x04, 0x20, 0x8F, 0xFE, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x7F, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFC, 0x01,
  0x00, 0x80, 0x20, 0x10, 0x08, 0x08, 0x05, 0x04, 0xFC, 0x00, 0x1F, 0x10,
  0x08, 0x08, 0x04, 0x02, 0x02, 0x31, 0x64, 0xC1, 0x60, 0xA0, 0x30, 0x18,
  0x0A, 0x05, 0x04, 0xC2, 0x3E, 0x00, 0xFF, 0x80, 0x80, 0x40, 0x20, 0x20,
  0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40,
  0x20, 0x00, 0x3E, 0x20, 0x90, 0x50, 0x24, 0x12, 0x08, 0x88, 0x38, 0x14,
  0x31, 0x10, 0x50, 0x18, 0x0C, 0x06, 0x02, 0x82, 0x3E, 0x00, 0x3E, 0x21,
  0x20, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x03, 0x42, 0xB3, 0x86, 0x40, 0x20,
  0x10, 0x08, 0x08, 0x0C, 0x78, 0x00, 0xC0, 0x18, 0x50, 0x00, 0x05, 0x5A,
  0x00, 0x80, 0x81, 0x83, 0x06, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x20, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0x0C, 0x18, 0x30, 0x60, 0x20, 0x00, 0xFC, 0x04, 0x08, 0x10,
  0x20, 0x41, 0x04, 0x08, 0x20, 0x41, 0x02, 0x00, 0x00, 0x18, 0x30, 0x07,
  0xE0, 0x60, 0x42, 0x00, 0x88, 0x02, 0x40, 0x05, 0x0F, 0x14, 0x44, 0x62,
  0x11, 0x88, 0x46, 0x21, 0x18, 0x84, 0x62, 0x11, 0x88, 0xC5, 0x1E, 0xE4,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0xFC, 0x00, 0x04, 0x01, 0x40,
  0x28, 0x05, 0x01, 0x20, 0x22, 0x04, 0x40, 0x88, 0x21, 0x04, 0x10, 0xFE,
  0x10, 0x44, 0x04, 0x80, 0x90, 0x14, 0x02, 0x80, 0x20, 0xFE, 0x40, 0xA0,
  0x50, 0x28, 0x14, 0x0A, 0x05, 0x1C, 0xFE, 0x40, 0xA0, 0x30, 0x18, 0x0C,
  0x06, 0x05, 0x06, 0xFE, 0x00, 0x0F, 0xCC, 0x02, 0x01, 0x00, 0x40, 0x10,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00,
  0x40, 0x0F, 0xC0, 0xFC, 0x20, 0xC8, 0x1A, 0x02, 0x80, 0xA0, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x02, 0x80, 0xA0, 0x28, 0x12, 0x0C, 0xFC,
  0x00, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFF, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0xFE, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFF,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x0F, 0xE1, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x81, 0xF8, 0x01, 0x80, 0x14,
  0x01, 0x40, 0x14, 0x01, 0x20, 0x11, 0x01, 0x0F, 0xE0, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x80, 0xF2, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22,
  0x22, 0xF0, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0xE0, 0x81, 0xC1, 0x20, 0x90, 0x88, 0x84, 0xC2, 0x41, 0x40, 0xD0, 0x6C,
  0x22, 0x10, 0x88, 0x44, 0x12, 0x09, 0x02, 0x81, 0x80, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFE,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x40, 0x3A, 0x02, 0xD0, 0x16, 0x40, 0xB2,
  0x09, 0x90, 0x4C, 0x42, 0x62, 0x23, 0x11, 0x18, 0x48, 0xC2, 0x86, 0x14,
  0x30, 0x61, 0x82, 0x08, 0x80, 0x70, 0x1C, 0x06, 0x81, 0xA0, 0x64, 0x19,
  0x06, 0x21, 0x88, 0x61, 0x18, 0x46, 0x09, 0x82, 0x60, 0x58, 0x0E, 0x03,
  0x80, 0x40, 0x1F, 0x82, 0x04, 0x60, 0x24, 0x02, 0x40, 0x24, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x24, 0x02, 0x20,
  0x23, 0x04, 0x1F, 0x80, 0xFC, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82,
  0x86, 0xF8, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1F, 0x82, 0x04,
  0x60, 0x24, 0x02, 0x40, 0x24, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x14, 0x01, 0x40, 0x24, 0x02, 0x20, 0x23, 0x04, 0x1F, 0x80, 0x10,
  0x00, 0x80, 0x08, 0x00, 0x40, 0xFC, 0x41, 0x20, 0x50, 0x28, 0x14, 0x0A,
  0x05, 0x04, 0xFC, 0x44, 0x22, 0x10, 0x88, 0x44, 0x12, 0x09, 0x02, 0x81,
  0x80, 0x3F, 0x40, 0x80, 0x80, 0x80, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x03, 0xFE, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x28, 0x09, 0x06, 0x3F, 0x00,
  0x80, 0x70, 0x09, 0x01, 0x20, 0x24, 0x08, 0x81, 0x08, 0x21, 0x08, 0x21,
  0x02, 0x20, 0x44, 0x09, 0x01, 0x20, 0x14, 0x02, 0x80, 0x60, 0x04, 0x00,
  0x80, 0x80, 0xA0, 0x60, 0x50, 0x30, 0x28, 0x28, 0x24, 0x14, 0x11, 0x0A,
  0x08, 0x84, 0x84, 0x44, 0x44, 0x22, 0x22, 0x11, 0x11, 0x04, 0x84, 0x82,
  0x42, 0x81, 0x41, 0x40, 0xA0, 0xA0, 0x30, 0x50, 0x18, 0x18, 0x08, 0x08,
  0x00, 0x40, 0xA0, 0x48, 0x44, 0x21, 0x20, 0x90, 0x30, 0x18, 0x0C, 0x06,
  0x04, 0x82, 0x42, 0x21, 0x09, 0x04, 0x81, 0x80, 0x80, 0x80, 0xA0, 0x50,
  0x48, 0x22, 0x21, 0x10, 0x48, 0x28, 0x14, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x00, 0xFF, 0x02, 0x02, 0x02, 0x04, 0x04, 0x08,
  0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40, 0x40, 0x80, 0xFF, 0xFC, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0F, 0x80,
  0xC0, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08, 0x04,
  0x04, 0x04, 0x02, 0x02, 0x01, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0xF0, 0x08, 0x0A, 0x05, 0x04, 0x42, 0x22, 0x09, 0x05,
  0x01, 0x80, 0x80, 0xFF, 0xC0, 0xC4, 0x30, 0x3C, 0x84, 0x08, 0x10, 0x20,
  0x4F, 0xA1, 0x83, 0x06, 0x0C, 0x37, 0xA0, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC2,
  0xBC, 0x1E, 0x41, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x01, 0x03, 0x03,
  0xE0, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0xE5, 0x8A, 0x83, 0x41, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x83, 0x41, 0x9F, 0x40, 0x1C, 0x22,
  0x41, 0x41, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x80, 0x40, 0x40, 0x3F, 0x1E,
  0x40, 0x81, 0x02, 0x1F, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x1C, 0xB1, 0x50, 0x78, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x50, 0x68, 0x53, 0xE8, 0x04, 0x02, 0x01, 0x01, 0x21, 0x8F,
  0x00, 0x81, 0x02, 0x04, 0x08, 0x17, 0xB0, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x04, 0x8F, 0xFF, 0x80, 0x20, 0x02, 0x49, 0x24,
  0x92, 0x49, 0x24, 0x92, 0xF0, 0x81, 0x02, 0x04, 0x08, 0x10, 0xE1, 0x44,
  0x91, 0x22, 0x86, 0x89, 0x11, 0x22, 0x42, 0x85, 0x04, 0xFF, 0xFF, 0xC0,
  0xB8, 0xF6, 0x28, 0xA0, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x30,
  0x41, 0x82, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x18, 0x20, 0x80, 0xBD, 0x86,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x1E, 0x31,
  0x90, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x50, 0x48, 0x23,
  0xE0, 0xBC, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xC2, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1C, 0xB1, 0x50, 0x68,
  0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x50, 0x68, 0x53, 0xC8, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0xBE, 0x31, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x00, 0x3D, 0x86, 0x04, 0x08, 0x08, 0x0C, 0x06, 0x06, 0x04,
  0x0C, 0x2F, 0xC0, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x0F, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x37, 0xA0, 0x81, 0x81, 0x41, 0x42, 0x42, 0x22, 0x22, 0x24, 0x24,
  0x14, 0x18, 0x18, 0x08, 0x81, 0x05, 0x0C, 0x14, 0x30, 0x90, 0xC2, 0x44,
  0x89, 0x12, 0x22, 0x49, 0x09, 0x24, 0x28, 0x50, 0xA1, 0x41, 0x86, 0x06,
  0x18, 0x10, 0x20, 0x41, 0x20, 0x88, 0x84, 0x41, 0x40, 0xA0, 0x20, 0x28,
  0x14, 0x11, 0x08, 0x88, 0x2C, 0x18, 0x80, 0xA0, 0x90, 0x48, 0x22, 0x21,
  0x10, 0x88, 0x44, 0x14, 0x0A, 0x05, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20,
  0x10, 0x10, 0x30, 0x00, 0xFC, 0x10, 0x82, 0x10, 0x42, 0x08, 0x21, 0x04,
  0x20, 0xFC, 0x0C, 0x41, 0x08, 0x20, 0x82, 0x08, 0x20, 0x8C, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x81, 0x04, 0x0C, 0xFF, 0xFF, 0xFF, 0xE0, 0xC1, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x60, 0xC4, 0x10, 0x41, 0x04, 0x10, 0x41, 0x08,
  0xC0, 0x60, 0x4E, 0x60, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraLight24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 17, 5, 2, -17 },
  { 4, 4, 6, 8, 2, -17 },
  { 7, 11, 17, 12, 0, -17 },
  { 31, 9, 19, 11, 1, -18 },
  { 53, 14, 17, 16, 1, -17 },
  { 83, 11, 17, 12, 1, -17 },
  { 107, 1, 6, 4, 2, -17 },
  { 108, 5, 21, 6, 1, -17 },
  { 122, 4, 21, 6, 1, -17 },
  { 133, 8, 7, 10, 1, -18 },
  { 140, 9, 11, 11, 1, -14 },
  { 153, 2, 6, 5, 1, -3 },
  { 155, 5, 1, 7, 1, -7 },
  { 156, 1, 2, 5, 2, -2 },
  { 157, 8, 17, 8, 0, -17 },
  { 174, 9, 17, 11, 1, -17 },
  { 194, 5, 17, 11, 2, -17 },
  { 205, 9, 17, 11, 1, -17 },
  { 225, 8, 17, 11, 1, -17 },
  { 242, 11, 17, 11, 0, -17 },
  { 266, 9, 17, 11, 1, -17 },
  { 286, 9, 17, 11, 1, -17 },
  { 306, 9, 17, 11, 1, -17 },
  { 326, 9, 17, 11, 1, -17 },
  { 346, 9, 17, 11, 1, -17 },
  { 366, 1, 13, 5, 2, -13 },
  { 368, 2, 16, 5, 1, -13 },
  { 372, 9, 11, 11, 1, -14 },
  { 385, 9, 5, 11, 1, -11 },
  { 391, 9, 11, 11, 1, -14 },
  { 404, 7, 17, 8, 0, -17 },
  { 419, 14, 19, 17, 1, -17 },
  { 453, 11, 17, 11, 0, -17 },
  { 477, 9, 17, 12, 2, -17 },
  { 497, 10, 17, 12, 1, -17 },
  { 519, 10, 17, 13, 2, -17 },
  { 541, 7, 17, 10, 2, -17 },
  { 556, 7, 17, 10, 2, -17 },
  { 571, 12, 17, 14, 1, -17 },
  { 597, 9, 17, 13, 2, -17 },
  { 617, 4, 17, 6, 1, -17 },
  { 626, 4, 21, 5, -1, -17 },
  { 637, 9, 17, 11, 2, -17 },
  { 657, 7, 17, 10, 2, -17 },
  { 672, 13, 17, 17, 2, -17 },
  { 700, 10, 17, 14, 2, -17 },
  { 722, 12, 17, 14, 1, -17 },
  { 748, 8, 17, 11, 2, -17 },
  { 765, 12, 21, 14, 1, -17 },
  { 797, 9, 17, 11, 2, -17 },
  { 817, 8, 17, 11, 1, -17 },
  { 834, 9, 17, 10, 0, -17 },
  { 854, 10, 17, 13, 2, -17 },
  { 876, 11, 17, 11, 0, -17 },
  { 900, 17, 17, 17, 0, -17 },
  { 937, 9, 17, 10, 0, -17 },
  { 957, 9, 17, 9, 0, -17 },
  { 977, 8, 17, 10, 1, -17 },
  { 994, 5, 21, 7, 2, -17 },
  { 1008, 8, 17, 8, 0, -17 },
  { 1025, 4, 21, 7, 1, -17 },
  { 1036, 9, 9, 11, 1, -17 },
  { 1047, 10, 1, 10, 0, 2 },
  { 1049, 4, 3, 6, 1, -18 },
  { 1051, 7, 13, 10, 1, -13 },
  { 1063, 8, 18, 12, 2, -18 },
  { 1081, 7, 13, 9, 1, -13 },
  { 1093, 9, 18, 12, 1, -18 },
  { 1114, 8, 13, 10, 1, -13 },
  { 1127, 7, 18, 6, 0, -18 },
  { 1143, 9, 19, 11, 1, -13 },
  { 1165, 7, 18, 11, 2, -18 },
  { 1181, 1, 17, 5, 2, -17 },
  { 1184, 3, 23, 5, 0, -17 },
  { 1193, 7, 18, 9, 2, -18 },
  { 1209, 1, 18, 5, 2, -18 },
  { 1212, 13, 13, 17, 2, -13 },
  { 1234, 7, 13, 11, 2, -13 },
  { 1246, 9, 13, 11, 1, -13 },
  { 1261, 8, 19, 11, 2, -13 },
  { 1280, 9, 19, 11, 1, -13 },
  { 1302, 5, 13, 7, 2, -13 },
  { 1311, 7, 13, 9, 1, -13 },
  { 1323, 6, 16, 6, 0, -16 },
  { 1335, 7, 13, 11, 2, -13 },
  { 1347, 8, 13, 8, 0, -13 },
  { 1360, 14, 13, 14, 0, -13 },
  { 1383, 9, 13, 9, 0, -13 },
  { 1398, 9, 19, 9, 0, -13 },
  { 1420, 6, 13, 8, 1, -13 },
  { 1430, 6, 21, 8, 1, -17 },
  { 1446, 1, 24, 10, 5, -18 },
  { 1449, 6, 21, 8, 1, -17 },
  { 1465, 9, 3, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_ExtraLight24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight24pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT24PT7B_H_
