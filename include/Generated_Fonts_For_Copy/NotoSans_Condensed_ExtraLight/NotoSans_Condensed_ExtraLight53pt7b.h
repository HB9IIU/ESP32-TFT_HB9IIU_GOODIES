#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT53PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB4,
  0x00, 0x01, 0xFF, 0xC0, 0xE0, 0xD8, 0x36, 0x0D, 0x83, 0x60, 0xD8, 0x36,
  0x0D, 0x83, 0x60, 0xD8, 0x36, 0x0D, 0x03, 0x40, 0xD0, 0x30, 0x00, 0x60,
  0x30, 0x00, 0x60, 0x30, 0x00, 0x60, 0x30, 0x00, 0x40, 0x30, 0x00, 0x40,
  0x30, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x60, 0x00, 0xC0,
  0x60, 0x00, 0xC0, 0x60, 0x00, 0x80, 0x60, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x01, 0x80, 0x40, 0x01, 0x80, 0x40, 0x01, 0x80, 0xC0, 0x01, 0x80,
  0xC0, 0x01, 0x00, 0xC0, 0x01, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00,
  0x80, 0x03, 0x00, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x02, 0x01, 0x80, 0x06, 0x01, 0x00, 0x06, 0x01,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x04, 0x03,
  0x00, 0x04, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x02, 0x00, 0x0C, 0x06,
  0x00, 0x0C, 0x06, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0xF8, 0x38, 0x87, 0x8C, 0x10, 0x13, 0x02, 0x00, 0x60,
  0x40, 0x18, 0x08, 0x03, 0x01, 0x00, 0x60, 0x20, 0x0C, 0x04, 0x01, 0x80,
  0x80, 0x18, 0x10, 0x03, 0x02, 0x00, 0x70, 0x40, 0x07, 0x08, 0x00, 0x79,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x17, 0x80, 0x02,
  0x38, 0x00, 0x41, 0x80, 0x08, 0x18, 0x01, 0x01, 0x80, 0x20, 0x30, 0x04,
  0x06, 0x00, 0x80, 0xC0, 0x10, 0x18, 0x02, 0x03, 0x00, 0x40, 0x60, 0x08,
  0x1C, 0x01, 0x03, 0x60, 0x21, 0xCF, 0xC4, 0xF0, 0x7F, 0xFC, 0x00, 0xF8,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x1F,
  0x00, 0x06, 0x01, 0x8C, 0x00, 0x60, 0x18, 0x30, 0x03, 0x00, 0xC1, 0x80,
  0x10, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x01, 0x80, 0xC0,
  0x18, 0x0C, 0x06, 0x00, 0x80, 0x60, 0x20, 0x04, 0x01, 0x03, 0x00, 0x20,
  0x08, 0x18, 0x01, 0x00, 0x41, 0x80, 0x08, 0x02, 0x0C, 0x00, 0x40, 0x10,
  0x40, 0x02, 0x01, 0x86, 0x00, 0x18, 0x0C, 0x30, 0xF8, 0xC0, 0x63, 0x0C,
  0xE6, 0x03, 0x18, 0xC3, 0x30, 0x18, 0x8C, 0x0C, 0xC1, 0x8C, 0x60, 0x66,
  0x0C, 0x63, 0x01, 0x9D, 0xC6, 0x10, 0x0C, 0x7C, 0x31, 0x80, 0x60, 0x01,
  0x0C, 0x03, 0x00, 0x18, 0x60, 0x18, 0x00, 0xC3, 0x00, 0xC0, 0x0C, 0x18,
  0x06, 0x00, 0x60, 0xC0, 0x30, 0x02, 0x06, 0x01, 0x80, 0x30, 0x30, 0x0C,
  0x01, 0x81, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06,
  0x01, 0x81, 0x80, 0x60, 0x0C, 0x0C, 0x03, 0x00, 0x30, 0x60, 0x30, 0x01,
  0xC6, 0x01, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x0E,
  0x0E, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x03, 0x00, 0x18,
  0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x08, 0x03, 0x00, 0x0C,
  0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x07,
  0x18, 0x00, 0x03, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0E, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x30, 0x06, 0x30,
  0x18, 0x04, 0x60, 0x1C, 0x0C, 0x60, 0x0C, 0x0C, 0xE0, 0x06, 0x0C, 0xC0,
  0x07, 0x0C, 0xC0, 0x03, 0x18, 0xC0, 0x01, 0x98, 0xC0, 0x00, 0xF0, 0xC0,
  0x00, 0xF0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0xF0, 0x60, 0x01, 0xF8, 0x70,
  0x03, 0x98, 0x38, 0x07, 0x0C, 0x1E, 0x3E, 0x0E, 0x0F, 0xF8, 0x07, 0x00,
  0x80, 0x00, 0xED, 0xB6, 0xDB, 0x6D, 0xB4, 0x80, 0x01, 0x81, 0x81, 0xC0,
  0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0C,
  0x03, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x81, 0x81, 0xF1, 0x8F,
  0x3F, 0xFC, 0x07, 0xC0, 0x03, 0x80, 0x02, 0xC0, 0x06, 0x60, 0x0C, 0x30,
  0x18, 0x38, 0x38, 0x18, 0x30, 0x0C, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x18, 0xCE, 0x73,
  0x18, 0xCE, 0x63, 0x19, 0x8C, 0x00, 0xFF, 0xFF, 0xFC, 0xDF, 0xF0, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xC0, 0xE0, 0x60, 0x18,
  0x30, 0x03, 0x0C, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0xB0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xD8, 0x00, 0x66, 0x00,
  0x19, 0x80, 0x06, 0x30, 0x03, 0x0C, 0x00, 0xC1, 0x80, 0x60, 0x70, 0x38,
  0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xC0, 0x70, 0x3C, 0x1D, 0x0E, 0xCE,
  0x37, 0x0F, 0x83, 0x40, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x07, 0xF8, 0x03, 0xFF, 0xC1, 0xE0, 0x1C,
  0x10, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xF8, 0x07, 0xFF, 0xC1, 0xC0, 0x1C, 0x70, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x60,
  0x03, 0x8F, 0xC3, 0xE0, 0x7F, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0D, 0x80, 0x00,
  0x36, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC6,
  0x00, 0x06, 0x18, 0x00, 0x38, 0x60, 0x00, 0xC1, 0x80, 0x06, 0x06, 0x00,
  0x18, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60,
  0x18, 0x03, 0x00, 0x60, 0x1C, 0x01, 0x80, 0x60, 0x06, 0x03, 0x00, 0x18,
  0x0C, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x18, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0x00,
  0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x8F, 0x00, 0x7F, 0xFC, 0x1E, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x73, 0x00, 0x38, 0xF8, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0xE0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x0F, 0xF0, 0xCF, 0xFE, 0x37, 0x01,
  0xCD, 0x80, 0x3B, 0xC0, 0x06, 0xE0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x01, 0xCC, 0x00,
  0x63, 0x80, 0x38, 0x70, 0x1C, 0x0F, 0x1E, 0x01, 0xFF, 0x00, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0,
  0x1C, 0x03, 0x83, 0x80, 0x1C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x00,
  0xE6, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0xC3, 0x00,
  0x0C, 0x38, 0x01, 0xC1, 0x80, 0x18, 0x0C, 0x03, 0x00, 0x70, 0xE0, 0x03,
  0x9C, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x79, 0xC0, 0x0E, 0x0E, 0x01,
  0xC0, 0x38, 0x38, 0x01, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0xE6, 0x00, 0x06,
  0xE0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x66, 0x00, 0x06, 0x60, 0x00, 0x67, 0x00, 0x0E, 0x30, 0x01, 0xC1, 0xC0,
  0x38, 0x0F, 0x0F, 0x00, 0x7F, 0xE0, 0x00, 0x40, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x70, 0x1C, 0x1C, 0x01, 0x83, 0x00, 0x18, 0xE0, 0x03, 0x18,
  0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xDC, 0x00, 0x1B, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x03, 0x60,
  0x00, 0xEC, 0x00, 0x1D, 0xC0, 0x07, 0x98, 0x00, 0xB1, 0x80, 0x76, 0x3C,
  0x3C, 0xC1, 0xFE, 0x18, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x03, 0x0F,
  0x80, 0x7F, 0xC0, 0x00, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x39, 0xCE, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63, 0x39, 0xCC, 0x63, 0x31,
  0x8C, 0x46, 0x30, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xE3, 0xFF, 0xC4,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x18, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x33, 0x80, 0x1F,
  0xC0, 0x66, 0x00, 0xF7, 0xC0, 0xCC, 0x03, 0x81, 0x80, 0xD8, 0x0E, 0x03,
  0x01, 0xE0, 0x18, 0x04, 0x03, 0xC0, 0x60, 0x08, 0x07, 0x80, 0xC0, 0x30,
  0x0F, 0x01, 0x80, 0x60, 0x1E, 0x03, 0x00, 0xC0, 0x3C, 0x04, 0x01, 0x80,
  0x78, 0x18, 0x03, 0x00, 0xF0, 0x30, 0x06, 0x01, 0xE0, 0x60, 0x0C, 0x03,
  0xC0, 0x40, 0x18, 0x07, 0x80, 0x80, 0x30, 0x0F, 0x01, 0x80, 0xE0, 0x36,
  0x03, 0x01, 0x40, 0x6C, 0x06, 0x02, 0xC0, 0xD8, 0x06, 0x0D, 0x83, 0x18,
  0x07, 0xF1, 0xFC, 0x30, 0x07, 0xC1, 0xF0, 0x60, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x01, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x24, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x66, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x81, 0x00, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x03,
  0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18,
  0x00, 0x18, 0x18, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0xE0, 0x0F, 0x8E, 0x00, 0x1C, 0xE0, 0x00, 0xCE, 0x00, 0x0E, 0xE0,
  0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E,
  0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0C, 0xE0, 0x01, 0xCE, 0x00, 0x18,
  0xE0, 0x07, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0E, 0x00, 0xF0, 0xE0, 0x01,
  0xCE, 0x00, 0x0C, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x0C, 0xE0, 0x01, 0xCE,
  0x00, 0x78, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0xC0, 0xE0, 0x06, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x10, 0x1F, 0x1F, 0x80, 0x3F, 0xF8, 0x00,
  0x10, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x0E, 0x01, 0xF0, 0x38, 0x00,
  0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x38, 0x00, 0x0C,
  0xE0, 0x00, 0x33, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0,
  0x00, 0x1B, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0xCE, 0x00, 0x03, 0x38, 0x00, 0x18, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x0E,
  0x00, 0x38, 0x38, 0x03, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0xF0, 0x01, 0xC0, 0xE0, 0x00, 0x20, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x1C,
  0x00, 0x01, 0x87, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x60, 0x78, 0x00, 0x70,
  0x1F, 0x87, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0C, 0xFF, 0xFF, 0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x83, 0xE7, 0xFC, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x70, 0x18, 0x06, 0x03, 0xBF, 0xCF, 0xE0, 0xE0, 0x00, 0x6E, 0x00, 0x0C,
  0xE0, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x03, 0x0E, 0x00, 0x60, 0xE0, 0x0E,
  0x0E, 0x00, 0xC0, 0xE0, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x0E, 0x06,
  0x00, 0xE0, 0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0x80, 0x0E, 0x30, 0x00, 0xE7,
  0x00, 0x0E, 0x70, 0x00, 0xEF, 0x80, 0x0F, 0x98, 0x00, 0xF0, 0xC0, 0x0F,
  0x0C, 0x00, 0xE0, 0x60, 0x0E, 0x07, 0x00, 0xE0, 0x30, 0x0E, 0x03, 0x80,
  0xE0, 0x18, 0x0E, 0x01, 0xC0, 0xE0, 0x0C, 0x0E, 0x00, 0x60, 0xE0, 0x06,
  0x0E, 0x00, 0x30, 0xE0, 0x03, 0x8E, 0x00, 0x18, 0xE0, 0x01, 0xCE, 0x00,
  0x0C, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF6, 0x00, 0x00,
  0x0F, 0xD8, 0x00, 0x00, 0x6F, 0x60, 0x00, 0x01, 0xBC, 0xC0, 0x00, 0x06,
  0xF3, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x00, 0xCF, 0x18, 0x00, 0x03, 0x3C,
  0x60, 0x00, 0x18, 0xF1, 0x80, 0x00, 0x63, 0xC3, 0x00, 0x01, 0x8F, 0x0C,
  0x00, 0x0C, 0x3C, 0x30, 0x00, 0x30, 0xF0, 0x60, 0x00, 0xC3, 0xC1, 0x80,
  0x06, 0x0F, 0x06, 0x00, 0x18, 0x3C, 0x1C, 0x00, 0x60, 0xF0, 0x30, 0x03,
  0x03, 0xC0, 0xC0, 0x0C, 0x0F, 0x03, 0x80, 0x30, 0x3C, 0x06, 0x01, 0x80,
  0xF0, 0x18, 0x06, 0x03, 0xC0, 0x70, 0x18, 0x0F, 0x00, 0xC0, 0xC0, 0x3C,
  0x03, 0x03, 0x00, 0xF0, 0x0E, 0x0C, 0x03, 0xC0, 0x18, 0x60, 0x0F, 0x00,
  0x61, 0x80, 0x3C, 0x01, 0xC6, 0x00, 0xF0, 0x03, 0x30, 0x03, 0xC0, 0x0C,
  0xC0, 0x0F, 0x00, 0x3B, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0C, 0x00, 0x30, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xD8, 0x00, 0x0F, 0x60,
  0x00, 0x3C, 0xC0, 0x00, 0xF3, 0x00, 0x03, 0xC6, 0x00, 0x0F, 0x1C, 0x00,
  0x3C, 0x30, 0x00, 0xF0, 0xE0, 0x03, 0xC1, 0x80, 0x0F, 0x07, 0x00, 0x3C,
  0x0C, 0x00, 0xF0, 0x38, 0x03, 0xC0, 0x60, 0x0F, 0x01, 0xC0, 0x3C, 0x03,
  0x00, 0xF0, 0x0E, 0x03, 0xC0, 0x18, 0x0F, 0x00, 0x70, 0x3C, 0x00, 0xC0,
  0xF0, 0x03, 0x83, 0xC0, 0x06, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x30, 0xF0,
  0x00, 0xE3, 0xC0, 0x01, 0x8F, 0x00, 0x07, 0x3C, 0x00, 0x0C, 0xF0, 0x00,
  0x1B, 0xC0, 0x00, 0x6F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x30, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x00, 0xC0, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x30, 0x00,
  0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0x18, 0x00,
  0x0E, 0x0E, 0x00, 0x06, 0x03, 0x80, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x3E,
  0x3E, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xE0, 0x3F, 0xFF,
  0x0E, 0x01, 0xE3, 0x80, 0x1C, 0xE0, 0x03, 0xB8, 0x00, 0x6E, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xB8, 0x00,
  0xEE, 0x00, 0x73, 0x80, 0x78, 0xFF, 0xFC, 0x3F, 0xFC, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x03, 0x01, 0xC0,
  0x00, 0xC0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0E, 0x70,
  0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x33, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0x60,
  0x00, 0x0C, 0x18, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x03, 0x80, 0x06, 0x00,
  0xE0, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xE0, 0x1E, 0x0E, 0x00, 0x70, 0xE0,
  0x03, 0x8E, 0x00, 0x18, 0xE0, 0x00, 0xCE, 0x00, 0x0C, 0xE0, 0x00, 0xCE,
  0x00, 0x0C, 0xE0, 0x00, 0xCE, 0x00, 0x0C, 0xE0, 0x00, 0xCE, 0x00, 0x0C,
  0xE0, 0x01, 0xCE, 0x00, 0x18, 0xE0, 0x03, 0x8E, 0x00, 0x70, 0xE0, 0x0E,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0E, 0x06, 0x00, 0xE0, 0x30, 0x0E, 0x03,
  0x00, 0xE0, 0x18, 0x0E, 0x01, 0x80, 0xE0, 0x0C, 0x0E, 0x00, 0xC0, 0xE0,
  0x06, 0x0E, 0x00, 0x60, 0xE0, 0x03, 0x0E, 0x00, 0x30, 0xE0, 0x01, 0x8E,
  0x00, 0x18, 0xE0, 0x00, 0xCE, 0x00, 0x0C, 0xE0, 0x00, 0x6E, 0x00, 0x07,
  0x03, 0xFF, 0x01, 0xFF, 0xF8, 0x70, 0x03, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x60,
  0x03, 0x8F, 0xE3, 0xE0, 0x7F, 0xF8, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x66,
  0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x80,
  0x06, 0x07, 0x00, 0x38, 0x0F, 0x8F, 0xC0, 0x0F, 0xFC, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x3B, 0x00, 0x00,
  0x66, 0x00, 0x00, 0xCE, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x18, 0x00, 0x0C,
  0x30, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81,
  0x80, 0x03, 0x01, 0x80, 0x0E, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x0E,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x30,
  0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x01, 0x83,
  0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x60,
  0x00, 0x18, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x33, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x66, 0x00, 0x0F,
  0x00, 0x03, 0x30, 0x00, 0x78, 0x00, 0x19, 0x80, 0x03, 0x60, 0x01, 0x8C,
  0x00, 0x1B, 0x00, 0x0C, 0x30, 0x01, 0x98, 0x00, 0x61, 0x80, 0x0C, 0xC0,
  0x03, 0x0C, 0x00, 0x63, 0x00, 0x38, 0x60, 0x03, 0x18, 0x01, 0x83, 0x80,
  0x30, 0xC0, 0x0C, 0x0C, 0x01, 0x86, 0x00, 0x60, 0x60, 0x0C, 0x30, 0x07,
  0x03, 0x00, 0x60, 0xC0, 0x30, 0x18, 0x03, 0x06, 0x01, 0x80, 0x60, 0x30,
  0x30, 0x0C, 0x03, 0x01, 0x81, 0x80, 0x60, 0x18, 0x0C, 0x06, 0x06, 0x00,
  0xC0, 0x60, 0x30, 0x30, 0x03, 0x06, 0x01, 0x81, 0x80, 0x18, 0x30, 0x0C,
  0x0C, 0x00, 0xC1, 0x80, 0x60, 0xE0, 0x06, 0x0C, 0x01, 0x86, 0x00, 0x38,
  0x60, 0x0C, 0x30, 0x00, 0xC6, 0x00, 0x61, 0x80, 0x06, 0x30, 0x03, 0x1C,
  0x00, 0x31, 0x80, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x66, 0x00, 0x06, 0xC0,
  0x03, 0x30, 0x00, 0x36, 0x00, 0x19, 0x80, 0x01, 0xB0, 0x00, 0xD8, 0x00,
  0x0D, 0x80, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x39, 0x80, 0x01, 0x86, 0x00, 0x18, 0x30, 0x00, 0xC1, 0xC0, 0x0E,
  0x06, 0x00, 0x60, 0x38, 0x07, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x80, 0x18,
  0x18, 0x00, 0xC0, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x66, 0x00,
  0x03, 0x30, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x30, 0x00,
  0x31, 0x80, 0x01, 0x86, 0x00, 0x18, 0x30, 0x00, 0xC0, 0xC0, 0x0C, 0x06,
  0x00, 0x60, 0x38, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x80, 0x18, 0x18,
  0x00, 0xC1, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0xE0, 0x00, 0x66, 0x00, 0x03,
  0x70, 0x00, 0x1C, 0xC0, 0x00, 0x3B, 0x00, 0x01, 0x98, 0x00, 0x1C, 0xC0,
  0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x38,
  0x18, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x60,
  0x30, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x61, 0x80, 0x01, 0x8C, 0x00,
  0x0C, 0x60, 0x00, 0x66, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF,
  0xC0, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1B, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x18, 0x00, 0x18, 0x60, 0x00, 0x60,
  0xC0, 0x03, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x30,
  0x0C, 0x00, 0xC0, 0x30, 0x03, 0x81, 0x80, 0x06, 0x06, 0x00, 0x1C, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0xE6, 0x00, 0x01, 0xB8, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x0F, 0xF8, 0x3E, 0x3C, 0x10, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0xFF, 0x07, 0xFB, 0x1E, 0x03, 0x38, 0x03, 0x70,
  0x03, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xE0, 0x05, 0x60, 0x0D, 0x70, 0x19, 0x3C, 0x31, 0x1F, 0xE1, 0x01,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x20, 0x0C, 0x3F, 0xC1, 0x9E, 0x1C, 0x37, 0x01,
  0xC6, 0x80, 0x1C, 0xF0, 0x01, 0x9C, 0x00, 0x1B, 0x80, 0x03, 0x70, 0x00,
  0x6C, 0x00, 0x0D, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x1B, 0x80, 0x07,
  0x78, 0x00, 0xCD, 0x00, 0x39, 0xB0, 0x0E, 0x33, 0xC7, 0x86, 0x3F, 0xE0,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x07, 0xFC, 0x3E, 0x38, 0xE0, 0x03, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7C, 0xF0, 0x7F, 0xE0, 0x0C, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x03, 0x03, 0x07, 0xF8, 0xC7, 0x87, 0x31, 0x80, 0x6C, 0xC0, 0x0F,
  0x70, 0x01, 0x58, 0x00, 0x76, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x05, 0x30, 0x03, 0x4E,
  0x01, 0x91, 0xE1, 0xC4, 0x1F, 0xE1, 0x00, 0x80, 0x00, 0x00, 0x80, 0x03,
  0xFC, 0x03, 0x8F, 0x03, 0x00, 0xC3, 0x00, 0x73, 0x80, 0x19, 0x80, 0x04,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x61, 0xE1, 0xF0, 0x7F, 0xE0, 0x02,
  0x00, 0x00, 0x40, 0x0F, 0xF0, 0x78, 0x81, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x03,
  0xFF, 0x8F, 0xFE, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x00, 0x80, 0x01, 0xFE, 0x11, 0xF1, 0xC4, 0xE0, 0x19, 0x30, 0x03,
  0x5C, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x01, 0xCC, 0x00, 0xB3,
  0x80, 0x6C, 0x78, 0x73, 0x07, 0xF8, 0xC0, 0x30, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xE4, 0x00, 0x71, 0xC0, 0x78, 0x3F, 0xFC, 0x00, 0xF8, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x0C, 0x0C, 0x3F, 0xC6, 0x79, 0xF3, 0x70, 0x1D, 0xA0, 0x06, 0xF0, 0x03,
  0x70, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xFF, 0xA0, 0x00, 0x03, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0x80, 0x07, 0x07, 0x07, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x0E, 0x8C, 0xFC, 0x70, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0,
  0x18, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC1,
  0x80, 0xC3, 0x00, 0xC7, 0x00, 0xC7, 0x00, 0xCF, 0x00, 0xDB, 0x80, 0xD9,
  0x80, 0xF1, 0xC0, 0xE0, 0xC0, 0xC0, 0xE0, 0xC0, 0x60, 0xC0, 0x70, 0xC0,
  0x30, 0xC0, 0x38, 0xC0, 0x18, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0,
  0x06, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x80, 0x06, 0x06, 0x3F, 0xC1, 0xFE, 0x33, 0x8F, 0x1C, 0x79,
  0xB0, 0x19, 0x80, 0xED, 0x00, 0xE8, 0x03, 0x70, 0x03, 0xC0, 0x1F, 0x80,
  0x1C, 0x00, 0x7C, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0x18,
  0x00, 0xF0, 0x00, 0xC0, 0x07, 0x80, 0x06, 0x00, 0x3C, 0x00, 0x30, 0x01,
  0xE0, 0x01, 0x80, 0x0F, 0x00, 0x0C, 0x00, 0x78, 0x00, 0x60, 0x03, 0xC0,
  0x03, 0x00, 0x1E, 0x00, 0x18, 0x00, 0xF0, 0x00, 0xC0, 0x07, 0x80, 0x06,
  0x00, 0x3C, 0x00, 0x30, 0x01, 0xE0, 0x01, 0x80, 0x0F, 0x00, 0x0C, 0x00,
  0x78, 0x00, 0x60, 0x03, 0xC0, 0x03, 0x00, 0x1E, 0x00, 0x18, 0x00, 0xF0,
  0x00, 0xC0, 0x07, 0x80, 0x06, 0x00, 0x3C, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x40, 0x61, 0xFE, 0x33, 0xC7, 0x9B, 0x80, 0xED, 0x00, 0x37, 0x80, 0x1B,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x78, 0x78, 0x0C, 0x03, 0x83, 0x00,
  0x38, 0xE0, 0x03, 0x18, 0x00, 0x37, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00,
  0x1B, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0D, 0x80, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x70, 0x01,
  0x86, 0x00, 0x70, 0x60, 0x1C, 0x07, 0x8F, 0x00, 0x7F, 0xC0, 0x00, 0x80,
  0x00, 0x00, 0x40, 0x18, 0x7F, 0x83, 0x3C, 0x78, 0x66, 0x03, 0x8D, 0x80,
  0x39, 0xE0, 0x03, 0x38, 0x00, 0x37, 0x00, 0x06, 0xE0, 0x00, 0xD8, 0x00,
  0x1B, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0D, 0xC0, 0x01, 0xB8, 0x00, 0x37, 0x00, 0x0E, 0xF0, 0x01,
  0x9B, 0x00, 0x73, 0x70, 0x1C, 0x67, 0x8F, 0x0C, 0x3F, 0xC1, 0x80, 0x80,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0x01, 0xFE, 0x11, 0xE1, 0xC4, 0x60, 0x19,
  0x30, 0x03, 0x5C, 0x00, 0x56, 0x00, 0x1D, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x03, 0xCC,
  0x00, 0xB3, 0x80, 0x6C, 0x78, 0xF3, 0x07, 0xF8, 0xC0, 0x30, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x8C, 0x7F, 0xCF, 0xEC, 0xC0, 0xD8, 0x0D, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x1F, 0xF8,
  0xF0, 0xFB, 0x80, 0x26, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1B, 0x00, 0x77, 0xC7,
  0xC7, 0xFF, 0x00, 0x40, 0x00, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x07, 0xFF, 0xFF, 0xE3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x0C, 0x01, 0xC4, 0x1F, 0x80, 0x40, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0B, 0x60, 0x0D,
  0xB8, 0x0C, 0xCF, 0x1C, 0x63, 0xFC, 0x30, 0x10, 0x00, 0xC0, 0x00, 0xD8,
  0x00, 0x36, 0x00, 0x0D, 0x80, 0x06, 0x60, 0x01, 0x8C, 0x00, 0x63, 0x00,
  0x30, 0xC0, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x60, 0x60, 0x18,
  0x0C, 0x06, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01,
  0x86, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x03, 0x10, 0x00, 0xCC, 0x00, 0x13,
  0x00, 0x06, 0xC0, 0x01, 0xA0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0B, 0x00, 0x36, 0x00, 0xD8, 0x03, 0x30, 0x06, 0xC0, 0x19, 0x80, 0x36,
  0x00, 0xCC, 0x01, 0x98, 0x06, 0x30, 0x18, 0xC0, 0x61, 0x80, 0xC6, 0x03,
  0x0C, 0x06, 0x30, 0x18, 0x60, 0x30, 0xC0, 0xC1, 0x83, 0x06, 0x0C, 0x0C,
  0x18, 0x30, 0x60, 0x60, 0xC1, 0x83, 0x03, 0x06, 0x06, 0x18, 0x0C, 0x60,
  0x30, 0x80, 0x63, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x60, 0x18, 0xC0, 0x33,
  0x00, 0x6C, 0x01, 0x98, 0x03, 0x60, 0x0D, 0x80, 0x1B, 0x00, 0x6C, 0x00,
  0xD8, 0x01, 0x60, 0x02, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xDC, 0x00, 0xE3, 0x00,
  0x30, 0xE0, 0x1C, 0x18, 0x06, 0x07, 0x03, 0x80, 0xC0, 0xC0, 0x18, 0x60,
  0x06, 0x18, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x30, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x61,
  0x80, 0x18, 0x60, 0x0C, 0x0C, 0x07, 0x03, 0x01, 0x80, 0x60, 0xE0, 0x18,
  0x30, 0x03, 0x1C, 0x00, 0xC6, 0x00, 0x1B, 0x00, 0x07, 0x60, 0x00, 0x6C,
  0x00, 0x19, 0x80, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x03, 0x06,
  0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x03, 0x00, 0x60, 0x30, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x60, 0x02,
  0x0C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x03,
  0x30, 0x00, 0x6C, 0x00, 0x05, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x23, 0x80, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x7F,
  0xFD, 0xFF, 0xF0, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x1C, 0x03, 0xF0, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x0F, 0xC0, 0x3C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xF0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x03, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x03, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x17, 0xFE,
  0x01, 0xC0, 0x78, 0x78, 0x01, 0xFE, 0x80, 0x03, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraLight53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 38, 11, 4, -38 },
  { 16, 10, 14, 17, 3, -38 },
  { 34, 24, 38, 26, 1, -38 },
  { 148, 19, 43, 24, 2, -40 },
  { 251, 29, 38, 35, 3, -38 },
  { 389, 24, 39, 26, 2, -38 },
  { 506, 3, 14, 9, 3, -38 },
  { 512, 9, 46, 14, 3, -38 },
  { 564, 10, 46, 14, 2, -38 },
  { 622, 16, 16, 22, 3, -40 },
  { 654, 20, 25, 24, 2, -31 },
  { 717, 5, 13, 10, 2, -6 },
  { 726, 11, 2, 15, 2, -15 },
  { 729, 3, 4, 11, 4, -4 },
  { 731, 16, 38, 18, 1, -38 },
  { 807, 18, 38, 24, 3, -38 },
  { 893, 10, 38, 24, 4, -38 },
  { 941, 19, 38, 24, 2, -38 },
  { 1032, 19, 39, 24, 2, -38 },
  { 1125, 22, 38, 24, 1, -38 },
  { 1230, 18, 38, 24, 3, -38 },
  { 1316, 18, 39, 24, 3, -38 },
  { 1404, 19, 38, 24, 2, -38 },
  { 1495, 20, 39, 24, 2, -38 },
  { 1593, 19, 39, 24, 2, -38 },
  { 1686, 3, 28, 11, 4, -28 },
  { 1697, 5, 35, 11, 2, -28 },
  { 1719, 20, 23, 24, 2, -30 },
  { 1777, 20, 13, 24, 2, -25 },
  { 1810, 20, 23, 24, 2, -30 },
  { 1868, 14, 38, 17, 1, -38 },
  { 1935, 31, 43, 37, 3, -38 },
  { 2102, 24, 38, 24, 0, -38 },
  { 2216, 20, 38, 26, 4, -38 },
  { 2311, 21, 39, 25, 3, -38 },
  { 2414, 22, 38, 29, 4, -38 },
  { 2519, 16, 38, 23, 4, -38 },
  { 2595, 16, 38, 21, 4, -38 },
  { 2671, 25, 39, 31, 3, -38 },
  { 2793, 21, 38, 30, 4, -38 },
  { 2893, 9, 38, 13, 2, -38 },
  { 2936, 10, 47, 11, -3, -38 },
  { 2995, 20, 38, 24, 4, -38 },
  { 3090, 16, 38, 21, 4, -38 },
  { 3166, 30, 38, 38, 4, -38 },
  { 3309, 22, 38, 30, 4, -38 },
  { 3414, 25, 39, 31, 3, -38 },
  { 3536, 18, 38, 24, 4, -38 },
  { 3622, 25, 47, 31, 3, -38 },
  { 3769, 20, 38, 25, 4, -38 },
  { 3864, 19, 39, 23, 2, -38 },
  { 3957, 21, 38, 21, 0, -38 },
  { 4057, 22, 39, 30, 4, -38 },
  { 4165, 23, 38, 23, 0, -38 },
  { 4275, 37, 38, 39, 1, -38 },
  { 4451, 21, 38, 21, 0, -38 },
  { 4551, 21, 38, 21, 0, -38 },
  { 4651, 18, 38, 21, 2, -38 },
  { 4737, 11, 46, 16, 4, -38 },
  { 4801, 16, 38, 18, 1, -38 },
  { 4877, 10, 46, 16, 2, -38 },
  { 4935, 22, 20, 24, 1, -38 },
  { 4990, 21, 2, 21, 0, 5 },
  { 4996, 9, 8, 13, 2, -40 },
  { 5005, 16, 30, 22, 2, -29 },
  { 5065, 19, 41, 25, 4, -40 },
  { 5163, 15, 30, 19, 3, -29 },
  { 5220, 18, 41, 25, 3, -40 },
  { 5313, 17, 30, 23, 3, -29 },
  { 5377, 14, 41, 13, 1, -41 },
  { 5449, 18, 42, 25, 3, -29 },
  { 5544, 17, 40, 25, 4, -40 },
  { 5629, 3, 38, 10, 4, -38 },
  { 5644, 8, 51, 10, -1, -38 },
  { 5695, 16, 40, 20, 4, -40 },
  { 5775, 2, 40, 10, 4, -40 },
  { 5785, 29, 29, 37, 4, -29 },
  { 5891, 17, 29, 25, 4, -29 },
  { 5953, 19, 30, 24, 3, -29 },
  { 6025, 19, 41, 25, 4, -29 },
  { 6123, 18, 41, 25, 3, -29 },
  { 6216, 12, 29, 16, 4, -29 },
  { 6260, 15, 30, 19, 2, -29 },
  { 6317, 11, 36, 13, 1, -35 },
  { 6367, 17, 29, 25, 4, -28 },
  { 6429, 18, 28, 19, 0, -28 },
  { 6492, 29, 28, 31, 1, -28 },
  { 6594, 18, 28, 20, 1, -28 },
  { 6657, 19, 41, 19, 0, -28 },
  { 6755, 14, 28, 17, 2, -28 },
  { 6804, 14, 46, 18, 2, -38 },
  { 6885, 2, 53, 23, 10, -40 },
  { 6899, 14, 46, 18, 2, -38 },
  { 6980, 20, 5, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_ExtraLight53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight53pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT53PT7B_H_
