#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT23PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0x99, 0x99, 0x99, 0x08, 0x81, 0x10, 0x22, 0x04, 0x47,
  0xFE, 0x21, 0x04, 0x40, 0x88, 0x11, 0x02, 0x23, 0xFF, 0x08, 0x82, 0x10,
  0x44, 0x08, 0x81, 0x10, 0x10, 0x3F, 0x50, 0x90, 0x90, 0x90, 0x90, 0x70,
  0x18, 0x16, 0x11, 0x11, 0x11, 0x11, 0x11, 0xFE, 0x10, 0x10, 0x30, 0x02,
  0x42, 0x22, 0x11, 0x11, 0x08, 0x88, 0x44, 0x82, 0x24, 0x11, 0x2E, 0x8A,
  0x92, 0x54, 0x4D, 0x22, 0x09, 0x10, 0x48, 0x84, 0x44, 0x22, 0x22, 0x11,
  0x10, 0x70, 0x18, 0x09, 0x04, 0x21, 0x08, 0x42, 0x09, 0x02, 0x40, 0x60,
  0x30, 0x12, 0x08, 0x46, 0x12, 0x82, 0xA0, 0x68, 0x11, 0x0A, 0x7C, 0x40,
  0xFC, 0x12, 0x24, 0x44, 0x88, 0x88, 0x88, 0x88, 0x44, 0x42, 0x11, 0x84,
  0x22, 0x21, 0x11, 0x11, 0x11, 0x11, 0x22, 0x24, 0x48, 0x10, 0x23, 0xD8,
  0xC2, 0x84, 0x91, 0x00, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x00, 0x5A, 0x80, 0xF8, 0xC0, 0x02, 0x04, 0x10, 0x20,
  0x41, 0x02, 0x04, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x60, 0x18, 0x26,
  0x42, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41,
  0x41, 0x42, 0x3C, 0x37, 0x91, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x38,
  0xC6, 0x02, 0x01, 0x01, 0x01, 0x02, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10,
  0x20, 0x40, 0x40, 0xFF, 0x38, 0xC6, 0x02, 0x01, 0x01, 0x01, 0x02, 0x04,
  0x38, 0x06, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0xFC, 0x01, 0x00, 0xC0,
  0x30, 0x14, 0x05, 0x02, 0x41, 0x10, 0x44, 0x21, 0x08, 0x44, 0x11, 0x04,
  0xFF, 0xC0, 0x40, 0x10, 0x04, 0x01, 0x00, 0x7E, 0x40, 0x40, 0x40, 0x40,
  0x40, 0xFC, 0x02, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x02, 0xFC, 0x0E,
  0x11, 0x20, 0x40, 0x40, 0x40, 0x80, 0xBE, 0xC3, 0xC1, 0x81, 0x81, 0x81,
  0x81, 0x41, 0x43, 0x3E, 0xFF, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04,
  0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x1C, 0x62, 0x41, 0x81,
  0x81, 0x41, 0x42, 0x34, 0x18, 0x26, 0x41, 0x81, 0x81, 0x81, 0x81, 0x41,
  0x3E, 0x18, 0x66, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x47, 0x39,
  0x01, 0x01, 0x02, 0x02, 0x04, 0x78, 0xC0, 0x30, 0x50, 0x00, 0x05, 0xA8,
  0x01, 0x83, 0x06, 0x0C, 0x08, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x18, 0x30, 0x60, 0x40, 0x40, 0x00, 0x39, 0x88, 0x10, 0x10, 0x20,
  0x41, 0x02, 0x08, 0x20, 0x81, 0x02, 0x00, 0x00, 0x10, 0x30, 0x0F, 0xE0,
  0x40, 0x42, 0x00, 0x90, 0x02, 0x43, 0x89, 0x11, 0x18, 0x84, 0x62, 0x11,
  0x88, 0x46, 0x21, 0x18, 0x88, 0x62, 0x32, 0x85, 0x59, 0x08, 0x84, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x3F, 0x00, 0x0C, 0x03, 0x00, 0xA0, 0x48, 0x12,
  0x04, 0x81, 0x10, 0x84, 0x21, 0x0F, 0xE2, 0x09, 0x02, 0x40, 0x90, 0x18,
  0x06, 0x01, 0xFE, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x82, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x07, 0x0C, 0x48, 0x08, 0x04, 0x02,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x60,
  0x0F, 0x80, 0xFE, 0x41, 0xA0, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x14, 0x0A, 0x09, 0xF8, 0xFF, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x7E, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7F, 0xFF, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x07, 0x83, 0x0C, 0x80, 0x30, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x7E, 0x00, 0xC0, 0x14, 0x02, 0x80, 0x48, 0x09, 0x81, 0x0F, 0xE0,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xF4, 0x44, 0x44, 0x44, 0x44, 0x44,
  0x44, 0x4F, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1E,
  0x83, 0x82, 0x84, 0x88, 0x88, 0x90, 0xA0, 0xF0, 0xD0, 0x88, 0x88, 0x84,
  0x84, 0x82, 0x82, 0x81, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x7F, 0xC0, 0x1E, 0x00, 0xF0, 0x0B, 0x40,
  0x5A, 0x02, 0xD0, 0x26, 0x41, 0x32, 0x09, 0x90, 0x8C, 0x44, 0x62, 0x23,
  0x12, 0x18, 0x50, 0xC2, 0x86, 0x18, 0x30, 0x41, 0x80, 0xE0, 0x70, 0x34,
  0x1A, 0x0C, 0x86, 0x43, 0x11, 0x88, 0xC2, 0x60, 0xB0, 0x58, 0x1C, 0x0E,
  0x03, 0x01, 0x0E, 0x02, 0x30, 0x81, 0x20, 0x24, 0x02, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x14, 0x02, 0x80, 0x50, 0x11, 0x06,
  0x1F, 0x00, 0xFC, 0x82, 0x82, 0x81, 0x81, 0x81, 0x82, 0x82, 0xFC, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0E, 0x02, 0x30, 0x81, 0x20, 0x24,
  0x02, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x14, 0x02,
  0x80, 0x50, 0x11, 0x06, 0x1F, 0x00, 0x20, 0x04, 0x00, 0x40, 0x0C, 0xFC,
  0x82, 0x82, 0x81, 0x81, 0x82, 0x82, 0x84, 0xF8, 0x88, 0x84, 0x84, 0x82,
  0x82, 0x81, 0x81, 0x1C, 0x63, 0x40, 0x80, 0x80, 0x80, 0x40, 0x60, 0x18,
  0x06, 0x03, 0x01, 0x01, 0x01, 0x01, 0x02, 0xFC, 0xFF, 0x84, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x05, 0x04, 0x7C, 0x80, 0x60, 0x14, 0x09,
  0x02, 0x40, 0x88, 0x42, 0x10, 0x84, 0x21, 0x04, 0x81, 0x20, 0x48, 0x12,
  0x03, 0x00, 0xC0, 0x30, 0x80, 0x81, 0x41, 0x81, 0x41, 0x81, 0x41, 0x41,
  0x41, 0x42, 0x21, 0x42, 0x22, 0x42, 0x22, 0x22, 0x22, 0x24, 0x22, 0x24,
  0x14, 0x24, 0x14, 0x24, 0x14, 0x18, 0x14, 0x18, 0x08, 0x18, 0x08, 0x18,
  0x41, 0xA0, 0x88, 0x44, 0x41, 0x20, 0xA0, 0x30, 0x10, 0x0C, 0x0A, 0x04,
  0x84, 0x42, 0x12, 0x09, 0x05, 0x01, 0x80, 0xA0, 0x90, 0x44, 0x42, 0x21,
  0x10, 0x50, 0x28, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0xFF, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40,
  0x40, 0x80, 0x80, 0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x8F, 0xC0, 0x81, 0x01, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x20, 0x40, 0x80, 0x81, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x1F, 0x08, 0x0A, 0x09, 0x04, 0x44, 0x22, 0x0A, 0x05, 0x01, 0xFF,
  0x80, 0x84, 0x43, 0x7C, 0x04, 0x08, 0x10, 0x27, 0xD0, 0xC1, 0x83, 0x06,
  0x1B, 0xD0, 0x80, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x82, 0xC2, 0xBC, 0x3E, 0x81, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x80, 0x81, 0x01, 0xF0, 0x01, 0x01, 0x01, 0x01, 0x01, 0x3F,
  0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x43, 0x3D, 0x3C,
  0x42, 0x41, 0x81, 0x81, 0xFF, 0x80, 0x80, 0x80, 0x40, 0x40, 0x3E, 0x0C,
  0x42, 0x08, 0x20, 0x8F, 0x88, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x80, 0x3F, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x43,
  0x3D, 0x01, 0x01, 0x01, 0x01, 0x46, 0x38, 0x81, 0x02, 0x04, 0x08, 0x17,
  0xB0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0xC7, 0xFF,
  0x80, 0x24, 0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0xA0, 0x81, 0x02,
  0x04, 0x08, 0x10, 0xA2, 0x48, 0x91, 0x43, 0x84, 0x89, 0x11, 0x22, 0x42,
  0x86, 0xFF, 0xFF, 0x80, 0xFD, 0xF8, 0x61, 0x82, 0x18, 0x21, 0x82, 0x18,
  0x21, 0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0x82, 0x18, 0x21, 0xBD, 0x86,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x3E, 0x20, 0x90,
  0x50, 0x28, 0x14, 0x06, 0x03, 0x02, 0x81, 0x20, 0x90, 0x47, 0xC0, 0xBC,
  0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0xC2, 0xBC, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x3D, 0x43, 0x41, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x41, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01, 0x01, 0xBE, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x00, 0x7E, 0x08, 0x20, 0x40, 0xC0, 0x81, 0x04,
  0x10, 0x7E, 0x21, 0x09, 0xF2, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xE0,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x1B, 0xD0, 0x81,
  0x81, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x24, 0x18, 0x18, 0x18, 0x82,
  0x0A, 0x18, 0x50, 0xC2, 0x8A, 0x24, 0x51, 0x12, 0x48, 0x92, 0x45, 0x14,
  0x28, 0xA0, 0xC3, 0x06, 0x18, 0x20, 0x80, 0x41, 0x22, 0x22, 0x14, 0x14,
  0x08, 0x18, 0x14, 0x24, 0x22, 0x42, 0xC1, 0x81, 0x41, 0x42, 0x42, 0x22,
  0x22, 0x24, 0x24, 0x14, 0x18, 0x18, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20,
  0xC0, 0xFC, 0x20, 0x84, 0x10, 0x82, 0x10, 0x41, 0x08, 0x3F, 0x1C, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x23, 0x02, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x81, 0x04, 0x10, 0x41, 0x04, 0x10, 0x31,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x42, 0x30, 0xF8, 0xC3, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraLight23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 16, 5, 2, -16 },
  { 3, 4, 6, 7, 2, -16 },
  { 6, 11, 16, 11, 0, -16 },
  { 28, 8, 18, 10, 1, -17 },
  { 46, 13, 17, 15, 1, -17 },
  { 74, 10, 17, 11, 1, -17 },
  { 96, 1, 6, 4, 2, -16 },
  { 97, 4, 20, 6, 1, -16 },
  { 107, 4, 20, 6, 1, -16 },
  { 117, 7, 7, 9, 1, -17 },
  { 124, 9, 10, 10, 1, -13 },
  { 136, 2, 5, 4, 1, -2 },
  { 138, 5, 1, 6, 1, -7 },
  { 139, 1, 2, 5, 2, -2 },
  { 140, 7, 16, 8, 0, -16 },
  { 154, 8, 17, 10, 1, -17 },
  { 171, 4, 16, 10, 2, -16 },
  { 179, 8, 17, 10, 1, -17 },
  { 196, 8, 17, 10, 1, -17 },
  { 213, 10, 17, 10, 0, -17 },
  { 235, 8, 16, 10, 1, -16 },
  { 251, 8, 17, 10, 1, -17 },
  { 268, 8, 16, 10, 1, -16 },
  { 284, 8, 17, 10, 1, -17 },
  { 301, 8, 17, 10, 1, -17 },
  { 318, 1, 12, 5, 2, -12 },
  { 320, 2, 15, 5, 1, -12 },
  { 324, 9, 10, 10, 1, -13 },
  { 336, 9, 6, 10, 1, -11 },
  { 343, 9, 10, 10, 1, -13 },
  { 355, 7, 17, 7, 0, -17 },
  { 370, 14, 18, 16, 1, -16 },
  { 402, 10, 16, 10, 0, -16 },
  { 422, 8, 16, 11, 2, -16 },
  { 438, 9, 17, 11, 1, -17 },
  { 458, 9, 16, 13, 2, -16 },
  { 476, 7, 16, 10, 2, -16 },
  { 490, 7, 16, 9, 2, -16 },
  { 504, 11, 17, 13, 1, -17 },
  { 528, 9, 16, 13, 2, -16 },
  { 546, 4, 16, 6, 1, -16 },
  { 554, 4, 20, 5, -1, -16 },
  { 564, 8, 16, 10, 2, -16 },
  { 580, 7, 16, 9, 2, -16 },
  { 594, 13, 16, 17, 2, -16 },
  { 620, 9, 16, 13, 2, -16 },
  { 638, 11, 17, 14, 1, -17 },
  { 662, 8, 16, 11, 2, -16 },
  { 678, 11, 21, 14, 1, -17 },
  { 707, 8, 16, 11, 2, -16 },
  { 723, 8, 17, 10, 1, -17 },
  { 740, 9, 16, 9, 0, -16 },
  { 758, 9, 16, 13, 2, -16 },
  { 776, 10, 16, 10, 0, -16 },
  { 796, 16, 16, 17, 0, -16 },
  { 828, 9, 16, 9, 0, -16 },
  { 846, 9, 16, 9, 0, -16 },
  { 864, 8, 16, 9, 1, -16 },
  { 880, 4, 20, 7, 2, -16 },
  { 890, 7, 16, 8, 0, -16 },
  { 904, 4, 20, 7, 1, -16 },
  { 914, 9, 8, 10, 1, -16 },
  { 923, 9, 1, 9, 0, 2 },
  { 925, 4, 4, 6, 1, -18 },
  { 927, 7, 12, 10, 1, -12 },
  { 938, 8, 17, 11, 2, -17 },
  { 955, 7, 12, 8, 1, -12 },
  { 966, 8, 17, 11, 1, -17 },
  { 983, 8, 12, 10, 1, -12 },
  { 995, 6, 18, 6, 0, -18 },
  { 1009, 8, 18, 11, 1, -12 },
  { 1027, 7, 17, 11, 2, -17 },
  { 1042, 1, 17, 4, 2, -17 },
  { 1045, 3, 23, 4, 0, -17 },
  { 1054, 7, 17, 9, 2, -17 },
  { 1069, 1, 17, 4, 2, -17 },
  { 1072, 12, 12, 16, 2, -12 },
  { 1090, 7, 12, 11, 2, -12 },
  { 1101, 9, 12, 11, 1, -12 },
  { 1115, 8, 17, 11, 2, -12 },
  { 1132, 8, 17, 11, 1, -12 },
  { 1149, 5, 12, 7, 2, -12 },
  { 1157, 6, 12, 8, 1, -12 },
  { 1166, 5, 15, 6, 0, -15 },
  { 1176, 7, 12, 11, 2, -12 },
  { 1187, 8, 12, 8, 0, -12 },
  { 1199, 13, 12, 13, 0, -12 },
  { 1219, 8, 12, 9, 0, -12 },
  { 1231, 8, 18, 8, 0, -12 },
  { 1249, 6, 12, 7, 1, -12 },
  { 1258, 6, 20, 8, 1, -16 },
  { 1273, 1, 24, 10, 4, -18 },
  { 1276, 6, 20, 8, 1, -16 },
  { 1291, 9, 2, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_ExtraLight23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight23pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT23PT7B_H_
