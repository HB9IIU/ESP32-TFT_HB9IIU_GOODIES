#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT43PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight43pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x90, 0x00, 0x0F,
  0xF8, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x83, 0x83,
  0x01, 0x81, 0x00, 0x20, 0x20, 0x04, 0x0C, 0x00, 0x81, 0x80, 0x10, 0x30,
  0x02, 0x04, 0x00, 0xC0, 0x80, 0x18, 0x10, 0x03, 0x02, 0x0F, 0xFF, 0xFD,
  0xFF, 0xFF, 0x81, 0x03, 0x00, 0x20, 0x60, 0x0C, 0x08, 0x01, 0x81, 0x00,
  0x30, 0x20, 0x04, 0x04, 0x00, 0x81, 0x80, 0x10, 0x30, 0x02, 0x06, 0x0F,
  0xFF, 0xFC, 0x18, 0x10, 0x03, 0x02, 0x00, 0x40, 0x40, 0x08, 0x18, 0x01,
  0x03, 0x00, 0x20, 0x60, 0x0C, 0x08, 0x01, 0x81, 0x00, 0x30, 0x20, 0x04,
  0x04, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x7F, 0x83, 0xD7, 0xCE,
  0x20, 0x98, 0x40, 0x60, 0x80, 0xC1, 0x01, 0x02, 0x02, 0x04, 0x06, 0x08,
  0x0C, 0x10, 0x08, 0x20, 0x18, 0x40, 0x1C, 0x80, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x09, 0xC0, 0x10, 0xC0, 0x20, 0xC0, 0x41, 0x80, 0x81, 0x01,
  0x02, 0x02, 0x04, 0x04, 0x18, 0x08, 0x30, 0x10, 0xD8, 0x23, 0x3F, 0xFC,
  0x0F, 0xE0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x1E, 0x00,
  0x60, 0x33, 0x00, 0x40, 0x61, 0x80, 0x40, 0x41, 0x80, 0xC0, 0xC0, 0x80,
  0x80, 0xC0, 0x81, 0x80, 0xC0, 0xC1, 0x00, 0xC0, 0xC1, 0x00, 0xC0, 0xC3,
  0x00, 0xC0, 0xC2, 0x00, 0xC0, 0xC6, 0x00, 0xC0, 0xC4, 0x00, 0xC0, 0xC4,
  0x38, 0xC0, 0x8C, 0xEC, 0x40, 0x88, 0x86, 0x41, 0x99, 0x82, 0x61, 0x91,
  0x03, 0x33, 0x11, 0x03, 0x1E, 0x31, 0x03, 0x00, 0x23, 0x03, 0x00, 0x63,
  0x01, 0x00, 0x43, 0x01, 0x00, 0x43, 0x01, 0x00, 0xC3, 0x03, 0x00, 0x81,
  0x03, 0x01, 0x81, 0x03, 0x01, 0x01, 0x03, 0x01, 0x01, 0x82, 0x03, 0x01,
  0x86, 0x02, 0x00, 0xC4, 0x06, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0x9C, 0x00,
  0x60, 0xC0, 0x08, 0x18, 0x03, 0x01, 0x00, 0x60, 0x20, 0x0C, 0x04, 0x01,
  0x80, 0x80, 0x10, 0x10, 0x02, 0x06, 0x00, 0x60, 0x80, 0x04, 0x30, 0x00,
  0xCC, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x19, 0x80, 0x06,
  0x18, 0x19, 0x83, 0x03, 0x60, 0x30, 0x6C, 0x03, 0x09, 0x80, 0x61, 0x20,
  0x06, 0x64, 0x00, 0x68, 0x80, 0x07, 0x18, 0x00, 0xC3, 0x00, 0x1C, 0x60,
  0x06, 0x86, 0x01, 0x98, 0x70, 0xE1, 0x87, 0xF8, 0x18, 0xFF, 0xFF, 0xE8,
  0x03, 0x06, 0x04, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60,
  0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x40, 0x60, 0x60, 0x60, 0x20, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x04,
  0x06, 0x03, 0x81, 0x81, 0x81, 0x03, 0x03, 0x06, 0x04, 0x0C, 0x18, 0x10,
  0x30, 0x60, 0xC1, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x83, 0x06,
  0x0C, 0x18, 0x20, 0xC1, 0x82, 0x0C, 0x18, 0x60, 0xC3, 0x04, 0x18, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x03, 0x88, 0x67, 0xEF,
  0x41, 0xE0, 0x07, 0x00, 0x12, 0x00, 0x8C, 0x06, 0x18, 0x30, 0x30, 0x80,
  0x80, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x33, 0x26, 0x66, 0x4C, 0xC8, 0x80, 0xFF,
  0xC0, 0xDF, 0x80, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x00, 0x07, 0xE0, 0x1D, 0xE0, 0x60, 0x61,
  0x80, 0xC2, 0x00, 0xCC, 0x01, 0x98, 0x01, 0x30, 0x03, 0x40, 0x06, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xD0,
  0x01, 0xB0, 0x03, 0x60, 0x04, 0xC0, 0x18, 0x80, 0x31, 0x80, 0x41, 0x81,
  0x83, 0x8E, 0x01, 0xF8, 0x00, 0x03, 0x07, 0x0F, 0x1B, 0x73, 0xE3, 0x83,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x0F, 0xC0, 0x79, 0xE1, 0x80, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xC0, 0xF9, 0xE3, 0x80, 0x64, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x0E, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x68, 0x01, 0x9C, 0x0E, 0x1F, 0xF8, 0x00, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x1B, 0x00,
  0x0C, 0xC0, 0x02, 0x30, 0x01, 0x8C, 0x00, 0x43, 0x00, 0x30, 0xC0, 0x08,
  0x30, 0x06, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x10, 0x0C,
  0x0C, 0x03, 0x02, 0x00, 0xC1, 0x80, 0x30, 0x40, 0x0C, 0x30, 0x03, 0x0F,
  0xFF, 0xFC, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFC, 0x7F, 0xF8,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0F, 0xFC, 0x1C, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x68, 0x01, 0x9C, 0x0E, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xB8, 0x38,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x3E, 0x19, 0xFF, 0x36, 0x07, 0x78,
  0x06, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x50, 0x00, 0xA0, 0x01, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x19, 0x80, 0x63,
  0x00, 0xC3, 0x87, 0x03, 0xFC, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x00, 0x07, 0xE0, 0x1E, 0x78, 0x30, 0x18,
  0x60, 0x0C, 0x60, 0x04, 0x40, 0x06, 0x40, 0x06, 0x40, 0x06, 0x40, 0x06,
  0x60, 0x04, 0x20, 0x0C, 0x30, 0x18, 0x18, 0x30, 0x0E, 0xE0, 0x03, 0x80,
  0x07, 0xC0, 0x1C, 0x70, 0x30, 0x18, 0x60, 0x0C, 0x60, 0x06, 0xC0, 0x06,
  0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x06,
  0x60, 0x06, 0x70, 0x0C, 0x38, 0x38, 0x0F, 0xF0, 0x0F, 0xC0, 0x39, 0xE0,
  0xC0, 0xE3, 0x00, 0xC6, 0x00, 0xD8, 0x01, 0xB0, 0x01, 0x60, 0x02, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xD0, 0x03,
  0xB0, 0x07, 0x70, 0x16, 0x70, 0xEC, 0x3F, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x08, 0x38, 0x1F, 0xE0, 0x00, 0xDF, 0xA0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x77, 0x72, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x33, 0x66, 0x66, 0x4C, 0xC8, 0x80, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x3F, 0x1E, 0x7A, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20,
  0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x30, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x38,
  0x06, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x18, 0x03, 0x00,
  0x1C, 0x00, 0x70, 0x0C, 0x00, 0x04, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x88, 0x07, 0xF0, 0x66, 0x03,
  0x8C, 0x09, 0x81, 0x83, 0x02, 0x40, 0xC0, 0xC0, 0x90, 0x30, 0x30, 0x34,
  0x08, 0x0C, 0x0F, 0x02, 0x03, 0x03, 0xC1, 0x80, 0xC0, 0xF0, 0x60, 0x30,
  0x3C, 0x18, 0x0C, 0x0F, 0x06, 0x03, 0x02, 0xC1, 0x80, 0xC0, 0xB0, 0x20,
  0x70, 0x24, 0x08, 0x14, 0x19, 0x03, 0x05, 0x04, 0x40, 0x66, 0x67, 0x18,
  0x0F, 0x0F, 0x86, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00,
  0x20, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x58, 0x00, 0x0B, 0x00, 0x03, 0x20, 0x00, 0x64,
  0x00, 0x08, 0xC0, 0x03, 0x18, 0x00, 0x61, 0x00, 0x08, 0x30, 0x01, 0x06,
  0x00, 0x60, 0x40, 0x0C, 0x08, 0x01, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x02,
  0x01, 0x80, 0x60, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0x80, 0x10, 0x20, 0x03,
  0x0C, 0x00, 0x61, 0x80, 0x04, 0x30, 0x00, 0xC4, 0x00, 0x19, 0x80, 0x03,
  0x30, 0x00, 0x24, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x08, 0xFF, 0x01,
  0xFF, 0xE2, 0x00, 0xE4, 0x00, 0x68, 0x00, 0xD0, 0x00, 0xA0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x68, 0x01, 0x90, 0x06,
  0x3F, 0xF8, 0x7F, 0xF8, 0x80, 0x19, 0x00, 0x1A, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x68, 0x01, 0x9F, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0xF9, 0xF0, 0x70, 0x08, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x60, 0x1F, 0xF8, 0xFE, 0x00, 0x7F, 0xF0, 0x20,
  0x1E, 0x10, 0x03, 0x88, 0x00, 0xE4, 0x00, 0x32, 0x00, 0x0D, 0x00, 0x06,
  0x80, 0x03, 0x40, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x0D, 0x00, 0x06, 0x80, 0x03,
  0x40, 0x03, 0x20, 0x01, 0x90, 0x01, 0x88, 0x03, 0x87, 0xFF, 0x83, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0xFF, 0xF4, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0x3F, 0x07, 0x00, 0x30, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x0F, 0xFC, 0x00, 0x01,
  0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x16, 0x00, 0x01, 0x60, 0x00,
  0x12, 0x00, 0x01, 0x30, 0x00, 0x13, 0x00, 0x01, 0x18, 0x00, 0x10, 0xC0,
  0x01, 0x06, 0x00, 0x10, 0x3C, 0x0F, 0x00, 0xFF, 0xE0, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFE,
  0xF8, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x3F, 0x80, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x03, 0x03, 0x06, 0xFE, 0x38, 0x80, 0x07, 0x00, 0x1A, 0x00, 0x64,
  0x00, 0xC8, 0x03, 0x10, 0x0C, 0x20, 0x30, 0x40, 0x60, 0x81, 0x81, 0x06,
  0x02, 0x0C, 0x04, 0x30, 0x08, 0xC0, 0x13, 0x80, 0x27, 0x00, 0x5B, 0x00,
  0xA6, 0x01, 0x86, 0x03, 0x0C, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x18, 0x20,
  0x10, 0x40, 0x30, 0x80, 0x31, 0x00, 0x62, 0x00, 0x64, 0x00, 0xC8, 0x00,
  0xD0, 0x00, 0xA0, 0x01, 0x80, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x5A, 0x00, 0x00, 0xB6, 0x00, 0x03, 0x6C, 0x00, 0x04,
  0xC8, 0x00, 0x09, 0x98, 0x00, 0x33, 0x30, 0x00, 0x66, 0x20, 0x00, 0x8C,
  0x60, 0x03, 0x18, 0xC0, 0x06, 0x30, 0x80, 0x08, 0x61, 0x80, 0x30, 0xC3,
  0x00, 0x61, 0x82, 0x00, 0x83, 0x06, 0x03, 0x06, 0x0C, 0x06, 0x0C, 0x08,
  0x08, 0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60, 0x20, 0x80, 0xC0, 0x63,
  0x01, 0x80, 0xC6, 0x03, 0x00, 0x88, 0x06, 0x01, 0xB0, 0x0C, 0x03, 0x60,
  0x18, 0x02, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x80, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0x60,
  0x03, 0x30, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x18,
  0x30, 0x0C, 0x18, 0x06, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60,
  0x60, 0x18, 0x30, 0x0C, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x00, 0x63, 0x00,
  0x11, 0x80, 0x0C, 0xC0, 0x02, 0x60, 0x01, 0xB0, 0x00, 0x58, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x06, 0x01, 0xFC, 0x00, 0x3E, 0x78, 0x03, 0x80, 0x60,
  0x30, 0x01, 0x81, 0x80, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x00, 0xCC, 0x00,
  0x06, 0x60, 0x00, 0x13, 0x00, 0x00, 0x90, 0x00, 0x06, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xD0, 0x00, 0x06, 0x80, 0x00, 0x34, 0x00, 0x01, 0xB0,
  0x00, 0x0D, 0x80, 0x00, 0x4C, 0x00, 0x06, 0x20, 0x00, 0x31, 0x80, 0x01,
  0x06, 0x00, 0x18, 0x30, 0x01, 0x80, 0xC0, 0x18, 0x03, 0x83, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x03, 0xFF, 0x88, 0x07, 0x20, 0x06, 0x80, 0x1A, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x68, 0x01, 0xA0, 0x0C, 0x83, 0xE3, 0xFE, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x3E, 0x78, 0x03, 0x80, 0x60, 0x38, 0x01, 0x81, 0x80, 0x06, 0x18, 0x00,
  0x30, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x13, 0x00, 0x00, 0x90,
  0x00, 0x06, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xD0, 0x00, 0x06, 0x80,
  0x00, 0x34, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x4C, 0x00, 0x06,
  0x20, 0x00, 0x31, 0x80, 0x01, 0x06, 0x00, 0x18, 0x30, 0x01, 0x80, 0xC0,
  0x18, 0x03, 0x83, 0x80, 0x0F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0xFF, 0x01, 0xFF, 0xC2, 0x01, 0xC4, 0x00, 0xC8, 0x01, 0x90, 0x01,
  0xA0, 0x03, 0x40, 0x06, 0x80, 0x0D, 0x00, 0x1A, 0x00, 0x34, 0x00, 0x68,
  0x00, 0x90, 0x03, 0x20, 0x0C, 0x40, 0x70, 0xFF, 0x81, 0x02, 0x02, 0x06,
  0x04, 0x04, 0x08, 0x0C, 0x10, 0x08, 0x20, 0x18, 0x40, 0x10, 0x80, 0x31,
  0x00, 0x22, 0x00, 0x64, 0x00, 0x48, 0x00, 0xD0, 0x00, 0xA0, 0x01, 0x80,
  0x07, 0xF0, 0x3E, 0xF8, 0xC0, 0x13, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x68, 0x01, 0x9C, 0x0E, 0x1F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x40,
  0x00, 0x98, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x0C, 0x38, 0x03, 0x07, 0x83,
  0x80, 0x7F, 0x80, 0xC0, 0x00, 0x78, 0x00, 0x0D, 0x00, 0x01, 0x30, 0x00,
  0x66, 0x00, 0x0C, 0xC0, 0x01, 0x08, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01,
  0x82, 0x00, 0x20, 0x40, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x20, 0x10, 0x04,
  0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x04, 0x00, 0x81, 0x80, 0x18, 0x30,
  0x03, 0x06, 0x00, 0x20, 0x80, 0x04, 0x30, 0x00, 0xC6, 0x00, 0x18, 0x80,
  0x01, 0x30, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xB0, 0x01, 0x40, 0x06, 0xC0, 0x05, 0x00, 0x19,
  0x00, 0x16, 0x00, 0x66, 0x00, 0xD8, 0x01, 0x18, 0x03, 0x60, 0x0C, 0x60,
  0x0C, 0x80, 0x30, 0x80, 0x22, 0x00, 0xC3, 0x00, 0x8C, 0x02, 0x0C, 0x06,
  0x30, 0x18, 0x30, 0x18, 0x40, 0x60, 0x40, 0x41, 0x01, 0x81, 0x01, 0x06,
  0x04, 0x06, 0x0C, 0x18, 0x10, 0x18, 0x30, 0x60, 0xC0, 0x60, 0xC0, 0x83,
  0x00, 0x82, 0x02, 0x0C, 0x03, 0x08, 0x0C, 0x20, 0x0C, 0x60, 0x31, 0x80,
  0x31, 0x80, 0x46, 0x00, 0x44, 0x01, 0x18, 0x01, 0x90, 0x06, 0x40, 0x06,
  0xC0, 0x1B, 0x00, 0x1B, 0x00, 0x6C, 0x00, 0x2C, 0x00, 0xB0, 0x00, 0xA0,
  0x02, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x60, 0x00, 0x60, 0x01, 0x98, 0x01, 0x8C, 0x00, 0xC2, 0x00, 0xC1, 0x80,
  0x60, 0x40, 0x60, 0x30, 0x30, 0x08, 0x10, 0x06, 0x18, 0x03, 0x08, 0x00,
  0xCC, 0x00, 0x64, 0x00, 0x16, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xB0, 0x00, 0xC8, 0x00, 0x46, 0x00, 0x61, 0x00, 0x20,
  0xC0, 0x30, 0x60, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x02, 0x0C, 0x01, 0x86,
  0x00, 0x46, 0x00, 0x33, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xE0, 0x01,
  0x98, 0x00, 0xCC, 0x00, 0x42, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x30, 0x30,
  0x18, 0x18, 0x08, 0x04, 0x0C, 0x03, 0x06, 0x01, 0x86, 0x00, 0x63, 0x00,
  0x31, 0x00, 0x09, 0x80, 0x06, 0xC0, 0x03, 0x40, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xFF,
  0xFC, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x24, 0x00, 0x33, 0x00,
  0x10, 0x80, 0x18, 0x60, 0x08, 0x30, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x01,
  0x82, 0x00, 0xC3, 0x00, 0x31, 0x00, 0x19, 0x80, 0x06, 0x80, 0x03, 0xC0,
  0x00, 0x80, 0xFF, 0xFF, 0x80, 0xC1, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x80,
  0x1F, 0xC3, 0xC7, 0x08, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0xFE, 0x3C, 0x33, 0x01, 0xB0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x7C, 0x06, 0xB0, 0x64,
  0xFE, 0x20, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC7, 0xE0,
  0xCE, 0x38, 0xD8, 0x18, 0xF0, 0x0C, 0xE0, 0x04, 0xE0, 0x06, 0xC0, 0x06,
  0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0xE0, 0x04,
  0xE0, 0x0C, 0xD0, 0x18, 0xDC, 0x38, 0xCF, 0xE0, 0x07, 0xF0, 0x79, 0xC6,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0E, 0x0C, 0x3F, 0xE0, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x1F, 0x88, 0xE3, 0x93, 0x81, 0xA6, 0x01,
  0x58, 0x01, 0xB0, 0x03, 0x40, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1A, 0x00, 0x36, 0x00, 0x6C, 0x01, 0x4C, 0x02, 0x8E, 0x19, 0x0F, 0xE2,
  0x07, 0xE0, 0x38, 0xE0, 0xE0, 0x61, 0x80, 0x46, 0x00, 0xCC, 0x01, 0x90,
  0x01, 0x60, 0x02, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x43, 0x83, 0x83, 0xFE, 0x00, 0x01, 0xE0, 0x7F, 0x06,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x7F,
  0x8F, 0xF8, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x07, 0xE2,
  0x3C, 0xE4, 0xC0, 0x69, 0x80, 0x56, 0x00, 0x6C, 0x00, 0xD0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x40, 0x06, 0x80, 0x0D, 0x80, 0x1B, 0x00, 0x53,
  0x01, 0xA3, 0x86, 0x43, 0xF8, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x90, 0x03, 0x38, 0x1C, 0x3F, 0xE0,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x7E, 0x33, 0x9C, 0xD8, 0x1B, 0xC0,
  0x2E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0C, 0xDF, 0x00,
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB0, 0x0C, 0x1C,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0xF0, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x0D, 0x80, 0x6C, 0x06, 0x60, 0x63, 0x03, 0x18, 0x30,
  0xC3, 0x06, 0x10, 0x31, 0x81, 0x98, 0x0D, 0xE0, 0x69, 0x03, 0xCC, 0x1C,
  0x20, 0xC1, 0x86, 0x04, 0x30, 0x31, 0x80, 0x8C, 0x06, 0x60, 0x13, 0x00,
  0xD8, 0x02, 0xC0, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC7, 0xC1, 0xF8, 0xDC, 0xE3, 0x9C, 0xD0, 0x36, 0x06, 0xE0, 0x14,
  0x02, 0xE0, 0x1C, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18,
  0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18,
  0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18,
  0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18,
  0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03, 0xC7, 0xE3,
  0x31, 0xCD, 0x01, 0xBC, 0x02, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xC0, 0x07, 0xE0, 0x1C, 0x78, 0x30, 0x1C, 0x30, 0x0C, 0x60,
  0x06, 0x60, 0x06, 0x40, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0x40,
  0x02, 0x60, 0x06, 0x60, 0x06, 0x20, 0x04, 0x30, 0x0C, 0x1C, 0x38, 0x0F,
  0xF0, 0xC7, 0xE0, 0xCE, 0x38, 0xD8, 0x18, 0xF0, 0x0C, 0xE0, 0x06, 0xE0,
  0x06, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0xE0,
  0x06, 0xE0, 0x04, 0xE0, 0x0C, 0xD0, 0x18, 0xDC, 0x38, 0xC7, 0xE0, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0xE2, 0x38, 0xE4, 0xE0,
  0x69, 0x80, 0x56, 0x00, 0x6C, 0x00, 0xD0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x06, 0x80, 0x0D, 0x80, 0x1B, 0x00, 0x53, 0x01, 0xA3, 0x86,
  0x43, 0xF8, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0xC7, 0xF3, 0xED,
  0x83, 0xC0, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x00, 0x1F, 0xC7, 0x8F, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x6C, 0x0E, 0xFF,
  0x80, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x03, 0xFF, 0xFE, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x06, 0x21, 0xF0, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xD0, 0x07, 0x60, 0x2C, 0xC3, 0xB1,
  0xF8, 0xC0, 0xC0, 0x07, 0x80, 0x0D, 0x00, 0x13, 0x00, 0x66, 0x00, 0xC4,
  0x01, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x20, 0x20, 0x60, 0xC0, 0xC1,
  0x80, 0x82, 0x01, 0x0C, 0x03, 0x18, 0x06, 0x30, 0x04, 0x40, 0x0D, 0x80,
  0x1B, 0x00, 0x14, 0x00, 0x28, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x0C,
  0x01, 0xA0, 0x06, 0x00, 0x98, 0x07, 0x00, 0xCC, 0x02, 0x80, 0x66, 0x01,
  0x60, 0x31, 0x00, 0xB0, 0x10, 0xC0, 0xC8, 0x08, 0x60, 0x64, 0x0C, 0x30,
  0x23, 0x06, 0x08, 0x11, 0x82, 0x06, 0x18, 0x41, 0x03, 0x0C, 0x21, 0x81,
  0x84, 0x18, 0xC0, 0x42, 0x0C, 0x60, 0x33, 0x06, 0x20, 0x19, 0x81, 0x10,
  0x0C, 0x80, 0xD8, 0x02, 0x40, 0x6C, 0x01, 0x60, 0x34, 0x00, 0xF0, 0x0A,
  0x00, 0x70, 0x07, 0x00, 0x18, 0x03, 0x80, 0x0C, 0x01, 0x80, 0xC0, 0x0D,
  0x80, 0x26, 0x01, 0x8C, 0x0C, 0x30, 0x30, 0x61, 0x80, 0x86, 0x03, 0x30,
  0x04, 0xC0, 0x1E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x80, 0x1A, 0x00, 0xCC,
  0x03, 0x10, 0x18, 0x60, 0x60, 0x83, 0x03, 0x08, 0x04, 0x60, 0x19, 0x00,
  0x2C, 0x00, 0xC0, 0x40, 0x02, 0xC0, 0x0D, 0x80, 0x19, 0x00, 0x22, 0x00,
  0xC6, 0x01, 0x8C, 0x03, 0x08, 0x04, 0x18, 0x18, 0x30, 0x30, 0x20, 0x40,
  0x41, 0x80, 0xC3, 0x01, 0x84, 0x01, 0x08, 0x03, 0x30, 0x06, 0x60, 0x04,
  0x80, 0x0B, 0x00, 0x1E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x46, 0x00, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xFF, 0xF0, 0x00, 0x60, 0x7C, 0x1C, 0x03, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0x03, 0xC0, 0x78, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x3E, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x1F, 0x00, 0x70,
  0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x07, 0x80, 0xF0,
  0x30, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x0E, 0x0F, 0x81, 0xC0,
  0x00, 0x7E, 0x01, 0xE7, 0x83, 0x80, 0xFE, 0x80, 0x38,
};

const GFXglyph NotoSans_Condensed_ExtraLight43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 31, 9, 3, -31 },
  { 13, 8, 11, 14, 3, -31 },
  { 24, 19, 31, 21, 1, -31 },
  { 98, 15, 36, 19, 2, -33 },
  { 166, 24, 31, 28, 2, -31 },
  { 259, 19, 31, 21, 2, -31 },
  { 333, 2, 11, 7, 3, -31 },
  { 336, 8, 38, 11, 2, -31 },
  { 374, 7, 38, 11, 2, -31 },
  { 408, 14, 14, 18, 2, -33 },
  { 433, 16, 20, 20, 2, -25 },
  { 473, 4, 11, 8, 2, -5 },
  { 479, 10, 1, 12, 1, -12 },
  { 481, 3, 3, 9, 3, -3 },
  { 483, 13, 31, 14, 1, -31 },
  { 534, 15, 31, 19, 2, -31 },
  { 593, 8, 31, 19, 4, -31 },
  { 624, 15, 31, 19, 2, -31 },
  { 683, 15, 31, 19, 2, -31 },
  { 742, 18, 31, 19, 1, -31 },
  { 812, 15, 31, 19, 2, -31 },
  { 871, 15, 32, 19, 2, -31 },
  { 931, 15, 31, 19, 2, -31 },
  { 990, 16, 31, 19, 2, -31 },
  { 1052, 15, 31, 19, 2, -31 },
  { 1111, 3, 23, 9, 3, -23 },
  { 1120, 4, 29, 9, 2, -23 },
  { 1135, 16, 19, 20, 2, -25 },
  { 1173, 16, 10, 20, 2, -20 },
  { 1193, 16, 19, 20, 2, -25 },
  { 1231, 11, 31, 14, 1, -31 },
  { 1274, 26, 35, 30, 2, -31 },
  { 1388, 19, 31, 19, 0, -31 },
  { 1462, 15, 31, 21, 4, -31 },
  { 1521, 18, 31, 21, 2, -31 },
  { 1591, 17, 31, 24, 4, -31 },
  { 1657, 12, 31, 19, 4, -31 },
  { 1704, 13, 31, 17, 4, -31 },
  { 1755, 20, 31, 25, 2, -31 },
  { 1833, 16, 31, 24, 4, -31 },
  { 1895, 7, 31, 11, 2, -31 },
  { 1923, 8, 39, 9, -3, -31 },
  { 1962, 15, 31, 19, 4, -31 },
  { 2021, 12, 31, 17, 4, -31 },
  { 2068, 23, 31, 31, 4, -31 },
  { 2158, 17, 31, 25, 4, -31 },
  { 2224, 21, 31, 25, 2, -31 },
  { 2306, 14, 31, 20, 4, -31 },
  { 2361, 21, 38, 25, 2, -31 },
  { 2461, 15, 31, 20, 4, -31 },
  { 2520, 15, 31, 19, 2, -31 },
  { 2579, 17, 31, 17, 0, -31 },
  { 2645, 18, 31, 24, 3, -31 },
  { 2715, 19, 31, 19, 0, -31 },
  { 2789, 30, 31, 31, 1, -31 },
  { 2906, 17, 31, 17, 0, -31 },
  { 2972, 17, 31, 17, 0, -31 },
  { 3038, 15, 31, 17, 1, -31 },
  { 3097, 8, 38, 13, 4, -31 },
  { 3135, 13, 31, 14, 1, -31 },
  { 3186, 9, 38, 13, 1, -31 },
  { 3229, 17, 17, 20, 1, -31 },
  { 3266, 17, 1, 17, 0, 4 },
  { 3269, 7, 7, 10, 2, -33 },
  { 3276, 13, 23, 18, 2, -23 },
  { 3314, 16, 33, 21, 3, -33 },
  { 3380, 13, 23, 16, 2, -23 },
  { 3418, 15, 33, 21, 2, -33 },
  { 3480, 15, 23, 19, 2, -23 },
  { 3524, 12, 33, 10, 0, -33 },
  { 3574, 15, 33, 21, 2, -23 },
  { 3636, 14, 33, 20, 3, -33 },
  { 3694, 3, 31, 8, 3, -31 },
  { 3706, 7, 41, 8, -1, -31 },
  { 3742, 13, 33, 16, 3, -33 },
  { 3796, 2, 33, 8, 3, -33 },
  { 3805, 24, 23, 30, 3, -23 },
  { 3874, 14, 23, 20, 3, -23 },
  { 3915, 16, 23, 20, 2, -23 },
  { 3961, 16, 33, 21, 3, -23 },
  { 4027, 15, 33, 21, 2, -23 },
  { 4089, 10, 23, 13, 3, -23 },
  { 4118, 12, 23, 16, 2, -23 },
  { 4153, 9, 28, 11, 1, -28 },
  { 4185, 14, 23, 20, 3, -23 },
  { 4226, 15, 23, 15, 0, -23 },
  { 4270, 25, 23, 25, 0, -23 },
  { 4342, 14, 23, 16, 1, -23 },
  { 4383, 15, 33, 16, 0, -23 },
  { 4445, 12, 23, 14, 1, -23 },
  { 4480, 11, 38, 15, 2, -31 },
  { 4533, 2, 43, 18, 8, -33 },
  { 4544, 11, 38, 15, 2, -31 },
  { 4597, 16, 4, 20, 2, -17 },
};

const GFXfont NotoSans_Condensed_ExtraLight43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight43pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT43PT7B_H_
