#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT28PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xA8, 0x0F, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x08,
  0x40, 0x84, 0x08, 0x40, 0x84, 0x08, 0x40, 0x88, 0xFF, 0xF1, 0x08, 0x10,
  0x81, 0x08, 0x10, 0x81, 0x08, 0x10, 0x8F, 0xFE, 0x21, 0x02, 0x10, 0x21,
  0x02, 0x10, 0x21, 0x02, 0x10, 0x04, 0x03, 0x03, 0x79, 0x10, 0xC4, 0x21,
  0x08, 0x42, 0x10, 0x44, 0x09, 0x01, 0xC0, 0x1C, 0x05, 0x81, 0x10, 0x44,
  0x11, 0x04, 0x41, 0x18, 0x4B, 0xFC, 0x04, 0x01, 0x00, 0x40, 0x38, 0x18,
  0x44, 0x10, 0x44, 0x10, 0x84, 0x20, 0x82, 0x20, 0x82, 0x40, 0x82, 0x40,
  0x82, 0x40, 0x84, 0x9E, 0x44, 0xA2, 0x45, 0x21, 0x39, 0x21, 0x01, 0x21,
  0x02, 0x21, 0x02, 0x21, 0x04, 0x21, 0x04, 0x21, 0x04, 0x21, 0x08, 0x22,
  0x08, 0x1E, 0x1E, 0x01, 0x08, 0x08, 0x40, 0x42, 0x02, 0x10, 0x10, 0x80,
  0x84, 0x02, 0x40, 0x1C, 0x00, 0xC0, 0x09, 0x00, 0x8C, 0x24, 0x21, 0x40,
  0x8A, 0x02, 0x90, 0x14, 0x80, 0x42, 0x07, 0x10, 0x6C, 0x7C, 0x30, 0xFE,
  0x08, 0x84, 0x42, 0x21, 0x08, 0x46, 0x21, 0x08, 0x43, 0x08, 0x42, 0x10,
  0x42, 0x18, 0x41, 0xC2, 0x08, 0x41, 0x08, 0x41, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x84, 0x23, 0x11, 0x18, 0x08, 0x04, 0x02, 0x1F, 0x70, 0xC0,
  0xA0, 0x48, 0x46, 0x21, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x3F, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x6D,
  0x25, 0x20, 0xFC, 0xF0, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08,
  0x08, 0x18, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40, 0x40, 0xC0, 0x80, 0x80,
  0x1F, 0x08, 0x62, 0x09, 0x02, 0x40, 0x50, 0x14, 0x07, 0x01, 0xC0, 0x60,
  0x18, 0x07, 0x01, 0xC0, 0x50, 0x14, 0x05, 0x01, 0x40, 0x88, 0x23, 0x18,
  0x7C, 0x0C, 0x52, 0x51, 0x84, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x3F, 0x10, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x30,
  0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x40,
  0x30, 0x08, 0x04, 0x03, 0xFF, 0x3F, 0x30, 0x60, 0x08, 0x03, 0x00, 0x40,
  0x10, 0x08, 0x02, 0x03, 0x07, 0x00, 0x30, 0x02, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x28, 0x19, 0xFC, 0x00, 0xC0, 0x14, 0x01, 0x40, 0x24,
  0x02, 0x40, 0x44, 0x04, 0x40, 0x84, 0x08, 0x41, 0x04, 0x30, 0x42, 0x04,
  0x60, 0x44, 0x04, 0xFF, 0xF0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x7F, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFC, 0x41, 0x80,
  0x60, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xA0, 0xDF, 0x80, 0x0F,
  0x86, 0x03, 0x00, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x5F, 0x18, 0x2C,
  0x07, 0x01, 0x40, 0x50, 0x14, 0x05, 0x01, 0x40, 0x58, 0x12, 0x08, 0x7C,
  0xFF, 0xC0, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x03, 0x00,
  0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x00,
  0xC0, 0x1F, 0x08, 0x24, 0x0D, 0x01, 0x40, 0x50, 0x14, 0x08, 0x86, 0x1B,
  0x03, 0x01, 0x31, 0x82, 0x40, 0x70, 0x18, 0x06, 0x01, 0x80, 0x50, 0x16,
  0x08, 0xFC, 0x3F, 0x18, 0x64, 0x09, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01,
  0xC0, 0x50, 0x36, 0x14, 0xFD, 0x00, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80,
  0x40, 0x31, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x6C, 0x00, 0x00, 0x00, 0x06,
  0xD2, 0x52, 0x00, 0x00, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x40, 0x00, 0xFD,
  0x08, 0x08, 0x10, 0x20, 0x40, 0x82, 0x0C, 0x10, 0x41, 0x02, 0x04, 0x08,
  0x00, 0x00, 0x00, 0x81, 0x00, 0x03, 0xF0, 0x06, 0x06, 0x06, 0x01, 0x82,
  0x00, 0x42, 0x00, 0x11, 0x00, 0x09, 0x07, 0xC2, 0x84, 0x21, 0x42, 0x10,
  0xA2, 0x08, 0x51, 0x04, 0x30, 0x82, 0x18, 0x41, 0x0A, 0x21, 0x85, 0x10,
  0xC4, 0x84, 0xA2, 0x41, 0x8E, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x71, 0x80, 0x02, 0x00, 0x02, 0x00, 0x30, 0x01, 0x40, 0x0A,
  0x00, 0x90, 0x04, 0x40, 0x22, 0x01, 0x10, 0x10, 0x80, 0x82, 0x04, 0x10,
  0x60, 0x83, 0xFE, 0x10, 0x10, 0x80, 0x88, 0x04, 0x40, 0x12, 0x00, 0xB0,
  0x05, 0x00, 0x30, 0xFF, 0x10, 0x32, 0x03, 0x40, 0x28, 0x05, 0x00, 0xA0,
  0x14, 0x06, 0x81, 0x9F, 0xC2, 0x06, 0x40, 0x28, 0x05, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x50, 0x0A, 0x06, 0x7F, 0x80, 0x0F, 0xC6, 0x04, 0x80, 0x20,
  0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x87, 0xE0, 0xFE,
  0x08, 0x18, 0x80, 0xC8, 0x06, 0x80, 0x28, 0x02, 0x80, 0x28, 0x03, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x02, 0x80, 0x28, 0x02, 0x80,
  0x48, 0x0C, 0x81, 0x8F, 0xE0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x7F, 0xA0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x1F, 0xF0, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x3F, 0xD0, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x00, 0x0F, 0xF0, 0x80, 0x88, 0x00, 0x80, 0x04, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x7F, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x38, 0x01, 0x40, 0x09, 0x00, 0x4C, 0x02, 0x1F, 0xE0,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x3F, 0xFE, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x10, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x09, 0xF0, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x20, 0x82, 0xF0,
  0x80, 0x50, 0x12, 0x06, 0x40, 0x88, 0x21, 0x08, 0x23, 0x04, 0x40, 0x90,
  0x17, 0x02, 0xA0, 0x66, 0x08, 0x41, 0x04, 0x20, 0x84, 0x08, 0x81, 0x90,
  0x12, 0x03, 0x40, 0x30, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x1F, 0xF0, 0xC0, 0x03, 0xC0, 0x03, 0xA0, 0x05, 0xA0, 0x05, 0xA0,
  0x05, 0x90, 0x09, 0x90, 0x09, 0x90, 0x09, 0x88, 0x11, 0x88, 0x11, 0x88,
  0x11, 0x84, 0x21, 0x84, 0x21, 0x84, 0x21, 0x82, 0x61, 0x82, 0x41, 0x82,
  0x41, 0x81, 0xC1, 0x81, 0x81, 0x81, 0x81, 0xC0, 0x1C, 0x01, 0xA0, 0x1A,
  0x01, 0x90, 0x19, 0x01, 0x88, 0x18, 0x81, 0x84, 0x18, 0x41, 0x82, 0x18,
  0x21, 0x81, 0x18, 0x11, 0x80, 0x98, 0x09, 0x80, 0x58, 0x05, 0x80, 0x38,
  0x03, 0x1F, 0x81, 0x83, 0x18, 0x08, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x02, 0x40, 0x13, 0x01, 0x0C, 0x18, 0x3F, 0x00, 0xFE, 0x20,
  0x48, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xA0, 0x68, 0xF3,
  0xC0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x1F,
  0x81, 0x83, 0x18, 0x08, 0x80, 0x28, 0x01, 0x40, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x02, 0x40, 0x13, 0x01, 0x0C, 0x18, 0x3F, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x20, 0xFE, 0x10, 0x22, 0x02, 0x40, 0x68, 0x05, 0x00,
  0xA0, 0x14, 0x04, 0x80, 0x90, 0x23, 0xF8, 0x42, 0x08, 0x21, 0x04, 0x20,
  0x44, 0x08, 0x80, 0x90, 0x12, 0x01, 0x40, 0x30, 0x1F, 0x98, 0x14, 0x01,
  0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00,
  0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x38, 0x1B, 0xFC, 0xFF, 0xE0, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x28,
  0x02, 0x40, 0x24, 0x02, 0x20, 0x41, 0xF8, 0x80, 0x18, 0x01, 0x40, 0x34,
  0x02, 0x40, 0x22, 0x02, 0x20, 0x42, 0x04, 0x20, 0x41, 0x04, 0x10, 0x81,
  0x08, 0x10, 0x80, 0x98, 0x09, 0x00, 0x90, 0x05, 0x00, 0x60, 0x06, 0x00,
  0x60, 0xC0, 0x60, 0x14, 0x06, 0x01, 0x40, 0x60, 0x24, 0x06, 0x02, 0x40,
  0x50, 0x22, 0x09, 0x02, 0x20, 0x90, 0x62, 0x09, 0x04, 0x20, 0x88, 0x41,
  0x08, 0x84, 0x11, 0x08, 0xC1, 0x10, 0x88, 0x11, 0x08, 0x81, 0x90, 0x48,
  0x0A, 0x04, 0x80, 0xA0, 0x50, 0x0A, 0x05, 0x00, 0xA0, 0x30, 0x06, 0x03,
  0x00, 0x40, 0x30, 0x40, 0x6C, 0x08, 0x81, 0x18, 0x41, 0x08, 0x22, 0x02,
  0x40, 0x50, 0x06, 0x00, 0x80, 0x18, 0x05, 0x00, 0x90, 0x22, 0x04, 0x61,
  0x04, 0x20, 0x8C, 0x09, 0x01, 0x60, 0x10, 0x80, 0x68, 0x09, 0x01, 0x30,
  0x42, 0x08, 0x41, 0x04, 0x40, 0x88, 0x12, 0x01, 0x40, 0x28, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xFF,
  0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x02, 0x00,
  0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x10, 0x08, 0x03, 0xFF,
  0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x80, 0x80, 0xC0, 0x40, 0x40, 0x20,
  0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x02, 0x02,
  0x02, 0x01, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x3F, 0x04, 0x01, 0x40, 0x28, 0x08, 0x81, 0x10,
  0x43, 0x08, 0x22, 0x06, 0x40, 0x50, 0x0E, 0x00, 0x80, 0xFF, 0xE0, 0xC3,
  0x0C, 0x30, 0x3E, 0x20, 0x80, 0x40, 0x10, 0x08, 0x04, 0x0E, 0x79, 0x40,
  0xE0, 0x60, 0x30, 0x38, 0x1A, 0x15, 0xF2, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x09, 0xF2, 0x86, 0xC0, 0xB0, 0x38, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x70, 0x3C, 0x0A, 0x86, 0x9F, 0x00, 0x0F, 0x98,
  0x08, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x60, 0x10, 0x08, 0x06,
  0x01, 0x00, 0x7E, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x11, 0xE4,
  0x87, 0x60, 0xD0, 0x14, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x07, 0x01, 0x40,
  0x50, 0x14, 0x0C, 0x83, 0x1F, 0x40, 0x1F, 0x08, 0x66, 0x09, 0x02, 0x40,
  0x50, 0x1C, 0x07, 0xFF, 0x80, 0x30, 0x04, 0x01, 0x00, 0x40, 0x08, 0x11,
  0xF8, 0x1F, 0x10, 0x10, 0x30, 0x30, 0x30, 0xFC, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1F, 0x48,
  0x36, 0x0D, 0x01, 0x40, 0x70, 0x18, 0x06, 0x01, 0x80, 0x70, 0x14, 0x05,
  0x01, 0x40, 0xC8, 0x31, 0xF4, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x61,
  0x87, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x79, 0x42, 0xC0,
  0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x08, 0xE0, 0x2A, 0xAA, 0xAA, 0xAA, 0x18, 0x80, 0x00, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x11, 0xB8,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x05, 0x04, 0x84, 0x42, 0x22,
  0x12, 0x0B, 0x05, 0x43, 0x21, 0x08, 0x84, 0x41, 0x20, 0x90, 0x28, 0x18,
  0xFF, 0xFF, 0xF8, 0x9E, 0x3C, 0xA3, 0x46, 0xC1, 0x82, 0xC1, 0x82, 0x81,
  0x02, 0x81, 0x03, 0x81, 0x03, 0x81, 0x03, 0x81, 0x03, 0x81, 0x03, 0x81,
  0x03, 0x81, 0x03, 0x81, 0x03, 0x81, 0x03, 0x81, 0x03, 0x9E, 0x50, 0xB0,
  0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x02, 0x1F, 0x04, 0x11, 0x03, 0x20, 0x24, 0x05, 0x80, 0xA0, 0x1C,
  0x03, 0x80, 0x78, 0x09, 0x01, 0x20, 0x24, 0x04, 0x41, 0x07, 0xC0, 0x9F,
  0x28, 0x6C, 0x0B, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x07, 0x03, 0xC0, 0xA8, 0x69, 0xF2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x00, 0x1F, 0x48, 0x76, 0x0D, 0x01, 0x40, 0x70, 0x18, 0x06,
  0x01, 0x80, 0x70, 0x14, 0x05, 0x01, 0x40, 0xC8, 0x31, 0xF4, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x9E, 0x8C, 0x30, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x00, 0x3E, 0x41, 0x80, 0x80, 0x80,
  0x40, 0x20, 0x18, 0x06, 0x03, 0x01, 0x01, 0x01, 0x83, 0xFE, 0x20, 0x40,
  0x87, 0xF2, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x30, 0x3C, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x38, 0x1A, 0x15, 0xF2, 0x80, 0xF0, 0x24, 0x09, 0x02,
  0x41, 0x08, 0x42, 0x10, 0x84, 0x22, 0x04, 0x81, 0x20, 0x50, 0x0C, 0x03,
  0x00, 0xC0, 0x80, 0x81, 0x41, 0x81, 0x41, 0x82, 0x41, 0x42, 0x41, 0x42,
  0x22, 0x42, 0x22, 0x42, 0x22, 0x24, 0x22, 0x24, 0x14, 0x24, 0x14, 0x24,
  0x14, 0x18, 0x14, 0x18, 0x08, 0x18, 0x08, 0x18, 0x81, 0xE0, 0x90, 0xC4,
  0x42, 0x40, 0xA0, 0x60, 0x10, 0x18, 0x1A, 0x09, 0x8C, 0x44, 0x36, 0x0A,
  0x06, 0xC0, 0x50, 0x14, 0x09, 0x02, 0x20, 0x88, 0x42, 0x10, 0x44, 0x13,
  0x04, 0x81, 0x20, 0x28, 0x0C, 0x03, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00,
  0x80, 0x40, 0x30, 0x38, 0x00, 0xFE, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08,
  0x10, 0x40, 0x82, 0x04, 0x10, 0x3F, 0x80, 0x06, 0x10, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x41, 0x0E, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x06, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x10, 0x10, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x07, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0xF0, 0x78, 0x30, 0xF8,
};

const GFXglyph NotoSans_Condensed_ExtraLight28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 20, 6, 2, -20 },
  { 6, 5, 7, 9, 2, -20 },
  { 11, 12, 20, 14, 1, -20 },
  { 41, 10, 23, 13, 1, -21 },
  { 70, 16, 20, 18, 1, -20 },
  { 110, 13, 20, 14, 1, -20 },
  { 143, 1, 7, 5, 2, -20 },
  { 144, 5, 24, 7, 1, -20 },
  { 159, 5, 24, 7, 1, -20 },
  { 174, 9, 9, 12, 1, -21 },
  { 185, 11, 13, 13, 1, -16 },
  { 203, 3, 7, 5, 1, -3 },
  { 206, 6, 1, 8, 1, -8 },
  { 207, 2, 2, 6, 2, -2 },
  { 208, 8, 20, 9, 1, -20 },
  { 228, 10, 20, 13, 1, -20 },
  { 253, 6, 20, 13, 2, -20 },
  { 268, 10, 20, 13, 1, -20 },
  { 293, 10, 20, 13, 1, -20 },
  { 318, 12, 20, 13, 0, -20 },
  { 348, 9, 20, 13, 2, -20 },
  { 371, 10, 20, 13, 1, -20 },
  { 396, 10, 20, 13, 1, -20 },
  { 421, 10, 20, 13, 1, -20 },
  { 446, 10, 20, 13, 1, -20 },
  { 471, 2, 15, 6, 2, -15 },
  { 475, 3, 19, 6, 1, -15 },
  { 483, 11, 12, 13, 1, -16 },
  { 500, 11, 7, 13, 1, -13 },
  { 510, 11, 12, 13, 1, -16 },
  { 527, 7, 20, 9, 1, -20 },
  { 545, 17, 23, 19, 1, -20 },
  { 594, 13, 20, 13, 0, -20 },
  { 627, 11, 20, 14, 2, -20 },
  { 655, 11, 20, 13, 2, -20 },
  { 683, 12, 20, 15, 2, -20 },
  { 713, 9, 20, 12, 2, -20 },
  { 736, 9, 20, 11, 2, -20 },
  { 759, 13, 20, 16, 2, -20 },
  { 792, 11, 20, 16, 2, -20 },
  { 820, 5, 20, 7, 1, -20 },
  { 833, 6, 25, 6, -2, -20 },
  { 852, 11, 20, 12, 2, -20 },
  { 880, 9, 20, 11, 2, -20 },
  { 903, 16, 20, 20, 2, -20 },
  { 943, 12, 20, 16, 2, -20 },
  { 973, 13, 20, 17, 2, -20 },
  { 1006, 10, 20, 13, 2, -20 },
  { 1031, 13, 25, 17, 2, -20 },
  { 1072, 11, 20, 13, 2, -20 },
  { 1100, 10, 20, 12, 1, -20 },
  { 1125, 11, 20, 11, 0, -20 },
  { 1153, 12, 20, 16, 2, -20 },
  { 1183, 12, 20, 12, 0, -20 },
  { 1213, 20, 20, 20, 0, -20 },
  { 1263, 11, 20, 11, 0, -20 },
  { 1291, 11, 20, 11, 0, -20 },
  { 1319, 10, 20, 11, 1, -20 },
  { 1344, 6, 24, 9, 2, -20 },
  { 1362, 8, 20, 9, 1, -20 },
  { 1382, 5, 24, 9, 1, -20 },
  { 1397, 11, 11, 13, 1, -20 },
  { 1413, 11, 1, 11, 0, 2 },
  { 1415, 5, 4, 7, 1, -21 },
  { 1418, 9, 15, 12, 1, -15 },
  { 1435, 10, 21, 13, 2, -21 },
  { 1462, 9, 15, 10, 1, -15 },
  { 1479, 10, 21, 13, 1, -21 },
  { 1506, 10, 15, 12, 1, -15 },
  { 1525, 8, 21, 7, 0, -21 },
  { 1546, 10, 22, 13, 1, -15 },
  { 1574, 9, 21, 13, 2, -21 },
  { 1598, 2, 20, 5, 2, -20 },
  { 1603, 5, 27, 5, -1, -20 },
  { 1620, 9, 21, 11, 2, -21 },
  { 1644, 1, 21, 5, 2, -21 },
  { 1647, 16, 15, 20, 2, -15 },
  { 1677, 9, 15, 13, 2, -15 },
  { 1694, 11, 15, 13, 1, -15 },
  { 1715, 10, 22, 13, 2, -15 },
  { 1743, 10, 22, 13, 1, -15 },
  { 1771, 6, 15, 9, 2, -15 },
  { 1783, 8, 15, 10, 1, -15 },
  { 1798, 7, 18, 7, 0, -18 },
  { 1814, 9, 15, 13, 2, -15 },
  { 1831, 10, 15, 10, 0, -15 },
  { 1850, 16, 15, 16, 0, -15 },
  { 1880, 9, 15, 11, 1, -15 },
  { 1897, 10, 22, 10, 0, -15 },
  { 1925, 7, 15, 9, 1, -15 },
  { 1939, 7, 24, 10, 1, -20 },
  { 1960, 1, 28, 12, 6, -21 },
  { 1964, 8, 24, 10, 1, -20 },
  { 1988, 11, 2, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_ExtraLight28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight28pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT28PT7B_H_
