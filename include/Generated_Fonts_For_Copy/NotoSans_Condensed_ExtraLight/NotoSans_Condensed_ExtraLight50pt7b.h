#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT50PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight50pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00,
  0x00, 0xDF, 0xF0, 0xE1, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0D,
  0x02, 0x40, 0x90, 0x24, 0x09, 0x02, 0x40, 0x80, 0x00, 0x40, 0x60, 0x01,
  0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x18,
  0x08, 0x00, 0x20, 0x30, 0x00, 0x40, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01,
  0x80, 0x06, 0x03, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x20, 0x10,
  0x00, 0x40, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00,
  0x0C, 0x06, 0x00, 0x18, 0x08, 0x00, 0x20, 0x10, 0x00, 0x40, 0x60, 0x00,
  0x80, 0xC0, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x0C, 0x06, 0x00, 0x18,
  0x08, 0x00, 0x30, 0x10, 0x00, 0x40, 0x60, 0x00, 0x80, 0xC0, 0x03, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x08, 0x00, 0x20, 0x10,
  0x00, 0x40, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0F,
  0xE0, 0x0F, 0xFF, 0x8E, 0x30, 0xC3, 0x0C, 0x01, 0x83, 0x00, 0xC0, 0xC0,
  0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x06,
  0x0C, 0x01, 0x83, 0x00, 0x30, 0xC0, 0x07, 0x30, 0x00, 0xFC, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0C, 0xE0, 0x03, 0x0C, 0x00, 0xC1,
  0x80, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30,
  0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC1, 0xA0, 0x30, 0xCF, 0x0C, 0xE1, 0xFF,
  0xF0, 0x07, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0x00, 0x04, 0x01, 0x9C, 0x00, 0xC0, 0x30, 0xC0, 0x08, 0x06,
  0x06, 0x01, 0x80, 0x60, 0x60, 0x18, 0x06, 0x06, 0x01, 0x00, 0x40, 0x20,
  0x30, 0x04, 0x02, 0x02, 0x00, 0xC0, 0x30, 0x60, 0x0C, 0x03, 0x06, 0x00,
  0xC0, 0x30, 0x40, 0x0C, 0x03, 0x0C, 0x00, 0xC0, 0x30, 0x80, 0x0C, 0x03,
  0x18, 0x00, 0x40, 0x21, 0x87, 0x84, 0x02, 0x11, 0xFC, 0x60, 0x63, 0x18,
  0x66, 0x06, 0x23, 0x06, 0x60, 0x66, 0x30, 0x33, 0x0C, 0x62, 0x03, 0x19,
  0x84, 0x60, 0x30, 0xF0, 0xC6, 0x03, 0x00, 0x08, 0x60, 0x30, 0x01, 0x86,
  0x03, 0x00, 0x18, 0x60, 0x10, 0x01, 0x06, 0x01, 0x00, 0x30, 0x60, 0x10,
  0x02, 0x06, 0x03, 0x00, 0x60, 0x60, 0x30, 0x06, 0x06, 0x03, 0x00, 0x40,
  0x20, 0x30, 0x0C, 0x02, 0x03, 0x00, 0xC0, 0x30, 0x20, 0x18, 0x03, 0x06,
  0x01, 0x80, 0x18, 0xC0, 0x30, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x18, 0x04, 0x00, 0x60, 0x18, 0x01,
  0x80, 0x60, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x10, 0x00, 0x80,
  0xC0, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x60, 0x00, 0x63, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xEC, 0x00, 0x06,
  0x18, 0x00, 0x30, 0x70, 0x19, 0xC0, 0xC0, 0x66, 0x01, 0x81, 0xB8, 0x07,
  0x06, 0xC0, 0x0C, 0x13, 0x00, 0x18, 0xCC, 0x00, 0x33, 0x30, 0x00, 0xD8,
  0xC0, 0x01, 0xE3, 0x00, 0x03, 0x0C, 0x00, 0x1E, 0x18, 0x00, 0x78, 0x60,
  0x03, 0x30, 0xC0, 0x38, 0xE1, 0xC3, 0xC1, 0x83, 0xFC, 0x03, 0x01, 0x80,
  0x00, 0xFB, 0x6D, 0xB2, 0x49, 0x24, 0x01, 0xC0, 0x60, 0x30, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x07, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18,
  0x18, 0x18, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x40, 0x83, 0xF8, 0x8F, 0x1F, 0xF8, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0x60, 0x06, 0x30, 0x0C, 0x30, 0x18, 0x18, 0x38, 0x0C, 0x10, 0x08, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x7F, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x39, 0x8C, 0x63, 0x31, 0x8C, 0x66,
  0x30, 0xFF, 0xFF, 0xFF, 0x67, 0xF6, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xC0, 0xE0, 0x60, 0x18, 0x18,
  0x03, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x06, 0x60, 0x01, 0x98, 0x00,
  0x26, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x40,
  0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00,
  0x36, 0x00, 0x09, 0x80, 0x06, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x10,
  0x60, 0x0C, 0x18, 0x07, 0x03, 0x01, 0x80, 0x7B, 0xC0, 0x0F, 0xE0, 0x00,
  0xC0, 0x70, 0x7C, 0x3B, 0x1C, 0xCE, 0x36, 0x0F, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x07, 0xF0, 0x0F, 0xFF,
  0x07, 0x00, 0xE0, 0x80, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x0F, 0xFF, 0x07, 0x00, 0xE3,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x30, 0x01, 0x8F, 0x83, 0xC0,
  0xFF, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0xCC, 0x00,
  0x06, 0x60, 0x00, 0x63, 0x00, 0x03, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86,
  0x00, 0x18, 0x30, 0x00, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0xC0, 0x60, 0x06,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30,
  0x18, 0x01, 0x80, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x3F, 0xFE, 0x3F, 0xFF, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0xFF, 0xE0, 0xFC, 0x7C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0E, 0x40, 0x0E, 0x3C, 0x1E, 0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x01,
  0xFF, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x0F, 0xC1, 0x9F, 0xF8, 0xDC, 0x0E, 0x78, 0x03, 0xB8,
  0x00, 0xDC, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1B, 0x00,
  0x0D, 0x80, 0x0C, 0xC0, 0x06, 0x30, 0x07, 0x1C, 0x03, 0x07, 0x87, 0x00,
  0xFF, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xC0, 0x70, 0xE0, 0x0C, 0x30, 0x01,
  0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x03, 0x60, 0x00, 0x98, 0x00, 0x66,
  0x00, 0x18, 0xC0, 0x06, 0x38, 0x03, 0x06, 0x01, 0xC0, 0xE0, 0xE0, 0x1C,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x73, 0x80, 0x38, 0x38, 0x18, 0x07,
  0x0C, 0x00, 0xE6, 0x00, 0x19, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x36, 0x00, 0x0D, 0x80,
  0x07, 0x70, 0x01, 0x8E, 0x00, 0xC1, 0xE1, 0xE0, 0x1F, 0xF0, 0x00, 0x40,
  0x00, 0x07, 0xF0, 0x03, 0xFF, 0x01, 0x80, 0xE0, 0xC0, 0x18, 0x70, 0x03,
  0x18, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C,
  0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0D, 0x80,
  0x07, 0x60, 0x01, 0xD8, 0x00, 0xF3, 0x00, 0x2C, 0xE0, 0x1B, 0x1E, 0x3C,
  0xC1, 0xFC, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x0E, 0x02, 0x0F, 0x00, 0xFF, 0x80, 0x06, 0x00,
  0x00, 0x67, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x7F, 0x60, 0x31, 0xCE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE6, 0x31, 0x8C, 0xC6, 0x31, 0x18, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xFF, 0x84, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x38, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x98, 0x00, 0x60, 0x0C,
  0xC0, 0x1F, 0xE0, 0x26, 0x01, 0x83, 0x01, 0xA0, 0x18, 0x18, 0x0F, 0x01,
  0x80, 0xC0, 0x78, 0x0C, 0x06, 0x03, 0xC0, 0xC0, 0x30, 0x1E, 0x06, 0x01,
  0x80, 0xF0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x01,
  0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x03, 0xC0,
  0xC0, 0x70, 0x1E, 0x06, 0x02, 0x81, 0xB0, 0x30, 0x14, 0x0D, 0x80, 0xC1,
  0xA0, 0xCC, 0x07, 0x19, 0xCE, 0x20, 0x1F, 0x87, 0xE1, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x04, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x40,
  0x00, 0x06, 0xC0, 0x00, 0x09, 0x80, 0x00, 0x33, 0x00, 0x00, 0x63, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0x0C, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x40, 0x01, 0x80, 0xC0, 0x02,
  0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x0C, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x06, 0x00, 0x30, 0x18, 0x00,
  0x60, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03,
  0x06, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x70, 0xFF, 0xE0, 0x1F,
  0xFF, 0x83, 0x00, 0x38, 0x60, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x03, 0x30,
  0x00, 0x76, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60,
  0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0xC6, 0x00, 0x70, 0xFF,
  0xFC, 0x1F, 0xFF, 0x03, 0x00, 0x78, 0x60, 0x01, 0x8C, 0x00, 0x19, 0x80,
  0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00,
  0x03, 0xE0, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00,
  0x0C, 0xC0, 0x03, 0x98, 0x01, 0xE3, 0xFF, 0xF8, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x1F, 0xFF, 0x07, 0x80, 0x20, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x01,
  0x03, 0xE1, 0xE0, 0x0F, 0xFC, 0x00, 0x08, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x30, 0x07, 0x81, 0x80, 0x0E, 0x0C, 0x00, 0x38, 0x60, 0x00, 0xE3,
  0x00, 0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00,
  0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8,
  0x00, 0x06, 0xC0, 0x00, 0x16, 0x00, 0x00, 0xF0, 0x00, 0x05, 0x80, 0x00,
  0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0,
  0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06,
  0x60, 0x00, 0x63, 0x00, 0x07, 0x18, 0x00, 0x70, 0xC0, 0x07, 0x06, 0x00,
  0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0xF8, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x20, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0x8E, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x0F, 0x00,
  0x0C, 0x0F, 0xC1, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x1C, 0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x81, 0xE1, 0xDF, 0xC7, 0xC0, 0xC0, 0x01, 0xF0, 0x00, 0x6C,
  0x00, 0x33, 0x00, 0x1C, 0xC0, 0x06, 0x30, 0x03, 0x0C, 0x01, 0xC3, 0x00,
  0x60, 0xC0, 0x30, 0x30, 0x18, 0x0C, 0x0E, 0x03, 0x03, 0x00, 0xC1, 0x80,
  0x30, 0xE0, 0x0C, 0x30, 0x03, 0x18, 0x00, 0xCE, 0x00, 0x37, 0xC0, 0x0D,
  0xB8, 0x03, 0xC6, 0x00, 0xE1, 0xC0, 0x30, 0x30, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x70, 0xC0, 0x0C,
  0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x6C,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xD0, 0x00, 0x00, 0xBD, 0x80, 0x00, 0x1B, 0xD8, 0x00, 0x01,
  0xBD, 0x80, 0x00, 0x13, 0xCC, 0x00, 0x03, 0x3C, 0xC0, 0x00, 0x33, 0xCC,
  0x00, 0x02, 0x3C, 0x60, 0x00, 0x63, 0xC6, 0x00, 0x06, 0x3C, 0x60, 0x00,
  0x63, 0xC3, 0x00, 0x0C, 0x3C, 0x30, 0x00, 0xC3, 0xC3, 0x00, 0x0C, 0x3C,
  0x18, 0x01, 0x83, 0xC1, 0x80, 0x18, 0x3C, 0x18, 0x01, 0x83, 0xC0, 0xC0,
  0x30, 0x3C, 0x0C, 0x03, 0x03, 0xC0, 0xC0, 0x30, 0x3C, 0x06, 0x06, 0x03,
  0xC0, 0x60, 0x60, 0x3C, 0x06, 0x06, 0x03, 0xC0, 0x30, 0xC0, 0x3C, 0x03,
  0x0C, 0x03, 0xC0, 0x30, 0xC0, 0x3C, 0x01, 0x98, 0x03, 0xC0, 0x19, 0x80,
  0x3C, 0x01, 0x98, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3D, 0x00, 0x01, 0xEC, 0x00, 0x0F, 0x70, 0x00,
  0x79, 0x80, 0x03, 0xC6, 0x00, 0x1E, 0x30, 0x00, 0xF0, 0xC0, 0x07, 0x86,
  0x00, 0x3C, 0x18, 0x01, 0xE0, 0xC0, 0x0F, 0x03, 0x00, 0x78, 0x18, 0x03,
  0xC0, 0x60, 0x1E, 0x03, 0x00, 0xF0, 0x0C, 0x07, 0x80, 0x60, 0x3C, 0x01,
  0x81, 0xE0, 0x0C, 0x0F, 0x00, 0x30, 0x78, 0x01, 0x83, 0xC0, 0x06, 0x1E,
  0x00, 0x30, 0xF0, 0x00, 0xC7, 0x80, 0x06, 0x3C, 0x00, 0x19, 0xE0, 0x00,
  0xCF, 0x00, 0x03, 0x78, 0x00, 0x1B, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07,
  0x00, 0xE0, 0x0C, 0x00, 0x70, 0x18, 0x00, 0x38, 0x38, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x18, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0xE0, 0x07,
  0xC7, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFF, 0x80, 0x7F, 0xFC,
  0x30, 0x0F, 0x18, 0x01, 0xCC, 0x00, 0x76, 0x00, 0x1B, 0x00, 0x0D, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x07, 0x60, 0x07, 0x30, 0x07,
  0x1F, 0xFF, 0x0F, 0xFC, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0x00, 0xE0, 0x0C, 0x00,
  0x70, 0x18, 0x00, 0x38, 0x38, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x60, 0x00,
  0x0C, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0x40, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0xE0, 0x07, 0xC7, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0x17, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0xFF, 0x80, 0x3F, 0xFE, 0x0C, 0x03, 0xC3, 0x00,
  0x38, 0xC0, 0x07, 0x30, 0x00, 0xCC, 0x00, 0x3B, 0x00, 0x06, 0xC0, 0x01,
  0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xCC,
  0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06, 0x30, 0x07, 0x0F, 0xFF, 0x83, 0xFF,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x00, 0xC0, 0xC0, 0x38,
  0x30, 0x06, 0x0C, 0x01, 0xC3, 0x00, 0x30, 0xC0, 0x0E, 0x30, 0x01, 0x8C,
  0x00, 0x73, 0x00, 0x0C, 0xC0, 0x03, 0xB0, 0x00, 0x6C, 0x00, 0x1F, 0x00,
  0x03, 0x03, 0xFE, 0x03, 0xFF, 0xE1, 0xC0, 0x18, 0xE0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x20, 0x03, 0x8F, 0xC3, 0xC1, 0xFF, 0xE0, 0x01, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x60, 0x00, 0x66, 0x00, 0x06, 0x30,
  0x00, 0xC3, 0x80, 0x18, 0x0F, 0x0F, 0x80, 0x7F, 0xE0, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x36, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60,
  0x00, 0x19, 0x80, 0x00, 0x43, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x30, 0x40, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60,
  0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x80, 0x18,
  0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x02, 0x03, 0x00, 0x0C, 0x0C,
  0x00, 0x30, 0x30, 0x00, 0xC0, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00,
  0x18, 0x60, 0x00, 0x63, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0C,
  0xC0, 0x00, 0x16, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x18, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x03, 0x60, 0x00, 0xF0, 0x00, 0x66, 0x00, 0x1E, 0x00,
  0x0C, 0xC0, 0x03, 0xC0, 0x01, 0x98, 0x00, 0x68, 0x00, 0x63, 0x00, 0x09,
  0x80, 0x0C, 0x60, 0x03, 0x30, 0x01, 0x86, 0x00, 0x66, 0x00, 0x30, 0xC0,
  0x0C, 0xC0, 0x0C, 0x18, 0x01, 0x8C, 0x01, 0x83, 0x00, 0x61, 0x80, 0x30,
  0x30, 0x0C, 0x30, 0x06, 0x06, 0x01, 0x86, 0x01, 0x80, 0xC0, 0x30, 0x40,
  0x30, 0x18, 0x04, 0x0C, 0x06, 0x01, 0x01, 0x81, 0x80, 0xC0, 0x30, 0x30,
  0x30, 0x18, 0x06, 0x06, 0x02, 0x06, 0x00, 0xC0, 0xC0, 0x60, 0xC0, 0x18,
  0x30, 0x0C, 0x18, 0x01, 0x86, 0x01, 0x83, 0x00, 0x30, 0xC0, 0x30, 0xC0,
  0x06, 0x18, 0x02, 0x18, 0x00, 0xC2, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x0C,
  0x60, 0x01, 0x98, 0x01, 0x98, 0x00, 0x33, 0x00, 0x13, 0x00, 0x06, 0x60,
  0x03, 0x60, 0x00, 0x48, 0x00, 0x6C, 0x00, 0x0F, 0x00, 0x0D, 0x80, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00,
  0xC1, 0x80, 0x0C, 0x18, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x03, 0x00, 0x60,
  0x30, 0x06, 0x03, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0xC0, 0x01,
  0x8C, 0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xD8, 0x00, 0x19, 0x80,
  0x01, 0x8C, 0x00, 0x30, 0xC0, 0x03, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x18, 0x18, 0x01, 0x83, 0x00,
  0x0C, 0x30, 0x00, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0x6E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0D, 0x80, 0x03, 0x30, 0x00, 0x63, 0x00, 0x0C, 0x60,
  0x03, 0x0C, 0x00, 0x60, 0xC0, 0x18, 0x18, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x18, 0x06, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x18, 0x00, 0xC3, 0x00, 0x18,
  0xC0, 0x03, 0x18, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0xFF, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x7F, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xB0, 0x00, 0x0C, 0x80, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00, 0x60, 0xC0,
  0x03, 0x06, 0x00, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x0C, 0x30, 0x00, 0x63,
  0x00, 0x01, 0xB8, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x60,
  0x30, 0x18, 0x0C, 0x0C, 0x06, 0x01, 0x07, 0xE0, 0x3F, 0xF0, 0xE0, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x1F, 0xE1, 0xF8, 0x4F, 0x00, 0xB8, 0x01,
  0x60, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xB0, 0x05, 0x60, 0x1A, 0x70, 0xE4, 0x7F, 0x08, 0x10, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x0F, 0xC0, 0xCF, 0xFC, 0x37, 0x03, 0x8D, 0x00, 0x63, 0xC0, 0x0C, 0xE0,
  0x03, 0x38, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00,
  0x6C, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0B,
  0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xE0,
  0x03, 0x38, 0x00, 0xCF, 0x00, 0x72, 0x60, 0x38, 0x8E, 0x3C, 0x21, 0xFE,
  0x00, 0x08, 0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x38, 0x08, 0xE0, 0x01, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1F, 0x1C, 0x0F, 0xF8, 0x02, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x07, 0xC3, 0x07,
  0xFC, 0xC3, 0x83, 0xB1, 0x80, 0x2C, 0xC0, 0x07, 0x30, 0x01, 0xD8, 0x00,
  0x76, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0D, 0x00, 0x03, 0x60,
  0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x01, 0xCC, 0x00,
  0x73, 0x00, 0x34, 0x60, 0x19, 0x0E, 0x1C, 0x41, 0xFE, 0x10, 0x0C, 0x00,
  0x01, 0xF0, 0x03, 0xFE, 0x03, 0x03, 0x83, 0x00, 0xC3, 0x00, 0x31, 0x80,
  0x18, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x68,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x1C, 0x01, 0x07, 0x87, 0x80, 0xFF, 0x80, 0x0C, 0x00,
  0x01, 0xFC, 0x0F, 0x60, 0x70, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0xFF, 0xE0, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x10,
  0xC0, 0x64, 0x60, 0x0F, 0x30, 0x01, 0xCC, 0x00, 0x76, 0x00, 0x0D, 0x80,
  0x03, 0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x40, 0x00, 0xD8, 0x00, 0x36,
  0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x73, 0x00, 0x1C, 0xE0,
  0x0F, 0x18, 0x06, 0xC3, 0x87, 0x30, 0x7F, 0x8C, 0x02, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x19, 0x00, 0x0C, 0x30, 0x07, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC3, 0xF0, 0xCF,
  0xF8, 0xDC, 0x1C, 0xD0, 0x0E, 0xF0, 0x06, 0xE0, 0x06, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x7D, 0xA0, 0x00, 0x01, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6D, 0xB0, 0x06, 0x1C, 0x38, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xC1, 0xBF, 0x78, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x2C, 0x01, 0x98,
  0x03, 0x30, 0x0C, 0x60, 0x30, 0xC0, 0xE1, 0x81, 0x83, 0x06, 0x06, 0x18,
  0x0C, 0x30, 0x18, 0xC0, 0x33, 0x80, 0x6F, 0x00, 0xDB, 0x01, 0xE6, 0x03,
  0x86, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x18, 0x60, 0x30, 0xC0,
  0x31, 0x80, 0x63, 0x00, 0x66, 0x00, 0xCC, 0x00, 0xD8, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x3E,
  0x11, 0xFE, 0x0F, 0xF2, 0x60, 0xE3, 0x07, 0x58, 0x0C, 0xC0, 0x6A, 0x00,
  0xF0, 0x07, 0xC0, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x30, 0x03,
  0xC0, 0x06, 0x00, 0x78, 0x00, 0x80, 0x0F, 0x00, 0x10, 0x01, 0xE0, 0x02,
  0x00, 0x3C, 0x00, 0x40, 0x07, 0x80, 0x08, 0x00, 0xF0, 0x01, 0x00, 0x1E,
  0x00, 0x20, 0x03, 0xC0, 0x04, 0x00, 0x78, 0x00, 0x80, 0x0F, 0x00, 0x10,
  0x01, 0xE0, 0x02, 0x00, 0x3C, 0x00, 0x40, 0x07, 0x80, 0x08, 0x00, 0xF0,
  0x01, 0x00, 0x1E, 0x00, 0x20, 0x03, 0xC0, 0x04, 0x00, 0x78, 0x00, 0x80,
  0x0F, 0x00, 0x10, 0x01, 0x80, 0x03, 0xF0, 0x8F, 0xF8, 0x9C, 0x1C, 0x90,
  0x0E, 0xA0, 0x06, 0xA0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x01,
  0xF8, 0x00, 0xFF, 0x80, 0x30, 0x1C, 0x0C, 0x01, 0x83, 0x00, 0x18, 0x60,
  0x03, 0x18, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x00,
  0x01, 0x20, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x40, 0x00, 0x6C, 0x00, 0x09, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00,
  0x0C, 0x60, 0x01, 0x8C, 0x00, 0x60, 0xC0, 0x1C, 0x1C, 0x03, 0x01, 0xE1,
  0xC0, 0x1F, 0xF0, 0x00, 0x20, 0x00, 0x03, 0xF0, 0x21, 0xFF, 0x09, 0xC0,
  0xE2, 0x60, 0x18, 0xB0, 0x03, 0x28, 0x00, 0xCE, 0x00, 0x1B, 0x00, 0x06,
  0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x02, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x02, 0xC0, 0x00, 0xB0, 0x00, 0x6C, 0x00,
  0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB8, 0x00, 0xCE, 0x00, 0x33, 0xC0, 0x18,
  0xD8, 0x0E, 0x33, 0x8F, 0x0C, 0x7F, 0x83, 0x02, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF0,
  0x01, 0xFF, 0x10, 0xE0, 0xE4, 0x60, 0x0B, 0x30, 0x01, 0xCC, 0x00, 0x76,
  0x00, 0x1D, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x73,
  0x00, 0x1C, 0xE0, 0x0B, 0x1C, 0x06, 0xC3, 0x87, 0x30, 0x7F, 0x8C, 0x02,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x03, 0xF1, 0xFA, 0x70, 0x4C, 0x0B, 0x01, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0xF3, 0x00, 0x98, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x80, 0x1B,
  0xC3, 0xC7, 0xFE, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x07, 0xFF, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x61, 0x0F, 0xE0, 0x20, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0B,
  0xE0, 0x0B, 0x60, 0x13, 0x38, 0xF3, 0x1F, 0xC3, 0x02, 0x00, 0xC0, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0x4C, 0x00, 0x62, 0x00, 0x31, 0x80, 0x18, 0xC0,
  0x18, 0x60, 0x0C, 0x18, 0x06, 0x0C, 0x02, 0x06, 0x03, 0x01, 0x01, 0x80,
  0xC0, 0xC0, 0x60, 0xC0, 0x30, 0x60, 0x0C, 0x30, 0x06, 0x10, 0x03, 0x18,
  0x00, 0x8C, 0x00, 0x66, 0x00, 0x32, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0xE0,
  0x06, 0xC0, 0x0F, 0x00, 0x64, 0x00, 0xB0, 0x06, 0x60, 0x0B, 0x00, 0x46,
  0x01, 0xB0, 0x0C, 0x60, 0x19, 0x00, 0xC6, 0x01, 0x98, 0x0C, 0x30, 0x11,
  0x80, 0xC3, 0x03, 0x18, 0x18, 0x30, 0x30, 0x81, 0x83, 0x03, 0x0C, 0x18,
  0x18, 0x20, 0xC1, 0x81, 0x86, 0x0C, 0x10, 0x18, 0x60, 0x43, 0x01, 0x86,
  0x06, 0x30, 0x0C, 0x40, 0x63, 0x00, 0xCC, 0x06, 0x20, 0x0C, 0xC0, 0x26,
  0x00, 0xCC, 0x03, 0x60, 0x04, 0x80, 0x36, 0x00, 0x78, 0x03, 0x40, 0x07,
  0x80, 0x14, 0x00, 0x78, 0x01, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x30, 0x01,
  0xC0, 0xE0, 0x03, 0x38, 0x03, 0x0C, 0x01, 0x83, 0x01, 0x81, 0x80, 0xC0,
  0x60, 0xC0, 0x30, 0x60, 0x0C, 0x60, 0x06, 0x30, 0x01, 0xB0, 0x00, 0xD8,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x06,
  0x30, 0x07, 0x18, 0x03, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC1, 0x80, 0x60,
  0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x03, 0x60, 0x01, 0xC0, 0x60, 0x00, 0xD8,
  0x00, 0x62, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x0C, 0x00, 0xC1, 0x80,
  0x30, 0x60, 0x0C, 0x18, 0x06, 0x02, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30,
  0x0C, 0x0C, 0x01, 0x83, 0x00, 0x60, 0x80, 0x18, 0x60, 0x02, 0x18, 0x00,
  0xC6, 0x00, 0x33, 0x00, 0x04, 0xC0, 0x01, 0xB0, 0x00, 0x68, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xF8, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x07, 0xC0, 0x70, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x7C, 0x03, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x3E, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x07, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x7C, 0x01, 0xE0, 0x38, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x3F, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x2F, 0xF8, 0x07,
  0x03, 0xC3, 0xC0, 0x1F, 0xE0, 0x00, 0x60,
};

const GFXglyph NotoSans_Condensed_ExtraLight50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 36, 11, 4, -36 },
  { 15, 10, 13, 16, 3, -36 },
  { 32, 23, 36, 25, 1, -36 },
  { 136, 18, 41, 23, 2, -38 },
  { 229, 28, 36, 33, 2, -36 },
  { 355, 22, 37, 25, 2, -36 },
  { 457, 3, 13, 9, 3, -36 },
  { 462, 10, 44, 13, 2, -36 },
  { 517, 9, 44, 13, 2, -36 },
  { 567, 16, 16, 21, 2, -38 },
  { 599, 19, 23, 23, 2, -29 },
  { 654, 5, 11, 10, 2, -5 },
  { 661, 12, 2, 14, 1, -15 },
  { 664, 4, 4, 10, 3, -4 },
  { 666, 15, 36, 17, 1, -36 },
  { 734, 18, 36, 23, 2, -36 },
  { 815, 10, 36, 23, 4, -36 },
  { 860, 18, 36, 23, 2, -36 },
  { 941, 18, 37, 23, 2, -36 },
  { 1025, 21, 36, 23, 1, -36 },
  { 1120, 17, 36, 23, 3, -36 },
  { 1197, 17, 37, 23, 3, -36 },
  { 1276, 18, 36, 23, 2, -36 },
  { 1357, 18, 37, 23, 2, -36 },
  { 1441, 18, 37, 23, 2, -36 },
  { 1525, 4, 27, 10, 3, -27 },
  { 1539, 5, 33, 10, 2, -27 },
  { 1560, 19, 22, 23, 2, -29 },
  { 1613, 19, 13, 23, 2, -24 },
  { 1644, 19, 22, 23, 2, -29 },
  { 1697, 14, 36, 16, 1, -36 },
  { 1760, 29, 41, 35, 3, -36 },
  { 1909, 23, 36, 23, 0, -36 },
  { 2013, 19, 36, 25, 4, -36 },
  { 2099, 20, 37, 24, 3, -36 },
  { 2192, 21, 36, 27, 4, -36 },
  { 2287, 15, 36, 22, 4, -36 },
  { 2355, 15, 36, 20, 4, -36 },
  { 2423, 23, 37, 29, 3, -36 },
  { 2530, 20, 36, 28, 4, -36 },
  { 2620, 8, 36, 13, 2, -36 },
  { 2656, 9, 45, 10, -3, -36 },
  { 2707, 18, 36, 22, 4, -36 },
  { 2788, 15, 36, 20, 4, -36 },
  { 2856, 28, 36, 36, 4, -36 },
  { 2982, 21, 36, 29, 4, -36 },
  { 3077, 24, 37, 30, 3, -36 },
  { 3188, 17, 36, 23, 4, -36 },
  { 3265, 24, 45, 30, 3, -36 },
  { 3400, 18, 36, 23, 4, -36 },
  { 3481, 18, 37, 22, 2, -36 },
  { 3565, 19, 36, 20, 0, -36 },
  { 3651, 20, 37, 28, 4, -36 },
  { 3744, 22, 36, 22, 0, -36 },
  { 3843, 35, 36, 36, 1, -36 },
  { 4001, 20, 36, 20, 0, -36 },
  { 4091, 19, 36, 19, 0, -36 },
  { 4177, 18, 36, 20, 1, -36 },
  { 4258, 10, 44, 16, 4, -36 },
  { 4313, 15, 36, 17, 1, -36 },
  { 4381, 9, 44, 16, 2, -36 },
  { 4431, 21, 19, 23, 1, -36 },
  { 4481, 20, 2, 20, 0, 4 },
  { 4486, 8, 8, 12, 2, -38 },
  { 4494, 15, 28, 21, 2, -27 },
  { 4547, 18, 39, 24, 4, -38 },
  { 4635, 15, 28, 18, 2, -27 },
  { 4688, 18, 39, 24, 2, -38 },
  { 4776, 17, 28, 22, 2, -27 },
  { 4836, 14, 38, 12, 0, -38 },
  { 4903, 18, 39, 24, 2, -27 },
  { 4991, 16, 38, 23, 4, -38 },
  { 5067, 3, 36, 10, 3, -36 },
  { 5081, 7, 48, 10, -1, -36 },
  { 5123, 15, 38, 19, 4, -38 },
  { 5195, 2, 38, 9, 4, -38 },
  { 5205, 27, 27, 35, 4, -27 },
  { 5297, 16, 27, 23, 4, -27 },
  { 5351, 19, 28, 23, 2, -27 },
  { 5418, 18, 39, 24, 4, -27 },
  { 5506, 18, 39, 24, 2, -27 },
  { 5594, 11, 27, 15, 4, -27 },
  { 5632, 14, 28, 18, 2, -27 },
  { 5681, 11, 34, 13, 1, -33 },
  { 5728, 16, 27, 23, 4, -26 },
  { 5782, 17, 26, 18, 0, -26 },
  { 5838, 28, 26, 29, 1, -26 },
  { 5929, 17, 26, 19, 1, -26 },
  { 5985, 18, 38, 18, 0, -26 },
  { 6071, 13, 26, 16, 2, -26 },
  { 6114, 13, 44, 17, 2, -36 },
  { 6186, 2, 50, 22, 10, -38 },
  { 6199, 13, 44, 17, 2, -36 },
  { 6271, 19, 5, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_ExtraLight50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight50pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT50PT7B_H_
