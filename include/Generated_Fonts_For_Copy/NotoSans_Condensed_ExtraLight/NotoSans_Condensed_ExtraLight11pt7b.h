#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT11PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFC, 0x29, 0x5E, 0xA5, 0x7D, 0x4A, 0x7A, 0xA6, 0x33, 0x3E,
  0x20, 0xCB, 0x4D, 0x3A, 0xF4, 0xD5, 0x57, 0x72, 0x94, 0x46, 0xCE, 0x2F,
  0xE0, 0x6A, 0xAA, 0x90, 0x95, 0x55, 0x60, 0x5E, 0x80, 0x21, 0x3E, 0x42,
  0x00, 0xC0, 0xE0, 0x80, 0x12, 0x22, 0x44, 0x88, 0xF6, 0xDB, 0x6F, 0x75,
  0x55, 0x71, 0x11, 0x12, 0x4F, 0xF1, 0x17, 0x11, 0x1F, 0x10, 0x8C, 0xA5,
  0x7C, 0x42, 0xF2, 0x62, 0x4F, 0x72, 0x7B, 0x6F, 0xF1, 0x11, 0x22, 0x24,
  0x79, 0x57, 0x59, 0x97, 0x79, 0x99, 0x71, 0x16, 0x84, 0x40, 0x18, 0x3A,
  0x30, 0x70, 0xFF, 0xC0, 0xC1, 0x87, 0xC0, 0xE4, 0x94, 0x82, 0x7A, 0x1B,
  0x75, 0xD7, 0x5A, 0xA0, 0x70, 0x21, 0x14, 0xA7, 0x46, 0x31, 0xE9, 0x9E,
  0x99, 0x9E, 0x78, 0x88, 0x88, 0x87, 0xE9, 0x99, 0x99, 0x9E, 0xF2, 0x79,
  0x27, 0xF2, 0x4F, 0x24, 0x7C, 0x21, 0x09, 0xC6, 0x2F, 0x99, 0x9F, 0x99,
  0x99, 0xD5, 0x57, 0x55, 0x55, 0x70, 0x9A, 0xC8, 0xCA, 0xA9, 0x92, 0x49,
  0x27, 0x86, 0x18, 0xF3, 0xCE, 0xDB, 0x69, 0x99, 0xDD, 0xBB, 0x99, 0x74,
  0x63, 0x18, 0xC6, 0x3E, 0xE9, 0x99, 0xE8, 0x88, 0x74, 0x63, 0x18, 0xC6,
  0x2E, 0x10, 0x80, 0xE9, 0x99, 0xEA, 0xA9, 0x78, 0x84, 0x31, 0x1F, 0xF2,
  0x22, 0x22, 0x22, 0x99, 0x99, 0x99, 0x9F, 0x8C, 0x64, 0xA5, 0x29, 0x84,
  0x91, 0x91, 0x99, 0x5A, 0x5A, 0x66, 0x24, 0x24, 0x95, 0x62, 0x26, 0x99,
  0x99, 0x56, 0x22, 0x22, 0xF1, 0x22, 0x24, 0x4F, 0xEA, 0xAA, 0xB0, 0x88,
  0x44, 0x22, 0x21, 0xE4, 0x92, 0x49, 0x3C, 0x22, 0x95, 0x10, 0xF0, 0xC0,
  0x71, 0x3D, 0x9F, 0x88, 0xE9, 0x99, 0x9E, 0xF2, 0x49, 0xC0, 0x27, 0xDB,
  0x6F, 0xF7, 0xC9, 0xC0, 0x6B, 0x24, 0x92, 0xF6, 0xDB, 0xC9, 0xC0, 0x93,
  0xDB, 0x6D, 0xBF, 0xBF, 0xE0, 0x92, 0xE9, 0xAD, 0xFF, 0xFE, 0x9A, 0x69,
  0xA6, 0x90, 0xF6, 0xDB, 0x40, 0xE9, 0x99, 0x9E, 0xE9, 0x99, 0x9E, 0x88,
  0x80, 0xF6, 0xDB, 0xC9, 0x20, 0xEA, 0xA0, 0x78, 0x42, 0x1E, 0x5D, 0x24,
  0x98, 0xB6, 0xDB, 0xC0, 0x99, 0xA6, 0x64, 0x96, 0x5B, 0x5B, 0x49, 0x20,
  0x96, 0x22, 0x69, 0x99, 0x56, 0x62, 0x44, 0x80, 0x64, 0xA5, 0xC0, 0x29,
  0x2C, 0x92, 0x44, 0xFF, 0xE0, 0xC8, 0x92, 0x49, 0x58, 0xF8,
};

const GFXglyph NotoSans_Condensed_ExtraLight11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 8, 2, 1, -8 },
  { 2, 2, 3, 4, 1, -8 },
  { 3, 5, 8, 5, 0, -8 },
  { 8, 4, 9, 5, 0, -8 },
  { 13, 6, 8, 7, 1, -8 },
  { 19, 5, 8, 5, 0, -8 },
  { 24, 1, 3, 2, 0, -8 },
  { 25, 2, 10, 3, 1, -8 },
  { 28, 2, 10, 3, 0, -8 },
  { 31, 3, 3, 5, 1, -8 },
  { 33, 5, 5, 5, 0, -6 },
  { 37, 1, 2, 2, 0, -1 },
  { 38, 3, 1, 3, 0, -3 },
  { 39, 1, 1, 2, 1, -1 },
  { 40, 4, 8, 4, 0, -8 },
  { 44, 3, 8, 5, 1, -8 },
  { 47, 2, 8, 5, 1, -8 },
  { 49, 4, 8, 5, 0, -8 },
  { 53, 4, 8, 5, 0, -8 },
  { 57, 5, 8, 5, 0, -8 },
  { 62, 3, 8, 5, 1, -8 },
  { 65, 3, 8, 5, 1, -8 },
  { 68, 4, 8, 5, 0, -8 },
  { 72, 4, 8, 5, 0, -8 },
  { 76, 4, 8, 5, 0, -8 },
  { 80, 1, 6, 2, 1, -6 },
  { 81, 2, 7, 2, 0, -6 },
  { 83, 5, 4, 5, 0, -6 },
  { 86, 5, 2, 5, 0, -5 },
  { 88, 5, 4, 5, 0, -6 },
  { 91, 3, 8, 3, 0, -8 },
  { 94, 6, 9, 8, 1, -8 },
  { 101, 5, 8, 5, 0, -8 },
  { 106, 4, 8, 5, 1, -8 },
  { 110, 4, 8, 5, 1, -8 },
  { 114, 4, 8, 6, 1, -8 },
  { 118, 3, 8, 5, 1, -8 },
  { 121, 3, 8, 4, 1, -8 },
  { 124, 5, 8, 6, 1, -8 },
  { 129, 4, 8, 6, 1, -8 },
  { 133, 2, 8, 3, 0, -8 },
  { 135, 2, 10, 2, -1, -8 },
  { 138, 4, 8, 5, 1, -8 },
  { 142, 3, 8, 4, 1, -8 },
  { 145, 6, 8, 8, 1, -8 },
  { 151, 4, 8, 6, 1, -8 },
  { 155, 5, 8, 7, 1, -8 },
  { 160, 4, 8, 5, 1, -8 },
  { 164, 5, 10, 7, 1, -8 },
  { 171, 4, 8, 5, 1, -8 },
  { 175, 4, 8, 5, 0, -8 },
  { 179, 4, 8, 4, 0, -8 },
  { 183, 4, 8, 6, 1, -8 },
  { 187, 5, 8, 5, 0, -8 },
  { 192, 8, 8, 8, 0, -8 },
  { 200, 4, 8, 4, 0, -8 },
  { 204, 4, 8, 4, 0, -8 },
  { 208, 4, 8, 4, 0, -8 },
  { 212, 2, 10, 3, 1, -8 },
  { 215, 4, 8, 4, 0, -8 },
  { 219, 3, 10, 3, 0, -8 },
  { 223, 5, 4, 5, 0, -8 },
  { 226, 4, 1, 4, 0, 1 },
  { 227, 2, 1, 3, 0, -8 },
  { 228, 4, 6, 5, 0, -6 },
  { 231, 4, 8, 5, 1, -8 },
  { 235, 3, 6, 4, 1, -6 },
  { 238, 3, 8, 5, 1, -8 },
  { 241, 3, 6, 5, 1, -6 },
  { 244, 3, 8, 3, 0, -8 },
  { 247, 3, 9, 5, 1, -6 },
  { 251, 3, 8, 5, 1, -8 },
  { 254, 1, 8, 2, 1, -8 },
  { 255, 1, 11, 2, 0, -8 },
  { 257, 3, 8, 4, 1, -8 },
  { 260, 1, 8, 2, 1, -8 },
  { 261, 6, 6, 8, 1, -6 },
  { 266, 3, 6, 5, 1, -6 },
  { 269, 4, 6, 5, 1, -6 },
  { 272, 4, 9, 5, 1, -6 },
  { 277, 3, 9, 5, 1, -6 },
  { 281, 2, 6, 3, 1, -6 },
  { 283, 4, 6, 4, 0, -6 },
  { 286, 3, 7, 3, 0, -7 },
  { 289, 3, 6, 5, 1, -6 },
  { 292, 4, 6, 4, 0, -6 },
  { 295, 6, 6, 6, 0, -6 },
  { 300, 4, 6, 4, 0, -6 },
  { 303, 4, 9, 4, 0, -6 },
  { 308, 3, 6, 4, 0, -6 },
  { 311, 3, 10, 4, 0, -8 },
  { 315, 1, 11, 5, 2, -8 },
  { 317, 3, 10, 4, 0, -8 },
  { 321, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_ExtraLight11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight11pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT11PT7B_H_
