#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT55PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight55pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x06, 0xFF, 0xE0, 0xC1, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06,
  0x00, 0x0C, 0x02, 0x00, 0x06, 0x01, 0x00, 0x03, 0x01, 0x80, 0x01, 0x00,
  0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30,
  0x08, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x04, 0x03, 0x00, 0x06,
  0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00,
  0x60, 0x10, 0x00, 0x30, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x08, 0x06, 0x00,
  0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x7F, 0xFF, 0xFF,
  0x00, 0xC0, 0x20, 0x00, 0x60, 0x30, 0x00, 0x20, 0x18, 0x00, 0x30, 0x0C,
  0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00,
  0x80, 0x01, 0x80, 0xC0, 0x00, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x07, 0xFF, 0x00, 0xFE, 0xFE, 0x1C, 0x60, 0xC3, 0x06,
  0x00, 0x70, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x0C, 0x06, 0x00, 0xC0,
  0x60, 0x0C, 0x06, 0x00, 0xE0, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x03,
  0x06, 0x00, 0x38, 0x60, 0x01, 0xE6, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x67, 0x80, 0x06, 0x1C, 0x00, 0x60,
  0xE0, 0x06, 0x06, 0x00, 0x60, 0x70, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06,
  0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x70, 0x06, 0x06, 0x00,
  0x60, 0xEC, 0x06, 0x1C, 0xFC, 0x6F, 0x83, 0xFF, 0xE0, 0x01, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x0C, 0x03, 0x0C, 0x00, 0x60, 0x18, 0x38, 0x01,
  0x80, 0x60, 0x60, 0x0C, 0x03, 0x01, 0x80, 0x30, 0x0C, 0x02, 0x00, 0x80,
  0x30, 0x0C, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x00, 0xC0, 0xC0, 0x0C,
  0x03, 0x03, 0x00, 0x30, 0x0C, 0x08, 0x00, 0xC0, 0x30, 0x60, 0x03, 0x00,
  0xC1, 0x80, 0x0C, 0x03, 0x0C, 0x00, 0x30, 0x0C, 0x30, 0x00, 0xC0, 0x30,
  0x83, 0xE3, 0x00, 0xC6, 0x1F, 0xCC, 0x02, 0x18, 0xC3, 0xB0, 0x18, 0xC6,
  0x06, 0x60, 0x63, 0x18, 0x19, 0x83, 0x88, 0x60, 0x33, 0x0C, 0x63, 0x00,
  0xCF, 0xE1, 0x8C, 0x03, 0x0F, 0x0C, 0x30, 0x0C, 0x00, 0x30, 0xC0, 0x30,
  0x00, 0xC3, 0x00, 0xC0, 0x06, 0x0C, 0x03, 0x00, 0x18, 0x30, 0x0C, 0x00,
  0xC0, 0xC0, 0x30, 0x03, 0x03, 0x00, 0xC0, 0x0C, 0x0C, 0x03, 0x00, 0x60,
  0x30, 0x0C, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0xC0, 0x30, 0x06,
  0x02, 0x00, 0xC0, 0x18, 0x18, 0x06, 0x00, 0x30, 0x60, 0x18, 0x00, 0xE7,
  0x00, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x30, 0x00,
  0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x08, 0x03, 0x00,
  0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0x30, 0x30, 0x00, 0x18, 0x38, 0x00, 0x06, 0x18, 0x00, 0x03, 0x38,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x60, 0xE0, 0x0C, 0x70, 0x30, 0x0C, 0x30,
  0x0C, 0x06, 0x30, 0x07, 0x03, 0x18, 0x01, 0x81, 0x9C, 0x00, 0x60, 0xCC,
  0x00, 0x38, 0xC6, 0x00, 0x0C, 0x63, 0x00, 0x03, 0x71, 0x80, 0x01, 0xF0,
  0xC0, 0x00, 0x78, 0x30, 0x00, 0x38, 0x18, 0x00, 0x1E, 0x0E, 0x00, 0x1B,
  0x83, 0x00, 0x1C, 0xC1, 0xC0, 0x1C, 0x30, 0x7C, 0xF8, 0x1C, 0x0F, 0xF8,
  0x07, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0xC0,
  0x70, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x01, 0xC0,
  0x60, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x07, 0xE0, 0x1C, 0x03,
  0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C,
  0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0E,
  0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x03, 0x02, 0x0F,
  0xF1, 0x1F, 0x1F, 0xFC, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x6C, 0x00, 0x63,
  0x00, 0x61, 0x80, 0x70, 0x60, 0x30, 0x18, 0x30, 0x0E, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x18, 0xC6, 0x73, 0x98, 0xC6, 0x63, 0x18, 0x8C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x3C, 0x38,
  0x0E, 0x03, 0x81, 0x80, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x0E,
  0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x70, 0x00, 0x6C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCE,
  0x00, 0x30, 0xC0, 0x06, 0x1C, 0x01, 0xC1, 0x80, 0x30, 0x18, 0x0C, 0x03,
  0xFF, 0x80, 0x1F, 0xC0, 0x01, 0xC0, 0xF0, 0x7C, 0x3B, 0x1C, 0xDC, 0x3E,
  0x0F, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0xF0, 0x00, 0xFF, 0xE0, 0x3E, 0x0F,
  0x07, 0x00, 0x38, 0x20, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x00,
  0xFF, 0xE0, 0x3C, 0x0F, 0x0F, 0x00, 0x38, 0x40, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xCE, 0x00, 0x38, 0xFE, 0x3F, 0x03, 0xFF,
  0xC0, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30,
  0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x61, 0x80, 0x01, 0xC3, 0x00,
  0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x18, 0x03, 0x00, 0x70,
  0x06, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x18, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0x87,
  0xFF, 0xF0, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x04, 0x00, 0x7F,
  0xFC, 0x0F, 0xC7, 0xC1, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x40, 0x01, 0xCC, 0x00,
  0xF1, 0xF8, 0xF8, 0x0F, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0xF0, 0x0F, 0x82, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC1, 0xFC,
  0x18, 0xFF, 0xE3, 0x38, 0x1E, 0x6C, 0x00, 0xCF, 0x00, 0x1D, 0xC0, 0x01,
  0xB8, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x03,
  0x60, 0x00, 0x6C, 0x00, 0x1C, 0xC0, 0x03, 0x18, 0x00, 0x61, 0x80, 0x18,
  0x38, 0x07, 0x03, 0xC3, 0xC0, 0x3F, 0xE0, 0x00, 0x60, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0x07, 0x81, 0xC0, 0x1C, 0x38, 0x00,
  0xC3, 0x00, 0x06, 0x30, 0x00, 0x67, 0x00, 0x06, 0x70, 0x00, 0x67, 0x00,
  0x06, 0x70, 0x00, 0x63, 0x00, 0x06, 0x30, 0x00, 0x63, 0x80, 0x0C, 0x18,
  0x01, 0xC0, 0xC0, 0x38, 0x07, 0x07, 0x00, 0x38, 0xE0, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x03, 0xDC, 0x00, 0x70, 0xF0, 0x0E, 0x03, 0x81, 0x80, 0x1C,
  0x30, 0x00, 0xE7, 0x00, 0x06, 0x60, 0x00, 0x76, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x36, 0x00,
  0x03, 0x60, 0x00, 0x77, 0x00, 0x06, 0x38, 0x00, 0xE1, 0xC0, 0x1C, 0x0F,
  0x8F, 0x80, 0x7F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE0,
  0x0F, 0x0F, 0x01, 0xC0, 0x38, 0x38, 0x01, 0x83, 0x00, 0x0C, 0x70, 0x00,
  0xC6, 0x00, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x6E, 0x00,
  0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60,
  0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x0F, 0x30, 0x01, 0xB1,
  0x80, 0x33, 0x1E, 0x07, 0x30, 0xFF, 0xC7, 0x03, 0xF8, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x38, 0xF8, 0x03, 0xFF, 0x00, 0x02,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x39, 0xCE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x18, 0xCE, 0x73, 0x18, 0xCC, 0x63, 0x31, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0xFF, 0xE3, 0xC1, 0xE2, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x06,
  0x30, 0x03, 0xFC, 0x06, 0x60, 0x07, 0xFE, 0x03, 0x60, 0x0C, 0x06, 0x03,
  0x60, 0x18, 0x0C, 0x03, 0x60, 0x38, 0x0C, 0x03, 0xC0, 0x30, 0x0C, 0x03,
  0xC0, 0x30, 0x0C, 0x03, 0xC0, 0x60, 0x0C, 0x03, 0xC0, 0x60, 0x0C, 0x03,
  0xC0, 0x60, 0x0C, 0x03, 0xC0, 0x60, 0x0C, 0x03, 0xC0, 0x60, 0x0C, 0x03,
  0xC0, 0x60, 0x0C, 0x03, 0xC0, 0x60, 0x0C, 0x03, 0xC0, 0x60, 0x0C, 0x03,
  0xC0, 0x60, 0x1C, 0x03, 0xC0, 0x60, 0x1C, 0x06, 0xC0, 0x30, 0x14, 0x06,
  0xC0, 0x30, 0x36, 0x0E, 0x60, 0x18, 0x67, 0x1C, 0x60, 0x1F, 0xC3, 0xF8,
  0x60, 0x07, 0x81, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x01, 0x00,
  0x01, 0xE0, 0x06, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x01, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18,
  0x30, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03,
  0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00,
  0x60, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06,
  0x03, 0x00, 0x03, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xE0, 0x00,
  0x30, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x1C, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x06, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xC0, 0x07, 0x8C, 0x00, 0x1C,
  0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xEC, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x00, 0xCC, 0x00,
  0x0C, 0xC0, 0x01, 0xCC, 0x00, 0x38, 0xC0, 0x07, 0x0F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0C, 0x01, 0xF0, 0xC0, 0x03, 0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xEC,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x0E, 0xC0, 0x00, 0xCC, 0x00, 0x38, 0xC0, 0x0F, 0x8F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xE0, 0x1F, 0x03,
  0xC0, 0xE0, 0x02, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x30, 0x1F, 0xDF, 0xC0, 0x1F, 0xFC, 0x00, 0x02, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x0C, 0x00, 0xF0, 0x30, 0x00, 0xE0, 0xC0, 0x01, 0xC3, 0x00,
  0x03, 0x8C, 0x00, 0x07, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00,
  0xEC, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0,
  0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xEC, 0x00, 0x03, 0x30, 0x00,
  0x1C, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x8C, 0x00, 0x1C, 0x30, 0x01, 0xE0,
  0xC0, 0x1F, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x07, 0x00, 0x00, 0xC0, 0xF0, 0x00,
  0x70, 0x0F, 0xC7, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0x00, 0x00, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0xFF, 0x86, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC1,
  0xFB, 0xFE, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0xE8,
  0x73, 0xFC, 0x7C, 0x00, 0xC0, 0x00, 0xEC, 0x00, 0x1C, 0xC0, 0x01, 0x8C,
  0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00, 0xE0, 0xC0, 0x0C, 0x0C, 0x01, 0xC0,
  0xC0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x0E, 0x00, 0xC0, 0xC0,
  0x0C, 0x18, 0x00, 0xC3, 0x80, 0x0C, 0x70, 0x00, 0xC6, 0x00, 0x0C, 0xF0,
  0x00, 0xDF, 0x00, 0x0D, 0xB8, 0x00, 0xF1, 0x80, 0x0E, 0x1C, 0x00, 0xE0,
  0xC0, 0x0C, 0x0E, 0x00, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0C,
  0x01, 0x80, 0xC0, 0x1C, 0x0C, 0x00, 0xC0, 0xC0, 0x0E, 0x0C, 0x00, 0x60,
  0xC0, 0x03, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0x8C, 0x00, 0x1C, 0xC0, 0x00,
  0xCC, 0x00, 0x0E, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x6F, 0x60, 0x00, 0x01, 0xBD, 0x80,
  0x00, 0x06, 0xF6, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x00, 0xCF, 0x30, 0x00,
  0x03, 0x3C, 0xC0, 0x00, 0x18, 0xF1, 0x80, 0x00, 0x63, 0xC6, 0x00, 0x01,
  0x8F, 0x18, 0x00, 0x0C, 0x3C, 0x30, 0x00, 0x30, 0xF0, 0xC0, 0x00, 0xC3,
  0xC3, 0x00, 0x06, 0x0F, 0x06, 0x00, 0x18, 0x3C, 0x18, 0x00, 0x60, 0xF0,
  0x60, 0x03, 0x03, 0xC0, 0xC0, 0x0C, 0x0F, 0x03, 0x00, 0x30, 0x3C, 0x0C,
  0x01, 0x80, 0xF0, 0x18, 0x06, 0x03, 0xC0, 0x60, 0x18, 0x0F, 0x01, 0x80,
  0xC0, 0x3C, 0x07, 0x03, 0x00, 0xF0, 0x0C, 0x0C, 0x03, 0xC0, 0x30, 0x60,
  0x0F, 0x00, 0xE1, 0x80, 0x3C, 0x01, 0x86, 0x00, 0xF0, 0x06, 0x30, 0x03,
  0xC0, 0x1C, 0xC0, 0x0F, 0x00, 0x33, 0x00, 0x3C, 0x00, 0xD8, 0x00, 0xF0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xC0, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x60, 0x00, 0x3D, 0x80, 0x00, 0xF3, 0x00,
  0x03, 0xCC, 0x00, 0x0F, 0x18, 0x00, 0x3C, 0x60, 0x00, 0xF0, 0xC0, 0x03,
  0xC3, 0x00, 0x0F, 0x06, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x30, 0x03, 0xC0,
  0xE0, 0x0F, 0x01, 0x80, 0x3C, 0x07, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x38,
  0x0F, 0x00, 0x60, 0x3C, 0x01, 0xC0, 0xF0, 0x03, 0x03, 0xC0, 0x0E, 0x0F,
  0x00, 0x18, 0x3C, 0x00, 0x70, 0xF0, 0x00, 0xC3, 0xC0, 0x03, 0x8F, 0x00,
  0x06, 0x3C, 0x00, 0x1C, 0xF0, 0x00, 0x33, 0xC0, 0x00, 0xEF, 0x00, 0x01,
  0xBC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x0F,
  0x80, 0x1C, 0x00, 0xF0, 0x0E, 0x00, 0x0C, 0x07, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0x60, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x67, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30,
  0x00, 0x03, 0x86, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x38,
  0x0E, 0x00, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x3F, 0xBF, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0C, 0x01, 0xE3,
  0x00, 0x1C, 0xC0, 0x03, 0xB0, 0x00, 0x6C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xEC, 0x00, 0x73,
  0x00, 0x38, 0xC1, 0xFC, 0x3F, 0xFC, 0x0F, 0xE0, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x1C, 0x00, 0xF0, 0x0E, 0x00,
  0x0C, 0x07, 0x00, 0x01, 0x81, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00, 0x07,
  0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x86, 0x00, 0x00, 0xC1,
  0xC0, 0x00, 0x70, 0x30, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0x3F, 0xBF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x05, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xC0, 0x0E, 0x0C, 0x00, 0x70, 0xC0,
  0x03, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC,
  0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x1C,
  0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00, 0x70, 0xC0, 0x0E,
  0x0C, 0x07, 0xC0, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xC0, 0x60, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0xC0, 0xC0,
  0x0C, 0x0C, 0x00, 0xE0, 0xC0, 0x06, 0x0C, 0x00, 0x70, 0xC0, 0x03, 0x0C,
  0x00, 0x38, 0xC0, 0x01, 0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xCC, 0x00, 0x0E,
  0xC0, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0x03, 0xE1, 0xC0,
  0x02, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xCC,
  0x00, 0x78, 0xFF, 0x7F, 0x03, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0xDC, 0x00, 0x01, 0x98, 0x00, 0x03, 0x30, 0x00,
  0x06, 0x60, 0x00, 0x1C, 0xE0, 0x00, 0x30, 0xC0, 0x00, 0xE0, 0xC0, 0x01,
  0x81, 0xE0, 0x0E, 0x01, 0xFD, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x08, 0x00,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x38, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x60,
  0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x01, 0x81, 0xC0,
  0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x00, 0xC3, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xD8,
  0x00, 0x1E, 0x00, 0x07, 0x60, 0x00, 0x78, 0x00, 0x19, 0x80, 0x01, 0xE0,
  0x00, 0x66, 0x00, 0x0D, 0x80, 0x01, 0x9C, 0x00, 0x33, 0x00, 0x0E, 0x30,
  0x00, 0xCC, 0x00, 0x30, 0xC0, 0x03, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0xC0,
  0x03, 0x0C, 0x00, 0x61, 0x80, 0x1C, 0x18, 0x01, 0x86, 0x00, 0x60, 0x60,
  0x06, 0x18, 0x01, 0x81, 0x80, 0x18, 0x60, 0x06, 0x06, 0x00, 0xC1, 0x80,
  0x38, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x0E, 0x06, 0x01, 0x81,
  0xC0, 0x18, 0x18, 0x06, 0x06, 0x00, 0x60, 0x60, 0x18, 0x18, 0x01, 0x81,
  0x80, 0x60, 0x60, 0x06, 0x0C, 0x01, 0x83, 0x80, 0x0C, 0x30, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x03, 0x0C,
  0x00, 0xC7, 0x00, 0x0E, 0x60, 0x01, 0x98, 0x00, 0x19, 0x80, 0x06, 0x60,
  0x00, 0x66, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x66, 0x00, 0x06, 0xC0,
  0x01, 0xB0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x18, 0xE0, 0x00, 0xC1, 0x80, 0x03, 0x07,
  0x00, 0x1C, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x70, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x38, 0x30, 0x00, 0x60, 0xC0,
  0x01, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x31, 0x80, 0x01, 0x86, 0x00,
  0x06, 0x1C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xE0, 0x07, 0x01, 0x80, 0x18,
  0x06, 0x00, 0xE0, 0x0C, 0x03, 0x00, 0x30, 0x1C, 0x00, 0xE0, 0x60, 0x01,
  0x83, 0x80, 0x07, 0x0C, 0x00, 0x0C, 0x70, 0x00, 0x39, 0x80, 0x00, 0x6E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1B, 0x00, 0x01, 0xD8, 0x00, 0x0C, 0xE0,
  0x00, 0x63, 0x00, 0x06, 0x1C, 0x00, 0x30, 0x60, 0x03, 0x83, 0x00, 0x18,
  0x1C, 0x00, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x07, 0x00, 0x60,
  0x30, 0x03, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x8E, 0x00,
  0x0C, 0x60, 0x00, 0x73, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF,
  0xDF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x06, 0x60, 0x00, 0x18, 0xC0, 0x00,
  0x70, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x81, 0x80, 0x06, 0x03, 0x00, 0x1C,
  0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x06, 0x01, 0x80, 0x0C, 0x07, 0x00,
  0x0C, 0x0C, 0x00, 0x18, 0x38, 0x00, 0x18, 0x60, 0x00, 0x31, 0xC0, 0x00,
  0x77, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x38,
  0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x00, 0xE0, 0x07,
  0xFE, 0x0F, 0x87, 0x82, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0xFC, 0x0F, 0xFE, 0x1F, 0x03, 0x1C, 0x01, 0x98, 0x00, 0xD8,
  0x00, 0x6C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xB0, 0x03, 0xD8, 0x01, 0x6E, 0x01, 0xB3, 0xC3, 0x98, 0xFF,
  0x8C, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x70, 0x0C,
  0x3F, 0xE0, 0xC7, 0x0F, 0x0C, 0xC0, 0x38, 0xD8, 0x01, 0xCD, 0x00, 0x0C,
  0xF0, 0x00, 0xCE, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0,
  0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xF0, 0x00, 0xCD,
  0x00, 0x1C, 0xD8, 0x01, 0x8C, 0xC0, 0x38, 0xC7, 0x9F, 0x0C, 0x3F, 0xC0,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x03, 0xFF, 0x0F, 0x87, 0x1C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x01, 0x0F,
  0xDF, 0x07, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x0E, 0x06,
  0x0F, 0xF8, 0xC3, 0xC3, 0x98, 0xE0, 0x1B, 0x38, 0x01, 0x66, 0x00, 0x3D,
  0x80, 0x03, 0xB0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x01, 0xB0, 0x00, 0x76, 0x00, 0x0E, 0xE0, 0x03, 0xCC,
  0x00, 0x58, 0xE0, 0x3B, 0x1F, 0x1E, 0x60, 0xFF, 0x04, 0x01, 0x00, 0x00,
  0x00, 0x40, 0x01, 0xFF, 0x00, 0xF1, 0xE0, 0x70, 0x1C, 0x38, 0x03, 0x0C,
  0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x02, 0x0F, 0x8F, 0x80, 0xFF, 0xC0, 0x02, 0x00, 0x01, 0xFC,
  0x0F, 0xF0, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x03, 0xFF, 0x8F, 0xFE,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0xFF, 0x8C, 0x3C, 0x39, 0x8E, 0x01, 0xB3, 0x80, 0x1E,
  0x60, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3B, 0x00, 0x07, 0x60, 0x00, 0xEE,
  0x00, 0x3C, 0xC0, 0x0D, 0x8C, 0x03, 0x30, 0xF1, 0xE6, 0x0F, 0xF0, 0xC0,
  0x20, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x72, 0x00, 0x1C, 0x60,
  0x07, 0x0F, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0xE0,
  0x30, 0xFF, 0x0C, 0x71, 0xF3, 0x30, 0x1C, 0xD8, 0x03, 0xB4, 0x00, 0x6F,
  0x00, 0x1B, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0xFF, 0xF0, 0x00, 0x00, 0x6D, 0xB6,
  0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0x06, 0x07, 0x07,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E,
  0xFC, 0xF8, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x3B, 0x00, 0x39, 0x80, 0x18,
  0xC0, 0x18, 0x60, 0x1C, 0x30, 0x0C, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x0E,
  0x03, 0x06, 0x01, 0x86, 0x00, 0xC7, 0x00, 0x63, 0x80, 0x33, 0x60, 0x1B,
  0x30, 0x0D, 0x8C, 0x07, 0x86, 0x03, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x30,
  0x60, 0x18, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x00, 0xC6, 0x00, 0x63, 0x00,
  0x19, 0x80, 0x0C, 0xC0, 0x03, 0x60, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x03, 0x83, 0x1F,
  0xE0, 0x7F, 0x8C, 0xE1, 0xC3, 0x8F, 0x36, 0x03, 0x98, 0x0E, 0xD0, 0x06,
  0x40, 0x1F, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xF8, 0x00, 0xE0,
  0x03, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00,
  0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C,
  0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00,
  0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03,
  0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0,
  0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00,
  0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xF0, 0x30, 0xFF, 0x0C, 0x71, 0xF3, 0x30, 0x0C, 0xD8, 0x03, 0xB4,
  0x00, 0x6E, 0x00, 0x1B, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x7F,
  0xC0, 0x0F, 0x0F, 0x01, 0xC0, 0x38, 0x30, 0x01, 0x87, 0x00, 0x0C, 0x60,
  0x00, 0xC6, 0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0xE0, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0xC3, 0x00,
  0x0C, 0x38, 0x01, 0x81, 0xC0, 0x38, 0x0F, 0x9F, 0x00, 0x7F, 0xC0, 0x00,
  0x40, 0x00, 0x00, 0x70, 0x0C, 0x3F, 0xE0, 0xC7, 0x0F, 0x0C, 0xC0, 0x38,
  0xD8, 0x01, 0xCD, 0x00, 0x0C, 0xF0, 0x00, 0xCE, 0x00, 0x06, 0xE0, 0x00,
  0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x6E,
  0x00, 0x0E, 0xF0, 0x00, 0xCD, 0x00, 0x1C, 0xD8, 0x01, 0x8C, 0xC0, 0x38,
  0xC7, 0x9F, 0x0C, 0x3F, 0xC0, 0xC0, 0x20, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x8C, 0x3C, 0x79, 0x8E, 0x01, 0xB3,
  0x80, 0x16, 0x60, 0x03, 0xD8, 0x00, 0x3B, 0x00, 0x07, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x3B, 0x00, 0x07, 0x60,
  0x00, 0xEE, 0x00, 0x3C, 0xE0, 0x0D, 0x8E, 0x03, 0x31, 0xF3, 0xC6, 0x0F,
  0xF0, 0xC0, 0x20, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0xCC, 0x3F,
  0xC7, 0xFC, 0xC0, 0xD8, 0x0D, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x0F, 0xFE, 0x3E, 0x1E,
  0x30, 0x02, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0xC0, 0x0C, 0xFC, 0xFC, 0x3F, 0xF0, 0x03, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x0F, 0xFF, 0xFF, 0xF1, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0F,
  0x30, 0x7F, 0x01, 0x80, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x0B, 0x60, 0x02,
  0xD8, 0x01, 0xB7, 0x00, 0xCC, 0xF1, 0xE3, 0x1F, 0xF0, 0xC0, 0x40, 0x00,
  0xC0, 0x00, 0x6C, 0x00, 0x1D, 0x80, 0x03, 0x30, 0x00, 0x67, 0x00, 0x0C,
  0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x18, 0x03, 0x83, 0x00, 0x60,
  0x60, 0x0C, 0x0E, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80,
  0x30, 0x30, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x01, 0x8C, 0x00,
  0x31, 0x80, 0x06, 0x30, 0x00, 0x66, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00,
  0x36, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0x60, 0x06, 0x80, 0x19, 0x80, 0x1B, 0x00, 0x66, 0x00, 0x4C, 0x01, 0x9C,
  0x03, 0x30, 0x06, 0x30, 0x0C, 0x40, 0x30, 0xC0, 0x31, 0x80, 0xC3, 0x00,
  0xC6, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x18, 0x18, 0x60, 0x30, 0x60, 0x60,
  0xC1, 0x81, 0x83, 0x83, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x0C, 0x30, 0x30,
  0x60, 0x30, 0xC0, 0x63, 0x00, 0xC7, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30,
  0x06, 0x60, 0x18, 0xC0, 0x19, 0x80, 0x36, 0x00, 0x66, 0x00, 0xD8, 0x01,
  0xB0, 0x03, 0x60, 0x03, 0xC0, 0x0D, 0x80, 0x0F, 0x00, 0x14, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x60, 0x00,
  0xCE, 0x00, 0x30, 0xC0, 0x06, 0x1C, 0x01, 0x81, 0x80, 0x70, 0x18, 0x0C,
  0x03, 0x03, 0x80, 0x30, 0x60, 0x06, 0x1C, 0x00, 0x63, 0x00, 0x0C, 0xE0,
  0x00, 0xD8, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xB0, 0x00, 0x66, 0x00, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0x60, 0xC0,
  0x18, 0x1C, 0x03, 0x01, 0x80, 0xC0, 0x38, 0x38, 0x03, 0x06, 0x00, 0x71,
  0xC0, 0x06, 0x30, 0x00, 0xEE, 0x00, 0x0E, 0x60, 0x00, 0x76, 0x00, 0x06,
  0x70, 0x00, 0x63, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00,
  0xC1, 0x80, 0x18, 0x18, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x03, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x06, 0x06, 0x00, 0x60, 0x60, 0x03,
  0x06, 0x00, 0x30, 0xE0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x8C, 0x00,
  0x19, 0x80, 0x01, 0x98, 0x00, 0x0D, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x3E, 0x01, 0xFC, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x07, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x01, 0xFC, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1F,
  0x00, 0x7E, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x3F, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x0B,
  0xFF, 0x00, 0x78, 0x3E, 0x0F, 0x00, 0x7F, 0xE8, 0x00, 0xFC, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLight55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 39, 12, 4, -39 },
  { 21, 10, 14, 18, 4, -39 },
  { 39, 25, 39, 27, 1, -39 },
  { 161, 20, 45, 25, 2, -42 },
  { 274, 30, 41, 36, 3, -40 },
  { 428, 25, 41, 27, 2, -40 },
  { 557, 2, 14, 10, 4, -39 },
  { 561, 10, 48, 15, 3, -39 },
  { 621, 10, 48, 15, 2, -39 },
  { 681, 17, 17, 23, 3, -42 },
  { 718, 21, 25, 25, 2, -32 },
  { 784, 5, 13, 10, 2, -6 },
  { 793, 12, 2, 16, 2, -16 },
  { 796, 3, 4, 11, 4, -4 },
  { 798, 17, 39, 18, 1, -39 },
  { 881, 19, 40, 25, 3, -40 },
  { 976, 10, 39, 25, 5, -39 },
  { 1025, 20, 40, 25, 2, -40 },
  { 1125, 20, 41, 25, 2, -40 },
  { 1228, 23, 39, 25, 1, -39 },
  { 1341, 19, 40, 25, 3, -39 },
  { 1436, 19, 41, 25, 3, -40 },
  { 1534, 20, 39, 25, 2, -39 },
  { 1632, 20, 41, 25, 2, -40 },
  { 1735, 20, 41, 25, 2, -40 },
  { 1838, 3, 29, 11, 4, -29 },
  { 1849, 5, 36, 11, 2, -29 },
  { 1872, 21, 23, 25, 2, -31 },
  { 1933, 21, 13, 25, 2, -26 },
  { 1968, 21, 23, 25, 2, -31 },
  { 2029, 15, 40, 17, 1, -40 },
  { 2104, 32, 44, 38, 3, -39 },
  { 2280, 25, 39, 25, 0, -39 },
  { 2402, 20, 39, 27, 5, -39 },
  { 2500, 22, 41, 26, 3, -40 },
  { 2613, 22, 39, 30, 5, -39 },
  { 2721, 16, 39, 24, 5, -39 },
  { 2799, 16, 39, 22, 5, -39 },
  { 2877, 26, 41, 32, 3, -40 },
  { 3011, 21, 39, 31, 5, -39 },
  { 3114, 9, 39, 14, 2, -39 },
  { 3158, 10, 49, 11, -3, -39 },
  { 3220, 20, 39, 25, 5, -39 },
  { 3318, 16, 39, 22, 5, -39 },
  { 3396, 30, 39, 40, 5, -39 },
  { 3543, 22, 39, 32, 5, -39 },
  { 3651, 26, 41, 33, 3, -40 },
  { 3785, 18, 39, 25, 5, -39 },
  { 3873, 26, 49, 33, 3, -40 },
  { 4033, 20, 39, 26, 5, -39 },
  { 4131, 20, 41, 24, 2, -40 },
  { 4234, 21, 39, 22, 0, -39 },
  { 4337, 23, 40, 31, 4, -39 },
  { 4452, 24, 39, 24, 0, -39 },
  { 4569, 38, 39, 40, 1, -39 },
  { 4755, 22, 39, 22, 0, -39 },
  { 4863, 21, 39, 21, 0, -39 },
  { 4966, 19, 39, 22, 2, -39 },
  { 5059, 10, 48, 17, 5, -39 },
  { 5119, 17, 39, 18, 1, -39 },
  { 5202, 10, 48, 17, 2, -39 },
  { 5262, 23, 20, 25, 1, -39 },
  { 5320, 22, 2, 22, 0, 5 },
  { 5326, 9, 9, 13, 2, -42 },
  { 5337, 17, 31, 23, 2, -30 },
  { 5403, 20, 43, 26, 4, -42 },
  { 5511, 16, 31, 20, 3, -30 },
  { 5573, 19, 43, 26, 3, -42 },
  { 5676, 18, 31, 24, 3, -30 },
  { 5746, 14, 42, 13, 1, -42 },
  { 5820, 19, 43, 26, 3, -30 },
  { 5923, 18, 42, 26, 4, -42 },
  { 6018, 3, 40, 11, 4, -40 },
  { 6033, 8, 53, 11, -1, -40 },
  { 6086, 17, 42, 21, 4, -42 },
  { 6176, 2, 42, 10, 4, -42 },
  { 6187, 30, 30, 38, 4, -30 },
  { 6300, 18, 30, 26, 4, -30 },
  { 6368, 20, 31, 25, 3, -30 },
  { 6446, 20, 43, 26, 4, -30 },
  { 6554, 19, 43, 26, 3, -30 },
  { 6657, 12, 30, 17, 4, -30 },
  { 6702, 16, 31, 20, 2, -30 },
  { 6764, 12, 37, 14, 1, -36 },
  { 6820, 18, 30, 26, 4, -29 },
  { 6888, 19, 29, 19, 0, -29 },
  { 6957, 30, 29, 32, 1, -29 },
  { 7066, 19, 29, 21, 1, -29 },
  { 7135, 20, 42, 20, 0, -29 },
  { 7240, 14, 29, 18, 2, -29 },
  { 7291, 15, 48, 19, 2, -39 },
  { 7381, 2, 55, 24, 11, -42 },
  { 7395, 15, 48, 19, 2, -39 },
  { 7485, 21, 5, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_ExtraLight55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight55pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT55PT7B_H_
