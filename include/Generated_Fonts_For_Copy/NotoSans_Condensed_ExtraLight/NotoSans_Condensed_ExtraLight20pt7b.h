#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT20PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight20pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x50, 0x30, 0x99, 0x99, 0x90, 0x09, 0x08, 0x84, 0x42,
  0x27, 0xF8, 0x90, 0x48, 0x24, 0x22, 0x7F, 0xC8, 0x84, 0x42, 0x41, 0x20,
  0x10, 0xFA, 0x44, 0x89, 0x12, 0x14, 0x18, 0x1C, 0x24, 0x48, 0x91, 0x3B,
  0x8C, 0x08, 0xF0, 0x92, 0x22, 0x24, 0x45, 0x08, 0xA1, 0x15, 0xA5, 0x4A,
  0xA9, 0x29, 0x21, 0x44, 0x28, 0x88, 0x91, 0x12, 0x41, 0x80, 0x78, 0x22,
  0x11, 0x08, 0x84, 0x81, 0x80, 0xC0, 0xA0, 0x89, 0x42, 0xA1, 0x50, 0x48,
  0x53, 0xCC, 0xF8, 0x32, 0x44, 0x88, 0x88, 0x88, 0x88, 0x84, 0x42, 0x30,
  0x89, 0x12, 0x49, 0x24, 0x92, 0x52, 0x80, 0x10, 0x4F, 0xC4, 0x29, 0x20,
  0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10, 0x20, 0x6A, 0x80, 0xF0,
  0xC0, 0x04, 0x10, 0x42, 0x08, 0x41, 0x04, 0x20, 0x82, 0x10, 0x42, 0x00,
  0x7C, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x14, 0x47,
  0x00, 0x2E, 0x92, 0x49, 0x24, 0x92, 0x40, 0xFC, 0x08, 0x08, 0x10, 0x20,
  0x81, 0x04, 0x08, 0x20, 0x82, 0x08, 0x1F, 0xC0, 0xFC, 0x08, 0x08, 0x10,
  0x40, 0x8E, 0x06, 0x02, 0x04, 0x08, 0x10, 0x5F, 0x00, 0x02, 0x03, 0x02,
  0x81, 0x41, 0x20, 0x90, 0x88, 0x44, 0x42, 0x41, 0x1F, 0xE0, 0x40, 0x20,
  0x10, 0x7C, 0x82, 0x04, 0x08, 0x17, 0x31, 0x01, 0x02, 0x04, 0x08, 0x10,
  0x5F, 0x00, 0x3E, 0x81, 0x04, 0x08, 0x17, 0x31, 0x41, 0x83, 0x06, 0x0C,
  0x14, 0x27, 0x80, 0xFE, 0x04, 0x10, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20,
  0x41, 0x02, 0x0C, 0x00, 0x7D, 0x06, 0x0C, 0x14, 0x45, 0x8C, 0x26, 0x83,
  0x06, 0x0C, 0x18, 0x2F, 0x80, 0x7D, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xA7,
  0x32, 0x04, 0x08, 0x20, 0x8F, 0x00, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x1A,
  0xA0, 0x06, 0x31, 0x84, 0x04, 0x06, 0x03, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0xC0, 0x60, 0x30, 0x10, 0x43, 0x18, 0x40, 0xF8, 0x10, 0x41, 0x04,
  0x21, 0x08, 0x20, 0x80, 0x00, 0x00, 0x80, 0x1F, 0x82, 0x04, 0x40, 0x24,
  0x02, 0x87, 0x18, 0x91, 0x91, 0x19, 0x11, 0x91, 0x19, 0x11, 0x8A, 0xA8,
  0x4C, 0x40, 0x04, 0x00, 0x20, 0x81, 0xF0, 0x08, 0x0A, 0x05, 0x02, 0x81,
  0x41, 0x10, 0x88, 0x44, 0x3E, 0x20, 0x90, 0x48, 0x28, 0x0C, 0x04, 0xFD,
  0x0A, 0x0C, 0x18, 0x30, 0xBE, 0x42, 0x83, 0x06, 0x0C, 0x18, 0x5F, 0x00,
  0x3F, 0x20, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40,
  0x20, 0x1F, 0xF8, 0x84, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x82, 0x82, 0x84, 0xF8, 0xFE, 0x08, 0x20, 0x82, 0x0F, 0xA0, 0x82, 0x08,
  0x20, 0x83, 0xF0, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x3E, 0x82, 0x08, 0x20,
  0x82, 0x00, 0x1F, 0x90, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x0F, 0x80,
  0xC0, 0x50, 0x28, 0x12, 0x08, 0xFC, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xE9, 0x24, 0x92, 0x49,
  0x25, 0xC0, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x2C, 0x87,
  0x0A, 0x24, 0x8A, 0x14, 0x38, 0x50, 0x91, 0x22, 0x24, 0x28, 0x50, 0x40,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xF0, 0x80,
  0x70, 0x0F, 0x01, 0xE0, 0x5A, 0x0B, 0x41, 0x68, 0x4C, 0x89, 0x91, 0x32,
  0x46, 0x28, 0xC5, 0x18, 0xC3, 0x08, 0x40, 0x81, 0x81, 0xC1, 0xA1, 0xA1,
  0x91, 0x91, 0x89, 0x89, 0x85, 0x85, 0x83, 0x83, 0x81, 0x3F, 0x10, 0x24,
  0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x09, 0x02,
  0x21, 0x07, 0x80, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x7E, 0x82, 0x08, 0x20,
  0x82, 0x00, 0x3F, 0x10, 0x24, 0x0A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x09, 0x02, 0x21, 0x07, 0x80, 0x20, 0x08, 0x01, 0x00,
  0xF9, 0x0A, 0x14, 0x28, 0x50, 0xA2, 0x78, 0x91, 0x12, 0x24, 0x28, 0x50,
  0x40, 0x7F, 0x02, 0x04, 0x08, 0x08, 0x0C, 0x06, 0x02, 0x04, 0x08, 0x10,
  0x5F, 0x00, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x82, 0x82, 0x7C, 0x80, 0xC0, 0x90, 0x48, 0x24, 0x12,
  0x10, 0x88, 0x44, 0x24, 0x0A, 0x05, 0x02, 0x81, 0x80, 0x40, 0x81, 0x05,
  0x0C, 0x14, 0x30, 0x50, 0xA1, 0x42, 0x89, 0x12, 0x22, 0x48, 0x89, 0x22,
  0x24, 0x50, 0x91, 0x41, 0x85, 0x06, 0x14, 0x18, 0x20, 0x60, 0x80, 0x43,
  0x42, 0x22, 0x24, 0x14, 0x18, 0x08, 0x18, 0x14, 0x24, 0x24, 0x42, 0x42,
  0x81, 0x81, 0x42, 0x42, 0x44, 0x24, 0x24, 0x18, 0x18, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0xFC, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x81,
  0x04, 0x08, 0x1F, 0xC0, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0xF0, 0xC1, 0x04, 0x08, 0x20, 0x81, 0x04, 0x10, 0x20, 0x81, 0x04, 0x10,
  0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x08, 0x0A, 0x05,
  0x04, 0x42, 0x22, 0x0B, 0x06, 0xFF, 0x88, 0x80, 0x7A, 0x10, 0x41, 0x05,
  0xF8, 0x61, 0x86, 0x17, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x9C, 0xA2, 0xC2,
  0x81, 0x81, 0x81, 0x81, 0x81, 0xC2, 0xC2, 0xBC, 0x3D, 0x04, 0x20, 0x82,
  0x08, 0x20, 0x81, 0x03, 0xC0, 0x02, 0x04, 0x08, 0x13, 0xA8, 0xE0, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x28, 0x5F, 0x80, 0x38, 0x8A, 0x14, 0x18, 0x3F,
  0xE0, 0x40, 0x80, 0x80, 0xF0, 0x3C, 0x82, 0x08, 0xF0, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x00, 0x3A, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x82, 0x8D, 0xE8, 0x10, 0x20, 0x61, 0x3C, 0x82, 0x08, 0x20, 0xB3, 0x28,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x40, 0xB0, 0xAA, 0xAA, 0xA8, 0x4C,
  0x04, 0x92, 0x49, 0x24, 0x92, 0x49, 0x60, 0x82, 0x08, 0x20, 0x8A, 0x29,
  0x28, 0xC3, 0x8A, 0x24, 0x92, 0x28, 0xC0, 0xFF, 0xFE, 0xF3, 0x91, 0x8A,
  0x10, 0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x21, 0x84, 0x30, 0x86, 0x10,
  0x80, 0xB3, 0x28, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x40, 0x38, 0x8A,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x84, 0xF0, 0xB9, 0x8A, 0x14, 0x18,
  0x30, 0x60, 0xC1, 0x85, 0x0B, 0xE4, 0x08, 0x10, 0x20, 0x40, 0x3A, 0x8E,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x8D, 0xE8, 0x10, 0x20, 0x40, 0x81,
  0xBC, 0x88, 0x88, 0x88, 0x88, 0x80, 0x7C, 0x21, 0x0C, 0x10, 0x61, 0x08,
  0x7E, 0x42, 0x3E, 0x84, 0x21, 0x08, 0x42, 0x10, 0x83, 0x80, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x8D, 0xE8, 0x83, 0x05, 0x12, 0x24,
  0x48, 0x8A, 0x14, 0x28, 0x60, 0x40, 0x84, 0x30, 0xC5, 0x18, 0xA3, 0x14,
  0xA2, 0x92, 0x8A, 0x51, 0x4A, 0x31, 0x46, 0x10, 0x42, 0x00, 0x42, 0x88,
  0x91, 0x41, 0x82, 0x06, 0x14, 0x24, 0x8B, 0x08, 0x83, 0x05, 0x0A, 0x24,
  0x44, 0x8A, 0x14, 0x28, 0x20, 0x40, 0x81, 0x04, 0x08, 0x60, 0xF8, 0x44,
  0x22, 0x11, 0x08, 0x84, 0x3E, 0x19, 0x08, 0x42, 0x10, 0x88, 0xC1, 0x08,
  0x42, 0x10, 0x84, 0x18, 0xFF, 0xFF, 0xF0, 0xC1, 0x08, 0x42, 0x10, 0x84,
  0x19, 0x08, 0x42, 0x10, 0x84, 0xC0, 0xF3, 0x1C,
};

const GFXglyph NotoSans_Condensed_ExtraLight20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 14, 4, 1, -14 },
  { 5, 4, 5, 6, 1, -14 },
  { 8, 9, 14, 10, 0, -14 },
  { 24, 7, 16, 9, 1, -15 },
  { 38, 11, 14, 13, 1, -14 },
  { 58, 9, 14, 10, 1, -14 },
  { 74, 1, 5, 3, 1, -14 },
  { 75, 4, 17, 5, 1, -14 },
  { 84, 3, 17, 5, 1, -14 },
  { 91, 6, 6, 8, 1, -15 },
  { 96, 7, 10, 9, 1, -12 },
  { 105, 2, 5, 4, 1, -2 },
  { 107, 4, 1, 6, 1, -6 },
  { 108, 2, 1, 4, 1, -1 },
  { 109, 6, 14, 7, 0, -14 },
  { 120, 7, 14, 9, 1, -14 },
  { 133, 3, 14, 9, 2, -14 },
  { 139, 7, 14, 9, 1, -14 },
  { 152, 7, 14, 9, 1, -14 },
  { 165, 9, 14, 9, 0, -14 },
  { 181, 7, 14, 9, 1, -14 },
  { 194, 7, 14, 9, 1, -14 },
  { 207, 7, 14, 9, 1, -14 },
  { 220, 7, 14, 9, 1, -14 },
  { 233, 7, 14, 9, 1, -14 },
  { 246, 2, 11, 4, 1, -11 },
  { 249, 2, 14, 4, 1, -11 },
  { 253, 7, 8, 9, 1, -11 },
  { 260, 7, 5, 9, 1, -10 },
  { 265, 7, 8, 9, 1, -11 },
  { 272, 6, 14, 6, 0, -14 },
  { 283, 12, 16, 14, 1, -14 },
  { 307, 9, 14, 9, 0, -14 },
  { 323, 7, 14, 10, 2, -14 },
  { 336, 8, 14, 10, 1, -14 },
  { 350, 8, 14, 11, 2, -14 },
  { 364, 6, 14, 9, 2, -14 },
  { 375, 6, 14, 8, 2, -14 },
  { 386, 9, 14, 12, 1, -14 },
  { 402, 8, 14, 11, 2, -14 },
  { 416, 3, 14, 5, 1, -14 },
  { 422, 4, 18, 4, -1, -14 },
  { 431, 7, 14, 9, 2, -14 },
  { 444, 6, 14, 8, 2, -14 },
  { 455, 11, 14, 14, 2, -14 },
  { 475, 8, 14, 12, 2, -14 },
  { 489, 10, 14, 12, 1, -14 },
  { 507, 6, 14, 9, 2, -14 },
  { 518, 10, 17, 12, 1, -14 },
  { 540, 7, 14, 9, 2, -14 },
  { 553, 7, 14, 9, 1, -14 },
  { 566, 8, 14, 8, 0, -14 },
  { 580, 8, 14, 11, 2, -14 },
  { 594, 9, 14, 9, 0, -14 },
  { 610, 14, 14, 15, 0, -14 },
  { 635, 8, 14, 8, 0, -14 },
  { 649, 8, 14, 8, 0, -14 },
  { 663, 7, 14, 8, 1, -14 },
  { 676, 4, 17, 6, 2, -14 },
  { 685, 6, 14, 7, 0, -14 },
  { 696, 4, 17, 6, 1, -14 },
  { 705, 9, 7, 9, 0, -14 },
  { 713, 8, 1, 8, 0, 2 },
  { 714, 3, 3, 5, 1, -15 },
  { 716, 6, 11, 8, 1, -11 },
  { 725, 8, 15, 10, 1, -15 },
  { 740, 6, 11, 7, 1, -11 },
  { 749, 7, 15, 10, 1, -15 },
  { 763, 7, 11, 9, 1, -11 },
  { 773, 6, 15, 5, 0, -15 },
  { 785, 7, 16, 10, 1, -11 },
  { 799, 6, 15, 9, 2, -15 },
  { 811, 2, 15, 4, 1, -15 },
  { 815, 3, 20, 4, 0, -15 },
  { 823, 6, 15, 8, 2, -15 },
  { 835, 1, 15, 4, 1, -15 },
  { 837, 11, 11, 14, 2, -11 },
  { 853, 6, 11, 9, 2, -11 },
  { 862, 7, 11, 9, 1, -11 },
  { 872, 7, 16, 10, 2, -11 },
  { 886, 7, 16, 10, 1, -11 },
  { 900, 4, 11, 6, 2, -11 },
  { 906, 5, 11, 7, 1, -11 },
  { 913, 5, 13, 5, 0, -13 },
  { 922, 7, 11, 9, 1, -11 },
  { 932, 7, 11, 7, 0, -11 },
  { 942, 11, 11, 12, 0, -11 },
  { 958, 7, 11, 8, 0, -11 },
  { 968, 7, 16, 7, 0, -11 },
  { 982, 5, 11, 7, 1, -11 },
  { 989, 5, 17, 7, 1, -14 },
  { 1000, 1, 20, 9, 4, -15 },
  { 1003, 5, 17, 7, 1, -14 },
  { 1014, 7, 2, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_ExtraLight20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight20pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT20PT7B_H_
