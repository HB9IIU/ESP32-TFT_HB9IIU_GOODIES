#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT57PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight57pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x06, 0xFF, 0xF0, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00,
  0x02, 0x00, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06,
  0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18,
  0x06, 0x00, 0x0C, 0x01, 0x00, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30,
  0x00, 0x20, 0x08, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80,
  0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01,
  0x00, 0x60, 0x00, 0xC0, 0x10, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03,
  0x00, 0x06, 0x00, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18,
  0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x40, 0x18, 0x00,
  0x10, 0x04, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0x91, 0xF0, 0xF0,
  0x81, 0x86, 0x04, 0x00, 0x70, 0x20, 0x03, 0x01, 0x00, 0x18, 0x08, 0x01,
  0xC0, 0x40, 0x0E, 0x02, 0x00, 0x70, 0x10, 0x01, 0x80, 0x80, 0x0C, 0x04,
  0x00, 0x60, 0x20, 0x01, 0x81, 0x00, 0x0E, 0x08, 0x00, 0x3C, 0x40, 0x00,
  0x7A, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x27,
  0x80, 0x01, 0x0E, 0x00, 0x08, 0x38, 0x00, 0x40, 0xE0, 0x02, 0x03, 0x00,
  0x10, 0x1C, 0x00, 0x80, 0x60, 0x04, 0x03, 0x00, 0x20, 0x18, 0x01, 0x00,
  0xC0, 0x08, 0x0E, 0x00, 0x40, 0x60, 0x02, 0x07, 0x00, 0x10, 0x31, 0x80,
  0x87, 0x0F, 0xE7, 0xF0, 0x1F, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x1F, 0x80, 0x01, 0x80,
  0x3F, 0xC0, 0x03, 0x00, 0x30, 0xE0, 0x03, 0x00, 0x60, 0x60, 0x06, 0x00,
  0x60, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x00,
  0xC0, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x18, 0x00, 0xC0, 0x30, 0x18, 0x00,
  0xC0, 0x30, 0x18, 0x00, 0xC0, 0x18, 0x30, 0x00, 0xC0, 0x18, 0x30, 0x00,
  0xC0, 0x38, 0x60, 0x00, 0xC0, 0x38, 0x60, 0x00, 0xC0, 0x30, 0x60, 0x00,
  0xC0, 0x30, 0xC1, 0xE0, 0xC0, 0x30, 0xC3, 0xF8, 0xC0, 0x31, 0x86, 0x1C,
  0xC0, 0x31, 0x8C, 0x0C, 0x60, 0x71, 0x8C, 0x0C, 0x60, 0x63, 0x08, 0x06,
  0x30, 0xE3, 0x18, 0x06, 0x3F, 0xC6, 0x18, 0x06, 0x1F, 0x86, 0x18, 0x06,
  0x00, 0x06, 0x18, 0x06, 0x00, 0x0C, 0x18, 0x06, 0x00, 0x0C, 0x18, 0x03,
  0x00, 0x1C, 0x18, 0x03, 0x00, 0x18, 0x18, 0x03, 0x00, 0x18, 0x18, 0x07,
  0x00, 0x30, 0x18, 0x06, 0x00, 0x30, 0x18, 0x06, 0x00, 0x70, 0x18, 0x06,
  0x00, 0x60, 0x18, 0x06, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x0C, 0x06,
  0x00, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0x06, 0x0C, 0x01, 0x80, 0x07, 0x38,
  0x01, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x70, 0x70, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x03, 0x80,
  0x03, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x01,
  0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x0E, 0x00, 0x0E,
  0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x0C, 0x38, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xC3, 0x80, 0x08, 0x60,
  0x70, 0x0C, 0x30, 0x0C, 0x03, 0x1C, 0x03, 0x80, 0xC6, 0x00, 0x70, 0x31,
  0x80, 0x0C, 0x0C, 0xE0, 0x01, 0x86, 0x38, 0x00, 0x71, 0x8C, 0x00, 0x0C,
  0x63, 0x00, 0x01, 0xB0, 0xE0, 0x00, 0x7C, 0x38, 0x00, 0x0E, 0x06, 0x00,
  0x03, 0x81, 0x80, 0x01, 0xF0, 0x70, 0x00, 0xEE, 0x0E, 0x00, 0x71, 0x81,
  0xC0, 0x38, 0x30, 0x3E, 0xFC, 0x0E, 0x07, 0xFC, 0x01, 0xC0, 0x10, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03,
  0x80, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x06,
  0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30,
  0x0E, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0xE0, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x06,
  0x01, 0x80, 0x70, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x20, 0x30, 0x1E, 0x08, 0x3B, 0xF2, 0x7F, 0x0F,
  0xF8, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0C, 0x80, 0x06, 0x30, 0x03, 0x86,
  0x00, 0xC0, 0xC0, 0x60, 0x38, 0x38, 0x06, 0x04, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x61,
  0x86, 0x38, 0xE3, 0x0C, 0x71, 0x86, 0x18, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xEF, 0xFE, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x0E, 0x07, 0x01, 0xC0, 0x38, 0x18, 0x01, 0x83, 0x80, 0x1C, 0x30, 0x00,
  0xC7, 0x00, 0x0C, 0x60, 0x00, 0xE6, 0x00, 0x06, 0x60, 0x00, 0x6E, 0x00,
  0x06, 0xE0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0x60, 0x00,
  0x66, 0x00, 0x06, 0x60, 0x00, 0x67, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00,
  0x1C, 0x18, 0x01, 0x81, 0xC0, 0x38, 0x0E, 0x07, 0x00, 0x7F, 0xE0, 0x03,
  0xFC, 0x00, 0x00, 0xE0, 0x3C, 0x0F, 0x83, 0xF0, 0xEE, 0x39, 0xDE, 0x3F,
  0x07, 0xC0, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x07,
  0xF8, 0x03, 0xFF, 0xE0, 0xF8, 0x0F, 0x06, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x1F,
  0x00, 0xE1, 0xE0, 0x03, 0x84, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x0F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x40, 0x00, 0xE3, 0x80, 0x0F,
  0x1F, 0xE7, 0xE0, 0x3F, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x60, 0xE0,
  0x00, 0x60, 0xE0, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0xE0, 0x01, 0x80, 0xE0,
  0x03, 0x80, 0xE0, 0x03, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x06, 0x00, 0xE0,
  0x0C, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x18, 0x00, 0xE0,
  0x30, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0xE0, 0x00, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x02,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC8, 0x00, 0x38, 0xC0,
  0x07, 0x0F, 0xE7, 0xE0, 0x3F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xC0,
  0x1F, 0xFC, 0x03, 0xC0, 0x40, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC1, 0xFC, 0x0C, 0x3F, 0xF0, 0xCE, 0x03, 0x8D, 0xC0, 0x1C, 0xD8,
  0x00, 0xCF, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x76, 0x00, 0x07, 0x70, 0x00,
  0x63, 0x00, 0x06, 0x38, 0x00, 0xC1, 0x80, 0x1C, 0x1C, 0x03, 0x80, 0xF8,
  0xF0, 0x03, 0xFE, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0x80, 0x70, 0x38, 0x01, 0xC1,
  0x80, 0x06, 0x18, 0x00, 0x38, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x30, 0x00,
  0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x07, 0x0C,
  0x00, 0x30, 0x70, 0x03, 0x81, 0xC0, 0x38, 0x07, 0x03, 0x80, 0x1C, 0x78,
  0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xC7, 0x80, 0x38,
  0x0E, 0x03, 0x80, 0x38, 0x38, 0x00, 0xE1, 0x80, 0x03, 0x9C, 0x00, 0x0C,
  0xC0, 0x00, 0x76, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x0E, 0xE0, 0x00, 0x63,
  0x00, 0x07, 0x1C, 0x00, 0x30, 0x70, 0x07, 0x01, 0xF1, 0xF0, 0x03, 0xFF,
  0x00, 0x01, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x1C, 0x07, 0x03,
  0x80, 0x30, 0x70, 0x01, 0x86, 0x00, 0x1C, 0xE0, 0x00, 0xCC, 0x00, 0x0C,
  0xC0, 0x00, 0xEC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF6, 0x00, 0x0F, 0x60, 0x01, 0xF7, 0x00, 0x36, 0x38,
  0x07, 0x61, 0xFF, 0xE6, 0x0F, 0xF8, 0x60, 0x08, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0x9F, 0x80, 0x7F, 0xE0, 0x00, 0x70,
  0x00, 0xEF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xEF, 0xFE, 0x3C, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x61,
  0x8E, 0x38, 0xC3, 0x0C, 0x71, 0x86, 0x18, 0xC0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xF8, 0x60, 0x3C, 0x40,
  0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x01, 0xFF, 0x03, 0x9C, 0x01,
  0xFF, 0x80, 0x66, 0x00, 0xE0, 0x60, 0x19, 0x80, 0x70, 0x18, 0x06, 0x60,
  0x18, 0x06, 0x01, 0x98, 0x0E, 0x01, 0x80, 0x6C, 0x03, 0x00, 0x60, 0x0F,
  0x00, 0xC0, 0x18, 0x03, 0xC0, 0x30, 0x06, 0x00, 0xF0, 0x1C, 0x01, 0x80,
  0x3C, 0x06, 0x00, 0x60, 0x0F, 0x01, 0x80, 0x18, 0x03, 0xC0, 0x60, 0x06,
  0x00, 0xB0, 0x18, 0x01, 0x80, 0x6C, 0x06, 0x00, 0x60, 0x1B, 0x01, 0x80,
  0x38, 0x06, 0xC0, 0x30, 0x0E, 0x01, 0xB0, 0x0C, 0x02, 0x80, 0xCC, 0x03,
  0x01, 0xA0, 0x31, 0x80, 0x60, 0x4C, 0x1C, 0x60, 0x1C, 0x73, 0x8E, 0x18,
  0x03, 0xF8, 0x7F, 0x06, 0x00, 0x38, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x08, 0x00, 0x07, 0x80, 0x0C, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x03, 0x80, 0x01,
  0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x01, 0xC0,
  0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xC0, 0x01, 0xC0, 0x30,
  0x00, 0x30, 0x0C, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60,
  0x60, 0x00, 0x18, 0x38, 0x00, 0x06, 0x0C, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x18, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xC0, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x30, 0x0F, 0xE1, 0x80, 0x07, 0x8C, 0x00, 0x0E, 0x60, 0x00,
  0x73, 0x00, 0x01, 0x98, 0x00, 0x0E, 0xC0, 0x00, 0x76, 0x00, 0x03, 0xB0,
  0x00, 0x1D, 0x80, 0x00, 0xEC, 0x00, 0x07, 0x60, 0x00, 0x33, 0x00, 0x01,
  0x98, 0x00, 0x1C, 0xC0, 0x01, 0xC6, 0x00, 0x1C, 0x30, 0x07, 0xC1, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x60, 0x01, 0xE3, 0x00, 0x03, 0x98, 0x00, 0x0C,
  0xC0, 0x00, 0x76, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xCC, 0x00, 0x0E, 0x60, 0x00,
  0xE3, 0x00, 0x1E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0xFC, 0x07, 0x80, 0x30, 0x1C, 0x00, 0x20, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x01, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x0E, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x03, 0x00, 0xFC, 0x06, 0x00, 0x1C, 0x0C, 0x00, 0x1E,
  0x18, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x39,
  0x80, 0x00, 0x33, 0x00, 0x00, 0x76, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01,
  0xB0, 0x00, 0x07, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x39, 0x80, 0x00, 0x73,
  0x00, 0x01, 0xC6, 0x00, 0x07, 0x0C, 0x00, 0x1E, 0x18, 0x00, 0x78, 0x30,
  0x07, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x1F, 0xFF, 0xEF, 0xFF, 0xF6, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF,
  0xFD, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x03,
  0xC0, 0x0F, 0x01, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x19, 0x80, 0x00, 0x03, 0x38, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x30, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00,
  0xC0, 0x78, 0x00, 0x78, 0x07, 0xF3, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0xFF, 0xFF, 0xF0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC1, 0xFE, 0xFF, 0xC0, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x83,
  0xBF, 0xCF, 0xE0, 0xC0, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0xCC, 0x00,
  0x1C, 0xC0, 0x03, 0x8C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00, 0xE0, 0xC0,
  0x0C, 0x0C, 0x01, 0xC0, 0xC0, 0x38, 0x0C, 0x07, 0x00, 0xC0, 0x60, 0x0C,
  0x0E, 0x00, 0xC1, 0xC0, 0x0C, 0x18, 0x00, 0xC3, 0x80, 0x0C, 0x70, 0x00,
  0xCF, 0x00, 0x0C, 0xF0, 0x00, 0xDB, 0x80, 0x0F, 0x9C, 0x00, 0xF0, 0xC0,
  0x0E, 0x0E, 0x00, 0xC0, 0x60, 0x0C, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x80, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x0E, 0x0C, 0x00, 0x60, 0xC0,
  0x07, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0xCC,
  0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x30, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFB, 0x00, 0x00, 0x06, 0xF6, 0x00, 0x00, 0x0D, 0xEC,
  0x00, 0x00, 0x1B, 0xCC, 0x00, 0x00, 0x67, 0x98, 0x00, 0x00, 0xCF, 0x30,
  0x00, 0x01, 0x9E, 0x30, 0x00, 0x06, 0x3C, 0x60, 0x00, 0x0C, 0x78, 0xC0,
  0x00, 0x18, 0xF0, 0xC0, 0x00, 0x61, 0xE1, 0x80, 0x00, 0xC3, 0xC3, 0x00,
  0x01, 0x87, 0x83, 0x00, 0x07, 0x0F, 0x06, 0x00, 0x0C, 0x1E, 0x0C, 0x00,
  0x18, 0x3C, 0x0C, 0x00, 0x70, 0x78, 0x18, 0x00, 0xC0, 0xF0, 0x30, 0x01,
  0x81, 0xE0, 0x30, 0x07, 0x03, 0xC0, 0x60, 0x0C, 0x07, 0x80, 0xC0, 0x18,
  0x0F, 0x00, 0xC0, 0x70, 0x1E, 0x01, 0x80, 0xC0, 0x3C, 0x03, 0x01, 0x80,
  0x78, 0x03, 0x07, 0x00, 0xF0, 0x06, 0x0C, 0x01, 0xE0, 0x0C, 0x18, 0x03,
  0xC0, 0x0C, 0x70, 0x07, 0x80, 0x18, 0xC0, 0x0F, 0x00, 0x31, 0x80, 0x1E,
  0x00, 0x77, 0x00, 0x3C, 0x00, 0x6C, 0x00, 0x78, 0x00, 0xD8, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x06, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7B, 0x00, 0x00, 0xF6, 0x00, 0x01, 0xE6, 0x00, 0x03, 0xCC, 0x00,
  0x07, 0x8C, 0x00, 0x0F, 0x18, 0x00, 0x1E, 0x18, 0x00, 0x3C, 0x30, 0x00,
  0x78, 0x30, 0x00, 0xF0, 0x60, 0x01, 0xE0, 0x60, 0x03, 0xC0, 0xC0, 0x07,
  0x80, 0xC0, 0x0F, 0x01, 0xC0, 0x1E, 0x01, 0x80, 0x3C, 0x03, 0x80, 0x78,
  0x03, 0x00, 0xF0, 0x07, 0x01, 0xE0, 0x06, 0x03, 0xC0, 0x0E, 0x07, 0x80,
  0x0C, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x18, 0x3C, 0x00, 0x38, 0x78, 0x00,
  0x30, 0xF0, 0x00, 0x71, 0xE0, 0x00, 0x63, 0xC0, 0x00, 0xE7, 0x80, 0x00,
  0xCF, 0x00, 0x01, 0xDE, 0x00, 0x01, 0xBC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x0E,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x18, 0x30, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x18, 0x18, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x3C, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x40, 0x00,
  0xFF, 0xC0, 0x1F, 0xFF, 0x83, 0x01, 0xF8, 0x60, 0x03, 0x8C, 0x00, 0x39,
  0x80, 0x03, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x3B, 0x00, 0x06, 0x60, 0x01, 0xCC,
  0x00, 0x71, 0x80, 0x7C, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xC0, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x30, 0x18,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x18, 0x30, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x18, 0x18, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x07, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0xC0, 0x7E, 0x0C, 0x00, 0x70, 0xC0,
  0x03, 0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xEC,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0E,
  0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x03,
  0x8C, 0x00, 0x70, 0xC0, 0x1E, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x0C, 0x07,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0xC0, 0xC0,
  0x0C, 0x0C, 0x00, 0xE0, 0xC0, 0x06, 0x0C, 0x00, 0x70, 0xC0, 0x03, 0x0C,
  0x00, 0x38, 0xC0, 0x01, 0x8C, 0x00, 0x1C, 0xC0, 0x00, 0xCC, 0x00, 0x0E,
  0xC0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x03, 0xFF, 0x01, 0xFF,
  0xFC, 0x78, 0x07, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x30, 0x01, 0xE7, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x30, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0xC0, 0x00, 0x39, 0x80, 0x00,
  0x63, 0x80, 0x01, 0xC3, 0x80, 0x07, 0x03, 0x80, 0x1C, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x38, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x0C, 0x00,
  0x06, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0xC0, 0x01, 0xC0, 0x60,
  0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x06, 0x00,
  0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x07, 0x01, 0xC0, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x38, 0x30, 0x00, 0x0C, 0x18,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x31, 0x80, 0x00, 0x1D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0xC0, 0x00, 0x38, 0x00, 0x06, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x60,
  0x00, 0x3C, 0x00, 0x06, 0x60, 0x00, 0x6C, 0x00, 0x0E, 0x60, 0x00, 0x6C,
  0x00, 0x0C, 0x70, 0x00, 0x6C, 0x00, 0x0C, 0x30, 0x00, 0x6E, 0x00, 0x0C,
  0x30, 0x00, 0x66, 0x00, 0x1C, 0x30, 0x00, 0xC6, 0x00, 0x18, 0x30, 0x00,
  0xC6, 0x00, 0x18, 0x38, 0x00, 0xC6, 0x00, 0x18, 0x18, 0x00, 0xC3, 0x00,
  0x38, 0x18, 0x01, 0xC3, 0x00, 0x38, 0x18, 0x01, 0x83, 0x00, 0x30, 0x1C,
  0x01, 0x83, 0x00, 0x30, 0x0C, 0x01, 0x83, 0x80, 0x30, 0x0C, 0x01, 0x81,
  0x80, 0x70, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x0E, 0x03, 0x01, 0x80, 0x60,
  0x06, 0x03, 0x01, 0x80, 0x60, 0x06, 0x03, 0x00, 0xC0, 0xE0, 0x06, 0x07,
  0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x07, 0x06, 0x00, 0xC0,
  0xC0, 0x03, 0x06, 0x00, 0xE1, 0xC0, 0x03, 0x06, 0x00, 0x61, 0x80, 0x03,
  0x0C, 0x00, 0x61, 0x80, 0x03, 0x8C, 0x00, 0x61, 0x80, 0x01, 0x8C, 0x00,
  0x61, 0x80, 0x01, 0x8C, 0x00, 0x33, 0x80, 0x01, 0x9C, 0x00, 0x33, 0x00,
  0x01, 0x98, 0x00, 0x33, 0x00, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x00, 0xD8,
  0x00, 0x37, 0x00, 0x00, 0xD8, 0x00, 0x1E, 0x00, 0x00, 0xD0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0C, 0xE0, 0x00, 0x71, 0x80, 0x01,
  0x86, 0x00, 0x0E, 0x0C, 0x00, 0x30, 0x30, 0x01, 0xC0, 0xE0, 0x06, 0x01,
  0x80, 0x38, 0x07, 0x00, 0xC0, 0x0C, 0x07, 0x00, 0x38, 0x18, 0x00, 0x60,
  0x60, 0x01, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x39, 0x80,
  0x00, 0x6E, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0xC6,
  0x00, 0x03, 0x1C, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x03, 0x81, 0x80,
  0x0C, 0x06, 0x00, 0x70, 0x1C, 0x01, 0x80, 0x30, 0x0E, 0x00, 0xE0, 0x30,
  0x01, 0x81, 0xC0, 0x07, 0x06, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xC0, 0x00,
  0xE3, 0x00, 0x01, 0x98, 0x00, 0x07, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x76, 0x00, 0x01, 0x9C, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0xC3, 0x80, 0x07, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x60, 0x30, 0x03,
  0x00, 0xC0, 0x0C, 0x03, 0x80, 0x70, 0x06, 0x01, 0x80, 0x1C, 0x06, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x87, 0x00, 0x06, 0x18, 0x00, 0x18,
  0x60, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0xFF, 0xFF,
  0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x66, 0x00, 0x00, 0x67,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x80, 0x01, 0x81, 0x80, 0x01, 0x81,
  0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x70, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x06, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x38, 0x1C, 0x07, 0x01,
  0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x00, 0xF0, 0x03, 0xFF, 0x81, 0xF1,
  0xF0, 0x60, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x0F, 0xFC, 0x1F, 0xC3, 0x1E, 0x00, 0xCE, 0x00, 0x33, 0x00,
  0x0D, 0x80, 0x03, 0x60, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xF6, 0x00, 0x2D, 0xC0, 0x1B, 0x30, 0x0C, 0xCF,
  0x8E, 0x30, 0xFF, 0x0C, 0x0C, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x07, 0x80, 0x61, 0xFF, 0x83, 0x1E, 0x1E, 0x19, 0x80, 0x38,
  0xD8, 0x00, 0xC6, 0x80, 0x07, 0x34, 0x00, 0x19, 0xE0, 0x00, 0xEE, 0x00,
  0x03, 0x70, 0x00, 0x1B, 0x80, 0x00, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xB8,
  0x00, 0x0D, 0xC0, 0x00, 0xEE, 0x00, 0x06, 0x78, 0x00, 0x33, 0x40, 0x03,
  0x1B, 0x00, 0x38, 0xCC, 0x03, 0x86, 0x3E, 0xF8, 0x30, 0xFF, 0x80, 0x00,
  0x40, 0x00, 0x00, 0x38, 0x01, 0xFF, 0xC1, 0xF1, 0xC1, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xE0, 0x08, 0x7E, 0x78, 0x0F, 0xFC, 0x00, 0x40, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0xF0, 0x30, 0x7F, 0xC3, 0x0F, 0x0F, 0x31,
  0xC0, 0x33, 0x38, 0x01, 0xB3, 0x00, 0x0F, 0x70, 0x00, 0xF6, 0x00, 0x07,
  0x60, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x0F, 0x30, 0x00, 0xB3,
  0x80, 0x1B, 0x1C, 0x03, 0x30, 0xF9, 0xE3, 0x07, 0xFC, 0x30, 0x04, 0x00,
  0x00, 0xE0, 0x00, 0xFF, 0x80, 0x3C, 0x38, 0x0E, 0x01, 0x83, 0x80, 0x18,
  0x60, 0x03, 0x1C, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xDC, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xE0, 0x0C, 0x1F, 0x9F, 0x80,
  0xFF, 0xC0, 0x01, 0x00, 0x00, 0x30, 0x03, 0xFC, 0x0F, 0x30, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xE3, 0x0F, 0x0F, 0x31, 0xC0,
  0x3B, 0x38, 0x01, 0xB3, 0x00, 0x0F, 0x70, 0x00, 0x76, 0x00, 0x07, 0x60,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00,
  0x76, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x0F, 0x30, 0x00, 0xB3, 0x80,
  0x1B, 0x1C, 0x03, 0x30, 0xF9, 0xE3, 0x07, 0xFC, 0x30, 0x04, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC6, 0x00, 0x38,
  0x7C, 0x0F, 0x03, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x07, 0x81, 0x87, 0xFC, 0x31, 0xE3, 0xC6, 0x60, 0x1C, 0xD8, 0x01,
  0x9A, 0x00, 0x3B, 0xC0, 0x03, 0x70, 0x00, 0x6E, 0x00, 0x0D, 0xC0, 0x01,
  0xB8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0x80, 0xFF, 0xB0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x07, 0x07, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x06, 0x06, 0x06, 0x9E,
  0xFC, 0x70, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x1B, 0x00, 0x19, 0x80, 0x1C,
  0xC0, 0x0C, 0x60, 0x0C, 0x30, 0x0E, 0x18, 0x0E, 0x0C, 0x06, 0x06, 0x06,
  0x03, 0x07, 0x01, 0x83, 0x00, 0xC3, 0x00, 0x63, 0xC0, 0x31, 0xE0, 0x19,
  0xB8, 0x0D, 0x8C, 0x07, 0x87, 0x03, 0xC1, 0x81, 0xC0, 0xE0, 0xC0, 0x30,
  0x60, 0x1C, 0x30, 0x06, 0x18, 0x03, 0x8C, 0x00, 0xC6, 0x00, 0x73, 0x00,
  0x19, 0x80, 0x0E, 0xC0, 0x03, 0x60, 0x01, 0xF0, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x01,
  0xC0, 0xC3, 0xFC, 0x0F, 0xF0, 0xCF, 0x1E, 0x1C, 0x7C, 0xCC, 0x07, 0x30,
  0x1C, 0xD8, 0x03, 0x60, 0x0E, 0xD0, 0x03, 0x60, 0x06, 0xF0, 0x03, 0xC0,
  0x06, 0xE0, 0x01, 0xC0, 0x06, 0xE0, 0x01, 0x80, 0x07, 0xE0, 0x01, 0x80,
  0x07, 0xE0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80,
  0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80,
  0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80,
  0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80,
  0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80,
  0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80,
  0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x78, 0x18, 0x7F, 0xC3, 0x1C, 0x3C, 0x66, 0x01, 0xCD, 0x80,
  0x1D, 0xA0, 0x01, 0xBC, 0x00, 0x37, 0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00,
  0x1B, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x3F, 0xF0, 0x03, 0xC3, 0xE0, 0x38,
  0x03, 0x03, 0x80, 0x0C, 0x18, 0x00, 0x71, 0xC0, 0x01, 0x8C, 0x00, 0x0C,
  0x60, 0x00, 0x37, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00,
  0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00,
  0x1B, 0x80, 0x00, 0xCC, 0x00, 0x0E, 0x60, 0x00, 0x63, 0x80, 0x03, 0x0C,
  0x00, 0x38, 0x70, 0x03, 0x81, 0xC0, 0x38, 0x07, 0xCF, 0x80, 0x0F, 0xF8,
  0x00, 0x04, 0x00, 0x00, 0x78, 0x06, 0x1F, 0xF0, 0x31, 0xE1, 0xE1, 0x9C,
  0x03, 0x8C, 0x80, 0x0C, 0x6C, 0x00, 0x73, 0x40, 0x01, 0x9E, 0x00, 0x0E,
  0xE0, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00,
  0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x70, 0x00,
  0x1B, 0x80, 0x00, 0xDC, 0x00, 0x0E, 0xF0, 0x00, 0x66, 0x80, 0x03, 0x36,
  0x00, 0x31, 0x98, 0x03, 0x8C, 0xE0, 0x38, 0x63, 0xEF, 0x83, 0x0F, 0xF8,
  0x18, 0x04, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x7F, 0xC3, 0x0F, 0x0F, 0x31, 0xC0, 0x33, 0x38, 0x01, 0xB3,
  0x00, 0x0F, 0x70, 0x00, 0xF6, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60,
  0x00, 0x77, 0x00, 0x0F, 0x30, 0x00, 0xB3, 0x80, 0x1B, 0x1C, 0x03, 0x30,
  0xF9, 0xE3, 0x07, 0xFC, 0x30, 0x04, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0xE6, 0x1F, 0xF1, 0xFD, 0x9C, 0x0C, 0xC0, 0x6C, 0x03, 0x40,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xFE, 0x1E, 0x1F, 0x38, 0x01,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x07,
  0xC0, 0x0E, 0xFE, 0xFC, 0x3F, 0xF8, 0x01, 0x00, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x0F, 0xFF, 0xFF, 0xF1, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0C,
  0x00, 0xF3, 0x07, 0xF0, 0x08, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0x60,
  0x01, 0xD8, 0x00, 0xF7, 0x00, 0x6C, 0xE0, 0x31, 0x3E, 0x7C, 0x43, 0xFC,
  0x10, 0x18, 0x00, 0xE0, 0x00, 0x76, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00,
  0x0E, 0x70, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x80, 0x1C, 0x18,
  0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x07, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60,
  0x07, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0xC0, 0x01, 0x98,
  0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x1B, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x07, 0xC0, 0x03,
  0x80, 0x06, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x03, 0xC0, 0x06, 0x60, 0x02,
  0xC0, 0x0E, 0x60, 0x06, 0xC0, 0x0C, 0x60, 0x06, 0x60, 0x0C, 0x70, 0x06,
  0x60, 0x0C, 0x30, 0x06, 0x60, 0x1C, 0x30, 0x0C, 0x60, 0x18, 0x30, 0x0C,
  0x30, 0x18, 0x38, 0x0C, 0x30, 0x18, 0x18, 0x0C, 0x30, 0x18, 0x18, 0x18,
  0x30, 0x30, 0x18, 0x18, 0x18, 0x30, 0x1C, 0x18, 0x18, 0x30, 0x0C, 0x18,
  0x18, 0x30, 0x0C, 0x30, 0x18, 0x60, 0x0C, 0x30, 0x1C, 0x60, 0x0C, 0x30,
  0x0C, 0x60, 0x06, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x0C, 0x60, 0x06, 0x60,
  0x0E, 0xC0, 0x06, 0x60, 0x06, 0xC0, 0x03, 0x60, 0x06, 0xC0, 0x03, 0xC0,
  0x06, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xC0,
  0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00, 0xEE, 0x00, 0x18, 0xC0,
  0x06, 0x0C, 0x00, 0xC1, 0x80, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x30,
  0x70, 0x07, 0x0C, 0x00, 0x63, 0x80, 0x0E, 0x60, 0x00, 0xDC, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x37,
  0x00, 0x0E, 0x60, 0x01, 0x8E, 0x00, 0x60, 0xC0, 0x0C, 0x1C, 0x03, 0x01,
  0x80, 0x60, 0x38, 0x18, 0x03, 0x07, 0x00, 0x70, 0xC0, 0x06, 0x38, 0x00,
  0x66, 0x00, 0x0D, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x36, 0x00, 0x03, 0x30,
  0x00, 0x73, 0x00, 0x06, 0x30, 0x00, 0x63, 0x80, 0x0E, 0x18, 0x00, 0xC1,
  0x80, 0x0C, 0x18, 0x00, 0xC0, 0xC0, 0x1C, 0x0C, 0x01, 0x80, 0xC0, 0x18,
  0x0E, 0x03, 0x80, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x30, 0x03, 0x06,
  0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x18, 0xE0, 0x01, 0x8C, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x0D, 0x80, 0x00, 0xD8, 0x00, 0x0D, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x08, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFE, 0xFF, 0xFC,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x7C, 0x03, 0xE0, 0x0E,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x07, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x7E, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x7C, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x70, 0x07, 0x80, 0xFC, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0x80, 0x1F, 0x0F, 0x80, 0xF0, 0x0F, 0xDE, 0x80, 0x0F, 0xF0,
  0x00, 0x06, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLight57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 41, 12, 4, -41 },
  { 22, 10, 15, 18, 4, -41 },
  { 41, 26, 41, 28, 1, -41 },
  { 175, 21, 46, 26, 2, -43 },
  { 296, 32, 42, 37, 3, -41 },
  { 464, 26, 42, 28, 2, -41 },
  { 601, 2, 15, 10, 4, -41 },
  { 605, 10, 50, 15, 3, -41 },
  { 668, 11, 50, 15, 2, -41 },
  { 737, 18, 18, 23, 3, -43 },
  { 778, 22, 26, 26, 2, -33 },
  { 850, 6, 13, 11, 2, -6 },
  { 860, 12, 3, 16, 2, -17 },
  { 865, 4, 4, 11, 4, -4 },
  { 867, 17, 41, 19, 1, -41 },
  { 955, 20, 41, 26, 3, -41 },
  { 1058, 11, 41, 26, 5, -41 },
  { 1115, 20, 41, 26, 3, -41 },
  { 1218, 21, 42, 26, 2, -41 },
  { 1329, 24, 41, 26, 1, -41 },
  { 1452, 20, 42, 26, 3, -41 },
  { 1557, 20, 42, 26, 3, -41 },
  { 1662, 20, 41, 26, 3, -41 },
  { 1765, 21, 42, 26, 2, -41 },
  { 1876, 20, 42, 26, 3, -41 },
  { 1981, 4, 30, 12, 4, -30 },
  { 1996, 6, 37, 11, 2, -30 },
  { 2024, 22, 25, 26, 2, -33 },
  { 2093, 22, 14, 26, 2, -27 },
  { 2132, 22, 25, 26, 2, -33 },
  { 2201, 16, 41, 18, 1, -41 },
  { 2283, 34, 46, 40, 3, -41 },
  { 2479, 26, 41, 26, 0, -41 },
  { 2613, 21, 41, 28, 5, -41 },
  { 2721, 23, 42, 27, 3, -41 },
  { 2842, 23, 41, 31, 5, -41 },
  { 2960, 17, 41, 25, 5, -41 },
  { 3048, 17, 41, 23, 5, -41 },
  { 3136, 27, 42, 33, 3, -41 },
  { 3278, 22, 41, 32, 5, -41 },
  { 3391, 10, 41, 14, 2, -41 },
  { 3443, 10, 51, 12, -3, -41 },
  { 3507, 20, 41, 25, 5, -41 },
  { 3610, 16, 41, 23, 5, -41 },
  { 3692, 31, 41, 41, 5, -41 },
  { 3851, 23, 41, 33, 5, -41 },
  { 3969, 28, 42, 34, 3, -41 },
  { 4116, 19, 41, 26, 5, -41 },
  { 4214, 28, 51, 34, 3, -41 },
  { 4393, 20, 41, 27, 5, -41 },
  { 4496, 19, 42, 25, 3, -41 },
  { 4596, 22, 41, 23, 0, -41 },
  { 4709, 23, 42, 32, 4, -41 },
  { 4830, 25, 41, 25, 0, -41 },
  { 4959, 40, 41, 42, 1, -41 },
  { 5164, 22, 41, 23, 0, -41 },
  { 5277, 22, 41, 22, 0, -41 },
  { 5390, 20, 41, 23, 2, -41 },
  { 5493, 11, 50, 18, 5, -41 },
  { 5562, 17, 41, 19, 1, -41 },
  { 5650, 11, 50, 18, 2, -41 },
  { 5719, 24, 22, 26, 1, -41 },
  { 5785, 23, 2, 23, 0, 5 },
  { 5791, 9, 9, 14, 2, -44 },
  { 5802, 18, 32, 24, 2, -31 },
  { 5874, 21, 44, 27, 4, -43 },
  { 5990, 17, 32, 21, 3, -31 },
  { 6058, 20, 44, 27, 3, -43 },
  { 6168, 19, 32, 25, 3, -31 },
  { 6244, 15, 44, 14, 1, -44 },
  { 6327, 20, 45, 27, 3, -31 },
  { 6440, 19, 43, 27, 4, -43 },
  { 6543, 3, 41, 11, 4, -41 },
  { 6559, 8, 55, 11, -1, -41 },
  { 6614, 17, 43, 22, 4, -43 },
  { 6706, 2, 43, 11, 4, -43 },
  { 6717, 32, 31, 40, 4, -31 },
  { 6841, 19, 31, 27, 4, -31 },
  { 6915, 21, 32, 26, 3, -31 },
  { 6999, 21, 44, 27, 4, -31 },
  { 7115, 20, 44, 27, 3, -31 },
  { 7225, 13, 31, 17, 4, -31 },
  { 7276, 16, 32, 21, 2, -31 },
  { 7340, 12, 38, 14, 1, -37 },
  { 7397, 18, 31, 27, 4, -30 },
  { 7467, 20, 30, 20, 0, -30 },
  { 7542, 32, 30, 33, 1, -30 },
  { 7662, 19, 30, 21, 1, -30 },
  { 7734, 20, 44, 21, 0, -30 },
  { 7844, 15, 30, 19, 2, -30 },
  { 7901, 15, 50, 20, 2, -41 },
  { 7995, 2, 57, 25, 11, -43 },
  { 8010, 14, 50, 20, 3, -41 },
  { 8098, 22, 6, 26, 2, -23 },
};

const GFXfont NotoSans_Condensed_ExtraLight57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight57pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT57PT7B_H_
