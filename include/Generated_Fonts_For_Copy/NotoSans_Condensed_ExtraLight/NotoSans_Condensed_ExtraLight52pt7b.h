#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT52PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xB6, 0xDB, 0x49, 0x24, 0x92, 0x49, 0x20,
  0x00, 0x0B, 0xFE, 0xE0, 0xF8, 0x36, 0x0D, 0x83, 0x60, 0xD8, 0x36, 0x0D,
  0x03, 0x40, 0xD0, 0x34, 0x0D, 0x03, 0x40, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x40, 0x30, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x20, 0x00, 0xC0, 0x60, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x80, 0x60, 0x00,
  0x80, 0x40, 0x01, 0x80, 0x40, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x01,
  0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0x00, 0xC0, 0x03,
  0x00, 0x80, 0x03, 0x00, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0x03,
  0x01, 0x80, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x06,
  0x01, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06,
  0x03, 0x00, 0x04, 0x03, 0x00, 0x04, 0x02, 0x00, 0x0C, 0x02, 0x00, 0x0C,
  0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x3F,
  0xBF, 0x0E, 0x30, 0x63, 0x86, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x03,
  0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x03, 0x06,
  0x00, 0x60, 0xC0, 0x06, 0x18, 0x00, 0x73, 0x00, 0x07, 0xE0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x06, 0x78, 0x00, 0xC3, 0x80, 0x18,
  0x38, 0x03, 0x03, 0x00, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30,
  0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x18, 0x03, 0x07, 0x40, 0x61,
  0xCF, 0x8C, 0xF0, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x18, 0x03, 0x8C, 0x00, 0x60, 0x0C, 0x18, 0x03, 0x00, 0x60, 0x60, 0x0C,
  0x01, 0x80, 0xC0, 0x20, 0x06, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x06, 0x00,
  0x40, 0x30, 0x30, 0x01, 0x00, 0xC0, 0xC0, 0x04, 0x03, 0x02, 0x00, 0x30,
  0x0C, 0x18, 0x00, 0xC0, 0x30, 0x60, 0x01, 0x00, 0xC3, 0x00, 0x04, 0x03,
  0x0C, 0x00, 0x10, 0x0C, 0x20, 0xE0, 0x60, 0x31, 0x8F, 0xE1, 0x80, 0xC6,
  0x30, 0xC6, 0x02, 0x31, 0x83, 0x18, 0x18, 0xC6, 0x06, 0x30, 0x62, 0x30,
  0x18, 0xE3, 0x18, 0xC0, 0x61, 0xF8, 0x63, 0x01, 0x81, 0x83, 0x0C, 0x02,
  0x00, 0x0C, 0x30, 0x08, 0x00, 0x20, 0xC0, 0x20, 0x01, 0x83, 0x00, 0xC0,
  0x06, 0x0C, 0x03, 0x00, 0x30, 0x30, 0x08, 0x00, 0xC0, 0xC0, 0x20, 0x02,
  0x03, 0x01, 0x80, 0x18, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x18, 0x03, 0x00,
  0x40, 0x60, 0x0C, 0x01, 0x81, 0x00, 0x30, 0x06, 0x0C, 0x01, 0x80, 0x0C,
  0x60, 0x06, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x1C,
  0x70, 0x00, 0x60, 0x70, 0x00, 0xC0, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01,
  0x80, 0x0C, 0x01, 0x00, 0x18, 0x02, 0x00, 0x30, 0x0C, 0x00, 0x20, 0x18,
  0x00, 0x60, 0x30, 0x00, 0xC0, 0xE0, 0x00, 0xC1, 0x80, 0x01, 0x86, 0x00,
  0x01, 0x9C, 0x00, 0x03, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x36, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x06, 0x01, 0x8C, 0x0E, 0x03, 0x30,
  0x0C, 0x06, 0x60, 0x0C, 0x0D, 0xC0, 0x1C, 0x13, 0x00, 0x18, 0x66, 0x00,
  0x18, 0xCC, 0x00, 0x3B, 0x18, 0x00, 0x36, 0x30, 0x00, 0x3C, 0x60, 0x00,
  0x30, 0x60, 0x00, 0xF0, 0xC0, 0x03, 0xE1, 0xC0, 0x0E, 0x61, 0xC0, 0x38,
  0xE1, 0xE3, 0xE0, 0xC1, 0xFF, 0x00, 0xC0, 0x20, 0x00, 0x00, 0xFD, 0xB6,
  0xDB, 0x69, 0x24, 0x01, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0x60,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0,
  0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06,
  0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0C,
  0x0C, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x08, 0x00, 0x04, 0x01, 0x82, 0x0F, 0xF9, 0x3F, 0x0F, 0xF8, 0x00, 0x60,
  0x00, 0x78, 0x00, 0x64, 0x00, 0x63, 0x00, 0x60, 0xC0, 0x30, 0x30, 0x30,
  0x1C, 0x08, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x19, 0xCE, 0x63, 0x18, 0xCC, 0x63, 0x11, 0x8C,
  0x00, 0xFF, 0xFF, 0xFC, 0xDF, 0xF0, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x01, 0xFE,
  0x00, 0xE1, 0xC0, 0x60, 0x38, 0x30, 0x06, 0x0C, 0x00, 0xC6, 0x00, 0x31,
  0x80, 0x06, 0x60, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x06, 0xC0,
  0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x0C, 0x70, 0x03, 0x0C, 0x00,
  0xC3, 0x80, 0x60, 0x70, 0x38, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xC0,
  0x70, 0x7C, 0x3B, 0x1C, 0xCE, 0x3F, 0x0D, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0xFF, 0x80, 0xF0, 0x78, 0x38, 0x03, 0x82, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x03, 0xFF, 0x80, 0xF0, 0x78, 0x78,
  0x03, 0x84, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x1F,
  0x80, 0x03, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x60, 0x03, 0x8F, 0xC3, 0xE0, 0x7F, 0xF0, 0x00, 0x20,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0x60,
  0x00, 0x0D, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x0C, 0x60, 0x00,
  0x31, 0x80, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0x30, 0x60, 0x01, 0x81,
  0x80, 0x06, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x80,
  0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0xC0,
  0x06, 0x03, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x06,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x3F, 0xFF, 0x0F, 0xFF, 0xC2,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x7F, 0xC0, 0xFF, 0xFC, 0x10, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC8,
  0x00, 0xE3, 0xE1, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x7F, 0xC0,
  0x3C, 0x30, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x07, 0xC0, 0xC7, 0xFC, 0x33, 0x03, 0x8D,
  0x80, 0x33, 0xC0, 0x0E, 0xE0, 0x01, 0xB8, 0x00, 0x6C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x06, 0x60, 0x01, 0x8C, 0x00, 0x63,
  0x00, 0x30, 0x60, 0x1C, 0x0E, 0x1E, 0x01, 0xFF, 0x00, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x3C, 0x3C, 0x0E, 0x01,
  0xC3, 0x00, 0x18, 0x60, 0x01, 0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00,
  0xCC, 0x00, 0x19, 0x80, 0x03, 0x18, 0x00, 0x63, 0x00, 0x1C, 0x70, 0x03,
  0x07, 0x00, 0xC0, 0x70, 0x30, 0x07, 0x1C, 0x00, 0x3F, 0x00, 0x03, 0xC0,
  0x01, 0xDC, 0x00, 0xE0, 0xE0, 0x38, 0x0E, 0x0E, 0x00, 0xE1, 0x80, 0x0E,
  0x60, 0x00, 0xCC, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0x60, 0x00, 0xEC, 0x00, 0x18,
  0xC0, 0x07, 0x1C, 0x01, 0xC1, 0xF0, 0xF0, 0x0F, 0xF8, 0x00, 0x10, 0x00,
  0x00, 0xC0, 0x00, 0xFF, 0x00, 0x38, 0x78, 0x0C, 0x03, 0x83, 0x00, 0x30,
  0x60, 0x03, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x3F,
  0x00, 0x07, 0x60, 0x00, 0xEC, 0x00, 0x1D, 0x80, 0x07, 0x98, 0x00, 0xB3,
  0x80, 0x24, 0x38, 0x1D, 0x83, 0xFE, 0x30, 0x1F, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x03, 0x0F, 0x80, 0x7F, 0xC0, 0x00, 0x80, 0x00, 0xDF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xDF, 0xF0, 0x31, 0xCE, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x67, 0x39,
  0x8C, 0x63, 0x31, 0x8C, 0x46, 0x30, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07,
  0x01, 0xFF, 0x8F, 0x0F, 0x10, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1E, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x60, 0x07, 0x00, 0x00,
  0xC0, 0x38, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x1E, 0x01, 0x98,
  0x03, 0xFE, 0x03, 0x60, 0x1C, 0x18, 0x0D, 0x80, 0xE0, 0x60, 0x3C, 0x03,
  0x01, 0x80, 0xF0, 0x18, 0x06, 0x03, 0xC0, 0x60, 0x18, 0x07, 0x01, 0x80,
  0x60, 0x1C, 0x0C, 0x01, 0x80, 0x70, 0x30, 0x06, 0x01, 0xC0, 0xC0, 0x18,
  0x07, 0x03, 0x00, 0x60, 0x3C, 0x0C, 0x01, 0x80, 0xF0, 0x30, 0x06, 0x03,
  0xC0, 0xC0, 0x38, 0x0F, 0x03, 0x00, 0xE0, 0x3C, 0x06, 0x03, 0x80, 0xB0,
  0x18, 0x1A, 0x06, 0xC0, 0x30, 0xCC, 0x31, 0x00, 0xFF, 0x3F, 0xC6, 0x01,
  0xF8, 0x7E, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x40, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0C,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x86,
  0x00, 0x02, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60,
  0x00, 0xC0, 0xC0, 0x00, 0xC3, 0x80, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x18, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0x00, 0x1E, 0x60, 0x00, 0xCC, 0x00, 0x1D, 0x80, 0x01, 0xB0, 0x00, 0x36,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0x60, 0x00, 0x6C,
  0x00, 0x0D, 0x80, 0x03, 0xB0, 0x00, 0x66, 0x00, 0x38, 0xC0, 0x7E, 0x1F,
  0xFF, 0x03, 0x00, 0xF8, 0x60, 0x01, 0xCC, 0x00, 0x1D, 0x80, 0x01, 0xB0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xD8, 0x00, 0x33, 0x00, 0x1E, 0x7F, 0xFF, 0x0F, 0xFF, 0x80, 0x00,
  0x06, 0x00, 0x07, 0xFF, 0x80, 0x78, 0x3E, 0x0F, 0x00, 0x20, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x20, 0x1F, 0x1F,
  0x00, 0x7F, 0xF0, 0x00, 0x18, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x30,
  0x03, 0xC1, 0x80, 0x07, 0x0C, 0x00, 0x1C, 0x60, 0x00, 0x73, 0x00, 0x01,
  0x98, 0x00, 0x0E, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00,
  0x3B, 0x00, 0x01, 0x98, 0x00, 0x18, 0xC0, 0x01, 0xC6, 0x00, 0x1C, 0x30,
  0x03, 0xC1, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x7F, 0xF8, 0x01, 0xF0, 0x3F, 0x03, 0x80, 0x06,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x38, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x07, 0x00, 0x03, 0x03, 0x80, 0x03,
  0x01, 0xF0, 0x7F, 0x00, 0x7F, 0xFC, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x80, 0xFF,
  0x8E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x07, 0xCF, 0xF8, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C,
  0xFF, 0x3F, 0x80, 0xC0, 0x00, 0xF8, 0x00, 0x3B, 0x00, 0x06, 0x60, 0x01,
  0x8C, 0x00, 0x71, 0x80, 0x1C, 0x30, 0x03, 0x06, 0x00, 0xC0, 0xC0, 0x38,
  0x18, 0x06, 0x03, 0x01, 0x80, 0x60, 0x70, 0x0C, 0x1C, 0x01, 0x83, 0x00,
  0x30, 0xC0, 0x06, 0x38, 0x00, 0xC7, 0x00, 0x19, 0xE0, 0x03, 0x66, 0x00,
  0x6C, 0xC0, 0x0F, 0x0C, 0x01, 0xC1, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x80,
  0xC0, 0x30, 0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x06, 0x0C, 0x00, 0xC1,
  0x80, 0x0C, 0x30, 0x01, 0xC6, 0x00, 0x18, 0xC0, 0x03, 0x98, 0x00, 0x33,
  0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xB0, 0x00, 0x00, 0xFD,
  0x80, 0x00, 0x07, 0xEC, 0x00, 0x00, 0x6F, 0x30, 0x00, 0x03, 0x79, 0x80,
  0x00, 0x1B, 0xCC, 0x00, 0x01, 0x9E, 0x30, 0x00, 0x0C, 0xF1, 0x80, 0x00,
  0x67, 0x8C, 0x00, 0x06, 0x3C, 0x30, 0x00, 0x31, 0xE1, 0x80, 0x01, 0x8F,
  0x0C, 0x00, 0x18, 0x78, 0x30, 0x00, 0xC3, 0xC1, 0x80, 0x06, 0x1E, 0x0C,
  0x00, 0x60, 0xF0, 0x60, 0x03, 0x07, 0x81, 0x80, 0x18, 0x3C, 0x0C, 0x01,
  0x81, 0xE0, 0x70, 0x0C, 0x0F, 0x01, 0x80, 0x60, 0x78, 0x0C, 0x06, 0x03,
  0xC0, 0x60, 0x30, 0x1E, 0x01, 0x81, 0x80, 0xF0, 0x0C, 0x18, 0x07, 0x80,
  0x60, 0xC0, 0x3C, 0x01, 0x86, 0x01, 0xE0, 0x0C, 0x60, 0x0F, 0x00, 0x63,
  0x00, 0x78, 0x01, 0x98, 0x03, 0xC0, 0x0D, 0x80, 0x1E, 0x00, 0x6C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0x80,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xD8,
  0x00, 0x0F, 0x60, 0x00, 0x3C, 0xC0, 0x00, 0xF3, 0x80, 0x03, 0xC6, 0x00,
  0x0F, 0x1C, 0x00, 0x3C, 0x30, 0x00, 0xF0, 0xE0, 0x03, 0xC1, 0x80, 0x0F,
  0x07, 0x00, 0x3C, 0x0C, 0x00, 0xF0, 0x38, 0x03, 0xC0, 0x60, 0x0F, 0x01,
  0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0E, 0x03, 0xC0, 0x18, 0x0F, 0x00, 0x70,
  0x3C, 0x00, 0xC0, 0xF0, 0x01, 0x83, 0xC0, 0x06, 0x0F, 0x00, 0x0C, 0x3C,
  0x00, 0x30, 0xF0, 0x00, 0x63, 0xC0, 0x01, 0x8F, 0x00, 0x03, 0x3C, 0x00,
  0x0C, 0xF0, 0x00, 0x1B, 0xC0, 0x00, 0x6F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x00,
  0xE0, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x70, 0x00, 0x06, 0x30, 0x00,
  0x03, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C, 0x18, 0x00,
  0x0C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0C, 0x00, 0xE3, 0x00, 0x1C, 0xC0, 0x03, 0xB0, 0x00, 0x6C, 0x00, 0x1B,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03, 0x30, 0x01,
  0xCC, 0x00, 0xE3, 0x03, 0xF0, 0xFF, 0xF0, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x01, 0x80,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x0C, 0x70, 0x00, 0x06,
  0x30, 0x00, 0x03, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x0C,
  0x18, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0x00, 0x38, 0x60, 0x03, 0x8C, 0x00, 0x39, 0x80,
  0x03, 0x30, 0x00, 0x66, 0x00, 0x0E, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00,
  0x03, 0x60, 0x00, 0x6C, 0x00, 0x1D, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00,
  0x1C, 0xC0, 0x03, 0x18, 0x01, 0xC3, 0x00, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE,
  0x01, 0x80, 0xE0, 0x30, 0x0C, 0x06, 0x01, 0xC0, 0xC0, 0x18, 0x18, 0x03,
  0x83, 0x00, 0x30, 0x60, 0x07, 0x0C, 0x00, 0x61, 0x80, 0x0E, 0x30, 0x00,
  0xC6, 0x00, 0x1C, 0xC0, 0x01, 0x98, 0x00, 0x3B, 0x00, 0x03, 0x60, 0x00,
  0x7C, 0x00, 0x06, 0x00, 0x70, 0x01, 0xFF, 0xE0, 0xF0, 0x7C, 0x70, 0x02,
  0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3B, 0x00, 0x1C,
  0xFE, 0x3E, 0x1F, 0xFE, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0D, 0x80,
  0x00, 0xCC, 0x00, 0x06, 0x70, 0x00, 0x71, 0xC0, 0x03, 0x07, 0x00, 0x70,
  0x1F, 0x1F, 0x00, 0x7F, 0xF0, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x01, 0xC6, 0x00,
  0x03, 0x0C, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x30, 0x30, 0x00,
  0x60, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x81, 0x80, 0x06, 0x01, 0x80, 0x0C,
  0x03, 0x00, 0x18, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0x60, 0x01, 0x81, 0x80, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x06,
  0x18, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x33,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x06, 0x60, 0x00, 0xF0, 0x00, 0x66, 0x00, 0x0B, 0x00, 0x06, 0x60, 0x01,
  0xB0, 0x00, 0x66, 0x00, 0x19, 0x80, 0x0C, 0x30, 0x01, 0x98, 0x00, 0xC3,
  0x00, 0x19, 0x80, 0x0C, 0x30, 0x01, 0x18, 0x00, 0xC3, 0x00, 0x31, 0x80,
  0x1C, 0x18, 0x03, 0x0C, 0x01, 0x81, 0x80, 0x30, 0xC0, 0x18, 0x18, 0x03,
  0x0C, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x38, 0x18, 0x06, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x60, 0x30, 0x0C, 0x06, 0x06, 0x03, 0x00, 0xC0, 0x40, 0x60,
  0x30, 0x0C, 0x0C, 0x02, 0x06, 0x00, 0x60, 0xC0, 0x30, 0x60, 0x06, 0x0C,
  0x03, 0x06, 0x00, 0x60, 0xC0, 0x30, 0x60, 0x06, 0x18, 0x03, 0x0C, 0x00,
  0x31, 0x80, 0x18, 0xC0, 0x03, 0x18, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x18,
  0xC0, 0x03, 0x10, 0x01, 0x9C, 0x00, 0x33, 0x00, 0x09, 0x80, 0x01, 0xB0,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0xD8, 0x00,
  0x1A, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x33, 0x00, 0x06, 0x18,
  0x00, 0x61, 0x80, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x1C, 0x06, 0x01, 0x80,
  0x60, 0x38, 0x06, 0x03, 0x00, 0x30, 0x30, 0x03, 0x06, 0x00, 0x18, 0x60,
  0x01, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0xD8, 0x00, 0x0C,
  0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x03, 0x06, 0x00, 0x30, 0x60, 0x06,
  0x03, 0x00, 0x60, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x18, 0x01, 0xC1,
  0x80, 0x0C, 0x38, 0x00, 0xC3, 0x00, 0x06, 0x70, 0x00, 0x66, 0x00, 0x03,
  0xE0, 0x00, 0x30, 0xC0, 0x00, 0x36, 0x00, 0x06, 0x60, 0x00, 0x67, 0x00,
  0x06, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x01, 0xC1, 0x80, 0x18, 0x1C,
  0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x70, 0x06, 0x06, 0x00,
  0x60, 0x60, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x01, 0x9C, 0x00, 0x19, 0x80,
  0x01, 0x98, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xC3, 0x00,
  0x06, 0x18, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x30, 0x0C, 0x01, 0x80,
  0x60, 0x18, 0x03, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x86,
  0x00, 0x0C, 0x30, 0x00, 0x33, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xFF, 0xFF,
  0xF8, 0xE0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x07, 0xF0, 0x1F,
  0xFC, 0x38, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x7F, 0x07,
  0xFF, 0x1E, 0x03, 0x38, 0x03, 0x70, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x60, 0x0F, 0x70,
  0x1B, 0x38, 0x33, 0x1F, 0xE3, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC3, 0xF8,
  0x31, 0xFF, 0x0C, 0xC0, 0xE3, 0x60, 0x0C, 0xF0, 0x03, 0xB8, 0x00, 0x6E,
  0x00, 0x1B, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x6E,
  0x00, 0x1B, 0xC0, 0x06, 0xD0, 0x03, 0x36, 0x01, 0xCC, 0xE1, 0xE3, 0x1F,
  0xE0, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x78, 0x10, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x3C, 0x78, 0x3F, 0xE0, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x03, 0xF0, 0xC3, 0xFE, 0x31, 0xC0, 0xCC, 0xE0, 0x1B, 0x70,
  0x03, 0xD8, 0x00, 0x76, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x0F, 0x30, 0x02, 0xCE, 0x01,
  0xB1, 0xE1, 0xCC, 0x3F, 0xC3, 0x00, 0x80, 0x00, 0x03, 0xF0, 0x07, 0xFC,
  0x07, 0x03, 0x07, 0x00, 0xC3, 0x00, 0x73, 0x00, 0x19, 0x80, 0x0D, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x83, 0xC3, 0xC0, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0xF0,
  0x1F, 0xC1, 0xC2, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xFC, 0x7F, 0xE0, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x03, 0xF0, 0xC3, 0xFF, 0x31, 0xC0, 0xEC, 0xE0, 0x0B,
  0x70, 0x03, 0xD8, 0x00, 0x76, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x0F, 0x30, 0x02, 0xCE,
  0x01, 0xB1, 0xE1, 0xCC, 0x3F, 0xC3, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x10, 0x01, 0xC7, 0x83, 0xE0, 0xFF, 0xE0, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x3F, 0x06, 0x3F, 0xE3, 0x30, 0x39, 0xB0, 0x0C, 0xF0, 0x03,
  0x70, 0x01, 0xB8, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xDF, 0xE0, 0x00, 0x03, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0x80, 0x06, 0x07, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x0C, 0x9C, 0xF8, 0x60, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0xC0, 0x0C, 0xC0,
  0x18, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC1,
  0x80, 0xC3, 0x00, 0xC7, 0x00, 0xC6, 0x00, 0xCF, 0x00, 0xDB, 0x00, 0xD9,
  0x80, 0xF1, 0x80, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x60, 0xC0,
  0x30, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x06, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x83, 0xE0, 0x1F, 0x84, 0x7F, 0xC3, 0xFE, 0x36, 0x07, 0x38, 0x39,
  0xA0, 0x19, 0x00, 0xEE, 0x00, 0xD8, 0x03, 0x70, 0x03, 0x80, 0x1B, 0x80,
  0x1C, 0x00, 0xD8, 0x00, 0xE0, 0x06, 0xC0, 0x06, 0x00, 0x16, 0x00, 0x30,
  0x00, 0xF0, 0x01, 0x80, 0x07, 0x80, 0x0C, 0x00, 0x3C, 0x00, 0x60, 0x01,
  0xE0, 0x03, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x78, 0x00, 0xC0, 0x03, 0xC0,
  0x06, 0x00, 0x1E, 0x00, 0x30, 0x00, 0xF0, 0x01, 0x80, 0x07, 0x80, 0x0C,
  0x00, 0x3C, 0x00, 0x60, 0x01, 0xE0, 0x03, 0x00, 0x0F, 0x00, 0x18, 0x00,
  0x78, 0x00, 0xC0, 0x03, 0xC0, 0x06, 0x00, 0x1E, 0x00, 0x30, 0x00, 0xF0,
  0x01, 0x80, 0x07, 0x80, 0x0C, 0x00, 0x30, 0x83, 0xF0, 0x43, 0xFE, 0x33,
  0x03, 0x9B, 0x00, 0xEF, 0x00, 0x37, 0x00, 0x1B, 0x80, 0x0D, 0x80, 0x06,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x30, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xC0, 0xE0, 0xE0, 0x0C, 0x70, 0x03, 0x98, 0x00, 0x66, 0x00, 0x1B, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x36, 0x00, 0x19, 0x80,
  0x06, 0x30, 0x03, 0x06, 0x01, 0xC1, 0xF1, 0xE0, 0x1F, 0xE0, 0x00, 0x40,
  0x00, 0x81, 0xF8, 0x21, 0xFF, 0x0C, 0xC0, 0xE3, 0x60, 0x0C, 0xD0, 0x03,
  0xB8, 0x00, 0x6E, 0x00, 0x1B, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x6E, 0x00, 0x1B, 0xC0, 0x06, 0xD0, 0x03, 0x36, 0x01, 0xCC,
  0xF1, 0xE3, 0x1F, 0xE0, 0xC0, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x60, 0xFF, 0x8C,
  0x38, 0x19, 0x8E, 0x01, 0xB3, 0x80, 0x1E, 0x60, 0x01, 0xCC, 0x00, 0x3B,
  0x00, 0x07, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x36,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C,
  0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x0E, 0xC0, 0x01, 0xCC,
  0x00, 0x39, 0x80, 0x0F, 0x18, 0x01, 0x63, 0x80, 0xCC, 0x3C, 0x79, 0x83,
  0xFC, 0x30, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xC3, 0xF8, 0xFF, 0x30, 0x6C, 0x0D,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x00, 0x07, 0xF0, 0x3F,
  0xFC, 0xE0, 0x33, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0D, 0x00, 0x3B, 0xE3, 0xE3,
  0xFF, 0x00, 0x30, 0x00, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x07, 0xFF, 0xFF, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0,
  0x0E, 0x20, 0xFC, 0x06, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x05, 0x60, 0x0D, 0x70, 0x19, 0x3C, 0x71, 0x1F,
  0xE1, 0x03, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x36, 0x00, 0x19, 0x80, 0x06,
  0x60, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x06,
  0x01, 0x81, 0x80, 0x60, 0x60, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x00, 0xC0,
  0xC0, 0x30, 0x30, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x08, 0x60,
  0x03, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x06, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0x00, 0xC0, 0x06, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x0D, 0x80, 0x0E, 0x00, 0x66, 0x00, 0xD0, 0x03,
  0x30, 0x06, 0xC0, 0x19, 0x80, 0x36, 0x01, 0x8C, 0x01, 0x30, 0x0C, 0x20,
  0x18, 0x80, 0x61, 0x80, 0xC6, 0x03, 0x0C, 0x06, 0x30, 0x10, 0x60, 0x21,
  0x81, 0x83, 0x03, 0x0C, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0x60, 0xC1, 0x82,
  0x03, 0x04, 0x0C, 0x30, 0x18, 0x60, 0x61, 0x80, 0x63, 0x01, 0x8C, 0x03,
  0x18, 0x0C, 0x60, 0x18, 0x80, 0x66, 0x00, 0xCC, 0x03, 0x30, 0x03, 0x60,
  0x0D, 0x80, 0x1B, 0x00, 0x6C, 0x00, 0xD0, 0x03, 0x40, 0x06, 0x80, 0x1E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x01, 0xB0, 0x01, 0xCC, 0x00, 0xC6, 0x00, 0xE1, 0x80, 0x60, 0xC0,
  0x60, 0x30, 0x30, 0x18, 0x30, 0x06, 0x18, 0x03, 0x18, 0x00, 0xCC, 0x00,
  0x6C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x03, 0x60,
  0x01, 0x98, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0xE0, 0x60, 0x60,
  0x38, 0x70, 0x0C, 0x30, 0x07, 0x30, 0x01, 0x98, 0x00, 0xF8, 0x00, 0x30,
  0x60, 0x00, 0x6C, 0x00, 0x19, 0x80, 0x03, 0x18, 0x00, 0x63, 0x00, 0x18,
  0x60, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x03, 0x00, 0x60,
  0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x01, 0x83, 0x00,
  0x30, 0x60, 0x06, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x60, 0x01, 0x8C, 0x00,
  0x11, 0x80, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x00, 0xB0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x27, 0x80, 0x07, 0xE0, 0x00, 0x60,
  0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3C, 0x03, 0xF0, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x3F, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x03, 0xF0,
  0x00, 0xE0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x01, 0xE0, 0xF0, 0x78,
  0x03, 0xFE, 0x80, 0x0F, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraLight52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 37, 11, 4, -37 },
  { 15, 10, 13, 17, 3, -37 },
  { 32, 24, 37, 26, 1, -37 },
  { 143, 19, 43, 24, 2, -40 },
  { 246, 30, 38, 34, 2, -38 },
  { 389, 23, 39, 26, 2, -38 },
  { 502, 3, 13, 9, 3, -37 },
  { 507, 10, 45, 14, 2, -37 },
  { 564, 9, 45, 14, 2, -37 },
  { 615, 17, 17, 21, 2, -40 },
  { 652, 20, 24, 24, 2, -30 },
  { 712, 5, 13, 10, 2, -6 },
  { 721, 11, 2, 15, 2, -15 },
  { 724, 3, 4, 10, 4, -4 },
  { 726, 16, 37, 17, 1, -37 },
  { 800, 18, 38, 24, 3, -38 },
  { 886, 10, 37, 24, 4, -37 },
  { 933, 19, 38, 24, 2, -38 },
  { 1024, 19, 39, 24, 2, -38 },
  { 1117, 22, 37, 24, 1, -37 },
  { 1219, 18, 37, 24, 3, -37 },
  { 1303, 18, 39, 24, 3, -38 },
  { 1391, 19, 37, 24, 2, -37 },
  { 1479, 19, 39, 24, 2, -38 },
  { 1572, 19, 39, 24, 2, -38 },
  { 1665, 3, 28, 11, 4, -28 },
  { 1676, 5, 35, 10, 2, -28 },
  { 1698, 20, 23, 24, 2, -30 },
  { 1756, 20, 13, 24, 2, -25 },
  { 1789, 20, 23, 24, 2, -30 },
  { 1847, 14, 38, 16, 1, -38 },
  { 1914, 30, 42, 36, 3, -37 },
  { 2072, 23, 37, 23, 0, -37 },
  { 2179, 19, 37, 26, 4, -37 },
  { 2267, 21, 39, 25, 3, -38 },
  { 2370, 21, 37, 28, 4, -37 },
  { 2468, 16, 37, 23, 4, -37 },
  { 2542, 16, 37, 21, 4, -37 },
  { 2616, 24, 39, 30, 3, -38 },
  { 2733, 21, 37, 29, 4, -37 },
  { 2831, 9, 37, 13, 2, -37 },
  { 2873, 10, 46, 11, -3, -37 },
  { 2931, 19, 37, 23, 4, -37 },
  { 3019, 16, 37, 21, 4, -37 },
  { 3093, 29, 37, 37, 4, -37 },
  { 3228, 22, 37, 30, 4, -37 },
  { 3330, 25, 39, 31, 3, -38 },
  { 3452, 18, 37, 24, 4, -37 },
  { 3536, 25, 47, 31, 3, -38 },
  { 3683, 19, 37, 24, 4, -37 },
  { 3771, 18, 39, 23, 2, -38 },
  { 3859, 20, 37, 21, 0, -37 },
  { 3952, 21, 38, 29, 4, -37 },
  { 4052, 23, 37, 23, 0, -37 },
  { 4159, 36, 37, 38, 1, -37 },
  { 4326, 20, 37, 21, 0, -37 },
  { 4419, 20, 37, 20, 0, -37 },
  { 4512, 18, 37, 21, 2, -37 },
  { 4596, 10, 45, 16, 4, -37 },
  { 4653, 16, 37, 17, 1, -37 },
  { 4727, 10, 45, 16, 2, -37 },
  { 4784, 21, 19, 24, 1, -37 },
  { 4834, 21, 1, 21, 0, 5 },
  { 4837, 8, 8, 12, 2, -40 },
  { 4845, 16, 29, 22, 2, -28 },
  { 4903, 18, 41, 25, 4, -40 },
  { 4996, 15, 29, 19, 3, -28 },
  { 5051, 18, 41, 25, 3, -40 },
  { 5144, 17, 29, 23, 3, -28 },
  { 5206, 13, 40, 12, 1, -40 },
  { 5271, 18, 41, 25, 3, -28 },
  { 5364, 17, 40, 24, 4, -40 },
  { 5449, 3, 38, 10, 4, -38 },
  { 5464, 8, 51, 10, -1, -38 },
  { 5515, 16, 40, 20, 4, -40 },
  { 5595, 2, 40, 10, 4, -40 },
  { 5605, 29, 28, 36, 4, -28 },
  { 5707, 17, 28, 24, 4, -28 },
  { 5767, 18, 29, 24, 3, -28 },
  { 5833, 18, 40, 25, 4, -28 },
  { 5923, 19, 40, 25, 2, -28 },
  { 6018, 11, 28, 16, 4, -28 },
  { 6057, 15, 29, 19, 2, -28 },
  { 6112, 11, 35, 13, 1, -34 },
  { 6161, 16, 29, 24, 4, -28 },
  { 6219, 18, 28, 18, 0, -28 },
  { 6282, 29, 28, 30, 1, -28 },
  { 6384, 17, 28, 20, 1, -28 },
  { 6444, 19, 41, 19, 0, -28 },
  { 6542, 13, 28, 17, 2, -28 },
  { 6588, 14, 45, 18, 2, -37 },
  { 6667, 2, 53, 22, 10, -40 },
  { 6681, 14, 45, 18, 2, -37 },
  { 6760, 20, 5, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_ExtraLight52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight52pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT52PT7B_H_
