#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT65PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight65pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x06, 0xFF, 0xFF,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x36, 0x03,
  0x60, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x03,
  0x00, 0x1C, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x38, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0,
  0x1C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06,
  0x00, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x38, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0C,
  0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30, 0x06, 0x00, 0x01, 0xC0, 0x18,
  0x03, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0E, 0x00,
  0x01, 0x80, 0x38, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30,
  0x03, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0x30, 0x06, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x06, 0x00, 0x60,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0x07, 0x8C,
  0x1E, 0x1C, 0x18, 0x0C, 0x70, 0x30, 0x00, 0xC0, 0x60, 0x03, 0x80, 0xC0,
  0x07, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00,
  0x60, 0x18, 0x00, 0xC0, 0x30, 0x01, 0xC0, 0x60, 0x03, 0x80, 0xC0, 0x03,
  0x81, 0x80, 0x03, 0x83, 0x00, 0x07, 0x86, 0x00, 0x07, 0xCC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xBE, 0x00, 0x03, 0x1E, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x18,
  0x0E, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x07,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0x38, 0x00, 0xC0, 0xE6, 0x01, 0x83, 0xCF,
  0x83, 0x1F, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x08, 0x01, 0xFE, 0x00, 0x03, 0x00, 0x1C,
  0x70, 0x00, 0x30, 0x03, 0x83, 0x80, 0x06, 0x00, 0x30, 0x18, 0x00, 0x60,
  0x06, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x0E, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x0E, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x30, 0x00, 0xC0, 0x0E, 0x03, 0x00,
  0x0C, 0x00, 0xE0, 0x60, 0x00, 0xC0, 0x0E, 0x06, 0x00, 0x0C, 0x00, 0xE0,
  0xE0, 0x00, 0xC0, 0x0E, 0x0C, 0x00, 0x0C, 0x00, 0xE0, 0xC0, 0x00, 0xC0,
  0x0E, 0x18, 0x04, 0x0E, 0x00, 0xC1, 0x83, 0xF0, 0x60, 0x0C, 0x38, 0x7F,
  0xC6, 0x00, 0xC3, 0x0E, 0x0C, 0x60, 0x0C, 0x31, 0xC0, 0xE6, 0x01, 0xC6,
  0x18, 0x06, 0x30, 0x18, 0x61, 0x80, 0x63, 0x83, 0x8E, 0x38, 0x07, 0x1C,
  0x70, 0xC3, 0x00, 0x31, 0xFE, 0x0C, 0x30, 0x03, 0x07, 0xC1, 0xC3, 0x00,
  0x30, 0x00, 0x18, 0x30, 0x03, 0x00, 0x03, 0x83, 0x00, 0x30, 0x00, 0x30,
  0x30, 0x03, 0x00, 0x03, 0x03, 0x00, 0x30, 0x00, 0x70, 0x30, 0x03, 0x00,
  0x06, 0x03, 0x00, 0x30, 0x00, 0xE0, 0x30, 0x03, 0x00, 0x0C, 0x03, 0x00,
  0x30, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x1C, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x38, 0x03, 0x80, 0x70, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x60, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x60, 0x00, 0xE0,
  0xC0, 0x0E, 0x00, 0x07, 0xF8, 0x00, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x0E, 0x03, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x30, 0x03, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x60,
  0x07, 0x00, 0x03, 0x00, 0x38, 0x00, 0x18, 0x01, 0xC0, 0x00, 0xC0, 0x0C,
  0x00, 0x06, 0x00, 0x60, 0x00, 0x38, 0x07, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x18, 0x18, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x07, 0x03, 0x00, 0x18, 0x70, 0x1C, 0x00, 0xC7, 0x00, 0x70, 0x06, 0x30,
  0x01, 0x80, 0x73, 0x80, 0x0E, 0x03, 0x9C, 0x00, 0x38, 0x18, 0xC0, 0x00,
  0xE0, 0xC6, 0x00, 0x07, 0x0E, 0x30, 0x00, 0x1C, 0x61, 0x80, 0x00, 0x77,
  0x0C, 0x00, 0x01, 0xB0, 0x60, 0x00, 0x0F, 0x83, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1F, 0x03, 0x00, 0x01, 0xDC, 0x1C, 0x00,
  0x1C, 0x70, 0x70, 0x01, 0xE3, 0x81, 0xC0, 0x3E, 0x0E, 0x07, 0xFF, 0xC0,
  0x38, 0x1F, 0xFC, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xDB, 0x6D,
  0xB6, 0xDB, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0xF0, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00,
  0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x40, 0x60, 0x1F, 0x02, 0x0F, 0x7E, 0x27,
  0xF0, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xD8, 0x00, 0x18,
  0xC0, 0x03, 0x8C, 0x00, 0x70, 0x60, 0x06, 0x03, 0x00, 0xC0, 0x38, 0x1C,
  0x01, 0xC0, 0x80, 0x08, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x70, 0xC1,
  0x87, 0x0C, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x73, 0xBE,
  0xF7, 0x00, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0x0F, 0x00, 0x38, 0x07, 0x00, 0xE0, 0x07, 0x03,
  0x80, 0x0E, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x60,
  0x00, 0x38, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x67, 0x00, 0x00, 0xCC, 0x00,
  0x01, 0x98, 0x00, 0x03, 0xB0, 0x00, 0x07, 0x60, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xD8,
  0x00, 0x03, 0xB0, 0x00, 0x07, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x19, 0xC0,
  0x00, 0x33, 0x80, 0x00, 0x67, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x8E, 0x00,
  0x06, 0x1C, 0x00, 0x0C, 0x18, 0x00, 0x38, 0x38, 0x00, 0x60, 0x38, 0x01,
  0xC0, 0x70, 0x07, 0x00, 0x78, 0x1C, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x07, 0xC0, 0x7E, 0x07, 0x70, 0x73, 0x87,
  0x1C, 0x70, 0xEF, 0x07, 0xF0, 0x3B, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0xFC, 0x1F, 0x03, 0xC0, 0x0F, 0x02, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0xFC, 0x1F, 0x07, 0xC0, 0x07, 0x0E, 0x00, 0x07,
  0x08, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE4, 0x00, 0x07, 0x8F, 0x00, 0x3E, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x06, 0x18, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x0C,
  0x18, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x18, 0x18, 0x00, 0x03, 0x81, 0x80,
  0x00, 0x30, 0x18, 0x00, 0x06, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x0C,
  0x01, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x18, 0x01, 0x80, 0x03, 0x80, 0x18,
  0x00, 0x30, 0x01, 0x80, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x18, 0x01, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x18, 0x03, 0x80, 0x01,
  0x80, 0x30, 0x00, 0x18, 0x07, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x3F, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xBF, 0xC1, 0x80,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x88, 0x00, 0x1E, 0x38,
  0x01, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x03, 0xF8, 0xE0, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x20, 0x03, 0x07, 0xFE, 0x06, 0x3F, 0xFE, 0x0C,
  0xE0, 0x1E, 0x1B, 0x80, 0x0E, 0x76, 0x00, 0x0C, 0xF8, 0x00, 0x1D, 0xE0,
  0x00, 0x1B, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x1B, 0x80, 0x00, 0x37, 0x00, 0x00, 0xEE, 0x00, 0x01,
  0xCC, 0x00, 0x03, 0x9C, 0x00, 0x06, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x38,
  0x70, 0x00, 0xE0, 0x70, 0x03, 0xC0, 0x70, 0x0F, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0x83, 0xE0, 0x1E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x18,
  0x30, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x0C,
  0x70, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x1C,
  0x30, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x70,
  0x0F, 0x00, 0xE0, 0x07, 0x83, 0xC0, 0x01, 0xC7, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xC7, 0x80, 0x07, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x38, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x60, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0xF0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x3E, 0x1F, 0x00, 0xF0, 0x0F, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x1C,
  0x00, 0x0C, 0x38, 0x00, 0x1C, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x33, 0x80,
  0x00, 0x77, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xEC, 0x00, 0x03, 0xDC, 0x00, 0x07,
  0xB8, 0x00, 0x1F, 0x38, 0x00, 0x6E, 0x38, 0x01, 0xDC, 0x7C, 0x0F, 0x38,
  0x3F, 0xF8, 0x60, 0x3F, 0xE0, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0xC0, 0x00,
  0x33, 0xBF, 0xF7, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xCE, 0xFB, 0xDC, 0x0C, 0x3C,
  0x78, 0xF1, 0xE1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1,
  0xC7, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xC3, 0x80,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x0F, 0xFF, 0x0F, 0xC3, 0xE1, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x01, 0x83,
  0x00, 0x0F, 0xFC, 0x03, 0x8E, 0x00, 0x3F, 0xF8, 0x07, 0x18, 0x00, 0xE0,
  0x30, 0x06, 0x30, 0x03, 0x80, 0x60, 0x0C, 0xE0, 0x0E, 0x00, 0xC0, 0x19,
  0xC0, 0x18, 0x01, 0x80, 0x3B, 0x00, 0x70, 0x03, 0x00, 0x76, 0x00, 0xC0,
  0x06, 0x00, 0xEC, 0x01, 0x80, 0x0C, 0x01, 0xD8, 0x07, 0x00, 0x38, 0x03,
  0xB0, 0x0E, 0x00, 0x70, 0x07, 0xE0, 0x18, 0x00, 0xE0, 0x0F, 0xC0, 0x30,
  0x01, 0xC0, 0x1F, 0x80, 0x60, 0x03, 0x80, 0x3F, 0x00, 0xC0, 0x07, 0x00,
  0x7E, 0x01, 0x80, 0x0E, 0x00, 0xDC, 0x03, 0x00, 0x1C, 0x01, 0x98, 0x07,
  0x00, 0x38, 0x03, 0x30, 0x0E, 0x00, 0xF0, 0x06, 0x60, 0x0C, 0x01, 0xE0,
  0x1C, 0xC0, 0x18, 0x02, 0xC0, 0x31, 0x80, 0x38, 0x0D, 0x80, 0xE3, 0x00,
  0x38, 0x39, 0x83, 0x87, 0x00, 0x79, 0xE3, 0xDF, 0x06, 0x00, 0x7F, 0x83,
  0xFC, 0x0C, 0x00, 0x3C, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x73, 0x00, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xE0, 0x18, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x30, 0x07, 0x00, 0x01, 0x80, 0x38, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x30, 0x38, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0xE0, 0x01, 0xF0, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0xF0, 0xE0, 0x1F, 0xC0,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x38,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xE1,
  0xFC, 0x07, 0x80, 0x06, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x02, 0x01, 0xF0, 0x03, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0x80, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0x80, 0x0F,
  0xC0, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x38,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x1C, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x37, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x06, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x0E, 0x38,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x0F,
  0x03, 0x80, 0x03, 0xC0, 0x70, 0x0F, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x08,
  0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x71, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x07, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x70, 0xFF,
  0xE7, 0xE0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E,
  0x81, 0xEF, 0xFC, 0xFF, 0x80, 0x80, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00,
  0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x00,
  0xE0, 0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xE0, 0x00,
  0xE1, 0xC0, 0x00, 0xE3, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0xE7, 0xC0, 0x00,
  0xEE, 0xE0, 0x00, 0xEC, 0x60, 0x00, 0xF8, 0x70, 0x00, 0xF8, 0x38, 0x00,
  0xF0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80,
  0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xBE, 0xC0, 0x00, 0x00, 0x1B, 0xEC, 0x00,
  0x00, 0x03, 0xBE, 0xE0, 0x00, 0x00, 0x3B, 0xE6, 0x00, 0x00, 0x03, 0x3E,
  0x60, 0x00, 0x00, 0x73, 0xE7, 0x00, 0x00, 0x07, 0x3E, 0x30, 0x00, 0x00,
  0x63, 0xE3, 0x00, 0x00, 0x0E, 0x3E, 0x38, 0x00, 0x00, 0xE3, 0xE1, 0x80,
  0x00, 0x0C, 0x3E, 0x18, 0x00, 0x01, 0xC3, 0xE1, 0xC0, 0x00, 0x1C, 0x3E,
  0x0C, 0x00, 0x01, 0x83, 0xE0, 0xC0, 0x00, 0x38, 0x3E, 0x0E, 0x00, 0x03,
  0x83, 0xE0, 0x60, 0x00, 0x30, 0x3E, 0x06, 0x00, 0x07, 0x03, 0xE0, 0x70,
  0x00, 0x70, 0x3E, 0x03, 0x00, 0x06, 0x03, 0xE0, 0x30, 0x00, 0xE0, 0x3E,
  0x03, 0x80, 0x0E, 0x03, 0xE0, 0x18, 0x00, 0xC0, 0x3E, 0x01, 0x80, 0x1C,
  0x03, 0xE0, 0x1C, 0x01, 0xC0, 0x3E, 0x00, 0xC0, 0x18, 0x03, 0xE0, 0x0C,
  0x03, 0x80, 0x3E, 0x00, 0xE0, 0x38, 0x03, 0xE0, 0x06, 0x03, 0x00, 0x3E,
  0x00, 0x60, 0x70, 0x03, 0xE0, 0x07, 0x07, 0x00, 0x3E, 0x00, 0x30, 0x60,
  0x03, 0xE0, 0x03, 0x0E, 0x00, 0x3E, 0x00, 0x38, 0xE0, 0x03, 0xE0, 0x01,
  0x8C, 0x00, 0x3E, 0x00, 0x19, 0xC0, 0x03, 0xE0, 0x01, 0xDC, 0x00, 0x3E,
  0x00, 0x0D, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xD8, 0x00, 0x00, 0xFB, 0x80, 0x00, 0x1F, 0x30, 0x00,
  0x03, 0xE7, 0x00, 0x00, 0x7C, 0x60, 0x00, 0x0F, 0x8E, 0x00, 0x01, 0xF0,
  0xC0, 0x00, 0x3E, 0x1C, 0x00, 0x07, 0xC1, 0x80, 0x00, 0xF8, 0x38, 0x00,
  0x1F, 0x03, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x7C, 0x06, 0x00, 0x0F, 0x80,
  0xE0, 0x01, 0xF0, 0x0C, 0x00, 0x3E, 0x01, 0xC0, 0x07, 0xC0, 0x18, 0x00,
  0xF8, 0x03, 0x80, 0x1F, 0x00, 0x30, 0x03, 0xE0, 0x07, 0x00, 0x7C, 0x00,
  0x60, 0x0F, 0x80, 0x0E, 0x01, 0xF0, 0x00, 0xC0, 0x3E, 0x00, 0x1C, 0x07,
  0xC0, 0x01, 0xC0, 0xF8, 0x00, 0x38, 0x1F, 0x00, 0x03, 0x83, 0xE0, 0x00,
  0x70, 0x7C, 0x00, 0x07, 0x0F, 0x80, 0x00, 0xE1, 0xF0, 0x00, 0x0E, 0x3E,
  0x00, 0x01, 0xC7, 0xC0, 0x00, 0x1C, 0xF8, 0x00, 0x03, 0x9F, 0x00, 0x00,
  0x3B, 0xE0, 0x00, 0x07, 0x7C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0E, 0x00, 0x7E,
  0x38, 0x00, 0x3C, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xB8, 0x00, 0x0E, 0xE0,
  0x00, 0x3B, 0x80, 0x01, 0xCE, 0x00, 0x0E, 0x38, 0x01, 0xF0, 0xFF, 0xFF,
  0x83, 0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x03, 0x86, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x07, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0xE0, 0x07, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x18, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0,
  0x00, 0x0C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0xE0, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xE0,
  0x1C, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0xE0,
  0x07, 0x00, 0xE0, 0x03, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x01, 0x80, 0xE0,
  0x01, 0xC0, 0xE0, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x07, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x3F, 0x07, 0xF0, 0xF0,
  0x00, 0xC3, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE4, 0x00, 0x07, 0x8F, 0x00, 0x3E, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x0F, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0xE0, 0x3E, 0x00, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x77, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x0E, 0x30, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x01,
  0xC1, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x18, 0x0C,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0x30, 0x06, 0x00, 0x07, 0x00, 0x60, 0x00, 0x70, 0x07, 0x00, 0x06, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80,
  0x0C, 0x00, 0x18, 0x01, 0xC0, 0x01, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0x80,
  0x01, 0xC0, 0x18, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x0E,
  0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x06, 0x07, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x98, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x0D,
  0x80, 0x00, 0x31, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xD8,
  0x00, 0x07, 0x0C, 0x00, 0x03, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x1D, 0xC0,
  0x00, 0x60, 0xE0, 0x00, 0x73, 0x00, 0x01, 0x83, 0x80, 0x01, 0x8C, 0x00,
  0x0E, 0x06, 0x00, 0x06, 0x30, 0x00, 0x38, 0x18, 0x00, 0x38, 0xE0, 0x00,
  0xE0, 0x60, 0x00, 0xE3, 0x80, 0x03, 0x01, 0xC0, 0x03, 0x06, 0x00, 0x1C,
  0x07, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x70, 0x01, 0xC0,
  0x30, 0x01, 0xC1, 0xC0, 0x06, 0x00, 0xE0, 0x07, 0x03, 0x00, 0x18, 0x03,
  0x80, 0x18, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x30, 0x03, 0x80, 0x18,
  0x03, 0x80, 0xE0, 0x0C, 0x00, 0x70, 0x0E, 0x03, 0x80, 0x30, 0x01, 0xC0,
  0x30, 0x06, 0x01, 0xC0, 0x03, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x0C, 0x03,
  0x00, 0x70, 0x18, 0x00, 0x30, 0x1C, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x70,
  0x03, 0x03, 0x80, 0x03, 0x81, 0x80, 0x0C, 0x0E, 0x00, 0x06, 0x06, 0x00,
  0x30, 0x38, 0x00, 0x18, 0x38, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xE0, 0x01,
  0x87, 0x00, 0x01, 0xC3, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x0C, 0x00, 0x18,
  0x70, 0x00, 0x0C, 0x30, 0x00, 0x71, 0x80, 0x00, 0x39, 0xC0, 0x01, 0xC6,
  0x00, 0x00, 0xE7, 0x00, 0x03, 0x38, 0x00, 0x03, 0x98, 0x00, 0x0C, 0xE0,
  0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0xEC, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xB0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x86, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x18,
  0x0E, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x18, 0x07, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x38, 0x38, 0x00, 0x06, 0x0C, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0xB0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0xC0, 0x00,
  0x03, 0x38, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x38, 0x30,
  0x00, 0x0C, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x01, 0x80, 0x70, 0x00, 0xE0,
  0x1C, 0x00, 0x30, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x03,
  0x80, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E,
  0x06, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x0C, 0x70, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x01, 0x9C,
  0x00, 0x01, 0xC6, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x70,
  0x60, 0x00, 0x30, 0x38, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x07, 0x00, 0x0C,
  0x03, 0x80, 0x0E, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x18, 0x03,
  0x80, 0x0E, 0x01, 0x80, 0x07, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0x30, 0x70, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x03,
  0x18, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x87, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x70, 0x38, 0x00,
  0x18, 0x06, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x00, 0x30, 0x01, 0xC0, 0x0E,
  0x00, 0x60, 0x01, 0x80, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x0C, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x3F,
  0x07, 0x81, 0x80, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0xFF, 0x01, 0xFF,
  0xF0, 0x7F, 0x07, 0x1E, 0x00, 0x73, 0x80, 0x07, 0x70, 0x00, 0x76, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xF7,
  0x00, 0x37, 0x78, 0x06, 0x33, 0xF7, 0xC3, 0x1F, 0xF8, 0x30, 0x1C, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x3F, 0x80, 0x61, 0xFF, 0xC0, 0xC7, 0x83,
  0xE1, 0x9C, 0x01, 0xE3, 0x30, 0x01, 0xC6, 0xC0, 0x01, 0xCD, 0x00, 0x01,
  0x9E, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0D,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x1D, 0xE0, 0x00,
  0x3B, 0xC0, 0x00, 0x66, 0x80, 0x01, 0xCD, 0x80, 0x07, 0x19, 0x80, 0x1E,
  0x33, 0xC0, 0x78, 0x63, 0xFF, 0xE0, 0xC1, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x0F, 0xC3, 0x83, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x20, 0x7F, 0xFC, 0x07, 0xFF, 0x80,
  0x1E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x3F, 0x81, 0x81, 0xFF, 0xC3,
  0x07, 0xC3, 0xC6, 0x1C, 0x01, 0xCC, 0x70, 0x00, 0xD8, 0xE0, 0x01, 0xB3,
  0x80, 0x01, 0xE6, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x60,
  0x00, 0x0E, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xB0, 0x00, 0x07, 0x70, 0x00, 0x0E,
  0xE0, 0x00, 0x1C, 0xC0, 0x00, 0x79, 0xC0, 0x00, 0xB1, 0x80, 0x03, 0x63,
  0x80, 0x0C, 0xC3, 0xC0, 0x39, 0x83, 0xFF, 0xE3, 0x03, 0xFF, 0x06, 0x00,
  0x70, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7C, 0x3C, 0x03, 0xC0,
  0x38, 0x1C, 0x00, 0x70, 0x70, 0x00, 0xC3, 0x80, 0x03, 0x8C, 0x00, 0x06,
  0x30, 0x00, 0x19, 0xC0, 0x00, 0x66, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x60,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x02, 0x07, 0x80, 0x38, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x0C, 0x1F, 0x0F,
  0x18, 0x70, 0x03, 0x31, 0xC0, 0x03, 0x63, 0x80, 0x02, 0xCE, 0x00, 0x07,
  0x98, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x3B,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xB0, 0x00,
  0x07, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x73, 0x00, 0x01, 0xE7, 0x00, 0x02, 0xC7, 0x00, 0x0D, 0x8E, 0x00, 0x33,
  0x0F, 0x00, 0xC6, 0x0F, 0xFF, 0x0C, 0x0F, 0xFC, 0x18, 0x01, 0xC0, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x08, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x03, 0xF8, 0x18, 0x7F,
  0xF0, 0xC7, 0xC7, 0xC6, 0x70, 0x0F, 0x33, 0x00, 0x39, 0xB0, 0x00, 0xED,
  0x00, 0x07, 0x78, 0x00, 0x1B, 0x80, 0x00, 0xDC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x38, 0x7F, 0xF7, 0x60, 0x00, 0x00, 0x00, 0x07, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x70, 0x03, 0x83, 0xC1, 0xE0, 0x70, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xEF,
  0xE7, 0xE1, 0xC0, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x0E, 0xC0, 0x03, 0x98, 0x00, 0x63, 0x00, 0x1C,
  0x60, 0x07, 0x0C, 0x00, 0xC1, 0x80, 0x38, 0x30, 0x0E, 0x06, 0x03, 0x80,
  0xC0, 0x60, 0x18, 0x1C, 0x03, 0x07, 0x00, 0x60, 0xC0, 0x0C, 0x38, 0x01,
  0x8F, 0x80, 0x33, 0xF0, 0x06, 0x67, 0x00, 0xD8, 0xE0, 0x1F, 0x0E, 0x03,
  0xC1, 0xC0, 0x70, 0x1C, 0x0C, 0x03, 0x81, 0x80, 0x38, 0x30, 0x07, 0x06,
  0x00, 0x70, 0xC0, 0x0E, 0x18, 0x00, 0xE3, 0x00, 0x1C, 0x60, 0x01, 0xCC,
  0x00, 0x39, 0x80, 0x03, 0xB0, 0x00, 0x76, 0x00, 0x07, 0xC0, 0x00, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x0C, 0x3F, 0xF0, 0x3F, 0xF0, 0xC7, 0x0F,
  0x07, 0x87, 0x8C, 0xC0, 0x38, 0xE0, 0x1C, 0xD8, 0x01, 0xCC, 0x00, 0xED,
  0x00, 0x0D, 0x80, 0x0E, 0xF0, 0x00, 0xD0, 0x00, 0x6E, 0x00, 0x0F, 0x00,
  0x06, 0xE0, 0x00, 0xF0, 0x00, 0x6E, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x00,
  0x60, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x00, 0x60, 0x00, 0x7C,
  0x00, 0x06, 0x00, 0x07, 0xC0, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x06, 0x00,
  0x07, 0xC0, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x00,
  0x60, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x00, 0x60, 0x00, 0x7C,
  0x00, 0x06, 0x00, 0x07, 0xC0, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x06, 0x00,
  0x07, 0xC0, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x00,
  0x60, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x00, 0x60, 0x00, 0x7C,
  0x00, 0x06, 0x00, 0x07, 0xC0, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x06, 0x00,
  0x07, 0xC0, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0xFE, 0x06, 0x1F, 0xFC, 0x31, 0xE0, 0xF1, 0x9C,
  0x01, 0xCC, 0xC0, 0x0E, 0x6C, 0x00, 0x3B, 0x40, 0x01, 0xDE, 0x00, 0x06,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0E, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xC3, 0xE0, 0x0E, 0x00, 0x70, 0x1C,
  0x00, 0x38, 0x18, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x38,
  0x00, 0x0C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x0F,
  0x00, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x7E, 0x01, 0x83, 0xFF, 0x03, 0x1F, 0x0F, 0x86, 0x70, 0x07, 0x8C, 0xC0,
  0x07, 0x1B, 0x00, 0x07, 0x36, 0x00, 0x06, 0x78, 0x00, 0x0E, 0xF0, 0x00,
  0x1D, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x37, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0D, 0xC0,
  0x00, 0x1B, 0x80, 0x00, 0x77, 0x80, 0x00, 0xEF, 0x00, 0x01, 0x9B, 0x00,
  0x07, 0x36, 0x00, 0x1C, 0x66, 0x00, 0x78, 0xC7, 0x01, 0xE1, 0x87, 0xFF,
  0x83, 0x07, 0xFC, 0x06, 0x01, 0xE0, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x0C, 0x1F, 0x0F, 0x18, 0x78, 0x07, 0x31, 0xC0,
  0x07, 0x63, 0x80, 0x06, 0xCE, 0x00, 0x07, 0x98, 0x00, 0x0F, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x60, 0x00, 0x0E, 0xC0,
  0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xF3, 0x00, 0x01, 0xE7, 0x00,
  0x06, 0xC7, 0x00, 0x0D, 0x8F, 0x00, 0x33, 0x0F, 0x01, 0xC6, 0x0F, 0xFF,
  0x0C, 0x0F, 0xFC, 0x18, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0xFB, 0x0F, 0xFC, 0x7F, 0xF3, 0x80, 0xCC, 0x03, 0x60, 0x0D, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xFE, 0x01, 0xFF, 0xFC, 0x7C, 0x0F, 0x1E, 0x00, 0x23, 0x80,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x74, 0x00, 0x0E, 0xF0, 0x07, 0x9F, 0xFF, 0xE0, 0x7F, 0xF8,
  0x01, 0xF0, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xC3, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x1C, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xF7, 0x00, 0x1B, 0x70,
  0x03, 0xB3, 0x80, 0x73, 0x1F, 0xFE, 0x30, 0xFF, 0x83, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x0D, 0x80, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x06, 0x30,
  0x00, 0x18, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0C, 0x18, 0x00,
  0x70, 0x60, 0x01, 0xC1, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0xE0,
  0x38, 0x03, 0x80, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x1C,
  0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0C,
  0x00, 0x18, 0x30, 0x00, 0x61, 0xC0, 0x01, 0xC6, 0x00, 0x03, 0x18, 0x00,
  0x0C, 0xE0, 0x00, 0x33, 0x80, 0x00, 0xEC, 0x00, 0x01, 0xB0, 0x00, 0x06,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x76,
  0x00, 0x0F, 0x00, 0x06, 0x60, 0x00, 0xD8, 0x00, 0x67, 0x00, 0x1D, 0x80,
  0x0E, 0x70, 0x01, 0x98, 0x00, 0xE3, 0x00, 0x19, 0x80, 0x0C, 0x30, 0x01,
  0x9C, 0x00, 0xC3, 0x80, 0x38, 0xC0, 0x1C, 0x38, 0x03, 0x8C, 0x01, 0xC1,
  0x80, 0x30, 0xC0, 0x18, 0x18, 0x03, 0x0E, 0x01, 0x81, 0xC0, 0x70, 0x60,
  0x18, 0x1C, 0x07, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x0C, 0x06,
  0x07, 0x03, 0x00, 0xC0, 0xE0, 0x30, 0x30, 0x0E, 0x0E, 0x03, 0x07, 0x00,
  0x60, 0xC0, 0x30, 0x70, 0x06, 0x0C, 0x03, 0x86, 0x00, 0x61, 0xC0, 0x18,
  0x60, 0x07, 0x1C, 0x01, 0x86, 0x00, 0x71, 0x80, 0x18, 0xE0, 0x03, 0x18,
  0x01, 0xCC, 0x00, 0x33, 0x80, 0x1C, 0xC0, 0x03, 0xB8, 0x00, 0xCC, 0x00,
  0x3B, 0x00, 0x0D, 0xC0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x3C, 0xE0, 0x00,
  0xE3, 0x80, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x80,
  0xE0, 0x1C, 0x01, 0xC0, 0x60, 0x03, 0x03, 0x80, 0x0E, 0x0C, 0x00, 0x18,
  0x70, 0x00, 0x71, 0x80, 0x00, 0xCE, 0x00, 0x03, 0xB0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3B, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x18, 0x00, 0x38, 0x70, 0x00, 0xC0,
  0xE0, 0x07, 0x03, 0x80, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x38,
  0x1C, 0x00, 0xE0, 0x60, 0x01, 0xC3, 0x80, 0x03, 0x0C, 0x00, 0x0E, 0x70,
  0x00, 0x1B, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0x63, 0x80, 0x01, 0xC3, 0x00, 0x03, 0x06, 0x00,
  0x06, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x60, 0x38, 0x00,
  0xC0, 0x70, 0x03, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x38,
  0x01, 0x80, 0x70, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0E, 0x07, 0x00,
  0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x38, 0x70, 0x00, 0x30, 0xE0, 0x00,
  0x61, 0x80, 0x00, 0xC7, 0x00, 0x01, 0xCE, 0x00, 0x01, 0x98, 0x00, 0x03,
  0x30, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x3C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x07, 0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00,
  0x7F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x01, 0xF8,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x78, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x9F, 0xF8, 0x00, 0x5E, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0xFC, 0x00, 0x7F,
  0xF4, 0x00, 0x07, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraLight65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 46, 14, 5, -46 },
  { 24, 12, 16, 21, 4, -46 },
  { 48, 30, 46, 32, 1, -46 },
  { 221, 23, 53, 29, 3, -49 },
  { 374, 36, 48, 43, 3, -47 },
  { 590, 29, 48, 32, 3, -47 },
  { 764, 3, 16, 11, 4, -46 },
  { 770, 12, 56, 17, 3, -46 },
  { 854, 12, 56, 17, 2, -46 },
  { 938, 20, 20, 27, 3, -49 },
  { 988, 25, 30, 30, 2, -38 },
  { 1082, 7, 15, 12, 2, -7 },
  { 1096, 14, 3, 18, 2, -19 },
  { 1102, 5, 5, 13, 4, -5 },
  { 1106, 20, 46, 22, 1, -46 },
  { 1221, 23, 48, 29, 3, -47 },
  { 1359, 13, 46, 29, 5, -46 },
  { 1434, 23, 47, 29, 3, -47 },
  { 1570, 23, 48, 29, 3, -47 },
  { 1708, 28, 47, 29, 1, -47 },
  { 1873, 22, 47, 29, 4, -46 },
  { 2003, 23, 48, 29, 3, -47 },
  { 2141, 23, 46, 29, 3, -46 },
  { 2274, 24, 48, 29, 3, -47 },
  { 2418, 23, 48, 29, 3, -47 },
  { 2556, 5, 35, 13, 4, -35 },
  { 2578, 7, 43, 13, 2, -35 },
  { 2616, 25, 28, 30, 2, -37 },
  { 2704, 25, 16, 30, 2, -31 },
  { 2754, 25, 28, 30, 2, -37 },
  { 2842, 18, 47, 21, 1, -47 },
  { 2948, 39, 52, 45, 3, -46 },
  { 3202, 29, 46, 29, 0, -46 },
  { 3369, 24, 46, 32, 5, -46 },
  { 3507, 26, 48, 31, 4, -47 },
  { 3663, 27, 46, 36, 5, -46 },
  { 3819, 20, 46, 28, 5, -46 },
  { 3934, 20, 46, 26, 5, -46 },
  { 4049, 30, 48, 38, 4, -47 },
  { 4229, 26, 46, 36, 5, -46 },
  { 4379, 11, 46, 16, 3, -46 },
  { 4443, 12, 58, 13, -4, -46 },
  { 4530, 24, 46, 29, 5, -46 },
  { 4668, 20, 46, 26, 5, -46 },
  { 4783, 36, 46, 47, 5, -46 },
  { 4990, 27, 46, 37, 5, -46 },
  { 5146, 31, 48, 38, 4, -47 },
  { 5332, 22, 46, 30, 5, -46 },
  { 5459, 31, 58, 38, 4, -47 },
  { 5684, 24, 46, 30, 5, -46 },
  { 5822, 23, 48, 29, 3, -47 },
  { 5960, 25, 46, 26, 0, -46 },
  { 6104, 26, 47, 36, 5, -46 },
  { 6257, 28, 46, 28, 0, -46 },
  { 6418, 46, 46, 47, 1, -46 },
  { 6683, 26, 46, 26, 0, -46 },
  { 6833, 25, 46, 25, 0, -46 },
  { 6977, 23, 46, 26, 2, -46 },
  { 7110, 13, 56, 20, 5, -46 },
  { 7201, 20, 46, 22, 1, -46 },
  { 7316, 13, 56, 20, 2, -46 },
  { 7407, 26, 24, 30, 2, -46 },
  { 7485, 26, 2, 26, 0, 6 },
  { 7492, 10, 11, 16, 3, -50 },
  { 7506, 20, 36, 27, 3, -35 },
  { 7596, 23, 50, 31, 5, -49 },
  { 7740, 19, 36, 24, 3, -35 },
  { 7826, 23, 50, 31, 3, -49 },
  { 7970, 22, 36, 28, 3, -35 },
  { 8069, 17, 50, 16, 1, -50 },
  { 8176, 23, 51, 31, 3, -35 },
  { 8323, 21, 49, 30, 5, -49 },
  { 8452, 4, 47, 13, 4, -47 },
  { 8476, 9, 63, 13, -1, -47 },
  { 8547, 19, 49, 25, 5, -49 },
  { 8664, 2, 49, 12, 5, -49 },
  { 8677, 36, 35, 45, 5, -35 },
  { 8835, 21, 35, 30, 5, -35 },
  { 8927, 24, 36, 30, 3, -35 },
  { 9035, 23, 50, 31, 5, -35 },
  { 9179, 23, 50, 31, 3, -35 },
  { 9323, 14, 35, 20, 5, -35 },
  { 9385, 19, 36, 23, 2, -35 },
  { 9471, 14, 44, 16, 1, -43 },
  { 9548, 20, 35, 30, 5, -34 },
  { 9636, 22, 34, 23, 0, -34 },
  { 9730, 36, 34, 38, 1, -34 },
  { 9883, 22, 34, 24, 1, -34 },
  { 9977, 23, 50, 24, 0, -34 },
  { 10121, 17, 34, 21, 2, -34 },
  { 10194, 17, 56, 23, 3, -46 },
  { 10313, 2, 66, 28, 13, -50 },
  { 10330, 17, 56, 23, 3, -46 },
  { 10449, 25, 6, 30, 2, -26 },
};

const GFXfont NotoSans_Condensed_ExtraLight65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight65pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT65PT7B_H_
