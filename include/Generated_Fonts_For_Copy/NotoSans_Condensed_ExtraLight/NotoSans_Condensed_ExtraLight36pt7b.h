#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT36PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xEA, 0xAA, 0x02, 0xF0, 0xC3, 0x87, 0x0E, 0x1C,
  0x28, 0x50, 0xA1, 0x42, 0x84, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x06,
  0x08, 0x06, 0x08, 0x04, 0x18, 0x04, 0x18, 0x04, 0x10, 0x7F, 0xFF, 0x04,
  0x10, 0x0C, 0x10, 0x0C, 0x10, 0x08, 0x10, 0x08, 0x30, 0x08, 0x20, 0x08,
  0x20, 0x08, 0x20, 0xFF, 0xFE, 0x18, 0x20, 0x10, 0x20, 0x10, 0x60, 0x10,
  0x60, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x30, 0x40, 0x04, 0x00, 0x40,
  0x1F, 0xC7, 0x46, 0xC4, 0x08, 0x40, 0x84, 0x08, 0x40, 0x84, 0x08, 0x40,
  0xC4, 0x06, 0x40, 0x34, 0x01, 0xC0, 0x07, 0x00, 0x4C, 0x04, 0x60, 0x43,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x42, 0xE4, 0xC7, 0xF8,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x3C, 0x03, 0x06, 0x60, 0x20, 0x42, 0x06,
  0x08, 0x20, 0x40, 0x83, 0x04, 0x08, 0x30, 0x80, 0x81, 0x08, 0x08, 0x11,
  0x80, 0x81, 0x10, 0x08, 0x11, 0x00, 0x83, 0x21, 0x88, 0x32, 0x6C, 0x82,
  0x64, 0x24, 0x24, 0x82, 0x66, 0x48, 0x33, 0xC8, 0x83, 0x00, 0x88, 0x10,
  0x18, 0x81, 0x01, 0x08, 0x10, 0x10, 0x81, 0x02, 0x08, 0x30, 0x20, 0x83,
  0x06, 0x08, 0x20, 0x40, 0xC2, 0x04, 0x04, 0x60, 0x80, 0x3C, 0x07, 0x80,
  0x04, 0x60, 0x06, 0x18, 0x02, 0x04, 0x01, 0x02, 0x00, 0x81, 0x00, 0x40,
  0x80, 0x20, 0xC0, 0x18, 0x40, 0x04, 0x60, 0x03, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xD8, 0x00, 0xC6, 0x00, 0xC1, 0x06, 0x40, 0xC2, 0x20, 0x31,
  0x30, 0x08, 0x98, 0x06, 0xCC, 0x01, 0xC2, 0x00, 0x61, 0x00, 0x70, 0xC0,
  0x6C, 0x30, 0x62, 0x0F, 0xE0, 0xC0, 0xFF, 0x55, 0x50, 0x04, 0x21, 0x84,
  0x30, 0x86, 0x10, 0x43, 0x0C, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x83, 0x0C, 0x10, 0x41, 0x82, 0x0C, 0x10, 0x60, 0x81, 0xC0, 0xC0, 0x81,
  0x81, 0x03, 0x02, 0x06, 0x0C, 0x08, 0x10, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x18,
  0x60, 0x04, 0x00, 0x80, 0x10, 0x42, 0x1F, 0x5E, 0x3C, 0x03, 0x80, 0xD0,
  0x11, 0x04, 0x11, 0x83, 0x00, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0xFF, 0xFC, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x33,
  0x22, 0x66, 0x44, 0xC0, 0xFF, 0x5D, 0x80, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x00, 0x0F, 0x81, 0x8C, 0x20, 0x66,
  0x02, 0x40, 0x24, 0x03, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C,
  0x01, 0x40, 0x34, 0x02, 0x60, 0x22, 0x06, 0x30, 0xC1, 0xF8, 0x06, 0x1C,
  0x79, 0xB6, 0x78, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1F, 0x07, 0x1C,
  0xC0, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60,
  0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x0F, 0xFF,
  0x3F, 0x0E, 0x1C, 0x80, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x40, 0x18, 0x1E, 0x00, 0x38, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x06,
  0x80, 0xCF, 0xF8, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x05, 0x00, 0x1A,
  0x00, 0x24, 0x00, 0xC8, 0x01, 0x10, 0x06, 0x20, 0x08, 0x40, 0x20, 0x80,
  0xC1, 0x01, 0x02, 0x06, 0x04, 0x08, 0x08, 0x30, 0x10, 0x40, 0x21, 0x80,
  0x43, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x7F, 0xE7, 0xFE, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0F, 0xF8, 0x40, 0xE0,
  0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x30, 0x06, 0xC0, 0xC7, 0xF8, 0x03, 0xE0, 0x71, 0x06, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x21,
  0xE1, 0x3B, 0x8A, 0x02, 0x60, 0x1B, 0x00, 0x58, 0x02, 0x80, 0x14, 0x00,
  0xE0, 0x07, 0x80, 0x3C, 0x01, 0x20, 0x09, 0x00, 0xCC, 0x04, 0x30, 0x60,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x1F, 0x81, 0x86, 0x18, 0x08, 0x80, 0x6C,
  0x01, 0x60, 0x0B, 0x00, 0x58, 0x06, 0x40, 0x23, 0x03, 0x0C, 0x30, 0x1F,
  0x00, 0x60, 0x0C, 0xC0, 0xC3, 0x0C, 0x0C, 0xC0, 0x34, 0x00, 0xA0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0B, 0x00, 0x48, 0x06, 0x60, 0x60, 0xFE, 0x00,
  0x1F, 0x03, 0x1C, 0x60, 0x4C, 0x06, 0xC0, 0x28, 0x03, 0x80, 0x38, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0xC0, 0x34, 0x05, 0x60, 0xD1, 0xF1,
  0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C,
  0x03, 0x87, 0xE0, 0x7D, 0x00, 0x00, 0x00, 0x00, 0x00, 0x5D, 0x80, 0x33,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x32, 0x26, 0x64, 0x48, 0x00,
  0x04, 0x00, 0x30, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x1C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x7E,
  0x61, 0x80, 0x60, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x40,
  0x40, 0x60, 0x60, 0x20, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x38, 0x18, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x78, 0x01, 0x80,
  0x60, 0x10, 0x00, 0x81, 0x00, 0x06, 0x18, 0x00, 0x10, 0x80, 0x00, 0x4C,
  0x00, 0x02, 0x40, 0xFE, 0x1A, 0x0C, 0x30, 0x70, 0x41, 0x83, 0x06, 0x0C,
  0x18, 0x20, 0x60, 0xC1, 0x03, 0x06, 0x08, 0x10, 0x30, 0x40, 0x81, 0x82,
  0x04, 0x0C, 0x10, 0x20, 0xE0, 0x83, 0x07, 0x06, 0x14, 0x2C, 0x19, 0xA3,
  0x20, 0x78, 0xE1, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x04, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x03, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x60,
  0x06, 0x20, 0x04, 0x20, 0x04, 0x30, 0x0C, 0x10, 0x08, 0x10, 0x08, 0x10,
  0x08, 0x18, 0x18, 0x08, 0x1F, 0xF8, 0x10, 0x0C, 0x30, 0x0C, 0x30, 0x04,
  0x20, 0x04, 0x20, 0x06, 0x60, 0x02, 0x40, 0x02, 0x40, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xFE, 0x07, 0xFF, 0x20, 0x0D, 0x00, 0x68, 0x01, 0x40, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x14, 0x00, 0xA0, 0x09, 0x01, 0xCF, 0xF8, 0x40,
  0x72, 0x00, 0xD0, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x50, 0x06, 0x80, 0xE7, 0xFC, 0x00, 0x03, 0xF8, 0x18,
  0x31, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0E, 0x04, 0x0F, 0xF0, 0xFE, 0x01, 0xFF, 0x82, 0x01,
  0x84, 0x01, 0x88, 0x01, 0x90, 0x01, 0x20, 0x03, 0x40, 0x02, 0x80, 0x05,
  0x00, 0x0A, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x68, 0x00, 0x90, 0x03,
  0x20, 0x04, 0x40, 0x38, 0x81, 0xC1, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x0F, 0xFD, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xFC, 0xFF, 0xFF, 0xFE, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0xFF, 0xA0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x01, 0xFC, 0x03, 0x83,
  0xC3, 0x00, 0x43, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x01, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xD0, 0x00,
  0x68, 0x00, 0x36, 0x00, 0x19, 0x00, 0x0C, 0xC0, 0x06, 0x30, 0x03, 0x0E,
  0x03, 0x81, 0xFF, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x10, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x27, 0xC0, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x7C, 0x80,
  0x1C, 0x01, 0xA0, 0x09, 0x00, 0xC8, 0x0C, 0x40, 0xC2, 0x04, 0x10, 0x60,
  0x86, 0x04, 0x20, 0x23, 0x01, 0x30, 0x0B, 0xC0, 0x56, 0x03, 0x18, 0x18,
  0x40, 0x83, 0x04, 0x08, 0x20, 0x61, 0x01, 0x08, 0x0C, 0x40, 0x32, 0x00,
  0x90, 0x06, 0x80, 0x14, 0x00, 0xC0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x1F, 0xFC, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xE0,
  0x00, 0x5A, 0x00, 0x05, 0xA0, 0x00, 0xDB, 0x00, 0x0D, 0x90, 0x00, 0x99,
  0x00, 0x19, 0x98, 0x01, 0x98, 0x80, 0x11, 0x88, 0x03, 0x18, 0xC0, 0x31,
  0x84, 0x02, 0x18, 0x40, 0x61, 0x86, 0x06, 0x18, 0x20, 0x41, 0x82, 0x0C,
  0x18, 0x30, 0xC1, 0x81, 0x08, 0x18, 0x11, 0x81, 0x81, 0x98, 0x18, 0x09,
  0x01, 0x80, 0x90, 0x18, 0x0F, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x1D, 0x00, 0x3B, 0x00, 0x72, 0x00, 0xE6, 0x01,
  0xC4, 0x03, 0x8C, 0x07, 0x08, 0x0E, 0x18, 0x1C, 0x10, 0x38, 0x30, 0x70,
  0x20, 0xE0, 0x61, 0xC0, 0x43, 0x80, 0xC7, 0x00, 0x8E, 0x01, 0x9C, 0x01,
  0x38, 0x03, 0x70, 0x02, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0C,
  0x03, 0xF0, 0x07, 0x0C, 0x06, 0x01, 0x06, 0x00, 0xC2, 0x00, 0x33, 0x00,
  0x09, 0x00, 0x04, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x50, 0x00, 0x68, 0x00, 0x36, 0x00, 0x11, 0x00, 0x18, 0xC0,
  0x08, 0x30, 0x0C, 0x0C, 0x1C, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xFC, 0x80,
  0xE8, 0x02, 0x80, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x38, 0x02, 0x80, 0x68, 0x1C, 0xFF, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x03,
  0xF0, 0x07, 0x0C, 0x06, 0x01, 0x06, 0x00, 0x42, 0x00, 0x33, 0x00, 0x09,
  0x00, 0x04, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x50, 0x00, 0x68, 0x00, 0x36, 0x00, 0x13, 0x00, 0x18, 0xC0, 0x08,
  0x30, 0x0C, 0x0C, 0x1C, 0x03, 0xF8, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0xFE, 0x07, 0xFE, 0x20, 0x19,
  0x00, 0x48, 0x03, 0x40, 0x1A, 0x00, 0x50, 0x02, 0x80, 0x14, 0x01, 0xA0,
  0x0D, 0x00, 0xC8, 0x0C, 0x7F, 0xC3, 0xF8, 0x10, 0x60, 0x81, 0x04, 0x0C,
  0x20, 0x21, 0x01, 0x88, 0x04, 0x40, 0x32, 0x00, 0x90, 0x06, 0x80, 0x14,
  0x00, 0xC0, 0x0F, 0xC3, 0x87, 0x60, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00,
  0x30, 0x06, 0x80, 0xCF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x07, 0x00, 0x34, 0x00, 0xD8, 0x06, 0x30, 0x30, 0x7F,
  0x80, 0x80, 0x03, 0xC0, 0x02, 0x40, 0x02, 0x40, 0x06, 0x60, 0x06, 0x60,
  0x04, 0x20, 0x04, 0x20, 0x0C, 0x30, 0x0C, 0x10, 0x08, 0x10, 0x08, 0x10,
  0x18, 0x18, 0x10, 0x08, 0x10, 0x08, 0x30, 0x0C, 0x30, 0x0C, 0x20, 0x04,
  0x20, 0x04, 0x60, 0x06, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x03,
  0x80, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x0C, 0x00, 0xD0, 0x03, 0x00, 0x34,
  0x00, 0xC0, 0x09, 0x80, 0x30, 0x02, 0x60, 0x1E, 0x01, 0x88, 0x06, 0x80,
  0x62, 0x01, 0x20, 0x10, 0x80, 0x48, 0x04, 0x30, 0x13, 0x03, 0x04, 0x0C,
  0xC0, 0xC1, 0x02, 0x10, 0x20, 0x40, 0x84, 0x08, 0x18, 0x21, 0x06, 0x06,
  0x18, 0x61, 0x80, 0x86, 0x08, 0x40, 0x21, 0x02, 0x10, 0x0C, 0x40, 0x84,
  0x03, 0x10, 0x33, 0x00, 0x4C, 0x0C, 0xC0, 0x12, 0x01, 0x20, 0x04, 0x80,
  0x48, 0x01, 0xA0, 0x16, 0x00, 0x38, 0x07, 0x80, 0x0E, 0x00, 0xC0, 0x03,
  0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x0C, 0x80, 0x22, 0x01, 0x8C,
  0x04, 0x10, 0x30, 0x60, 0xC0, 0x82, 0x03, 0x18, 0x04, 0x40, 0x1B, 0x00,
  0x28, 0x00, 0xE0, 0x01, 0x00, 0x0E, 0x00, 0x28, 0x01, 0xA0, 0x04, 0x40,
  0x31, 0x00, 0x86, 0x06, 0x08, 0x10, 0x30, 0xC0, 0x42, 0x01, 0x98, 0x02,
  0x40, 0x0B, 0x00, 0x30, 0xC0, 0x0F, 0x00, 0x24, 0x00, 0x98, 0x06, 0x20,
  0x10, 0xC0, 0xC3, 0x02, 0x04, 0x08, 0x18, 0x60, 0x21, 0x00, 0x8C, 0x03,
  0x20, 0x04, 0x80, 0x1E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x3F,
  0xFF, 0x80, 0x20, 0x04, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x10,
  0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80,
  0x30, 0x04, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x10, 0xFE, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x7F, 0xFF, 0x01, 0x00, 0x0C, 0x00, 0x28, 0x01, 0xA0, 0x04, 0x40, 0x31,
  0x00, 0x82, 0x06, 0x08, 0x10, 0x30, 0xC0, 0x42, 0x01, 0x98, 0x02, 0x40,
  0x0F, 0x00, 0x10, 0xFF, 0xFE, 0xC1, 0x82, 0x04, 0x08, 0x10, 0x1F, 0xC4,
  0x0C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x07, 0xE3, 0x84,
  0xC0, 0xB0, 0x14, 0x03, 0x80, 0x70, 0x0A, 0x03, 0x40, 0x6C, 0x14, 0xFC,
  0x80, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x9F, 0xC5, 0x83, 0x28, 0x09, 0x80, 0x6C, 0x01, 0x40, 0x0A,
  0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0xE0, 0x05, 0x00, 0x28, 0x01, 0x40,
  0x0B, 0x00, 0xD8, 0x06, 0xE0, 0x65, 0x86, 0x27, 0xE0, 0x0F, 0xCC, 0x12,
  0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x11, 0xFC, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x1F, 0x99,
  0x82, 0xD8, 0x0E, 0x80, 0x7C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x68, 0x07,
  0x60, 0x39, 0x82, 0xC7, 0xE6, 0x1F, 0x83, 0x0C, 0x60, 0x64, 0x02, 0xC0,
  0x2C, 0x03, 0x80, 0x38, 0x01, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x02, 0x1F, 0xE0, 0x01, 0x01,
  0xF0, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x3F, 0xC1, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1F, 0x99, 0x82,
  0xD8, 0x0E, 0x80, 0x7C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x68, 0x07, 0x60,
  0x39, 0x86, 0xC7, 0xE6, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x34, 0x03, 0x1F, 0xF0, 0x1E, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x9F, 0x96, 0x1B, 0x81, 0xE0, 0x1C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x5D, 0x00, 0x02,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x48, 0x08, 0x70, 0x80, 0x00, 0x00,
  0x02, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x1B, 0xC6, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0xD0, 0x32,
  0x04, 0x41, 0x08, 0x61, 0x08, 0x22, 0x04, 0xC0, 0xB8, 0x15, 0x83, 0x10,
  0x63, 0x08, 0x21, 0x06, 0x20, 0x44, 0x0C, 0x80, 0x90, 0x1A, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x9F, 0x0F, 0xCA, 0x09, 0x06, 0xC0, 0xE0, 0x6C,
  0x06, 0x02, 0x80, 0x60, 0x28, 0x04, 0x02, 0x80, 0x40, 0x38, 0x04, 0x03,
  0x80, 0x40, 0x38, 0x04, 0x03, 0x80, 0x40, 0x38, 0x04, 0x03, 0x80, 0x40,
  0x38, 0x04, 0x03, 0x80, 0x40, 0x38, 0x04, 0x03, 0x80, 0x40, 0x38, 0x04,
  0x03, 0x80, 0x40, 0x30, 0x9F, 0x96, 0x1B, 0x81, 0xE0, 0x1C, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x1F, 0xC1, 0x83, 0x18, 0x08,
  0x80, 0x6C, 0x01, 0x60, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x48, 0x06, 0x60, 0x21, 0x83,
  0x07, 0xF0, 0x9F, 0x85, 0x83, 0x28, 0x09, 0x80, 0x6C, 0x01, 0x40, 0x0A,
  0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0xE0, 0x05, 0x00, 0x28, 0x01, 0x40,
  0x0B, 0x00, 0xD8, 0x06, 0xA0, 0x65, 0x86, 0x27, 0xE1, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x1F, 0x99,
  0x82, 0xD8, 0x0E, 0x80, 0x7C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x68, 0x07,
  0x60, 0x79, 0x86, 0xC7, 0xE6, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x9F, 0xB0, 0xA0, 0xC0, 0xC0, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x1F, 0xCC, 0x09, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x58, 0x19, 0xFE, 0x00, 0x20, 0x40, 0x81, 0x02, 0x1F, 0xC8, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0C,
  0x0F, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0xC0,
  0xAC, 0x34, 0xFC, 0x80, 0xC0, 0x14, 0x01, 0x40, 0x36, 0x02, 0x60, 0x22,
  0x06, 0x20, 0x63, 0x04, 0x10, 0x41, 0x0C, 0x10, 0x81, 0x88, 0x08, 0x80,
  0x98, 0x0D, 0x00, 0x50, 0x05, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x30, 0x1A,
  0x01, 0x80, 0x90, 0x1C, 0x04, 0xC0, 0xA0, 0x66, 0x05, 0x03, 0x10, 0x2C,
  0x10, 0x83, 0x20, 0x86, 0x11, 0x04, 0x30, 0x88, 0x60, 0x84, 0x62, 0x04,
  0x61, 0x10, 0x32, 0x08, 0x81, 0x90, 0x4C, 0x04, 0x83, 0x40, 0x2C, 0x0A,
  0x01, 0x40, 0x50, 0x0E, 0x02, 0x80, 0x30, 0x18, 0x01, 0x80, 0x40, 0xC0,
  0x34, 0x06, 0x60, 0x42, 0x0C, 0x30, 0x81, 0x18, 0x19, 0x00, 0xB0, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xB0, 0x19, 0x01, 0x18, 0x30, 0x82, 0x0C, 0x40,
  0x4C, 0x06, 0x80, 0x30, 0xC0, 0x1A, 0x00, 0x98, 0x04, 0x40, 0x62, 0x03,
  0x10, 0x10, 0xC0, 0x82, 0x0C, 0x10, 0x40, 0xC2, 0x02, 0x30, 0x11, 0x00,
  0x88, 0x06, 0x40, 0x16, 0x00, 0xA0, 0x07, 0x00, 0x18, 0x00, 0x80, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x3C, 0x01,
  0xC0, 0x00, 0x7F, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x20, 0x18,
  0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30,
  0x0F, 0xFC, 0x01, 0x83, 0xC3, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC1, 0xC0, 0xE0, 0x18, 0x04, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60,
  0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x78, 0x06, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x30,
  0x0F, 0x07, 0x86, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0xC3, 0xC1, 0x80, 0x7E, 0x07, 0x0E, 0x78, 0x0F,
  0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLight36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 26, 8, 3, -26 },
  { 8, 7, 10, 11, 2, -26 },
  { 17, 16, 26, 18, 1, -26 },
  { 69, 12, 29, 16, 2, -27 },
  { 113, 20, 26, 24, 2, -26 },
  { 178, 17, 26, 18, 1, -26 },
  { 234, 2, 10, 6, 2, -26 },
  { 237, 6, 32, 10, 2, -26 },
  { 261, 7, 32, 10, 1, -26 },
  { 289, 11, 11, 15, 2, -27 },
  { 305, 14, 17, 16, 1, -21 },
  { 335, 4, 9, 7, 1, -4 },
  { 340, 8, 1, 10, 1, -10 },
  { 341, 3, 3, 7, 2, -3 },
  { 343, 11, 26, 12, 1, -26 },
  { 379, 12, 26, 16, 2, -26 },
  { 418, 7, 26, 16, 3, -26 },
  { 441, 12, 26, 16, 2, -26 },
  { 480, 12, 26, 16, 2, -26 },
  { 519, 15, 26, 16, 1, -26 },
  { 568, 12, 26, 16, 2, -26 },
  { 607, 13, 26, 16, 2, -26 },
  { 650, 12, 26, 16, 2, -26 },
  { 689, 13, 26, 16, 2, -26 },
  { 732, 12, 26, 16, 2, -26 },
  { 771, 3, 19, 7, 2, -19 },
  { 779, 4, 24, 7, 1, -19 },
  { 791, 14, 16, 16, 1, -21 },
  { 819, 14, 9, 16, 1, -17 },
  { 835, 14, 16, 16, 1, -21 },
  { 863, 9, 26, 11, 1, -26 },
  { 893, 21, 29, 25, 2, -26 },
  { 970, 16, 26, 16, 0, -26 },
  { 1022, 13, 26, 18, 3, -26 },
  { 1065, 14, 26, 17, 2, -26 },
  { 1111, 15, 26, 20, 3, -26 },
  { 1160, 11, 26, 16, 3, -26 },
  { 1196, 11, 26, 14, 3, -26 },
  { 1232, 17, 26, 21, 2, -26 },
  { 1288, 14, 26, 20, 3, -26 },
  { 1334, 5, 26, 9, 2, -26 },
  { 1351, 7, 32, 7, -2, -26 },
  { 1379, 13, 26, 16, 3, -26 },
  { 1422, 11, 26, 14, 3, -26 },
  { 1458, 20, 26, 26, 3, -26 },
  { 1523, 15, 26, 21, 3, -26 },
  { 1572, 17, 26, 21, 2, -26 },
  { 1628, 12, 26, 16, 3, -26 },
  { 1667, 17, 32, 21, 2, -26 },
  { 1735, 13, 26, 17, 3, -26 },
  { 1778, 12, 26, 16, 2, -26 },
  { 1817, 14, 26, 14, 0, -26 },
  { 1863, 14, 26, 20, 3, -26 },
  { 1909, 16, 26, 16, 0, -26 },
  { 1961, 26, 26, 26, 0, -26 },
  { 2046, 14, 26, 14, 0, -26 },
  { 2092, 14, 26, 14, 0, -26 },
  { 2138, 13, 26, 15, 1, -26 },
  { 2181, 7, 32, 11, 3, -26 },
  { 2209, 10, 26, 12, 1, -26 },
  { 2242, 7, 32, 11, 1, -26 },
  { 2270, 14, 14, 16, 1, -26 },
  { 2295, 15, 1, 14, 0, 3 },
  { 2297, 6, 6, 9, 1, -28 },
  { 2302, 11, 19, 15, 1, -19 },
  { 2329, 13, 27, 17, 3, -27 },
  { 2373, 10, 19, 13, 2, -19 },
  { 2397, 13, 27, 17, 2, -27 },
  { 2441, 12, 19, 16, 2, -19 },
  { 2470, 10, 28, 9, 0, -28 },
  { 2505, 13, 28, 17, 2, -19 },
  { 2551, 11, 27, 17, 3, -27 },
  { 2589, 3, 26, 7, 2, -26 },
  { 2599, 6, 35, 7, -1, -26 },
  { 2626, 11, 27, 14, 3, -27 },
  { 2664, 1, 27, 7, 3, -27 },
  { 2668, 20, 19, 25, 3, -19 },
  { 2716, 11, 19, 17, 3, -19 },
  { 2743, 13, 19, 17, 2, -19 },
  { 2774, 13, 27, 17, 3, -19 },
  { 2818, 13, 27, 17, 2, -19 },
  { 2862, 8, 19, 11, 3, -19 },
  { 2881, 11, 19, 13, 1, -19 },
  { 2908, 7, 24, 9, 1, -24 },
  { 2929, 11, 19, 17, 3, -19 },
  { 2956, 12, 19, 13, 0, -19 },
  { 2985, 21, 19, 21, 0, -19 },
  { 3035, 12, 19, 14, 1, -19 },
  { 3064, 13, 28, 13, 0, -19 },
  { 3110, 10, 19, 12, 1, -19 },
  { 3134, 9, 32, 13, 2, -26 },
  { 3170, 1, 36, 15, 7, -27 },
  { 3175, 9, 32, 13, 2, -26 },
  { 3211, 14, 3, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_ExtraLight36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight36pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT36PT7B_H_
