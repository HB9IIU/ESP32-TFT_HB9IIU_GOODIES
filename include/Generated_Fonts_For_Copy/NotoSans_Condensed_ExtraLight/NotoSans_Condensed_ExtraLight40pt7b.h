#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT40PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight40pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x92, 0x49, 0x24, 0x80, 0x03, 0x7C,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x01, 0x02,
  0x00, 0x40, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x02, 0x04, 0x00, 0x81, 0x00,
  0x20, 0x40, 0x08, 0x10, 0x02, 0x04, 0x1F, 0xFF, 0xF0, 0x60, 0xC0, 0x10,
  0x20, 0x04, 0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x0C, 0x08,
  0x03, 0x06, 0x00, 0xC1, 0x83, 0xFF, 0xFE, 0x08, 0x10, 0x02, 0x04, 0x00,
  0x81, 0x00, 0x60, 0x40, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x02, 0x00, 0x40,
  0x80, 0x10, 0x20, 0x00, 0x02, 0x00, 0x08, 0x00, 0xFE, 0x0F, 0xBE, 0x62,
  0x0B, 0x08, 0x0C, 0x20, 0x20, 0x80, 0x82, 0x02, 0x08, 0x08, 0x20, 0x30,
  0x80, 0x62, 0x00, 0xC8, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x09, 0xC0,
  0x21, 0x80, 0x82, 0x02, 0x0C, 0x08, 0x10, 0x20, 0x40, 0x83, 0x02, 0x0C,
  0x08, 0x28, 0x21, 0xBE, 0xBC, 0x3F, 0x80, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x1C, 0x00, 0x80, 0xD8, 0x02, 0x04, 0x30, 0x18, 0x10, 0x40, 0x40, 0xC1,
  0x83, 0x03, 0x06, 0x08, 0x08, 0x18, 0x20, 0x20, 0x61, 0x80, 0x81, 0x84,
  0x02, 0x06, 0x30, 0x08, 0x18, 0x80, 0x20, 0x62, 0x10, 0x81, 0x99, 0xF3,
  0x04, 0x44, 0x64, 0x13, 0x20, 0x90, 0xC8, 0x83, 0x36, 0x22, 0x04, 0x71,
  0x98, 0x10, 0x04, 0x60, 0x40, 0x31, 0x81, 0x00, 0x86, 0x04, 0x02, 0x18,
  0x10, 0x18, 0x60, 0x40, 0x41, 0x81, 0x03, 0x02, 0x04, 0x08, 0x08, 0x30,
  0x20, 0x30, 0x81, 0x80, 0x46, 0x04, 0x01, 0xF0, 0x07, 0x80, 0x0E, 0xE0,
  0x04, 0x18, 0x06, 0x04, 0x03, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x60,
  0x40, 0x30, 0x60, 0x08, 0x30, 0x06, 0x30, 0x01, 0x10, 0x00, 0xF0, 0x00,
  0x30, 0x00, 0x78, 0x00, 0x66, 0x00, 0x61, 0x81, 0xA0, 0x40, 0xB0, 0x30,
  0x50, 0x0C, 0x28, 0x03, 0x34, 0x00, 0x92, 0x00, 0x79, 0x00, 0x18, 0x80,
  0x0C, 0x60, 0x0F, 0x18, 0x0C, 0xCE, 0x0C, 0x21, 0xFC, 0x18, 0xFF, 0xE0,
  0x02, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x60, 0xC1, 0x02, 0x0C, 0x18,
  0x30, 0x60, 0x81, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x60, 0x40, 0x81, 0x83,
  0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x18, 0xC0, 0x60, 0x30, 0x30, 0x18,
  0x08, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x02, 0x02, 0x02, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x0C,
  0x0C, 0x18, 0x18, 0x30, 0x20, 0xE0, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0xE2, 0x33, 0xBE, 0x06, 0x00, 0x50, 0x09, 0x81, 0x88, 0x30, 0x42, 0x06,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x6D, 0xB5, 0xB4, 0x80, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x30, 0x02, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x7F, 0x81, 0x03, 0x0C, 0x04, 0x60,
  0x19, 0x80, 0x64, 0x00, 0x90, 0x02, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x00, 0x34, 0x00, 0x98, 0x02, 0x60, 0x18,
  0x80, 0x43, 0x03, 0x06, 0x18, 0x0F, 0xC0, 0x01, 0x07, 0x0F, 0x1B, 0x33,
  0xE3, 0x43, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x0F, 0x81, 0xF7, 0x8C, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00,
  0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30,
  0x00, 0xFF, 0xFC, 0x1F, 0x81, 0xF7, 0x8C, 0x03, 0x20, 0x06, 0x00, 0x18,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x60, 0x7F, 0x01, 0xF8, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x03, 0x30, 0x1C, 0x7F, 0xC0, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x05, 0x80, 0x06, 0xC0, 0x02, 0x60, 0x03, 0x30, 0x03,
  0x18, 0x01, 0x0C, 0x01, 0x86, 0x00, 0x83, 0x00, 0xC1, 0x80, 0x40, 0xC0,
  0x60, 0x60, 0x20, 0x30, 0x30, 0x18, 0x30, 0x0C, 0x10, 0x06, 0x18, 0x03,
  0x08, 0x01, 0x87, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x3F, 0xF8, 0xFF, 0xE2,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x7F, 0xC1, 0xC3, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x08, 0x00, 0x68, 0x03, 0x38, 0x38, 0x7F, 0xC0, 0x01,
  0xF0, 0x1F, 0xE0, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x40, 0xCF, 0xE3, 0x60, 0xCE,
  0x01, 0xB8, 0x02, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x14, 0x00, 0xD0, 0x03, 0x60, 0x0C, 0x80, 0x23, 0x01, 0x86, 0x0C,
  0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0x03, 0x18, 0x06,
  0x40, 0x09, 0x00, 0x3C, 0x00, 0xD0, 0x03, 0x40, 0x09, 0x80, 0x63, 0x01,
  0x06, 0x0C, 0x0C, 0xC0, 0x1E, 0x00, 0xF8, 0x06, 0x38, 0x30, 0x31, 0x80,
  0x6C, 0x00, 0xF0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0,
  0x0F, 0x00, 0x36, 0x01, 0x8C, 0x0C, 0x1F, 0xE0, 0x0F, 0x80, 0xF7, 0x83,
  0x03, 0x18, 0x0C, 0x40, 0x1B, 0x00, 0x6C, 0x00, 0xA0, 0x02, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x34, 0x01, 0xD8, 0x0B,
  0x38, 0xEC, 0x7E, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x06, 0x10, 0x70, 0x7F, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x33, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x33, 0x32, 0x66, 0x4C, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x3E, 0x1E,
  0xF2, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80, 0x60, 0x08, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x80, 0x03, 0x80, 0xE0, 0x06,
  0x00, 0x30, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x04, 0x20, 0x0C, 0x06, 0x60, 0x3F, 0x82, 0x40, 0x61, 0x82, 0x40,
  0xC1, 0x82, 0xC1, 0x81, 0x03, 0xC1, 0x81, 0x03, 0xC1, 0x01, 0x03, 0xC1,
  0x01, 0x03, 0xC1, 0x01, 0x03, 0xC1, 0x01, 0x03, 0xC1, 0x01, 0x02, 0xC1,
  0x03, 0x02, 0xC1, 0x03, 0x02, 0xC1, 0x83, 0x06, 0x40, 0x84, 0x8C, 0x40,
  0xFC, 0xF8, 0x60, 0x10, 0x20, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x80, 0x03,
  0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x33, 0x00, 0x0C, 0x40, 0x02,
  0x10, 0x00, 0x86, 0x00, 0x61, 0x80, 0x10, 0x20, 0x04, 0x08, 0x03, 0x03,
  0x00, 0xC0, 0xC0, 0x20, 0x10, 0x08, 0x06, 0x07, 0xFF, 0x81, 0x80, 0x20,
  0x40, 0x08, 0x30, 0x03, 0x0C, 0x00, 0xC2, 0x00, 0x10, 0x80, 0x06, 0x60,
  0x01, 0x98, 0x00, 0x64, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0xFE,
  0x01, 0xFF, 0xE3, 0x00, 0xE6, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0xB0, 0x01,
  0x60, 0x02, 0xC0, 0x05, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x4C, 0x03, 0x1F,
  0xFC, 0x3F, 0xF8, 0x60, 0x0C, 0xC0, 0x0D, 0x80, 0x0B, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x05, 0x80, 0x1B,
  0x00, 0x66, 0x07, 0x8F, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xDF, 0x0E, 0x01,
  0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0x03, 0x03, 0xFE, 0xFC, 0x00, 0x7F, 0xF0, 0x30, 0x1E, 0x18, 0x03,
  0x8C, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x09, 0x80, 0x06, 0xC0, 0x03, 0x60,
  0x00, 0xB0, 0x00, 0x58, 0x00, 0x2C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xB0, 0x00, 0x58, 0x00, 0x2C, 0x00,
  0x36, 0x00, 0x1B, 0x00, 0x09, 0x80, 0x0C, 0xC0, 0x04, 0x60, 0x06, 0x30,
  0x0E, 0x18, 0x3E, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0F, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x7D, 0xFC, 0x18, 0x01, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0xFF,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xA0, 0x00, 0x34, 0x00, 0x06,
  0xC0, 0x00, 0xD8, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x63, 0x00, 0x0C,
  0x30, 0x01, 0x83, 0x80, 0x70, 0x1F, 0xF8, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0xFC, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0xC1, 0x83, 0x06, 0x0A, 0x77, 0xC0, 0xC0,
  0x07, 0x80, 0x1B, 0x00, 0x66, 0x00, 0x8C, 0x03, 0x18, 0x0C, 0x30, 0x30,
  0x60, 0x60, 0xC1, 0x81, 0x86, 0x03, 0x08, 0x06, 0x30, 0x0C, 0xC0, 0x1B,
  0x80, 0x35, 0x80, 0x79, 0x00, 0xE3, 0x01, 0x82, 0x03, 0x06, 0x06, 0x06,
  0x0C, 0x0C, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x18, 0xC0, 0x11, 0x80, 0x33,
  0x00, 0x26, 0x00, 0x6C, 0x00, 0x60, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xFF, 0xF0, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x17, 0x40, 0x00, 0x5D, 0x80, 0x03, 0x76, 0x00, 0x09,
  0xC8, 0x00, 0x27, 0x30, 0x01, 0x9C, 0xC0, 0x04, 0x71, 0x00, 0x11, 0xC6,
  0x00, 0xC7, 0x18, 0x02, 0x1C, 0x20, 0x08, 0x70, 0xC0, 0x61, 0xC3, 0x01,
  0x07, 0x04, 0x04, 0x1C, 0x18, 0x30, 0x70, 0x60, 0x81, 0xC0, 0x82, 0x07,
  0x03, 0x18, 0x1C, 0x0C, 0x40, 0x70, 0x11, 0x01, 0xC0, 0x6C, 0x07, 0x01,
  0xA0, 0x1C, 0x02, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x04, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3D, 0x00, 0x1E, 0xC0, 0x0F, 0x20,
  0x07, 0x98, 0x03, 0xC4, 0x01, 0xE3, 0x00, 0xF0, 0x80, 0x78, 0x60, 0x3C,
  0x10, 0x1E, 0x0C, 0x0F, 0x02, 0x07, 0x81, 0x83, 0xC0, 0x41, 0xE0, 0x30,
  0xF0, 0x08, 0x78, 0x06, 0x3C, 0x01, 0x1E, 0x00, 0xCF, 0x00, 0x27, 0x80,
  0x1B, 0xC0, 0x05, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x18,
  0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x30, 0x0C, 0x0C, 0x00, 0xC3, 0x00, 0x08,
  0x40, 0x01, 0x98, 0x00, 0x13, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xA0, 0x00, 0x34,
  0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x11, 0x00, 0x06, 0x30, 0x00, 0xC3,
  0x00, 0x30, 0x70, 0x0C, 0x07, 0x07, 0x00, 0x3F, 0xC0, 0xFC, 0x03, 0xFF,
  0x0C, 0x07, 0x30, 0x06, 0xC0, 0x1B, 0x00, 0x2C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x02, 0xC0, 0x1B, 0x00, 0x6C, 0x03, 0x30,
  0xF8, 0xFF, 0x83, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0xFB, 0xC0, 0x30, 0x0C, 0x0C, 0x00, 0xC3, 0x00, 0x08,
  0x60, 0x01, 0x98, 0x00, 0x13, 0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xA0, 0x00, 0x34,
  0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x11, 0x00, 0x06, 0x30, 0x00, 0xC3,
  0x00, 0x30, 0x70, 0x0C, 0x07, 0x07, 0x00, 0x3F, 0xC0, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0xFC, 0x01, 0xFF, 0xC3, 0x01, 0xC6, 0x00, 0xCC, 0x01, 0x98,
  0x01, 0x30, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x36, 0x00,
  0x4C, 0x01, 0x98, 0x06, 0x30, 0x38, 0x7F, 0xE0, 0xC1, 0x81, 0x83, 0x03,
  0x03, 0x06, 0x06, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x0C, 0x60, 0x18, 0xC0,
  0x19, 0x80, 0x33, 0x00, 0x36, 0x00, 0x6C, 0x00, 0x60, 0x07, 0xE0, 0x7B,
  0xE3, 0x00, 0x98, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x30, 0x18, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x40, 0x03,
  0x60, 0x06, 0x30, 0x06, 0x1C, 0x1C, 0x0F, 0xF0, 0xC0, 0x00, 0xF0, 0x00,
  0x24, 0x00, 0x19, 0x00, 0x06, 0x60, 0x01, 0x18, 0x00, 0x42, 0x00, 0x30,
  0x80, 0x0C, 0x30, 0x02, 0x0C, 0x01, 0x81, 0x00, 0x60, 0x60, 0x10, 0x18,
  0x04, 0x02, 0x03, 0x00, 0x80, 0xC0, 0x30, 0x20, 0x0C, 0x08, 0x01, 0x06,
  0x00, 0x41, 0x80, 0x18, 0x40, 0x02, 0x30, 0x00, 0x8C, 0x00, 0x32, 0x00,
  0x0C, 0x80, 0x01, 0x60, 0x00, 0x58, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x40, 0x02, 0x00, 0x1A, 0x00, 0x10, 0x00, 0x98, 0x01, 0xC0,
  0x04, 0xC0, 0x0A, 0x00, 0x66, 0x00, 0x50, 0x03, 0x10, 0x02, 0x80, 0x10,
  0x80, 0x36, 0x00, 0x86, 0x01, 0xB0, 0x0C, 0x30, 0x08, 0x80, 0x60, 0x80,
  0x44, 0x03, 0x04, 0x02, 0x20, 0x10, 0x30, 0x31, 0x81, 0x81, 0x81, 0x8C,
  0x0C, 0x0C, 0x08, 0x20, 0x60, 0x20, 0x41, 0x02, 0x01, 0x06, 0x0C, 0x10,
  0x0C, 0x30, 0x61, 0x80, 0x61, 0x01, 0x0C, 0x01, 0x08, 0x08, 0x40, 0x08,
  0x40, 0x42, 0x00, 0x66, 0x03, 0x30, 0x03, 0x30, 0x19, 0x80, 0x09, 0x00,
  0x48, 0x00, 0x48, 0x02, 0x40, 0x02, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0xE0, 0x03, 0x80, 0x03, 0x00, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x60, 0x02, 0x20, 0x06, 0x30, 0x06, 0x10, 0x0C, 0x18, 0x0C, 0x18, 0x18,
  0x08, 0x18, 0x0C, 0x10, 0x04, 0x30, 0x06, 0x20, 0x02, 0x60, 0x03, 0x40,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x40, 0x02, 0x60,
  0x06, 0x60, 0x04, 0x30, 0x0C, 0x30, 0x08, 0x10, 0x18, 0x18, 0x10, 0x08,
  0x30, 0x0C, 0x30, 0x04, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x0D, 0x00, 0x1B, 0x00, 0x22, 0x00, 0xC6, 0x01, 0x0C, 0x06, 0x08,
  0x0C, 0x18, 0x10, 0x10, 0x60, 0x30, 0x80, 0x61, 0x00, 0x46, 0x00, 0xC8,
  0x00, 0xB0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0x80, 0x0C, 0x00, 0x40, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x30, 0xFF, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0xFF, 0x00, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x40, 0x02, 0x60,
  0x06, 0x20, 0x04, 0x30, 0x0C, 0x10, 0x08, 0x18, 0x18, 0x08, 0x10, 0x0C,
  0x30, 0x04, 0x20, 0x06, 0x60, 0x02, 0x40, 0x03, 0xC0, 0x01, 0xFF, 0xFF,
  0x83, 0x06, 0x0C, 0x10, 0x20, 0x40, 0x02, 0x03, 0xFC, 0x60, 0x60, 0x02,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x0F, 0xF3, 0xC3,
  0x60, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x5C, 0x05,
  0x60, 0x93, 0xF1, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC1, 0x03, 0x3F, 0x8D, 0x83, 0x38, 0x06,
  0xA0, 0x0B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x2A, 0x01, 0xA8, 0x04, 0x98, 0x72, 0x3F, 0x80, 0x00, 0x80, 0xFF, 0x18,
  0x13, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x10, 0xFF, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x03, 0x04, 0x7F, 0x13, 0x82,
  0x4C, 0x05, 0x60, 0x0D, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0D, 0x00, 0x36, 0x01, 0xC8, 0x05, 0x38, 0x64, 0x7F, 0x10, 0x01, 0x00,
  0x7E, 0x0E, 0x18, 0x60, 0x66, 0x01, 0xA0, 0x0D, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x7F, 0xFF, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x81, 0x87, 0xF8, 0x01, 0x80,
  0xFC, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x03,
  0xFE, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x01, 0x00, 0x7F, 0x93, 0x83, 0x4C, 0x05,
  0x60, 0x0D, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x00,
  0x36, 0x01, 0x48, 0x05, 0x38, 0x64, 0x3F, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x19, 0x00, 0xC7, 0xFE, 0x01,
  0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC1, 0x06, 0x7F, 0x36, 0x1D, 0xC0, 0x6A, 0x01, 0x60, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0C, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x30,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC2, 0x1B, 0xE6, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x06, 0xC0, 0x4C, 0x0C, 0xC1, 0x8C,
  0x30, 0xC2, 0x0C, 0x60, 0xCC, 0x0C, 0xC0, 0x94, 0x0B, 0x60, 0xA2, 0x0C,
  0x30, 0xC1, 0x0C, 0x18, 0xC0, 0x8C, 0x0C, 0xC0, 0x4C, 0x06, 0xC0, 0x2C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x82,
  0x7F, 0x0F, 0xC9, 0x06, 0x41, 0xA8, 0x1A, 0x02, 0xC0, 0x38, 0x0F, 0x00,
  0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0,
  0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C,
  0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03,
  0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x30, 0x01, 0x04,
  0x7F, 0x26, 0x1D, 0x40, 0x6A, 0x01, 0x60, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0C, 0x03, 0x00,
  0x1F, 0xC0, 0xE0, 0xC1, 0x00, 0xC6, 0x00, 0x88, 0x01, 0xB0, 0x03, 0x60,
  0x02, 0xC0, 0x05, 0x80, 0x0A, 0x00, 0x14, 0x00, 0x3C, 0x00, 0x58, 0x00,
  0xB0, 0x01, 0x60, 0x02, 0x40, 0x0C, 0x80, 0x19, 0x80, 0x21, 0x80, 0xC1,
  0x83, 0x01, 0xFC, 0x00, 0x03, 0x02, 0x3F, 0x89, 0x83, 0x2C, 0x06, 0xA0,
  0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x2A,
  0x01, 0xBC, 0x04, 0xD8, 0x73, 0x3F, 0x8C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x00, 0x7F, 0x13, 0x82, 0x4C, 0x05, 0x60, 0x1D, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x00, 0x36, 0x01, 0x4C, 0x05, 0x38, 0x64,
  0x7F, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x47, 0xE6, 0x16, 0x0A, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x02, 0x01, 0xFF, 0x30, 0x26,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x38,
  0x02, 0xE0, 0xE7, 0xFC, 0x30, 0x30, 0x30, 0x30, 0x30, 0xFF, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x10, 0x1F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x3E, 0x01, 0xD0,
  0x16, 0xE1, 0xB3, 0xF9, 0x80, 0xC0, 0x0D, 0x00, 0x24, 0x00, 0x98, 0x06,
  0x60, 0x18, 0x80, 0x43, 0x03, 0x0C, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x86,
  0x06, 0x18, 0x08, 0x40, 0x23, 0x00, 0xCC, 0x01, 0x20, 0x04, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x80, 0x30, 0x0D,
  0x80, 0xE0, 0x13, 0x01, 0x60, 0x22, 0x02, 0xC0, 0xC4, 0x04, 0x81, 0x8C,
  0x19, 0x02, 0x18, 0x33, 0x04, 0x10, 0x46, 0x18, 0x20, 0x84, 0x30, 0x63,
  0x08, 0x40, 0xC6, 0x10, 0x81, 0x88, 0x33, 0x01, 0x10, 0x26, 0x02, 0x60,
  0x48, 0x06, 0xC0, 0x90, 0x0D, 0x01, 0xA0, 0x0A, 0x03, 0xC0, 0x14, 0x03,
  0x80, 0x38, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x1B, 0x01, 0x88, 0x0C,
  0x60, 0xC1, 0x04, 0x0C, 0x60, 0x22, 0x01, 0xB0, 0x05, 0x00, 0x38, 0x01,
  0xC0, 0x0A, 0x00, 0xD8, 0x04, 0x40, 0x63, 0x02, 0x08, 0x30, 0x61, 0x01,
  0x18, 0x0C, 0x80, 0x2C, 0x01, 0x80, 0x40, 0x05, 0x80, 0x36, 0x00, 0xC8,
  0x02, 0x20, 0x18, 0xC0, 0x63, 0x01, 0x04, 0x04, 0x18, 0x30, 0x60, 0x80,
  0x82, 0x02, 0x18, 0x0C, 0x60, 0x11, 0x00, 0x4C, 0x01, 0xB0, 0x06, 0x80,
  0x0A, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x03, 0xE0, 0x06, 0x00,
  0x00, 0x7F, 0xE0, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x80, 0x60, 0x0F, 0xFE, 0x00, 0x40, 0xF0, 0x60, 0x30, 0x0C,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x60, 0x18, 0x38, 0x0F, 0x00, 0x60, 0x18, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x01, 0x80, 0x30,
  0x0C, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x06, 0x00, 0xF0, 0x3C, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x06, 0x0F, 0x00, 0x3E, 0x01, 0x67, 0x83, 0xC0, 0xFE, 0x80, 0x38,
};

const GFXglyph NotoSans_Condensed_ExtraLight40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 29, 8, 3, -29 },
  { 12, 7, 11, 13, 3, -29 },
  { 22, 18, 29, 20, 1, -29 },
  { 88, 14, 32, 18, 2, -30 },
  { 144, 22, 29, 26, 2, -29 },
  { 224, 17, 29, 20, 2, -29 },
  { 286, 1, 11, 7, 3, -29 },
  { 288, 7, 35, 11, 2, -29 },
  { 319, 8, 35, 11, 1, -29 },
  { 354, 12, 12, 16, 2, -30 },
  { 372, 16, 18, 18, 1, -23 },
  { 408, 3, 9, 8, 2, -4 },
  { 412, 9, 2, 11, 1, -12 },
  { 415, 2, 3, 8, 3, -3 },
  { 416, 12, 29, 13, 1, -29 },
  { 460, 14, 29, 18, 2, -29 },
  { 511, 8, 29, 18, 3, -29 },
  { 540, 14, 29, 18, 2, -29 },
  { 591, 14, 29, 18, 2, -29 },
  { 642, 17, 29, 18, 1, -29 },
  { 704, 14, 29, 18, 2, -29 },
  { 755, 14, 29, 18, 2, -29 },
  { 806, 14, 29, 18, 2, -29 },
  { 857, 14, 29, 18, 2, -29 },
  { 908, 14, 29, 18, 2, -29 },
  { 959, 2, 21, 8, 3, -21 },
  { 965, 4, 26, 8, 1, -21 },
  { 978, 16, 17, 18, 1, -23 },
  { 1012, 16, 10, 18, 1, -19 },
  { 1032, 16, 17, 18, 1, -23 },
  { 1066, 11, 29, 13, 1, -29 },
  { 1106, 24, 33, 28, 2, -29 },
  { 1205, 18, 29, 18, 0, -29 },
  { 1271, 15, 29, 20, 3, -29 },
  { 1326, 16, 29, 19, 2, -29 },
  { 1384, 17, 29, 22, 3, -29 },
  { 1446, 12, 29, 17, 3, -29 },
  { 1490, 12, 29, 16, 3, -29 },
  { 1534, 19, 29, 23, 2, -29 },
  { 1603, 16, 29, 22, 3, -29 },
  { 1661, 6, 29, 10, 2, -29 },
  { 1683, 7, 36, 8, -2, -29 },
  { 1715, 15, 29, 18, 3, -29 },
  { 1770, 12, 29, 16, 3, -29 },
  { 1814, 22, 29, 29, 3, -29 },
  { 1894, 17, 29, 23, 3, -29 },
  { 1956, 19, 29, 24, 2, -29 },
  { 2025, 14, 29, 18, 3, -29 },
  { 2076, 19, 36, 24, 2, -29 },
  { 2162, 15, 29, 19, 3, -29 },
  { 2217, 14, 29, 18, 2, -29 },
  { 2268, 16, 29, 16, 0, -29 },
  { 2326, 16, 29, 22, 3, -29 },
  { 2384, 18, 29, 18, 0, -29 },
  { 2450, 29, 29, 29, 0, -29 },
  { 2556, 16, 29, 16, 0, -29 },
  { 2614, 15, 29, 15, 0, -29 },
  { 2669, 14, 29, 16, 1, -29 },
  { 2720, 8, 35, 12, 3, -29 },
  { 2755, 12, 29, 13, 1, -29 },
  { 2799, 8, 35, 12, 1, -29 },
  { 2834, 16, 16, 18, 1, -29 },
  { 2866, 16, 1, 16, 0, 4 },
  { 2868, 6, 7, 10, 2, -31 },
  { 2874, 12, 22, 17, 2, -22 },
  { 2907, 14, 30, 19, 3, -30 },
  { 2960, 12, 22, 15, 2, -22 },
  { 2993, 14, 30, 19, 2, -30 },
  { 3046, 13, 22, 17, 2, -22 },
  { 3082, 11, 31, 10, 0, -31 },
  { 3125, 14, 32, 19, 2, -22 },
  { 3181, 13, 30, 19, 3, -30 },
  { 3230, 2, 29, 8, 3, -29 },
  { 3238, 6, 39, 8, -1, -29 },
  { 3268, 12, 30, 15, 3, -30 },
  { 3313, 2, 30, 8, 3, -30 },
  { 3321, 22, 22, 28, 3, -22 },
  { 3382, 13, 22, 19, 3, -22 },
  { 3418, 15, 22, 18, 2, -22 },
  { 3460, 14, 31, 19, 3, -22 },
  { 3515, 14, 31, 19, 2, -22 },
  { 3570, 9, 22, 12, 3, -22 },
  { 3595, 12, 22, 14, 1, -22 },
  { 3628, 8, 26, 10, 1, -26 },
  { 3654, 13, 21, 19, 3, -21 },
  { 3689, 14, 21, 14, 0, -21 },
  { 3726, 23, 21, 23, 0, -21 },
  { 3787, 13, 21, 15, 1, -21 },
  { 3822, 14, 31, 14, 0, -21 },
  { 3877, 11, 21, 13, 1, -21 },
  { 3906, 10, 35, 14, 2, -29 },
  { 3950, 1, 40, 17, 8, -30 },
  { 3955, 10, 35, 14, 2, -29 },
  { 3999, 16, 4, 18, 1, -16 },
};

const GFXfont NotoSans_Condensed_ExtraLight40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight40pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT40PT7B_H_
