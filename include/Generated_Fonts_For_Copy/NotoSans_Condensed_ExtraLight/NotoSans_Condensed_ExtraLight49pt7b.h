#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT49PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight49pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xD8, 0x00,
  0x02, 0xFF, 0x80, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC0, 0xE0, 0x50, 0x28, 0x14, 0x08, 0x00, 0xC0, 0x60, 0x03, 0x01, 0x00,
  0x0C, 0x04, 0x00, 0x30, 0x30, 0x00, 0x80, 0xC0, 0x02, 0x03, 0x00, 0x18,
  0x0C, 0x00, 0x60, 0x30, 0x01, 0x80, 0x80, 0x06, 0x02, 0x07, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x01, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00,
  0xC0, 0x40, 0x03, 0x01, 0x00, 0x0C, 0x04, 0x00, 0x20, 0x30, 0x00, 0x80,
  0xC0, 0x02, 0x03, 0x00, 0x18, 0x0C, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0x06, 0x02, 0x00, 0x18, 0x18, 0x00, 0x40, 0x60, 0x01, 0x01, 0x80, 0x0C,
  0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x40, 0x03, 0x01, 0x00, 0x0C, 0x04,
  0x00, 0x20, 0x30, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x1F, 0xF0, 0x1F, 0xBF, 0x0E, 0x20, 0xC6, 0x08, 0x01, 0x82,
  0x00, 0xC0, 0x80, 0x30, 0x20, 0x0C, 0x08, 0x03, 0x02, 0x00, 0xC0, 0x80,
  0x30, 0x20, 0x06, 0x08, 0x01, 0xC2, 0x00, 0x38, 0x80, 0x07, 0xA0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x27, 0x80, 0x08, 0x70, 0x02,
  0x0E, 0x00, 0x81, 0x80, 0x20, 0x20, 0x08, 0x0C, 0x02, 0x03, 0x00, 0x80,
  0xC0, 0x20, 0x20, 0x08, 0x18, 0x02, 0x06, 0x80, 0x83, 0x3C, 0x23, 0x87,
  0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x1F, 0x80, 0x0C, 0x03, 0x18, 0x00, 0x80, 0x20, 0xC0, 0x18, 0x06,
  0x04, 0x01, 0x00, 0x60, 0x60, 0x30, 0x04, 0x06, 0x03, 0x00, 0x40, 0x60,
  0x20, 0x0C, 0x02, 0x06, 0x00, 0xC0, 0x20, 0x40, 0x0C, 0x02, 0x0C, 0x00,
  0xC0, 0x20, 0xC0, 0x0C, 0x02, 0x08, 0x00, 0xC0, 0x21, 0x80, 0x0C, 0x02,
  0x10, 0x20, 0x40, 0x63, 0x1F, 0x84, 0x06, 0x31, 0x8C, 0x60, 0x62, 0x30,
  0x46, 0x04, 0x62, 0x06, 0x20, 0xC4, 0x60, 0x63, 0x98, 0xC6, 0x02, 0x1F,
  0x8C, 0x60, 0x20, 0x00, 0x84, 0x03, 0x00, 0x18, 0x40, 0x30, 0x01, 0x04,
  0x03, 0x00, 0x30, 0x40, 0x30, 0x03, 0x04, 0x03, 0x00, 0x20, 0x40, 0x30,
  0x06, 0x04, 0x03, 0x00, 0x40, 0x60, 0x20, 0x0C, 0x06, 0x02, 0x00, 0xC0,
  0x60, 0x60, 0x08, 0x02, 0x06, 0x01, 0x80, 0x30, 0x40, 0x18, 0x01, 0x8C,
  0x03, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x00, 0x38, 0xE0, 0x00, 0xC0, 0xC0,
  0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x10, 0x01, 0x80, 0x40, 0x06,
  0x01, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x00, 0x80, 0xC0, 0x03, 0x06,
  0x00, 0x0C, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3B, 0x00, 0x01, 0xCC, 0x00, 0x0E, 0x18, 0x06, 0x30,
  0x30, 0x19, 0x80, 0xC0, 0x46, 0x01, 0x81, 0x30, 0x03, 0x0C, 0xC0, 0x0E,
  0x33, 0x00, 0x18, 0x8C, 0x00, 0x36, 0x30, 0x00, 0x78, 0xC0, 0x01, 0xC3,
  0x00, 0x07, 0x06, 0x00, 0x3E, 0x18, 0x01, 0xD8, 0x30, 0x0E, 0x30, 0x70,
  0xF0, 0x60, 0xFF, 0x01, 0xC0, 0xFF, 0xFF, 0x55, 0x40, 0x01, 0x81, 0x80,
  0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x06, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x06,
  0x03, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0xC0, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0x40,
  0x30, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03,
  0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x61, 0x87, 0xFD,
  0xBE, 0x0F, 0xF0, 0x01, 0x80, 0x03, 0xC0, 0x06, 0x60, 0x04, 0x30, 0x0C,
  0x30, 0x18, 0x18, 0x30, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x39, 0x8C, 0x63,
  0x31, 0x8C, 0x46, 0x30, 0xFF, 0xFF, 0xFC, 0x6E, 0xF6, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xC7, 0x00, 0xC0, 0xE0, 0x60, 0x18,
  0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x11, 0x80, 0x06, 0x60, 0x01, 0x98,
  0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x00, 0x90, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x40, 0x00, 0xD0, 0x00, 0x36, 0x00, 0x09, 0x80, 0x06, 0x60, 0x01, 0x98,
  0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x30, 0x01, 0x0C, 0x00, 0xC3, 0x80,
  0x30, 0x60, 0x18, 0x0C, 0x0E, 0x03, 0xEF, 0x00, 0x3F, 0x80, 0x01, 0x81,
  0xC1, 0xA1, 0x91, 0x8B, 0x87, 0x82, 0x81, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x0F, 0xF0, 0x1E, 0x1E, 0x1C, 0x03, 0x88, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x1E, 0x1E, 0x38, 0x03, 0x88,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0E, 0x80, 0x0E, 0x7C, 0x1E, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x16, 0x00, 0x01, 0xB0, 0x00, 0x09, 0x80,
  0x00, 0xCC, 0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00, 0x30,
  0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0x81, 0x80, 0x08, 0x0C, 0x00,
  0xC0, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x03, 0x00, 0x30, 0x18, 0x01, 0x81, 0x80, 0x0C, 0x08, 0x00, 0x60, 0xC0,
  0x03, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x7F, 0xFE, 0x3F, 0xFF, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x7F, 0x81,
  0xFF, 0xF0, 0x40, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C,
  0x80, 0x1C, 0x78, 0x3C, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0xE3, 0x03,
  0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x04,
  0x03, 0x1F, 0xE1, 0xB8, 0x38, 0xD0, 0x06, 0x50, 0x03, 0x38, 0x00, 0xD8,
  0x00, 0x6C, 0x00, 0x16, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x34, 0x00, 0x33, 0x00, 0x19, 0x80,
  0x0C, 0x60, 0x0C, 0x38, 0x0E, 0x0E, 0x0E, 0x03, 0xFE, 0x00, 0x10, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0x87, 0x81,
  0x80, 0x70, 0xC0, 0x0C, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80,
  0x06, 0x60, 0x01, 0x98, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x0C, 0x18, 0x07,
  0x07, 0x03, 0x80, 0x61, 0xC0, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0xFC, 0x00,
  0xE1, 0xC0, 0x60, 0x38, 0x30, 0x07, 0x1C, 0x00, 0xE6, 0x00, 0x1B, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x36, 0x00, 0x19, 0xC0, 0x0E, 0x38, 0x07, 0x07, 0x87, 0x80,
  0x7F, 0x80, 0x07, 0xF0, 0x0F, 0x1E, 0x0E, 0x03, 0x86, 0x00, 0xC6, 0x00,
  0x33, 0x00, 0x19, 0x80, 0x05, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06, 0xC0, 0x03,
  0x60, 0x03, 0xB8, 0x01, 0x4C, 0x01, 0x63, 0x83, 0xB0, 0xFF, 0x18, 0x0E,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38,
  0x10, 0x78, 0x0F, 0xF0, 0x00, 0x6F, 0xE6, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x6E, 0xF6, 0x31, 0xCE, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xC6, 0x31, 0x98, 0xC6,
  0x23, 0x18, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xC7, 0x8F, 0x20, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x0C, 0x00, 0xF0,
  0x03, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x70, 0x03,
  0x80, 0x06, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x38, 0x06, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x03, 0x07, 0x00, 0x00, 0x08, 0x30, 0x00, 0x00, 0x61, 0x00,
  0x00, 0x03, 0x18, 0x03, 0xF8, 0x0C, 0xC0, 0x38, 0xE0, 0x64, 0x03, 0x03,
  0x03, 0x60, 0x30, 0x18, 0x1B, 0x01, 0x80, 0xC0, 0x58, 0x18, 0x06, 0x02,
  0xC0, 0xC0, 0x30, 0x16, 0x06, 0x01, 0x80, 0xA0, 0x20, 0x08, 0x07, 0x01,
  0x00, 0x40, 0x28, 0x08, 0x02, 0x01, 0x40, 0x40, 0x30, 0x0A, 0x02, 0x01,
  0x80, 0xD0, 0x10, 0x0C, 0x06, 0xC0, 0xC0, 0x60, 0x36, 0x06, 0x07, 0x81,
  0x30, 0x18, 0x2C, 0x19, 0x80, 0xE3, 0x31, 0x8C, 0x03, 0xF0, 0xF8, 0x30,
  0x04, 0x01, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1A, 0x00, 0x00, 0x4C, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x31,
  0x00, 0x00, 0x86, 0x00, 0x06, 0x18, 0x00, 0x18, 0x60, 0x00, 0x60, 0x80,
  0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x80, 0x60, 0x06,
  0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x08, 0x03, 0x00, 0x30, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60,
  0x60, 0x00, 0x83, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x1B, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0x0C, 0x00, 0xE3, 0x00,
  0x0C, 0xC0, 0x03, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01,
  0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03, 0x30, 0x00, 0xCC,
  0x00, 0x63, 0x00, 0xF0, 0xFF, 0xF0, 0x30, 0x3F, 0x0C, 0x00, 0x73, 0x00,
  0x0E, 0xC0, 0x01, 0xB0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x6C,
  0x00, 0x1B, 0x00, 0x0C, 0xC0, 0x0E, 0x3F, 0xFF, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x7C, 0x3C, 0x1C, 0x00, 0x87, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x20, 0x7C, 0x3C, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0xC0, 0x1E, 0x0C, 0x00, 0x70, 0xC0, 0x03, 0x8C,
  0x00, 0x1C, 0xC0, 0x00, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0x6C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x00, 0xCC,
  0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00, 0x70, 0xC0, 0x1E, 0x0F, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFD, 0xFF,
  0xFB, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF, 0xFB, 0xFF, 0xF6, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xC1, 0xF8, 0x1E, 0x00, 0x30,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x80, 0x00, 0x33,
  0x00, 0x00, 0x67, 0x00, 0x00, 0xC7, 0x00, 0x01, 0x87, 0x00, 0x03, 0x07,
  0x00, 0x06, 0x07, 0xC0, 0xFC, 0x03, 0xFF, 0xC0, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0x80, 0xFF, 0x3C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x03, 0x43, 0xBF, 0x8F, 0x00, 0xC0, 0x01, 0xB0,
  0x00, 0xCC, 0x00, 0x73, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x07, 0x0C, 0x01,
  0x83, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x0C, 0x0C, 0x03, 0x06, 0x00,
  0xC3, 0x80, 0x30, 0xC0, 0x0C, 0x60, 0x03, 0x38, 0x00, 0xCF, 0x00, 0x36,
  0xC0, 0x0F, 0x38, 0x03, 0x86, 0x00, 0xE0, 0xC0, 0x30, 0x30, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x30, 0x30, 0x0E, 0x0C, 0x01, 0x83, 0x00, 0x30,
  0xC0, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x0C, 0xC0, 0x03, 0x30,
  0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xB0,
  0x00, 0x02, 0xF6, 0x00, 0x00, 0xDE, 0xC0, 0x00, 0x1B, 0xCC, 0x00, 0x02,
  0x79, 0x80, 0x00, 0xCF, 0x30, 0x00, 0x19, 0xE3, 0x00, 0x02, 0x3C, 0x60,
  0x00, 0xC7, 0x8C, 0x00, 0x18, 0xF0, 0xC0, 0x02, 0x1E, 0x18, 0x00, 0xC3,
  0xC3, 0x00, 0x18, 0x78, 0x30, 0x02, 0x0F, 0x06, 0x00, 0xC1, 0xE0, 0xC0,
  0x18, 0x3C, 0x0C, 0x02, 0x07, 0x81, 0x80, 0xC0, 0xF0, 0x30, 0x18, 0x1E,
  0x03, 0x02, 0x03, 0xC0, 0x60, 0xC0, 0x78, 0x0C, 0x18, 0x0F, 0x00, 0xC2,
  0x01, 0xE0, 0x18, 0xC0, 0x3C, 0x03, 0x18, 0x07, 0x80, 0x32, 0x00, 0xF0,
  0x06, 0xC0, 0x1E, 0x00, 0xD8, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0x80, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xD8, 0x00, 0x3D, 0x80, 0x03, 0xCC, 0x00, 0x3C, 0xC0,
  0x03, 0xC6, 0x00, 0x3C, 0x60, 0x03, 0xC3, 0x00, 0x3C, 0x30, 0x03, 0xC1,
  0x80, 0x3C, 0x18, 0x03, 0xC0, 0xC0, 0x3C, 0x0C, 0x03, 0xC0, 0x60, 0x3C,
  0x06, 0x03, 0xC0, 0x30, 0x3C, 0x03, 0x03, 0xC0, 0x18, 0x3C, 0x01, 0x83,
  0xC0, 0x0C, 0x3C, 0x00, 0xC3, 0xC0, 0x06, 0x3C, 0x00, 0x63, 0xC0, 0x03,
  0x3C, 0x00, 0x33, 0xC0, 0x01, 0xBC, 0x00, 0x1B, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x01, 0xFF, 0x00,
  0x0F, 0x87, 0x80, 0x38, 0x03, 0x80, 0xE0, 0x03, 0x81, 0x80, 0x03, 0x06,
  0x00, 0x03, 0x1C, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x33, 0x00, 0x00, 0x63, 0x00, 0x01, 0x86, 0x00, 0x03, 0x06,
  0x00, 0x0C, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x0F, 0x8F, 0x80, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x0E,
  0xC0, 0x1C, 0xC1, 0xF8, 0xFF, 0xE0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x0F, 0x87, 0x80, 0x38, 0x03, 0x80, 0xE0, 0x03, 0x81,
  0x80, 0x03, 0x06, 0x00, 0x03, 0x1C, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60,
  0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x33, 0x00, 0x00, 0x63, 0x00, 0x01, 0x86,
  0x00, 0x03, 0x06, 0x00, 0x0C, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x0F,
  0x8F, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0xFF, 0xC0, 0x3F, 0xFE, 0x0C, 0x01, 0xC3, 0x00,
  0x18, 0xC0, 0x07, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x01,
  0x30, 0x00, 0x4C, 0x00, 0x13, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xCC,
  0x00, 0x73, 0x00, 0x18, 0xC0, 0x0C, 0x30, 0x1E, 0x0F, 0xFE, 0x03, 0x03,
  0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x18,
  0x30, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x01, 0x8C,
  0x00, 0x73, 0x00, 0x0C, 0xC0, 0x03, 0xB0, 0x00, 0x6C, 0x00, 0x1C, 0x07,
  0xFE, 0x0F, 0x87, 0xCE, 0x00, 0x46, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x80, 0x0E, 0x7E, 0x1E, 0x1F,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x06,
  0xC0, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0xC3, 0x00, 0x0C, 0x38, 0x03,
  0x81, 0xF0, 0xF0, 0x07, 0xFC, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xD8,
  0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x03, 0x10, 0x00, 0x18, 0xC0, 0x00,
  0xC6, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x80, 0x03, 0x06, 0x00, 0x18, 0x30,
  0x01, 0x81, 0x80, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x02, 0x01, 0x80, 0x30,
  0x04, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x20,
  0x30, 0x01, 0x81, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x01, 0x86, 0x00,
  0x0C, 0x20, 0x00, 0x63, 0x00, 0x01, 0x18, 0x00, 0x0C, 0xC0, 0x00, 0x6C,
  0x00, 0x03, 0x60, 0x00, 0x0B, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x06, 0x60, 0x01, 0xE0, 0x01, 0x98,
  0x00, 0x58, 0x00, 0x66, 0x00, 0x36, 0x00, 0x19, 0x80, 0x0C, 0x80, 0x0C,
  0x20, 0x03, 0x30, 0x03, 0x0C, 0x00, 0xCC, 0x00, 0xC3, 0x00, 0x23, 0x00,
  0x30, 0xC0, 0x18, 0xC0, 0x18, 0x30, 0x06, 0x10, 0x06, 0x06, 0x01, 0x86,
  0x01, 0x81, 0x80, 0x41, 0x80, 0x60, 0x60, 0x30, 0x60, 0x30, 0x18, 0x0C,
  0x08, 0x0C, 0x03, 0x03, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0x30,
  0x20, 0x30, 0x30, 0x0C, 0x18, 0x0C, 0x18, 0x01, 0x06, 0x01, 0x06, 0x00,
  0x61, 0x80, 0x61, 0x80, 0x18, 0x40, 0x18, 0x60, 0x06, 0x30, 0x06, 0x30,
  0x01, 0x8C, 0x00, 0x8C, 0x00, 0x33, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x0C,
  0xC0, 0x03, 0x20, 0x03, 0x20, 0x00, 0xD8, 0x00, 0xD8, 0x00, 0x16, 0x00,
  0x16, 0x00, 0x07, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x70, 0x00, 0x66, 0x00, 0x18,
  0x60, 0x03, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x18, 0x06, 0x03, 0x00, 0xC0,
  0x30, 0x38, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x00, 0xC6, 0x00,
  0x19, 0x80, 0x03, 0x30, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00,
  0xC3, 0x00, 0x18, 0x60, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x30, 0x08, 0x06,
  0x01, 0x81, 0x80, 0x30, 0x30, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x06, 0x60,
  0x00, 0xCC, 0x00, 0x0F, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x6C, 0x00, 0x19,
  0x80, 0x03, 0x30, 0x00, 0x63, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0xC0,
  0xC0, 0x18, 0x18, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x03, 0x06, 0x00,
  0x60, 0xC0, 0x0C, 0x18, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x01, 0x10, 0x00,
  0x36, 0x00, 0x06, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE0,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFC, 0xC0, 0x00, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0D,
  0x80, 0x01, 0x98, 0x00, 0x18, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x60, 0x06,
  0x06, 0x00, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x18, 0x01, 0x81,
  0x80, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x06, 0x60, 0x00, 0x6E, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x0F, 0xF0, 0x78, 0x70, 0x80, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x07, 0xF0, 0xFF,
  0xE3, 0x80, 0xCC, 0x01, 0xB0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xB0, 0x0B, 0x38, 0x66, 0x3F,
  0x84, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0xFF, 0x0C, 0xE3, 0xC6, 0xC0, 0x72, 0xC0, 0x19, 0x40, 0x06, 0xE0,
  0x03, 0x60, 0x01, 0xB0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0D, 0x80, 0x06, 0xA0, 0x03, 0x58,
  0x03, 0x26, 0x03, 0x93, 0x87, 0x88, 0x7F, 0x00, 0x03, 0xFE, 0x0F, 0x18,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x0E, 0x0F, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x1F, 0xE3,
  0x0E, 0x1C, 0xC7, 0x01, 0xB3, 0x80, 0x2C, 0xC0, 0x07, 0x70, 0x01, 0xD8,
  0x00, 0x76, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0D, 0x00, 0x03,
  0x60, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x07, 0x30, 0x01, 0xCC,
  0x00, 0xB1, 0x80, 0x6C, 0x38, 0x73, 0x07, 0xF8, 0xC0, 0x07, 0xF8, 0x07,
  0x1E, 0x07, 0x03, 0x87, 0x00, 0xC3, 0x00, 0x31, 0x00, 0x19, 0x80, 0x04,
  0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x02,
  0x0F, 0x0F, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x0E, 0x20, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x3F, 0xF8, 0xFF, 0xE0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x07, 0xF8,
  0xC3, 0xC7, 0x31, 0xC0, 0x6C, 0xE0, 0x0F, 0x30, 0x01, 0xD8, 0x00, 0x76,
  0x00, 0x1D, 0x80, 0x03, 0x60, 0x00, 0xD0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x40, 0x00,
  0xD8, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x01, 0xCC, 0x00, 0xF3,
  0x00, 0x2C, 0x60, 0x1B, 0x0E, 0x1C, 0xC1, 0xFE, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE4, 0x00, 0x71, 0xC0, 0x38, 0x3F, 0xFC, 0x01, 0xF8, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x3F, 0x8C, 0xE7,
  0x9B, 0x01, 0xAC, 0x03, 0xD0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x60, 0x5F, 0xB0,
  0x00, 0x01, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB0,
  0x04, 0x1C, 0x38, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0xC1, 0xBE, 0x78, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x07, 0xC0, 0x1B, 0x00, 0xCC, 0x06, 0x30, 0x38, 0xC0, 0xC3,
  0x06, 0x0C, 0x30, 0x30, 0xC0, 0xC6, 0x03, 0x38, 0x0C, 0xE0, 0x26, 0xC0,
  0xB3, 0x03, 0x86, 0x0C, 0x18, 0x30, 0x30, 0xC0, 0xC3, 0x01, 0x8C, 0x06,
  0x30, 0x0C, 0xC0, 0x33, 0x00, 0x6C, 0x01, 0xB0, 0x03, 0xC0, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x8F, 0xE0, 0x7F,
  0x13, 0x8E, 0x1C, 0xF2, 0x40, 0x66, 0x07, 0x50, 0x0D, 0x80, 0x6A, 0x00,
  0xE0, 0x0D, 0x80, 0x1C, 0x00, 0xB0, 0x03, 0x00, 0x1E, 0x00, 0x60, 0x03,
  0xC0, 0x0C, 0x00, 0x78, 0x01, 0x80, 0x0F, 0x00, 0x30, 0x01, 0xE0, 0x06,
  0x00, 0x3C, 0x00, 0xC0, 0x07, 0x80, 0x18, 0x00, 0xF0, 0x03, 0x00, 0x1E,
  0x00, 0x60, 0x03, 0xC0, 0x0C, 0x00, 0x78, 0x01, 0x80, 0x0F, 0x00, 0x30,
  0x01, 0xE0, 0x06, 0x00, 0x3C, 0x00, 0xC0, 0x07, 0x80, 0x18, 0x00, 0xF0,
  0x03, 0x00, 0x1E, 0x00, 0x60, 0x03, 0xC0, 0x0C, 0x00, 0x78, 0x01, 0x80,
  0x0C, 0x87, 0xF1, 0x1C, 0x72, 0x60, 0x35, 0x80, 0x7A, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0C, 0x07, 0xF8, 0x03, 0xC7, 0x81, 0x80, 0x70, 0xE0, 0x0C, 0x30,
  0x01, 0x98, 0x00, 0x66, 0x00, 0x09, 0x80, 0x03, 0x60, 0x00, 0xD0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x40, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03, 0x60,
  0x01, 0x8C, 0x00, 0x63, 0x80, 0x30, 0x60, 0x1C, 0x0E, 0x0E, 0x01, 0xFE,
  0x00, 0x87, 0xF0, 0x47, 0x1E, 0x26, 0x03, 0x96, 0x00, 0xCA, 0x00, 0x37,
  0x00, 0x1B, 0x00, 0x0D, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x6E, 0x00, 0x35, 0x00, 0x1A,
  0xC0, 0x19, 0xB0, 0x18, 0xCC, 0x3C, 0x63, 0xF8, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF8, 0xC3, 0xC7,
  0x31, 0xC0, 0x6C, 0xE0, 0x0B, 0x30, 0x01, 0xDC, 0x00, 0x76, 0x00, 0x1D,
  0x80, 0x03, 0x60, 0x00, 0xD0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x40, 0x00, 0xD8, 0x00,
  0x36, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x01, 0xCC, 0x00, 0xF3, 0x00, 0x2C,
  0x60, 0x1B, 0x0E, 0x1C, 0xC1, 0xFC, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x87, 0xE3, 0xF9, 0x82,
  0xC0, 0xA0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x00, 0x1F, 0xF8, 0xF1, 0xF6, 0x00, 0x98, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xA0, 0x0E, 0xF0,
  0xF1, 0xFF, 0x80, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x0F, 0xFF,
  0xFF, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x00, 0xC4, 0x3F, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0x70, 0x06, 0xB0, 0x19, 0x78, 0xE2, 0x7F, 0x84, 0xC0, 0x01, 0xA0, 0x00,
  0xD8, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x31, 0x80, 0x10, 0xC0, 0x18, 0x60,
  0x0C, 0x10, 0x06, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x80,
  0x60, 0xC0, 0x30, 0x60, 0x08, 0x30, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C,
  0x00, 0x44, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x05, 0x80, 0x02, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0x60, 0x05, 0x00, 0x64, 0x01, 0xB0, 0x0C, 0xC0, 0x36, 0x01,
  0x98, 0x06, 0xC0, 0x33, 0x00, 0x88, 0x04, 0x20, 0x31, 0x81, 0x86, 0x06,
  0x30, 0x30, 0xC0, 0xC6, 0x06, 0x18, 0x10, 0x40, 0x81, 0x06, 0x0C, 0x30,
  0x30, 0xC1, 0x86, 0x06, 0x18, 0x30, 0xC0, 0xC2, 0x06, 0x10, 0x08, 0xC0,
  0x46, 0x01, 0x98, 0x0C, 0xC0, 0x33, 0x01, 0x98, 0x06, 0x40, 0x32, 0x00,
  0xD8, 0x02, 0x40, 0x0B, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0xE0, 0x03, 0x60, 0x06,
  0x30, 0x06, 0x30, 0x0C, 0x18, 0x0C, 0x18, 0x18, 0x0C, 0x18, 0x0C, 0x30,
  0x06, 0x30, 0x06, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x01, 0x80, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x18,
  0x18, 0x18, 0x30, 0x0C, 0x30, 0x06, 0x60, 0x06, 0x60, 0x03, 0xC0, 0x03,
  0x60, 0x01, 0xD8, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x0C,
  0x00, 0xC1, 0x00, 0x30, 0x60, 0x18, 0x18, 0x06, 0x06, 0x01, 0x80, 0xC0,
  0x40, 0x30, 0x30, 0x0C, 0x0C, 0x01, 0x03, 0x00, 0x61, 0x80, 0x18, 0x60,
  0x06, 0x18, 0x00, 0xC4, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x01, 0x30, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x0F,
  0xC0, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x18, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x07, 0xC0, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x07, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0F,
  0x00, 0x3C, 0x07, 0x80, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x07, 0xE0, 0x38, 0x00,
  0x08, 0x00, 0x1F, 0xE0, 0x1E, 0x1E, 0x0E, 0x01, 0xFF, 0x80, 0x1F, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLight49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 35, 10, 4, -35 },
  { 15, 9, 13, 16, 3, -35 },
  { 30, 22, 35, 24, 1, -35 },
  { 127, 18, 40, 22, 2, -37 },
  { 217, 28, 35, 32, 2, -35 },
  { 340, 22, 35, 24, 2, -35 },
  { 437, 2, 13, 9, 3, -35 },
  { 441, 9, 43, 13, 2, -35 },
  { 490, 9, 43, 13, 2, -35 },
  { 539, 16, 15, 20, 2, -37 },
  { 569, 18, 23, 22, 2, -29 },
  { 621, 5, 11, 9, 2, -5 },
  { 628, 11, 2, 14, 1, -14 },
  { 631, 4, 4, 10, 3, -4 },
  { 633, 15, 35, 16, 1, -35 },
  { 699, 18, 35, 22, 2, -35 },
  { 778, 9, 35, 22, 4, -35 },
  { 818, 17, 35, 22, 2, -35 },
  { 893, 17, 35, 22, 2, -35 },
  { 968, 21, 35, 22, 1, -35 },
  { 1060, 17, 35, 22, 3, -35 },
  { 1135, 17, 36, 22, 3, -35 },
  { 1212, 18, 35, 22, 2, -35 },
  { 1291, 18, 35, 22, 2, -35 },
  { 1370, 17, 35, 22, 2, -35 },
  { 1445, 4, 26, 10, 3, -26 },
  { 1458, 5, 32, 10, 2, -26 },
  { 1478, 18, 21, 22, 2, -28 },
  { 1526, 18, 12, 22, 2, -23 },
  { 1553, 18, 21, 22, 2, -28 },
  { 1601, 13, 35, 16, 1, -35 },
  { 1658, 29, 40, 34, 3, -35 },
  { 1803, 22, 35, 22, 0, -35 },
  { 1900, 18, 35, 24, 4, -35 },
  { 1979, 19, 35, 24, 3, -35 },
  { 2063, 20, 35, 27, 4, -35 },
  { 2151, 15, 35, 21, 4, -35 },
  { 2217, 15, 35, 20, 4, -35 },
  { 2283, 23, 35, 29, 3, -35 },
  { 2384, 19, 35, 27, 4, -35 },
  { 2468, 8, 35, 12, 2, -35 },
  { 2503, 9, 44, 10, -3, -35 },
  { 2553, 18, 35, 22, 4, -35 },
  { 2632, 14, 35, 19, 4, -35 },
  { 2694, 27, 35, 35, 4, -35 },
  { 2813, 20, 35, 28, 4, -35 },
  { 2901, 23, 35, 29, 3, -35 },
  { 3002, 16, 35, 22, 4, -35 },
  { 3072, 23, 43, 29, 3, -35 },
  { 3196, 18, 35, 23, 4, -35 },
  { 3275, 17, 35, 22, 2, -35 },
  { 3350, 19, 35, 19, 0, -35 },
  { 3434, 20, 35, 27, 4, -35 },
  { 3522, 21, 35, 21, 0, -35 },
  { 3614, 34, 35, 36, 1, -35 },
  { 3763, 19, 35, 20, 0, -35 },
  { 3847, 19, 35, 19, 0, -35 },
  { 3931, 18, 35, 20, 1, -35 },
  { 4010, 10, 43, 15, 4, -35 },
  { 4064, 15, 35, 16, 1, -35 },
  { 4130, 9, 43, 15, 2, -35 },
  { 4179, 20, 18, 22, 1, -35 },
  { 4224, 20, 2, 20, 0, 4 },
  { 4229, 8, 7, 12, 2, -37 },
  { 4236, 15, 26, 21, 2, -26 },
  { 4285, 17, 37, 23, 4, -37 },
  { 4364, 15, 26, 18, 2, -26 },
  { 4413, 18, 37, 23, 2, -37 },
  { 4497, 17, 26, 21, 2, -26 },
  { 4553, 14, 37, 12, 0, -37 },
  { 4618, 18, 38, 23, 2, -26 },
  { 4704, 15, 37, 23, 4, -37 },
  { 4774, 3, 36, 10, 3, -36 },
  { 4788, 7, 48, 10, -1, -36 },
  { 4830, 14, 37, 19, 4, -37 },
  { 4895, 2, 37, 9, 4, -37 },
  { 4905, 27, 26, 34, 4, -26 },
  { 4993, 15, 26, 23, 4, -26 },
  { 5042, 18, 26, 23, 2, -26 },
  { 5101, 17, 37, 23, 4, -26 },
  { 5180, 18, 37, 23, 2, -26 },
  { 5264, 10, 26, 15, 4, -26 },
  { 5297, 14, 26, 18, 2, -26 },
  { 5343, 10, 32, 12, 1, -32 },
  { 5383, 15, 26, 23, 4, -26 },
  { 5432, 17, 26, 17, 0, -26 },
  { 5488, 27, 26, 29, 1, -26 },
  { 5576, 16, 26, 18, 1, -26 },
  { 5628, 18, 38, 18, 0, -26 },
  { 5714, 13, 26, 16, 2, -26 },
  { 5757, 13, 43, 17, 2, -35 },
  { 5827, 1, 49, 21, 10, -37 },
  { 5834, 13, 43, 17, 2, -35 },
  { 5904, 18, 5, 22, 2, -20 },
};

const GFXfont NotoSans_Condensed_ExtraLight49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight49pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT49PT7B_H_
