#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT71PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight71pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x01, 0xDF, 0xFF, 0xDC, 0x40, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0C, 0x00, 0x06, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0,
  0x0E, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x18, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00,
  0xC0, 0x0E, 0x00, 0x00, 0x60, 0x06, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x03, 0x00, 0x38, 0x00, 0x01, 0x80, 0x1C, 0x00,
  0x01, 0xC0, 0x0C, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0x70, 0x03, 0x00,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x80, 0x18,
  0x00, 0x01, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x07, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x18, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x60,
  0x07, 0x00, 0x00, 0x30, 0x03, 0x80, 0x00, 0x38, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x06, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x3C,
  0x60, 0xF8, 0x1C, 0x18, 0x06, 0x0E, 0x06, 0x00, 0x07, 0x01, 0x80, 0x01,
  0xC0, 0x60, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x01, 0x80,
  0x03, 0x80, 0x60, 0x00, 0xE0, 0x18, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x01,
  0x80, 0x03, 0x80, 0x60, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x03,
  0x81, 0x80, 0x00, 0xF0, 0x60, 0x00, 0x1F, 0x18, 0x00, 0x01, 0xE6, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xBF, 0x00, 0x00, 0x63, 0xE0, 0x00, 0x18, 0x3C, 0x00,
  0x06, 0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0x60, 0x0E, 0x00, 0x18, 0x03,
  0x80, 0x06, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x60, 0x07, 0x00, 0x18,
  0x01, 0xC0, 0x06, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x60, 0x0E, 0x00,
  0x18, 0x03, 0x80, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x72, 0x00, 0x60, 0x38,
  0xF0, 0x18, 0x3C, 0x3F, 0xC6, 0x7E, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0x00, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x00,
  0x38, 0x0C, 0x00, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x06,
  0x00, 0x18, 0x00, 0x70, 0x06, 0x00, 0x18, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x70, 0x00, 0x60,
  0x03, 0x00, 0x60, 0x00, 0x60, 0x03, 0x00, 0x60, 0x00, 0xE0, 0x03, 0x00,
  0xE0, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0x01, 0xC0, 0x00,
  0xE0, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x03,
  0x03, 0x80, 0x00, 0xE0, 0x03, 0x03, 0x00, 0x00, 0x60, 0x03, 0x07, 0x00,
  0x00, 0x60, 0x03, 0x06, 0x07, 0xE0, 0x60, 0x07, 0x06, 0x0F, 0xF0, 0x60,
  0x07, 0x0E, 0x1C, 0x38, 0x70, 0x07, 0x0C, 0x38, 0x1C, 0x70, 0x06, 0x1C,
  0x30, 0x0C, 0x30, 0x06, 0x18, 0x70, 0x0E, 0x38, 0x0E, 0x18, 0x70, 0x0E,
  0x38, 0x1C, 0x38, 0x60, 0x06, 0x1C, 0x3C, 0x30, 0x60, 0x06, 0x0F, 0xF8,
  0x70, 0xE0, 0x07, 0x07, 0xF0, 0x70, 0xE0, 0x07, 0x00, 0x00, 0x60, 0xE0,
  0x07, 0x00, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0x00, 0xC0, 0xE0, 0x07, 0x00,
  0x01, 0xC0, 0xC0, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x03, 0x00, 0x01, 0x80,
  0xC0, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x07,
  0x00, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x06,
  0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x1C, 0x00, 0x60, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x0E, 0x00,
  0x18, 0x00, 0x30, 0x0C, 0x00, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x00,
  0x1C, 0x18, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x00, 0x70, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x06, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1C, 0x07, 0x00,
  0x1C, 0x3C, 0x03, 0x80, 0x1C, 0x38, 0x03, 0x80, 0x1C, 0x70, 0x01, 0xC0,
  0x1C, 0x70, 0x00, 0xE0, 0x18, 0x60, 0x00, 0xE0, 0x18, 0xE0, 0x00, 0x70,
  0x38, 0xE0, 0x00, 0x38, 0x38, 0xE0, 0x00, 0x38, 0x30, 0xE0, 0x00, 0x1C,
  0x70, 0xE0, 0x00, 0x0E, 0x60, 0xE0, 0x00, 0x0F, 0xE0, 0xE0, 0x00, 0x07,
  0xE0, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x07, 0xE0, 0x70, 0x00, 0x0E, 0x70, 0x38, 0x00, 0x1C,
  0x70, 0x3C, 0x00, 0x78, 0x38, 0x1F, 0x00, 0xF0, 0x1C, 0x0F, 0xFF, 0xE0,
  0x1E, 0x03, 0xFF, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xB6, 0xDB, 0x00, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x20,
  0x0C, 0x02, 0x78, 0x18, 0x3D, 0xFE, 0x21, 0xFC, 0x3F, 0x5F, 0x80, 0x0F,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x63,
  0x00, 0x01, 0x83, 0x00, 0x07, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x70, 0x07,
  0x01, 0xE0, 0x0F, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x73,
  0x8E, 0x38, 0xE7, 0x1C, 0x71, 0x8E, 0x38, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF2, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xF0, 0x78, 0x01,
  0xE0, 0x1E, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x01, 0xC0, 0x60, 0x00, 0x70,
  0x70, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x67, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC0, 0xE0,
  0x01, 0xC0, 0x78, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x07, 0xC1, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x01,
  0xC0, 0x1E, 0x03, 0xF0, 0x3D, 0x83, 0xCC, 0x3C, 0x63, 0x83, 0x38, 0x1F,
  0x80, 0xF8, 0x06, 0x80, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0x0F, 0x03, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x0F, 0xC0, 0x7C, 0x0F, 0x00, 0x0F,
  0x0F, 0x00, 0x01, 0xC2, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x79, 0x80, 0x00, 0x78, 0xF8, 0x01, 0xF8, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x07, 0x18, 0x00, 0x00, 0x18, 0x60,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0xE0, 0x60, 0x00, 0x03, 0x01, 0x80, 0x00, 0x1C, 0x06, 0x00, 0x00,
  0x60, 0x18, 0x00, 0x03, 0x80, 0x60, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x70,
  0x06, 0x00, 0x03, 0x80, 0x18, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x70, 0x01,
  0x80, 0x01, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x01, 0x80, 0x0E, 0x00, 0x06, 0x00, 0x38, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0x60, 0x07, 0x00, 0x01, 0x80, 0x38, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x18, 0x07, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xF8, 0x07, 0xE0, 0x20, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE2, 0x00, 0x01, 0xE1, 0x80, 0x01,
  0xE0, 0xF8, 0x03, 0xE0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x03, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0xF8, 0x07, 0x0F, 0xFF, 0x03, 0x8F,
  0x87, 0xE1, 0xCE, 0x00, 0x70, 0xEC, 0x00, 0x1C, 0x6C, 0x00, 0x07, 0x36,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x03, 0x38, 0x00,
  0x03, 0x9C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x78, 0x07, 0x80, 0x78, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x1E, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC3, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80,
  0xE0, 0x01, 0xC0, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x0F, 0x3C, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x07,
  0x80, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07,
  0x9C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x0E,
  0x70, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x0F, 0x80, 0x7C, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xF0, 0x7C, 0x01,
  0xC0, 0x0F, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x30,
  0xE0, 0x00, 0x1C, 0x70, 0x00, 0x06, 0x38, 0x00, 0x03, 0x98, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x9C, 0x00, 0x07, 0xCF,
  0x00, 0x06, 0xE3, 0xC0, 0x07, 0x70, 0xF0, 0x0F, 0x38, 0x3F, 0xFF, 0x1C,
  0x0F, 0xFE, 0x0E, 0x00, 0x78, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x20, 0x07, 0x80, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF6,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x20, 0x1C, 0x78, 0xF9, 0xF3, 0xC3, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x0E, 0x1C, 0x38, 0x71,
  0xE3, 0x87, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x0E, 0x18, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xF0, 0xFC,
  0x0F, 0x86, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0xFF, 0xC0, 0x0C, 0x30, 0x00, 0x7F, 0xF8, 0x03, 0x9C, 0x00, 0x78,
  0x0E, 0x00, 0xE7, 0x00, 0x1C, 0x03, 0x80, 0x39, 0x80, 0x0E, 0x00, 0xE0,
  0x06, 0x60, 0x07, 0x00, 0x38, 0x01, 0xB8, 0x01, 0xC0, 0x0E, 0x00, 0x6E,
  0x00, 0xE0, 0x03, 0x80, 0x1B, 0x80, 0x38, 0x00, 0xE0, 0x07, 0xE0, 0x0C,
  0x00, 0x38, 0x01, 0xF0, 0x03, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0xC0, 0x03,
  0x80, 0x1F, 0x00, 0x70, 0x00, 0xE0, 0x07, 0xC0, 0x1C, 0x00, 0x30, 0x01,
  0xF0, 0x07, 0x00, 0x0C, 0x00, 0x7C, 0x01, 0xC0, 0x03, 0x00, 0x1B, 0x00,
  0x70, 0x00, 0xC0, 0x06, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xB0, 0x07, 0x00,
  0x1C, 0x00, 0x6C, 0x00, 0xC0, 0x07, 0x00, 0x3B, 0x00, 0x30, 0x01, 0xC0,
  0x0E, 0xE0, 0x0E, 0x00, 0xD0, 0x03, 0x38, 0x03, 0x80, 0x36, 0x01, 0xCE,
  0x00, 0x60, 0x1D, 0x80, 0x61, 0x80, 0x1C, 0x06, 0x70, 0x38, 0x60, 0x03,
  0xC7, 0x0E, 0x3C, 0x1C, 0x00, 0x7F, 0x81, 0xFE, 0x07, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x18,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x00, 0xC0, 0x03,
  0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00,
  0x0C, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0xF0, 0xE0, 0x00,
  0x1E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0,
  0x00, 0x07, 0x38, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E,
  0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x38, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x83,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0E, 0x00, 0x07,
  0xC3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x38,
  0x00, 0x03, 0xCE, 0x00, 0x01, 0xE3, 0x80, 0x01, 0xF0, 0xE0, 0x0F, 0xF8,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x02, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x01, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xC0, 0x03, 0xF0, 0x0E,
  0x00, 0x07, 0xC0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x1C, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x1C,
  0x00, 0x1F, 0x00, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xB8, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEE, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0x01, 0xE0, 0x1F,
  0x00, 0x00, 0x30, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x0E, 0x70,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xE8, 0x1E,
  0x7F, 0xE3, 0xFE, 0x03, 0x80, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0E,
  0x0E, 0x00, 0x07, 0x83, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x38, 0x00,
  0x78, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x3C, 0x00,
  0x38, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0x38, 0x70, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0x9F, 0x00, 0x00, 0xE7,
  0xE0, 0x00, 0x3B, 0xB8, 0x00, 0x0F, 0xC7, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0xF8, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x38,
  0x00, 0xE0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x03,
  0x80, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x03,
  0x83, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFD, 0x80, 0x00, 0x00, 0x03, 0x7B, 0x80, 0x00, 0x00, 0x0E, 0xFF, 0x00,
  0x00, 0x00, 0x1D, 0xF6, 0x00, 0x00, 0x00, 0x33, 0xEE, 0x00, 0x00, 0x00,
  0xE7, 0xDC, 0x00, 0x00, 0x01, 0xCF, 0x98, 0x00, 0x00, 0x03, 0x1F, 0x38,
  0x00, 0x00, 0x0E, 0x3E, 0x70, 0x00, 0x00, 0x1C, 0x7C, 0x60, 0x00, 0x00,
  0x30, 0xF8, 0xE0, 0x00, 0x00, 0xE1, 0xF1, 0xC0, 0x00, 0x01, 0xC3, 0xE1,
  0x80, 0x00, 0x03, 0x07, 0xC3, 0x80, 0x00, 0x0E, 0x0F, 0x87, 0x00, 0x00,
  0x1C, 0x1F, 0x06, 0x00, 0x00, 0x30, 0x3E, 0x0E, 0x00, 0x00, 0xE0, 0x7C,
  0x1C, 0x00, 0x01, 0xC0, 0xF8, 0x18, 0x00, 0x03, 0x01, 0xF0, 0x38, 0x00,
  0x0E, 0x03, 0xE0, 0x70, 0x00, 0x1C, 0x07, 0xC0, 0x60, 0x00, 0x30, 0x0F,
  0x80, 0xE0, 0x00, 0xE0, 0x1F, 0x01, 0xC0, 0x01, 0xC0, 0x3E, 0x01, 0x80,
  0x03, 0x00, 0x7C, 0x03, 0x80, 0x0E, 0x00, 0xF8, 0x07, 0x00, 0x1C, 0x01,
  0xF0, 0x06, 0x00, 0x38, 0x03, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0xC0, 0x1C,
  0x01, 0xC0, 0x0F, 0x80, 0x18, 0x03, 0x80, 0x1F, 0x00, 0x38, 0x06, 0x00,
  0x3E, 0x00, 0x70, 0x1C, 0x00, 0x7C, 0x00, 0x60, 0x38, 0x00, 0xF8, 0x00,
  0xE0, 0x60, 0x01, 0xF0, 0x01, 0xC1, 0xC0, 0x03, 0xE0, 0x01, 0x83, 0x80,
  0x07, 0xC0, 0x03, 0x86, 0x00, 0x0F, 0x80, 0x07, 0x1C, 0x00, 0x1F, 0x00,
  0x06, 0x38, 0x00, 0x3E, 0x00, 0x0E, 0x60, 0x00, 0x7C, 0x00, 0x1D, 0xC0,
  0x00, 0xF8, 0x00, 0x1B, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xE0,
  0x00, 0x18, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFD, 0xC0, 0x00, 0x07, 0xEE, 0x00, 0x00, 0x3F, 0x38,
  0x00, 0x01, 0xF9, 0xC0, 0x00, 0x0F, 0xC7, 0x00, 0x00, 0x7E, 0x38, 0x00,
  0x03, 0xF0, 0xE0, 0x00, 0x1F, 0x87, 0x00, 0x00, 0xFC, 0x1C, 0x00, 0x07,
  0xE0, 0xE0, 0x00, 0x3F, 0x03, 0x80, 0x01, 0xF8, 0x1C, 0x00, 0x0F, 0xC0,
  0x70, 0x00, 0x7E, 0x03, 0x80, 0x03, 0xF0, 0x0E, 0x00, 0x1F, 0x80, 0x70,
  0x00, 0xFC, 0x01, 0xC0, 0x07, 0xE0, 0x0E, 0x00, 0x3F, 0x00, 0x38, 0x01,
  0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x07, 0x00, 0x7E, 0x00, 0x38, 0x03, 0xF0,
  0x00, 0xE0, 0x1F, 0x80, 0x07, 0x00, 0xFC, 0x00, 0x1C, 0x07, 0xE0, 0x00,
  0xE0, 0x3F, 0x00, 0x03, 0x81, 0xF8, 0x00, 0x0C, 0x0F, 0xC0, 0x00, 0x70,
  0x7E, 0x00, 0x01, 0x83, 0xF0, 0x00, 0x0E, 0x1F, 0x80, 0x00, 0x30, 0xFC,
  0x00, 0x01, 0xC7, 0xE0, 0x00, 0x06, 0x3F, 0x00, 0x00, 0x39, 0xF8, 0x00,
  0x00, 0xEF, 0xC0, 0x00, 0x07, 0x7E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x00, 0x03, 0x1C, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x07, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0xF0,
  0xE0, 0x00, 0xF8, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0xF0, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x03, 0x80,
  0x0F, 0xC0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x38, 0x00,
  0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x38,
  0x03, 0x80, 0x0E, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01,
  0xC0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0x70, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3C, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xF8, 0x1F, 0xC1, 0xE0, 0x00, 0xC1,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x79, 0x80, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x3C, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x06, 0x1C, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x00, 0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0xE0, 0x0C, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x30, 0x06, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x07, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x39, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x36, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0D,
  0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xDC, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x73, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x38, 0x18, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0x8E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE1, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x38, 0x60, 0x00, 0x70, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x03,
  0x80, 0x03, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0xC0, 0x01, 0xC0,
  0x38, 0x00, 0x70, 0x30, 0x00, 0x60, 0x06, 0x00, 0x1C, 0x0E, 0x00, 0x38,
  0x01, 0x80, 0x06, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x06, 0x00,
  0x70, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x0E, 0x01, 0xC0, 0x0C, 0x01, 0x80, 0x03, 0x80, 0x70, 0x03,
  0x00, 0xE0, 0x00, 0x60, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x06, 0x00,
  0x38, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0xE0,
  0x01, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x60, 0x70, 0x00, 0x0C, 0x0C,
  0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0xC1, 0x80, 0x00, 0x38, 0x70, 0x00, 0x30, 0xE0, 0x00, 0x06,
  0x1C, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x73, 0x80, 0x00, 0xE3, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x19, 0xC0, 0x00,
  0x03, 0x38, 0x00, 0x06, 0x70, 0x00, 0x00, 0xCC, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x0D, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xE1,
  0x80, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x70,
  0x03, 0x80, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x0E, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xE0, 0x38,
  0x00, 0x07, 0x03, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E,
  0x03, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x0E,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x18, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C,
  0x70, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x18, 0x07, 0x00, 0x07, 0x00,
  0x70, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xC0, 0x03, 0x80, 0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x60, 0x38, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x86, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0C, 0xE0,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x03, 0x03, 0x80, 0x00, 0x38, 0x0C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x1C,
  0x01, 0x80, 0x00, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x07, 0x00, 0x06, 0x00, 0x30, 0x00, 0x38, 0x03, 0x80, 0x00, 0xC0,
  0x18, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x01, 0xFF, 0x00, 0x3F,
  0xFF, 0x01, 0xF8, 0x3E, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFD,
  0xC3, 0xF0, 0x07, 0x1E, 0x00, 0x1C, 0xF0, 0x00, 0x77, 0x80, 0x01, 0xDC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7D, 0xC0, 0x03, 0x77, 0x80, 0x1D, 0xCF, 0x00, 0xE7, 0x1F,
  0xFF, 0x1C, 0x3F, 0xF0, 0x30, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x7F, 0xC0, 0x38, 0x7F, 0xFC, 0x0E, 0x3E, 0x0F, 0x83, 0x9C, 0x00,
  0xF0, 0xEE, 0x00, 0x1C, 0x3B, 0x00, 0x03, 0x8F, 0x80, 0x00, 0x73, 0xE0,
  0x00, 0x1C, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0x3C, 0x00,
  0x01, 0xCF, 0x80, 0x00, 0x73, 0xE0, 0x00, 0x38, 0xEC, 0x00, 0x0E, 0x3B,
  0x00, 0x07, 0x0E, 0x70, 0x03, 0xC3, 0x8E, 0x03, 0xE0, 0xE1, 0xFF, 0xF0,
  0x30, 0x3F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFF,
  0x03, 0xF0, 0xF0, 0xF8, 0x01, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF8,
  0x03, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x7F, 0x81, 0xC0, 0x7F, 0xF8, 0x70, 0x3E, 0x0F, 0x1C, 0x1E,
  0x00, 0xE7, 0x0E, 0x00, 0x1D, 0xC7, 0x80, 0x03, 0x71, 0xC0, 0x00, 0x7C,
  0xE0, 0x00, 0x1F, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x7C, 0xE0, 0x00, 0x1F, 0x1C, 0x00, 0x0D,
  0xC7, 0x80, 0x03, 0x70, 0xF0, 0x01, 0x9C, 0x1E, 0x01, 0xC7, 0x03, 0xFF,
  0xE1, 0xC0, 0x7F, 0xF0, 0x30, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0x0F, 0x80, 0x78, 0x07, 0x81, 0xC0, 0x07, 0x87, 0x80,
  0x07, 0x0E, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0xE0, 0x00,
  0x1D, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x10, 0x3C, 0x01, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0x81, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F,
  0x81, 0xC0, 0x7F, 0xF8, 0x70, 0x3E, 0x0F, 0x1C, 0x1E, 0x00, 0xE7, 0x0E,
  0x00, 0x0D, 0xC7, 0x00, 0x03, 0x71, 0xC0, 0x00, 0x7C, 0xE0, 0x00, 0x1F,
  0x38, 0x00, 0x03, 0xCC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x07, 0x60, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xCC, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x7C, 0xE0, 0x00, 0x1F, 0x1C, 0x00, 0x0D, 0xC7, 0x80, 0x07,
  0x70, 0xF0, 0x03, 0x9C, 0x1E, 0x01, 0xC7, 0x03, 0xFF, 0xE1, 0xC0, 0x7F,
  0xF0, 0x70, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC2, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x3F,
  0x83, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x7F, 0x81, 0xC3, 0xFF,
  0xC3, 0x8F, 0x87, 0xC7, 0x38, 0x03, 0xCE, 0xE0, 0x03, 0xDD, 0x80, 0x03,
  0xBE, 0x00, 0x07, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xC0, 0x2F, 0xFF, 0xF6,
  0x00, 0x00, 0x00, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x01,
  0x00, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC9, 0xF3, 0xF8,
  0xFC, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x3B, 0x80, 0x01, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3,
  0x80, 0x0E, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0x80,
  0x70, 0x0E, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x03, 0x83, 0x80,
  0x0E, 0x0E, 0x00, 0x38, 0x70, 0x00, 0xE3, 0xE0, 0x03, 0x8F, 0x80, 0x0E,
  0x77, 0x00, 0x3B, 0x9C, 0x00, 0xEC, 0x38, 0x03, 0xE0, 0xE0, 0x0F, 0x01,
  0xC0, 0x3C, 0x07, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x70,
  0x38, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x38, 0x00,
  0x1C, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xFF, 0x00, 0x3F, 0xC1, 0x83, 0xFF, 0x80,
  0xFF, 0xE3, 0x8F, 0x0F, 0x07, 0x83, 0xE7, 0x30, 0x07, 0x0E, 0x01, 0xEE,
  0xC0, 0x07, 0x30, 0x01, 0xDD, 0x00, 0x0E, 0xE0, 0x03, 0xBE, 0x00, 0x0D,
  0x80, 0x03, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0x80, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x00,
  0xF8, 0x00, 0x06, 0x00, 0x01, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x00, 0x60, 0x00,
  0x1F, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0x00, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x01, 0xF0, 0x00, 0x0C, 0x00,
  0x03, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x80,
  0x00, 0x60, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x06, 0x00, 0x01, 0xF0,
  0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x30,
  0x00, 0x0F, 0x80, 0x00, 0x60, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0x80, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x7F,
  0xC1, 0x83, 0xFF, 0xC3, 0x8F, 0x07, 0xC7, 0x38, 0x03, 0xCE, 0xE0, 0x03,
  0xDD, 0x80, 0x03, 0xBE, 0x00, 0x07, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x1C, 0x00,
  0xF0, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x0E, 0x38, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x19,
  0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x03,
  0x80, 0x03, 0x80, 0xF0, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x7F, 0xC0, 0x30, 0x7F,
  0xFC, 0x0E, 0x3E, 0x0F, 0x83, 0x9C, 0x00, 0xF0, 0xE6, 0x00, 0x1C, 0x3B,
  0x00, 0x03, 0x8E, 0xC0, 0x00, 0x73, 0xE0, 0x00, 0x1C, 0xF8, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xE0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x06, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x0E, 0xF0, 0x00, 0x03, 0x3C, 0x00, 0x01, 0xCF, 0x80, 0x00, 0x73,
  0xE0, 0x00, 0x38, 0xEC, 0x00, 0x0E, 0x3B, 0x80, 0x07, 0x0E, 0x70, 0x03,
  0xC3, 0x8E, 0x01, 0xE0, 0xE1, 0xFF, 0xF0, 0x38, 0x3F, 0xF0, 0x0E, 0x01,
  0xE0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xC0, 0x7F, 0xF8,
  0x70, 0x3E, 0x0F, 0x1C, 0x1E, 0x00, 0xE7, 0x0E, 0x00, 0x1D, 0xC7, 0x80,
  0x03, 0x71, 0xC0, 0x00, 0x7C, 0xE0, 0x00, 0x1F, 0x38, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07,
  0x60, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x0F, 0x70, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x7C, 0xE0,
  0x00, 0x1F, 0x1C, 0x00, 0x0D, 0xC7, 0x80, 0x07, 0x70, 0xF0, 0x03, 0x9C,
  0x1E, 0x01, 0xC7, 0x03, 0xFF, 0xE1, 0xC0, 0x7F, 0xF0, 0x70, 0x01, 0xE0,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFE, 0xE7,
  0x80, 0xE6, 0x00, 0xEC, 0x00, 0xEC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0xFF, 0xFF, 0x1F, 0x03, 0xE3, 0x80, 0x06, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x80, 0x01,
  0xCF, 0x00, 0x7C, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x78, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xB8, 0x00, 0x1F, 0x70, 0x00, 0x2E, 0xF0, 0x00,
  0xDC, 0xE0, 0x03, 0x18, 0xF0, 0x1E, 0x31, 0xFF, 0xF0, 0x60, 0xFF, 0xC0,
  0xC0, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x9C, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x61, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x07,
  0x00, 0x07, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x80, 0x70, 0x01, 0xC0,
  0x38, 0x00, 0xE0, 0x1C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x18, 0x00, 0x60, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07,
  0x00, 0x0E, 0x03, 0x00, 0x03, 0x03, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x18, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00,
  0x06, 0xE0, 0x00, 0x3C, 0x00, 0x0E, 0x60, 0x00, 0x3C, 0x00, 0x0E, 0x60,
  0x00, 0x3C, 0x00, 0x0E, 0x70, 0x00, 0x7E, 0x00, 0x0C, 0x70, 0x00, 0x6E,
  0x00, 0x0C, 0x70, 0x00, 0x66, 0x00, 0x1C, 0x30, 0x00, 0x66, 0x00, 0x1C,
  0x38, 0x00, 0xE7, 0x00, 0x1C, 0x38, 0x00, 0xE7, 0x00, 0x18, 0x38, 0x00,
  0xC3, 0x00, 0x38, 0x18, 0x00, 0xC3, 0x00, 0x38, 0x1C, 0x01, 0xC3, 0x80,
  0x38, 0x1C, 0x01, 0xC3, 0x80, 0x30, 0x1C, 0x01, 0x81, 0x80, 0x30, 0x0C,
  0x01, 0x81, 0x80, 0x70, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x0E, 0x03, 0x81,
  0xC0, 0x60, 0x0E, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0xC0, 0xE0,
  0x07, 0x07, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0xE0, 0xC0, 0x07, 0x06,
  0x00, 0xE0, 0xC0, 0x03, 0x06, 0x00, 0x61, 0xC0, 0x03, 0x0E, 0x00, 0x71,
  0xC0, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x03, 0x8C, 0x00, 0x71, 0x80, 0x01,
  0x8C, 0x00, 0x31, 0x80, 0x01, 0x9C, 0x00, 0x33, 0x80, 0x01, 0xDC, 0x00,
  0x3B, 0x80, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x00, 0xD8, 0x00, 0x1B, 0x00,
  0x00, 0xD8, 0x00, 0x1B, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xC0, 0x01, 0xC1,
  0xC0, 0x01, 0xC3, 0x80, 0x00, 0xE3, 0x80, 0x00, 0x67, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x76, 0x00, 0x00, 0x77, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x80,
  0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00,
  0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xB8, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x63, 0x80, 0x00, 0x71, 0xC0,
  0x00, 0x38, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x06,
  0x00, 0x07, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0,
  0x30, 0x00, 0xE0, 0x1C, 0x00, 0x60, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x18, 0x00, 0xE0, 0x1C, 0x00, 0x30, 0x0E, 0x00, 0x18, 0x06,
  0x00, 0x0E, 0x03, 0x00, 0x07, 0x03, 0x80, 0x01, 0x81, 0xC0, 0x00, 0xE0,
  0xC0, 0x00, 0x70, 0xE0, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x07,
  0x38, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x0C, 0x78, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x01, 0xFC, 0x00,
  0xFF, 0x80, 0x3E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x0F, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x2F,
  0xFF, 0x00, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x07, 0xE1, 0xE8, 0x00, 0x3F,
  0xF9, 0x00, 0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLight71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 52, 15, 5, -51 },
  { 34, 13, 19, 23, 5, -51 },
  { 65, 33, 51, 35, 1, -51 },
  { 276, 26, 58, 32, 3, -54 },
  { 465, 40, 52, 46, 3, -51 },
  { 725, 32, 52, 35, 3, -51 },
  { 933, 3, 19, 12, 5, -51 },
  { 941, 13, 62, 19, 3, -51 },
  { 1042, 13, 62, 19, 3, -51 },
  { 1143, 23, 22, 29, 3, -54 },
  { 1207, 27, 32, 32, 3, -41 },
  { 1315, 6, 17, 13, 3, -8 },
  { 1328, 16, 3, 20, 2, -21 },
  { 1334, 4, 6, 14, 5, -5 },
  { 1337, 22, 51, 24, 1, -51 },
  { 1478, 25, 52, 32, 4, -51 },
  { 1641, 13, 51, 32, 6, -51 },
  { 1724, 25, 51, 32, 3, -51 },
  { 1884, 25, 52, 32, 3, -51 },
  { 2047, 30, 51, 32, 1, -51 },
  { 2239, 25, 52, 32, 4, -51 },
  { 2402, 25, 52, 32, 4, -51 },
  { 2565, 25, 51, 32, 3, -51 },
  { 2725, 26, 52, 32, 3, -51 },
  { 2894, 25, 52, 32, 3, -51 },
  { 3057, 4, 39, 14, 5, -38 },
  { 3077, 7, 47, 14, 3, -38 },
  { 3119, 27, 31, 32, 3, -41 },
  { 3224, 27, 18, 32, 3, -34 },
  { 3285, 27, 31, 32, 3, -41 },
  { 3390, 20, 52, 23, 1, -51 },
  { 3520, 42, 58, 49, 4, -51 },
  { 3825, 32, 51, 32, 0, -51 },
  { 4029, 26, 51, 35, 6, -51 },
  { 4195, 28, 52, 34, 4, -51 },
  { 4377, 29, 51, 39, 6, -51 },
  { 4562, 21, 51, 31, 6, -51 },
  { 4696, 21, 51, 28, 6, -51 },
  { 4830, 33, 52, 41, 4, -51 },
  { 5045, 28, 51, 40, 6, -51 },
  { 5224, 12, 51, 18, 3, -51 },
  { 5301, 13, 64, 15, -4, -51 },
  { 5405, 26, 51, 32, 6, -51 },
  { 5571, 21, 51, 28, 6, -51 },
  { 5705, 39, 51, 51, 6, -51 },
  { 5954, 29, 51, 41, 6, -51 },
  { 6139, 34, 52, 42, 4, -51 },
  { 6360, 24, 51, 32, 6, -51 },
  { 6513, 34, 63, 42, 4, -51 },
  { 6781, 26, 51, 33, 6, -51 },
  { 6947, 25, 52, 31, 3, -51 },
  { 7110, 28, 51, 28, 0, -51 },
  { 7289, 28, 52, 40, 6, -51 },
  { 7471, 31, 51, 31, 0, -51 },
  { 7669, 50, 51, 52, 1, -51 },
  { 7988, 28, 51, 28, 0, -51 },
  { 8167, 27, 51, 27, 0, -51 },
  { 8340, 25, 51, 29, 2, -51 },
  { 8500, 14, 62, 22, 6, -51 },
  { 8609, 22, 51, 24, 1, -51 },
  { 8750, 14, 62, 22, 2, -51 },
  { 8859, 29, 27, 32, 2, -51 },
  { 8957, 29, 3, 28, 0, 6 },
  { 8968, 11, 11, 17, 3, -54 },
  { 8984, 22, 39, 30, 3, -38 },
  { 9092, 26, 55, 34, 5, -54 },
  { 9271, 20, 39, 26, 4, -38 },
  { 9369, 26, 55, 34, 3, -54 },
  { 9548, 23, 39, 31, 4, -38 },
  { 9661, 19, 54, 17, 1, -54 },
  { 9790, 26, 55, 34, 3, -38 },
  { 9969, 23, 54, 33, 5, -54 },
  { 10125, 4, 52, 14, 5, -52 },
  { 10151, 10, 69, 14, -1, -52 },
  { 10238, 22, 54, 27, 5, -54 },
  { 10387, 3, 54, 13, 5, -54 },
  { 10408, 39, 38, 49, 5, -38 },
  { 10594, 23, 38, 33, 5, -38 },
  { 10704, 26, 39, 33, 3, -38 },
  { 10831, 26, 55, 34, 5, -38 },
  { 11010, 26, 55, 34, 3, -38 },
  { 11189, 16, 38, 22, 5, -38 },
  { 11265, 20, 39, 26, 3, -38 },
  { 11363, 16, 48, 18, 1, -47 },
  { 11459, 23, 39, 33, 5, -38 },
  { 11572, 25, 38, 25, 0, -38 },
  { 11691, 40, 38, 41, 1, -38 },
  { 11881, 24, 38, 27, 1, -38 },
  { 11995, 25, 55, 26, 0, -38 },
  { 12167, 19, 38, 23, 2, -38 },
  { 12258, 19, 62, 25, 3, -51 },
  { 12406, 2, 71, 31, 14, -54 },
  { 12424, 19, 62, 25, 3, -51 },
  { 12572, 27, 6, 32, 3, -28 },
};

const GFXfont NotoSans_Condensed_ExtraLight71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight71pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT71PT7B_H_
