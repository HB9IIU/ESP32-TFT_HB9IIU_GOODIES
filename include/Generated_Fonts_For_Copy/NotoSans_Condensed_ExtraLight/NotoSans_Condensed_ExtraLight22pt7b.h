#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT22PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0x8C, 0x63, 0x18, 0xC4, 0x08, 0x82, 0x20, 0x88, 0x24,
  0x11, 0x1F, 0xF1, 0x10, 0x44, 0x11, 0x04, 0x4F, 0xFC, 0x48, 0x22, 0x08,
  0x82, 0x20, 0x88, 0x10, 0x10, 0x7E, 0x90, 0x90, 0x90, 0x90, 0x50, 0x30,
  0x1C, 0x12, 0x11, 0x11, 0x11, 0x12, 0xDE, 0x30, 0x10, 0x70, 0x48, 0x88,
  0x88, 0x88, 0x88, 0x89, 0x08, 0x90, 0x8A, 0x68, 0xA9, 0x4A, 0x97, 0x51,
  0x05, 0x10, 0x91, 0x09, 0x10, 0x91, 0x10, 0x91, 0x0E, 0x38, 0x11, 0x04,
  0x41, 0x10, 0x44, 0x09, 0x02, 0x80, 0x40, 0x70, 0x12, 0x28, 0x4A, 0x0A,
  0x83, 0x20, 0x48, 0x29, 0xF3, 0xFC, 0x12, 0x24, 0x44, 0x88, 0x88, 0x88,
  0x88, 0x44, 0x42, 0x30, 0x84, 0x42, 0x22, 0x11, 0x11, 0x11, 0x11, 0x22,
  0x24, 0x80, 0x10, 0x22, 0x4B, 0xE1, 0x05, 0x11, 0x00, 0x08, 0x08, 0x08,
  0x08, 0x08, 0xFF, 0x08, 0x08, 0x08, 0x08, 0x5A, 0x80, 0xF8, 0xC0, 0x02,
  0x04, 0x10, 0x20, 0x41, 0x02, 0x08, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10,
  0x60, 0x3C, 0x42, 0x42, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x42, 0x42, 0x3C, 0x13, 0x59, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x78, 0x86, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x08, 0x08,
  0x10, 0x20, 0x40, 0x40, 0xFF, 0x7C, 0x82, 0x02, 0x02, 0x02, 0x02, 0x06,
  0x38, 0x04, 0x02, 0x01, 0x01, 0x01, 0x02, 0x02, 0xFC, 0x03, 0x00, 0xC0,
  0x50, 0x14, 0x09, 0x02, 0x41, 0x10, 0x84, 0x21, 0x10, 0x44, 0x13, 0xFF,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x7E, 0x40, 0x40, 0x40, 0x40, 0x40, 0x90,
  0x6C, 0x02, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0xFC, 0x1E, 0x20, 0x40,
  0x40, 0x40, 0x80, 0x9C, 0xA2, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42,
  0x3C, 0xFF, 0x01, 0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08,
  0x10, 0x10, 0x10, 0x20, 0x20, 0x3C, 0x42, 0x82, 0x81, 0x81, 0x42, 0x24,
  0x18, 0x24, 0x42, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x38, 0x46, 0x82,
  0x82, 0x81, 0x81, 0x81, 0x83, 0x43, 0x3D, 0x01, 0x02, 0x02, 0x02, 0x04,
  0x78, 0xC0, 0x30, 0x50, 0x00, 0x05, 0xA8, 0x01, 0x03, 0x0C, 0x30, 0xC0,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x03, 0x0C, 0x10, 0x60, 0x80, 0x7A, 0x10, 0x41, 0x04,
  0x10, 0x42, 0x10, 0x82, 0x08, 0x00, 0x02, 0x08, 0x07, 0x80, 0xC3, 0x08,
  0x04, 0x40, 0x24, 0x00, 0xA3, 0xC6, 0x22, 0x31, 0x11, 0x88, 0x8C, 0x44,
  0x62, 0x23, 0x11, 0x18, 0x95, 0x23, 0x11, 0x00, 0x04, 0x00, 0x30, 0x40,
  0x7C, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x48, 0x12, 0x04, 0x81, 0x20, 0x84,
  0x21, 0x0F, 0xC4, 0x11, 0x02, 0x40, 0x90, 0x28, 0x06, 0x01, 0xF8, 0x86,
  0x82, 0x81, 0x81, 0x82, 0x82, 0xFC, 0x86, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x82, 0xFC, 0x0F, 0x18, 0x48, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x08, 0x04, 0x02, 0x00, 0x80, 0x3F, 0xF8, 0x43, 0x20, 0xD0,
  0x28, 0x14, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x28, 0x14, 0x0A,
  0x09, 0xF8, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x3F, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFE, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x0F, 0x84, 0x12, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00,
  0x83, 0xE0, 0x18, 0x05, 0x01, 0x40, 0x50, 0x12, 0x04, 0x7F, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xF4, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0x4F, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x2E, 0x83, 0x82, 0x84, 0x88,
  0x88, 0x90, 0xA0, 0xA0, 0xD0, 0x90, 0x88, 0x88, 0x84, 0x84, 0x82, 0x81,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F,
  0x80, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xA0, 0x5A, 0x05, 0xA0, 0x59, 0x09,
  0x90, 0x99, 0x09, 0x89, 0x18, 0x91, 0x89, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x80, 0xC0, 0x70, 0x38, 0x1A, 0x0D, 0x06, 0x43, 0x11, 0x88, 0xC2, 0x61,
  0x30, 0x58, 0x2C, 0x0E, 0x07, 0x01, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x24,
  0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xA0, 0x14, 0x04,
  0x80, 0x88, 0x20, 0xF8, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x9D,
  0xC2, 0x04, 0x08, 0x10, 0x20, 0x40, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x24,
  0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xA0, 0x14, 0x04,
  0x80, 0x88, 0x20, 0xF8, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0xF8, 0x84,
  0x82, 0x82, 0x82, 0x82, 0x82, 0x84, 0xF8, 0x88, 0x88, 0x84, 0x84, 0x82,
  0x82, 0x81, 0x3E, 0x41, 0x80, 0x80, 0x80, 0x80, 0x40, 0x30, 0x0C, 0x02,
  0x01, 0x01, 0x01, 0x02, 0x02, 0xFC, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x09, 0x04, 0x7C, 0x80, 0x60, 0x24, 0x09, 0x02, 0x40,
  0x90, 0x42, 0x10, 0x84, 0x22, 0x08, 0x81, 0x20, 0x48, 0x14, 0x03, 0x00,
  0xC0, 0x20, 0x81, 0x01, 0x81, 0x81, 0x41, 0x82, 0x41, 0x82, 0x41, 0x82,
  0x42, 0x42, 0x22, 0x44, 0x22, 0x44, 0x22, 0x44, 0x24, 0x24, 0x14, 0x28,
  0x14, 0x28, 0x14, 0x28, 0x14, 0x28, 0x08, 0x10, 0x08, 0x10, 0x41, 0xA0,
  0x88, 0x44, 0x42, 0x20, 0xA0, 0x50, 0x10, 0x08, 0x0A, 0x05, 0x04, 0x42,
  0x22, 0x09, 0x05, 0x03, 0x81, 0xC0, 0x90, 0x48, 0x42, 0x21, 0x10, 0x90,
  0x28, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0xFE, 0x04,
  0x10, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x7F,
  0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x80, 0x81,
  0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40, 0x40, 0x80, 0x81,
  0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x08, 0x18,
  0x14, 0x24, 0x22, 0x42, 0x41, 0x81, 0x81, 0xFF, 0x80, 0x88, 0x90, 0x38,
  0x88, 0x08, 0x10, 0x23, 0xD8, 0xC1, 0x83, 0x0E, 0x1B, 0xD0, 0x81, 0x02,
  0x04, 0x08, 0x17, 0x31, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0xFC, 0x1E, 0xC1, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x81, 0x01, 0xE0,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x3D, 0x43, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x43, 0x3D, 0x3C, 0x85, 0x0C, 0x18, 0x3F, 0xE0, 0x40,
  0x80, 0x81, 0x01, 0xF0, 0x1C, 0x82, 0x08, 0x23, 0xE2, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x3D, 0x43, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x02, 0x7C, 0x81, 0x02,
  0x04, 0x08, 0x17, 0x31, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x82, 0xD0, 0x55, 0x55, 0x55, 0x64, 0x02, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x9C, 0x82, 0x08, 0x20, 0x82, 0x18, 0xA4, 0x92, 0x8E, 0x24, 0x92, 0x28,
  0xA1, 0x84, 0xFF, 0xFF, 0x80, 0xB9, 0xCC, 0x62, 0x86, 0x18, 0x41, 0x84,
  0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0x84, 0x18, 0x41, 0xB9,
  0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x3C, 0x42,
  0x41, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0xB9, 0x8A,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0x0D, 0xE8, 0x10, 0x20, 0x40,
  0x80, 0x3D, 0x43, 0x43, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x43,
  0x3D, 0x01, 0x01, 0x01, 0x01, 0x01, 0xBC, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x7A, 0x18, 0x20, 0x81, 0x81, 0x81, 0x04, 0x10, 0x7E, 0x21, 0x3E, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x1C, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x0E, 0x1B, 0xD0, 0x81, 0x82, 0x42, 0x42, 0x42, 0x44, 0x24,
  0x24, 0x28, 0x18, 0x18, 0x10, 0x82, 0x0C, 0x10, 0x91, 0x44, 0x8A, 0x24,
  0x51, 0x22, 0x90, 0xA2, 0x85, 0x14, 0x28, 0xA1, 0x45, 0x04, 0x10, 0x20,
  0x80, 0x41, 0x42, 0x22, 0x24, 0x14, 0x18, 0x18, 0x18, 0x24, 0x22, 0x42,
  0xC1, 0x81, 0x41, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x14, 0x18, 0x18,
  0x08, 0x10, 0x10, 0x10, 0x20, 0xE0, 0xF8, 0x20, 0x84, 0x10, 0x82, 0x10,
  0x41, 0x08, 0x3F, 0x0C, 0x42, 0x08, 0x20, 0x82, 0x08, 0x23, 0x06, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x81, 0xC0, 0xFF, 0xFF, 0xFC, 0xC0, 0x82, 0x08,
  0x10, 0x41, 0x04, 0x10, 0x71, 0x04, 0x10, 0x41, 0x04, 0x20, 0x8E, 0x00,
  0x71, 0x8F,
};

const GFXglyph NotoSans_Condensed_ExtraLight22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 16, 5, 2, -16 },
  { 3, 5, 6, 7, 1, -16 },
  { 7, 10, 16, 11, 0, -16 },
  { 27, 8, 18, 10, 1, -17 },
  { 45, 12, 16, 14, 1, -16 },
  { 69, 10, 16, 11, 1, -16 },
  { 89, 1, 6, 4, 1, -16 },
  { 90, 4, 19, 6, 1, -16 },
  { 100, 4, 19, 6, 1, -16 },
  { 110, 7, 7, 9, 1, -17 },
  { 117, 8, 10, 10, 1, -13 },
  { 127, 2, 5, 4, 1, -2 },
  { 129, 5, 1, 6, 1, -6 },
  { 130, 1, 2, 4, 2, -2 },
  { 131, 7, 16, 7, 0, -16 },
  { 145, 8, 16, 10, 1, -16 },
  { 161, 4, 16, 10, 2, -16 },
  { 169, 8, 16, 10, 1, -16 },
  { 185, 8, 16, 10, 1, -16 },
  { 201, 10, 16, 10, 0, -16 },
  { 221, 8, 16, 10, 1, -16 },
  { 237, 8, 16, 10, 1, -16 },
  { 253, 8, 16, 10, 1, -16 },
  { 269, 8, 16, 10, 1, -16 },
  { 285, 8, 16, 10, 1, -16 },
  { 301, 1, 12, 4, 2, -12 },
  { 303, 2, 15, 4, 1, -12 },
  { 307, 8, 10, 10, 1, -13 },
  { 317, 8, 5, 10, 1, -10 },
  { 322, 8, 10, 10, 1, -13 },
  { 332, 6, 16, 7, 0, -16 },
  { 344, 13, 18, 15, 1, -16 },
  { 374, 10, 16, 10, 0, -16 },
  { 394, 8, 16, 11, 2, -16 },
  { 410, 9, 16, 11, 1, -16 },
  { 428, 9, 16, 12, 2, -16 },
  { 446, 6, 16, 10, 2, -16 },
  { 458, 6, 16, 9, 2, -16 },
  { 470, 10, 16, 13, 1, -16 },
  { 490, 8, 16, 12, 2, -16 },
  { 506, 4, 16, 6, 1, -16 },
  { 514, 4, 20, 5, -1, -16 },
  { 524, 8, 16, 10, 2, -16 },
  { 540, 6, 16, 9, 2, -16 },
  { 552, 12, 16, 16, 2, -16 },
  { 576, 9, 16, 13, 2, -16 },
  { 594, 11, 16, 13, 1, -16 },
  { 616, 7, 16, 10, 2, -16 },
  { 630, 11, 20, 13, 1, -16 },
  { 658, 8, 16, 10, 2, -16 },
  { 674, 8, 16, 10, 1, -16 },
  { 690, 9, 16, 9, 0, -16 },
  { 708, 9, 16, 12, 2, -16 },
  { 726, 10, 16, 10, 0, -16 },
  { 746, 16, 16, 16, 0, -16 },
  { 778, 9, 16, 9, 0, -16 },
  { 796, 9, 16, 9, 0, -16 },
  { 814, 7, 16, 9, 1, -16 },
  { 828, 4, 19, 7, 2, -16 },
  { 838, 7, 16, 7, 0, -16 },
  { 852, 4, 19, 7, 1, -16 },
  { 862, 8, 9, 10, 1, -16 },
  { 871, 9, 1, 9, 0, 2 },
  { 873, 3, 4, 5, 1, -17 },
  { 875, 7, 12, 9, 1, -12 },
  { 886, 7, 17, 11, 2, -17 },
  { 901, 7, 12, 8, 1, -12 },
  { 912, 8, 17, 11, 1, -17 },
  { 929, 7, 12, 10, 1, -12 },
  { 940, 6, 17, 5, 0, -17 },
  { 953, 8, 17, 11, 1, -12 },
  { 970, 7, 17, 10, 2, -17 },
  { 985, 2, 16, 4, 1, -16 },
  { 989, 3, 21, 4, 0, -16 },
  { 997, 6, 17, 8, 2, -17 },
  { 1010, 1, 17, 4, 2, -17 },
  { 1013, 12, 12, 15, 2, -12 },
  { 1031, 7, 12, 10, 2, -12 },
  { 1042, 8, 12, 10, 1, -12 },
  { 1054, 7, 17, 11, 2, -12 },
  { 1069, 8, 17, 11, 1, -12 },
  { 1086, 4, 12, 7, 2, -12 },
  { 1092, 6, 12, 8, 1, -12 },
  { 1101, 5, 14, 6, 0, -14 },
  { 1110, 7, 12, 10, 2, -12 },
  { 1121, 8, 12, 8, 0, -12 },
  { 1133, 13, 12, 13, 0, -12 },
  { 1153, 8, 12, 8, 0, -12 },
  { 1165, 8, 17, 8, 0, -12 },
  { 1182, 6, 12, 7, 1, -12 },
  { 1191, 6, 19, 8, 1, -16 },
  { 1206, 1, 22, 9, 4, -17 },
  { 1209, 6, 19, 8, 1, -16 },
  { 1224, 8, 2, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_ExtraLight22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight22pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT22PT7B_H_
