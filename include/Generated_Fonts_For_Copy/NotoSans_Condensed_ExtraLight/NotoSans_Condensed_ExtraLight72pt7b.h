#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT72PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight72pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x01, 0xDF, 0xFF, 0xDE, 0x40, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x18, 0x01, 0xC0,
  0x00, 0x18, 0x01, 0xC0, 0x00, 0x38, 0x01, 0x80, 0x00, 0x38, 0x01, 0x80,
  0x00, 0x38, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80,
  0x00, 0x30, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x70, 0x03, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x60, 0x07, 0x00,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xE0, 0x06, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0x80, 0x0C, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x01, 0x80, 0x1C, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x18, 0x00, 0x03, 0x80, 0x18, 0x00,
  0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x38, 0x00, 0x07, 0x00, 0x38, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0x31, 0xFC, 0x1E, 0x0C, 0x0E, 0x0F, 0x03, 0x00,
  0x83, 0x80, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x03,
  0x00, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0x38,
  0x03, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x00, 0x60, 0x0C, 0x00,
  0x1C, 0x03, 0x00, 0x07, 0x80, 0xC0, 0x00, 0xF0, 0x30, 0x00, 0x1E, 0x0C,
  0x00, 0x03, 0xC3, 0x00, 0x00, 0x7C, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x37, 0xE0,
  0x00, 0x0C, 0x7C, 0x00, 0x03, 0x07, 0x80, 0x00, 0xC0, 0xF0, 0x00, 0x30,
  0x1E, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x1C, 0x00,
  0x30, 0x07, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x00, 0xC0, 0x1C,
  0x00, 0x30, 0x07, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x00, 0xC0,
  0x38, 0x00, 0x30, 0x1C, 0x80, 0x0C, 0x0F, 0x3C, 0x03, 0x0F, 0x8F, 0xF8,
  0xDF, 0x80, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0x80, 0x07, 0x8F, 0x00, 0x01, 0x80, 0x03, 0x81, 0x80, 0x01, 0xC0,
  0x03, 0x80, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00,
  0x38, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x0C, 0x00, 0x60, 0x0E, 0x00, 0x06, 0x00, 0x38, 0x06, 0x00, 0x07, 0x00,
  0x1C, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0x07, 0x01,
  0x80, 0x00, 0xE0, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x01, 0xC0, 0xC0, 0x00,
  0x18, 0x00, 0xE0, 0xE0, 0x00, 0x0C, 0x00, 0x70, 0x60, 0x00, 0x06, 0x00,
  0x30, 0x30, 0x18, 0x03, 0x00, 0x18, 0x38, 0x3F, 0x81, 0x80, 0x0C, 0x18,
  0x3F, 0xE0, 0xC0, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0x07, 0x0C, 0x18, 0x0E,
  0x18, 0x03, 0x86, 0x1C, 0x07, 0x0C, 0x01, 0x87, 0x0C, 0x01, 0x87, 0x01,
  0xC3, 0x0E, 0x00, 0xE1, 0xC1, 0xC3, 0x87, 0x00, 0x70, 0xF1, 0xE1, 0xC3,
  0x00, 0x18, 0x3F, 0xE0, 0xC1, 0x80, 0x0C, 0x07, 0xC0, 0xE0, 0xC0, 0x06,
  0x00, 0x00, 0x60, 0x60, 0x03, 0x00, 0x00, 0x70, 0x30, 0x01, 0xC0, 0x00,
  0x38, 0x18, 0x00, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x70, 0x00, 0x1C, 0x0E,
  0x00, 0x38, 0x00, 0x0C, 0x07, 0x00, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x0E,
  0x00, 0x07, 0x00, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x60, 0x03, 0x00, 0x03,
  0x80, 0x30, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0x60, 0x03, 0x80, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x00, 0x70, 0x1C, 0x00, 0x38,
  0x00, 0x18, 0x0E, 0x00, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0C, 0x00, 0x03,
  0xFE, 0x00, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xE3, 0xE0, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x06, 0x00, 0x38, 0x00, 0x06, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x30, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x0C,
  0x38, 0x03, 0x80, 0x0C, 0x38, 0x01, 0xC0, 0x0C, 0x70, 0x01, 0xC0, 0x1C,
  0x70, 0x00, 0xE0, 0x1C, 0xE0, 0x00, 0x70, 0x1C, 0xE0, 0x00, 0x78, 0x18,
  0xE0, 0x00, 0x38, 0x38, 0xE0, 0x00, 0x1C, 0x38, 0xE0, 0x00, 0x0E, 0x30,
  0xE0, 0x00, 0x0E, 0x70, 0xE0, 0x00, 0x07, 0x60, 0xE0, 0x00, 0x03, 0xE0,
  0xE0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x03, 0xE0,
  0x70, 0x00, 0x07, 0xF0, 0x70, 0x00, 0x0E, 0x70, 0x38, 0x00, 0x1E, 0x38,
  0x1C, 0x00, 0x3C, 0x1C, 0x1F, 0x00, 0xF8, 0x1C, 0x0F, 0xFF, 0xE0, 0x0E,
  0x03, 0xFF, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xD8, 0x00, 0x3C, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xF0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x18, 0x0F, 0xFC,
  0x30, 0xFC, 0xFE, 0x6F, 0xE0, 0x1F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1B, 0x80, 0x00, 0x73, 0x00, 0x01, 0xC3, 0x00, 0x03, 0x07,
  0x00, 0x0E, 0x07, 0x00, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x03, 0xC0, 0x0E,
  0x01, 0x00, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x3C, 0x70, 0xE1,
  0xC3, 0x8E, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xBF, 0xFF, 0x10, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xF9, 0xF8, 0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x01,
  0xC0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x18, 0x00,
  0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x70,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x39, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x07, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x70,
  0x0F, 0x00, 0x70, 0x03, 0xE0, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x77, 0x03,
  0x9C, 0x3C, 0x71, 0xE1, 0xCF, 0x07, 0x78, 0x1F, 0xC0, 0x74, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x01, 0xFE, 0x7F, 0x01, 0xF8, 0x01, 0xE0, 0x38,
  0x00, 0x3C, 0x08, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0xF9, 0xFC, 0x0F, 0x80, 0x0F, 0x0F,
  0x00, 0x03, 0xC3, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x3C, 0x7E, 0x00, 0x7C, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0x8E, 0x00,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x1F, 0xC0,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xF0, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE2, 0x00, 0x00, 0xE1, 0x80, 0x01,
  0xF0, 0xF8, 0x03, 0xF0, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x07, 0x07, 0xFF, 0x03, 0x8F,
  0xFF, 0xC1, 0xCF, 0x00, 0xF0, 0xEE, 0x00, 0x3C, 0x76, 0x00, 0x07, 0x3E,
  0x00, 0x03, 0x9F, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x77, 0x80, 0x00, 0x1B,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xC6, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x3C, 0x03,
  0xC0, 0x3C, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x3C, 0x00, 0xF0, 0x0E,
  0x00, 0x0E, 0x07, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E,
  0x38, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x0E, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0,
  0x00, 0x0E, 0x38, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0xE0,
  0x3C, 0x00, 0x70, 0x07, 0x80, 0x38, 0x00, 0xF0, 0x3C, 0x00, 0x1F, 0x1E,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x0F, 0x01,
  0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x9C, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x3D, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x70, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x1C, 0x1E, 0x00,
  0x1E, 0x03, 0xE0, 0x0F, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0x7F,
  0x00, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x98,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x07,
  0xCE, 0x00, 0x01, 0x63, 0x80, 0x00, 0xD8, 0x70, 0x00, 0x66, 0x1E, 0x00,
  0x39, 0x83, 0xE0, 0x7C, 0x60, 0x7F, 0xFC, 0x38, 0x07, 0xFE, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x08, 0x01, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF7, 0xBF, 0xEF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xBD, 0xFF, 0x78, 0x80, 0x1C, 0x7C, 0xF9,
  0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x0F, 0x1C, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x0E,
  0x1C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0x83,
  0xF9, 0xFC, 0x70, 0x07, 0xC8, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0xFE, 0x00, 0x38, 0xE0, 0x00, 0xFF, 0xE0,
  0x0E, 0x30, 0x00, 0xFC, 0x78, 0x01, 0x9C, 0x00, 0x78, 0x06, 0x00, 0x67,
  0x00, 0x3C, 0x01, 0x80, 0x1D, 0x80, 0x0E, 0x00, 0x60, 0x07, 0x60, 0x07,
  0x00, 0x18, 0x01, 0xF8, 0x01, 0xC0, 0x06, 0x00, 0x3E, 0x00, 0x60, 0x01,
  0x80, 0x0F, 0x80, 0x38, 0x00, 0x60, 0x03, 0xE0, 0x0E, 0x00, 0x38, 0x00,
  0xF8, 0x03, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0xC0, 0x0C, 0x00, 0x38, 0x00, 0xF0, 0x03, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x30, 0x00, 0xE0,
  0x07, 0xC0, 0x0C, 0x00, 0x38, 0x01, 0xF0, 0x03, 0x00, 0x0E, 0x00, 0x7E,
  0x00, 0xC0, 0x07, 0x80, 0x1B, 0x80, 0x38, 0x01, 0xE0, 0x06, 0xE0, 0x0E,
  0x00, 0x78, 0x03, 0xB8, 0x01, 0x80, 0x36, 0x00, 0xCE, 0x00, 0x70, 0x0D,
  0xC0, 0x71, 0x80, 0x1E, 0x06, 0x30, 0x38, 0x60, 0x03, 0xE7, 0x8F, 0xBE,
  0x1C, 0x00, 0x7F, 0xC1, 0xFF, 0x07, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0x00, 0x00, 0x07, 0xE0, 0x03,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x0C,
  0x38, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x18,
  0x1C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x30,
  0x0E, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x70, 0x06, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0,
  0x03, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0xC0, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x80,
  0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x38, 0x0C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x0C, 0x38, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x0E, 0x00, 0x1F, 0xC3, 0x80, 0x00, 0xF8, 0xE0, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00,
  0x03, 0xB8, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x38, 0xE0,
  0x00, 0x1E, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x1F, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x7E, 0x0E, 0x00, 0x03, 0xE3, 0x80, 0x00,
  0x3C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xCE,
  0x00, 0x01, 0xE3, 0x80, 0x01, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xF1, 0xFE, 0x01, 0xF0, 0x00, 0xE0, 0x1F, 0x00, 0x01, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x10, 0x03, 0xF0, 0x07, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x38, 0x00, 0xFE, 0x01, 0xC0, 0x00, 0xF8, 0x0E, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0D,
  0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF8, 0x1C, 0x00, 0x1F, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x03, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0x07, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0x07,
  0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x30, 0xFF, 0xF7, 0xFE, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE8, 0x1E, 0x7F, 0xF3, 0xFE,
  0x0F, 0xC0, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07,
  0x83, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x78, 0x0E, 0x00,
  0x1C, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x0E,
  0x00, 0xE0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x0E, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0x70,
  0x00, 0x0E, 0x3C, 0x00, 0x03, 0x9F, 0x80, 0x00, 0xE7, 0xE0, 0x00, 0x3B,
  0x9C, 0x00, 0x0F, 0xC7, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0xF8, 0x3C, 0x00,
  0x3C, 0x07, 0x00, 0x0E, 0x01, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x0F, 0x00, 0xE0,
  0x01, 0xC0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0,
  0xE0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x1C, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x37, 0xEC, 0x00, 0x00, 0x00,
  0x77, 0xEE, 0x00, 0x00, 0x00, 0x77, 0xEE, 0x00, 0x00, 0x00, 0x67, 0xE6,
  0x00, 0x00, 0x00, 0xE7, 0xE7, 0x00, 0x00, 0x00, 0xE7, 0xE7, 0x00, 0x00,
  0x00, 0xC7, 0xE3, 0x00, 0x00, 0x01, 0xC7, 0xE3, 0x80, 0x00, 0x01, 0xC7,
  0xE3, 0x80, 0x00, 0x01, 0xC7, 0xE1, 0x80, 0x00, 0x03, 0x87, 0xE1, 0xC0,
  0x00, 0x03, 0x87, 0xE1, 0xC0, 0x00, 0x03, 0x87, 0xE0, 0xC0, 0x00, 0x07,
  0x07, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0xE0,
  0x60, 0x00, 0x0E, 0x07, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0xE0, 0x70, 0x00,
  0x0E, 0x07, 0xE0, 0x30, 0x00, 0x1C, 0x07, 0xE0, 0x38, 0x00, 0x1C, 0x07,
  0xE0, 0x38, 0x00, 0x1C, 0x07, 0xE0, 0x18, 0x00, 0x18, 0x07, 0xE0, 0x1C,
  0x00, 0x38, 0x07, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0xE0, 0x0C, 0x00, 0x30,
  0x07, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0xE0,
  0x06, 0x00, 0x60, 0x07, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00,
  0xE0, 0x07, 0xE0, 0x03, 0x00, 0xC0, 0x07, 0xE0, 0x03, 0x81, 0xC0, 0x07,
  0xE0, 0x03, 0x81, 0xC0, 0x07, 0xE0, 0x01, 0x81, 0x80, 0x07, 0xE0, 0x01,
  0xC3, 0x80, 0x07, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0xE0, 0x00, 0xC3, 0x00,
  0x07, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0xE0,
  0x00, 0x66, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xB8, 0x00, 0x00, 0x7D, 0xC0, 0x00, 0x03, 0xE7, 0x00,
  0x00, 0x1F, 0x38, 0x00, 0x00, 0xF8, 0xE0, 0x00, 0x07, 0xC7, 0x00, 0x00,
  0x3E, 0x1C, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x0F, 0x83, 0x80, 0x00, 0x7C,
  0x1C, 0x00, 0x03, 0xE0, 0x70, 0x00, 0x1F, 0x03, 0x80, 0x00, 0xF8, 0x0E,
  0x00, 0x07, 0xC0, 0x70, 0x00, 0x3E, 0x01, 0xC0, 0x01, 0xF0, 0x0E, 0x00,
  0x0F, 0x80, 0x38, 0x00, 0x7C, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0x00, 0x1F,
  0x00, 0x38, 0x00, 0xF8, 0x00, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x3E, 0x00,
  0x1C, 0x01, 0xF0, 0x00, 0xE0, 0x0F, 0x80, 0x03, 0x80, 0x7C, 0x00, 0x1C,
  0x03, 0xE0, 0x00, 0x70, 0x1F, 0x00, 0x03, 0x80, 0xF8, 0x00, 0x0E, 0x07,
  0xC0, 0x00, 0x70, 0x3E, 0x00, 0x01, 0xC1, 0xF0, 0x00, 0x0E, 0x0F, 0x80,
  0x00, 0x38, 0x7C, 0x00, 0x00, 0xC3, 0xE0, 0x00, 0x07, 0x1F, 0x00, 0x00,
  0x18, 0xF8, 0x00, 0x00, 0xE7, 0xC0, 0x00, 0x03, 0xBE, 0x00, 0x00, 0x1D,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xE0, 0x07, 0xF0, 0xE0,
  0x00, 0xF8, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0xE0, 0x07, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0E, 0x00, 0x7F,
  0x03, 0x80, 0x03, 0xE0, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x63, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0xF0,
  0x38, 0x03, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xE0, 0x0E,
  0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00,
  0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01,
  0xC0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x1C, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0x7F, 0xE1, 0xF0,
  0x00, 0xE1, 0xE0, 0x00, 0x10, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x3C, 0x7C, 0x00,
  0xFC, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x60,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0C, 0x70,
  0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xE0, 0x06,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0xC0, 0x07,
  0x00, 0x01, 0xC0, 0x03, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01,
  0xC0, 0x03, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0x60, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x39, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x18, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x1D, 0x80, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x07, 0x00, 0x00, 0x67, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x71, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C,
  0x07, 0x00, 0x03, 0x87, 0x00, 0x03, 0x80, 0x60, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0x81, 0x80,
  0x03, 0x80, 0x38, 0x00, 0x30, 0x38, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x0E, 0x00, 0x60, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x38, 0x01, 0xC0, 0x03, 0x00, 0x38, 0x07, 0x00, 0x38, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x07, 0x00, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x01,
  0xC0, 0x18, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x38, 0x07, 0x00,
  0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x60, 0x38,
  0x00, 0x0E, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x01, 0xC0,
  0xE0, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x03,
  0x03, 0x00, 0x00, 0x70, 0x60, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x0C, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x70,
  0x00, 0x38, 0x60, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0xCE, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x03, 0xB0, 0x00, 0x03, 0x70, 0x00, 0x00, 0x76, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x0E,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x70, 0x03, 0x80, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x70,
  0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x1C, 0xC0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00,
  0x0E, 0x01, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x70,
  0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38,
  0x0C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x70,
  0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x03, 0x80, 0x1C,
  0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xC0, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x06, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x38,
  0x0E, 0x00, 0x01, 0x80, 0x38, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00,
  0x30, 0x00, 0x18, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x1C, 0x1C, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0,
  0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFE, 0x07,
  0x80, 0x3C, 0x08, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0x07, 0x0F, 0x80,
  0x1C, 0x78, 0x00, 0x73, 0x80, 0x01, 0xDE, 0x00, 0x07, 0x70, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x2F, 0x80, 0x01,
  0xB7, 0x00, 0x0C, 0xDE, 0x00, 0x73, 0x3C, 0x03, 0x8C, 0x7F, 0xFC, 0x30,
  0xFF, 0xE0, 0xC0, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x1F, 0x80,
  0x38, 0x3F, 0xF8, 0x0E, 0x1F, 0xFF, 0x83, 0x8E, 0x01, 0xF0, 0xE7, 0x00,
  0x1E, 0x3B, 0x80, 0x03, 0x8E, 0xC0, 0x00, 0x73, 0xE0, 0x00, 0x1C, 0xF8,
  0x00, 0x03, 0x3C, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E,
  0xF0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x06, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x3B, 0xE0, 0x00, 0x1C, 0xF8, 0x00, 0x07, 0x3B, 0x00, 0x03, 0x8E,
  0xE0, 0x01, 0xE3, 0x9C, 0x00, 0xF0, 0xE3, 0x80, 0x78, 0x38, 0x7F, 0xFC,
  0x0E, 0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0x80, 0x60, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x03, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x7E, 0x03, 0x80, 0xFF, 0xC1,
  0xC1, 0xFF, 0xF8, 0xE1, 0xF0, 0x1E, 0x71, 0xE0, 0x03, 0xB8, 0xE0, 0x00,
  0xDC, 0xE0, 0x00, 0x36, 0x70, 0x00, 0x1B, 0x70, 0x00, 0x07, 0xB8, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x70, 0x00,
  0x0D, 0x9C, 0x00, 0x06, 0xCF, 0x00, 0x06, 0x63, 0xC0, 0x07, 0x30, 0xF0,
  0x0F, 0x18, 0x3F, 0xFF, 0x0C, 0x07, 0xFE, 0x06, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0x80, 0xF0, 0x0E,
  0x00, 0x78, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x0C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x06, 0x07,
  0x80, 0x3E, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xE7, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0xE0, 0xC1, 0xFF, 0xF8, 0x61, 0xF0, 0x0E, 0x31, 0xE0,
  0x03, 0x98, 0xE0, 0x00, 0xCC, 0xE0, 0x00, 0x36, 0x70, 0x00, 0x0F, 0x70,
  0x00, 0x07, 0xB8, 0x00, 0x03, 0xD8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x1E, 0xE0,
  0x00, 0x0F, 0x70, 0x00, 0x0F, 0x9C, 0x00, 0x05, 0xC7, 0x00, 0x06, 0xE3,
  0xC0, 0x06, 0x70, 0xF0, 0x0E, 0x38, 0x3F, 0xFE, 0x1C, 0x07, 0xFE, 0x0E,
  0x00, 0x78, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x88, 0x00, 0x03, 0x87, 0x00, 0x07, 0xC3, 0xF0, 0x0F, 0xC0, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x1F, 0x01, 0xC1, 0xFF, 0xC3, 0x87, 0xFF, 0xC7,
  0x1C, 0x03, 0xCE, 0x70, 0x03, 0xDD, 0xC0, 0x03, 0xBB, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC8, 0xF3, 0xF8, 0xFC,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x01, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xC3, 0x80,
  0x07, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x38,
  0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x81, 0xC0, 0x0E,
  0x0E, 0x00, 0x38, 0x38, 0x00, 0xE1, 0xE0, 0x03, 0x8F, 0x80, 0x0E, 0x37,
  0x00, 0x39, 0xDC, 0x00, 0xEE, 0x38, 0x03, 0xF0, 0xE0, 0x0F, 0x81, 0xC0,
  0x3C, 0x07, 0x00, 0xF0, 0x0E, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x70, 0x38,
  0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x00,
  0x70, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x38, 0x00, 0x1C,
  0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xE0,
  0xFF, 0x80, 0x3F, 0xF0, 0xE3, 0xFF, 0xC0, 0xFF, 0xF8, 0xE7, 0x81, 0xE1,
  0xE0, 0x3C, 0xE6, 0x00, 0x71, 0x80, 0x1C, 0xEC, 0x00, 0x73, 0x00, 0x0E,
  0xE8, 0x00, 0x3B, 0x00, 0x0E, 0xF8, 0x00, 0x3E, 0x00, 0x06, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x1F, 0x01,
  0xC1, 0xFF, 0xC3, 0x87, 0xFF, 0xC7, 0x1C, 0x03, 0xCE, 0x70, 0x03, 0xDD,
  0xC0, 0x03, 0xBB, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x3E, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x83, 0x80, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03,
  0x98, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x07, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0x80, 0x38, 0x3F, 0xF8, 0x0E, 0x1F, 0xFF, 0x83, 0x8F, 0x01,
  0xF0, 0xE7, 0x00, 0x1C, 0x39, 0x80, 0x03, 0x8E, 0xC0, 0x00, 0x73, 0xA0,
  0x00, 0x1C, 0xF8, 0x00, 0x03, 0xBE, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xBC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x06, 0xF0, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0xEF, 0x80, 0x00, 0x3B, 0xE0, 0x00, 0x1C, 0xF8, 0x00, 0x07, 0x3B,
  0x00, 0x03, 0x8E, 0xE0, 0x01, 0xE3, 0x9C, 0x00, 0xF0, 0xE3, 0xC0, 0x78,
  0x38, 0x7F, 0xFC, 0x0E, 0x0F, 0xFE, 0x03, 0x80, 0x7C, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF8, 0x30, 0x3F, 0xFF, 0x0C,
  0x1F, 0x01, 0xE3, 0x0F, 0x00, 0x1C, 0xC3, 0x80, 0x03, 0x31, 0xC0, 0x00,
  0x6C, 0x70, 0x00, 0x1B, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x3D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x3C, 0x00,
  0x07, 0xC7, 0x00, 0x03, 0x71, 0xE0, 0x00, 0xDC, 0x3C, 0x00, 0x67, 0x07,
  0xC0, 0x71, 0xC0, 0xFF, 0xF8, 0x70, 0x0F, 0xFC, 0x1C, 0x00, 0x78, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x3C, 0xE0, 0xFF, 0xE1, 0xFF, 0xE3, 0xC1,
  0xE7, 0x00, 0xE6, 0x00, 0xEC, 0x00, 0xEC, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0xF3, 0xE0, 0x0E, 0x38, 0x00, 0x27, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0xEC, 0x00, 0x1E, 0xF0, 0x07, 0xCF, 0xFF, 0xF8, 0x3F, 0xFE, 0x00,
  0x3F, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x81, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x78, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xD8, 0x00, 0x07, 0xB8, 0x00, 0x1B, 0x70, 0x00,
  0x36, 0x70, 0x00, 0xCC, 0xF0, 0x03, 0x98, 0xF0, 0x1E, 0x30, 0xFF, 0xF8,
  0x60, 0xFF, 0xC0, 0xC0, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xB0, 0x00,
  0x01, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x30, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x0E,
  0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x01, 0x80,
  0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x0E,
  0x00, 0x1C, 0x07, 0x00, 0x06, 0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0xC1,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x0E,
  0x38, 0x00, 0x03, 0x18, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x60, 0x00, 0x3E,
  0x00, 0x06, 0x70, 0x00, 0x3E, 0x00, 0x0E, 0x70, 0x00, 0x76, 0x00, 0x0E,
  0x70, 0x00, 0x76, 0x00, 0x0E, 0x30, 0x00, 0x67, 0x00, 0x0C, 0x38, 0x00,
  0x67, 0x00, 0x0C, 0x38, 0x00, 0xE3, 0x00, 0x1C, 0x38, 0x00, 0xE3, 0x00,
  0x1C, 0x18, 0x00, 0xE3, 0x80, 0x18, 0x1C, 0x00, 0xC3, 0x80, 0x18, 0x1C,
  0x01, 0xC3, 0x80, 0x38, 0x1C, 0x01, 0xC1, 0x80, 0x38, 0x0C, 0x01, 0xC1,
  0xC0, 0x38, 0x0C, 0x01, 0x81, 0xC0, 0x30, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x0E, 0x03, 0x80, 0xC0, 0x70, 0x06, 0x03, 0x80, 0xE0, 0x70, 0x06, 0x03,
  0x00, 0xE0, 0x60, 0x07, 0x07, 0x00, 0xE0, 0x60, 0x07, 0x07, 0x00, 0x60,
  0xE0, 0x03, 0x07, 0x00, 0x60, 0xE0, 0x03, 0x06, 0x00, 0x70, 0xC0, 0x03,
  0x8E, 0x00, 0x70, 0xC0, 0x03, 0x8E, 0x00, 0x31, 0xC0, 0x03, 0x8E, 0x00,
  0x31, 0xC0, 0x01, 0x8C, 0x00, 0x39, 0x80, 0x01, 0xCC, 0x00, 0x39, 0x80,
  0x01, 0xDC, 0x00, 0x1B, 0x80, 0x01, 0xDC, 0x00, 0x1B, 0x80, 0x00, 0xD8,
  0x00, 0x1B, 0x80, 0x00, 0xD8, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x18,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x70, 0x00,
  0x70, 0x30, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xDC, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE1, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x60, 0x30, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x06, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x70, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0xE0, 0x38, 0x00, 0x30, 0x06, 0x00, 0x1C, 0x01, 0xC0, 0x07,
  0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0,
  0x0E, 0x00, 0x38, 0x03, 0x00, 0x06, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00,
  0x70, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0x38, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x0C, 0xE0, 0x00, 0x03, 0x38, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x87, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0,
  0x03, 0xFC, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x05, 0xFF, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00,
  0x7F, 0xFD, 0x00, 0x03, 0xFF, 0x20, 0x00, 0x1F, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraLight72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 52, 15, 5, -51 },
  { 34, 13, 18, 23, 5, -51 },
  { 64, 32, 51, 36, 2, -51 },
  { 268, 26, 59, 33, 3, -55 },
  { 460, 41, 53, 47, 3, -52 },
  { 732, 32, 53, 36, 3, -52 },
  { 944, 3, 18, 13, 5, -51 },
  { 951, 14, 62, 19, 3, -51 },
  { 1060, 13, 62, 19, 3, -51 },
  { 1161, 23, 23, 30, 3, -55 },
  { 1228, 27, 33, 33, 3, -42 },
  { 1340, 7, 17, 14, 3, -8 },
  { 1355, 16, 3, 20, 2, -21 },
  { 1361, 5, 6, 14, 5, -5 },
  { 1365, 22, 51, 24, 1, -51 },
  { 1506, 25, 53, 33, 4, -52 },
  { 1672, 14, 51, 33, 6, -51 },
  { 1762, 26, 52, 33, 3, -52 },
  { 1931, 25, 53, 33, 3, -52 },
  { 2097, 31, 52, 33, 1, -52 },
  { 2299, 25, 52, 33, 4, -51 },
  { 2462, 25, 53, 33, 4, -52 },
  { 2628, 26, 51, 33, 3, -51 },
  { 2794, 26, 53, 33, 3, -52 },
  { 2967, 26, 53, 33, 3, -52 },
  { 3140, 5, 39, 15, 5, -38 },
  { 3165, 7, 47, 14, 3, -38 },
  { 3207, 27, 31, 33, 3, -41 },
  { 3312, 27, 17, 33, 3, -34 },
  { 3370, 27, 31, 33, 3, -41 },
  { 3475, 19, 53, 23, 2, -52 },
  { 3601, 42, 58, 50, 4, -51 },
  { 3906, 32, 51, 32, 0, -51 },
  { 4110, 26, 51, 36, 6, -51 },
  { 4276, 29, 53, 35, 4, -52 },
  { 4469, 29, 51, 39, 6, -51 },
  { 4654, 22, 51, 31, 6, -51 },
  { 4795, 22, 51, 29, 6, -51 },
  { 4936, 34, 53, 42, 4, -52 },
  { 5162, 28, 51, 40, 6, -51 },
  { 5341, 12, 51, 18, 3, -51 },
  { 5418, 13, 64, 15, -4, -51 },
  { 5522, 26, 51, 32, 6, -51 },
  { 5688, 21, 51, 29, 6, -51 },
  { 5822, 40, 51, 52, 6, -51 },
  { 6077, 29, 51, 41, 6, -51 },
  { 6262, 35, 53, 43, 4, -52 },
  { 6494, 24, 51, 33, 6, -51 },
  { 6647, 35, 64, 43, 4, -52 },
  { 6927, 26, 51, 34, 6, -51 },
  { 7093, 25, 53, 32, 3, -52 },
  { 7259, 28, 51, 29, 0, -51 },
  { 7438, 29, 52, 40, 6, -51 },
  { 7627, 32, 51, 32, 0, -51 },
  { 7831, 51, 51, 52, 1, -51 },
  { 8157, 28, 51, 29, 0, -51 },
  { 8336, 28, 51, 28, 0, -51 },
  { 8515, 25, 51, 29, 2, -51 },
  { 8675, 14, 62, 22, 6, -51 },
  { 8784, 22, 51, 24, 1, -51 },
  { 8925, 14, 62, 22, 2, -51 },
  { 9034, 29, 27, 33, 2, -51 },
  { 9132, 29, 3, 29, 0, 6 },
  { 9143, 11, 11, 17, 3, -55 },
  { 9159, 22, 40, 30, 3, -39 },
  { 9269, 26, 56, 34, 5, -55 },
  { 9451, 21, 40, 26, 4, -39 },
  { 9556, 25, 56, 34, 4, -55 },
  { 9731, 24, 40, 31, 4, -39 },
  { 9851, 19, 55, 17, 1, -55 },
  { 9982, 25, 56, 34, 4, -39 },
  { 10157, 23, 55, 34, 5, -55 },
  { 10316, 4, 52, 14, 5, -52 },
  { 10342, 10, 69, 14, -1, -52 },
  { 10429, 22, 55, 27, 5, -55 },
  { 10581, 3, 55, 14, 5, -55 },
  { 10602, 40, 39, 50, 5, -39 },
  { 10797, 23, 39, 34, 5, -39 },
  { 10910, 26, 40, 33, 4, -39 },
  { 11040, 26, 56, 34, 5, -39 },
  { 11222, 26, 56, 34, 3, -39 },
  { 11404, 16, 39, 22, 5, -39 },
  { 11482, 20, 40, 26, 3, -39 },
  { 11582, 16, 48, 18, 1, -47 },
  { 11678, 23, 39, 34, 5, -38 },
  { 11791, 25, 38, 25, 0, -38 },
  { 11910, 40, 38, 42, 1, -38 },
  { 12100, 25, 38, 27, 1, -38 },
  { 12219, 26, 55, 26, 0, -38 },
  { 12398, 19, 38, 23, 2, -38 },
  { 12489, 19, 62, 25, 3, -51 },
  { 12637, 3, 73, 31, 14, -55 },
  { 12665, 19, 62, 25, 3, -51 },
  { 12813, 27, 7, 33, 3, -29 },
};

const GFXfont NotoSans_Condensed_ExtraLight72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight72pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT72PT7B_H_
