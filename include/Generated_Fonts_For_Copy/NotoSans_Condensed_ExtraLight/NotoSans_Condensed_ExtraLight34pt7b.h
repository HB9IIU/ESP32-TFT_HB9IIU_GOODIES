#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT34PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight34pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xA0, 0x0F, 0xC7, 0x8F, 0x1E, 0x3C, 0x58,
  0xB1, 0x62, 0x84, 0x06, 0x18, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80, 0x41,
  0x00, 0x82, 0x01, 0x04, 0x3F, 0xFF, 0x08, 0x20, 0x10, 0x40, 0x20, 0x80,
  0x41, 0x00, 0x82, 0x01, 0x04, 0x06, 0x18, 0x7F, 0xFE, 0x10, 0x40, 0x20,
  0x80, 0x41, 0x00, 0x82, 0x01, 0x04, 0x02, 0x18, 0x08, 0x20, 0x10, 0x40,
  0x02, 0x00, 0x10, 0x03, 0xE0, 0x75, 0xE6, 0x21, 0x21, 0x01, 0x08, 0x18,
  0x40, 0xC2, 0x02, 0x10, 0x10, 0x80, 0x64, 0x01, 0xA0, 0x03, 0x00, 0x0E,
  0x00, 0x4C, 0x02, 0x30, 0x10, 0x80, 0x86, 0x04, 0x30, 0x21, 0x81, 0x08,
  0x08, 0xDC, 0x4C, 0x3F, 0x80, 0x10, 0x00, 0x80, 0x04, 0x00, 0x10, 0x02,
  0x0D, 0x80, 0x83, 0x10, 0x10, 0x41, 0x04, 0x08, 0x20, 0x81, 0x04, 0x30,
  0x20, 0x84, 0x04, 0x10, 0x80, 0x82, 0x20, 0x10, 0x44, 0x02, 0x09, 0x9C,
  0x41, 0x26, 0x48, 0x24, 0x84, 0x89, 0x30, 0x9B, 0x24, 0x10, 0x8C, 0x83,
  0x01, 0x10, 0x60, 0x22, 0x0C, 0x08, 0x41, 0x81, 0x08, 0x30, 0x61, 0x04,
  0x08, 0x20, 0x81, 0x02, 0x10, 0x40, 0x46, 0x08, 0x07, 0x80, 0x06, 0x00,
  0x0F, 0x80, 0x10, 0xC0, 0x10, 0x40, 0x30, 0x40, 0x30, 0x40, 0x10, 0x40,
  0x10, 0x40, 0x10, 0xC0, 0x08, 0x80, 0x09, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x13, 0x00, 0x21, 0x02, 0x61, 0x86, 0x40, 0xC4, 0xC0, 0x44, 0xC0, 0x24,
  0xC0, 0x38, 0xC0, 0x18, 0x40, 0x18, 0x60, 0x2C, 0x30, 0xC6, 0x1F, 0x83,
  0xFF, 0xFF, 0x40, 0x0C, 0x61, 0x08, 0x21, 0x84, 0x10, 0xC2, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xC1, 0x04, 0x18, 0x20, 0x81, 0x06,
  0x0C, 0xC1, 0x82, 0x04, 0x10, 0x60, 0x83, 0x0C, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x0C, 0x30, 0x86, 0x18, 0x43, 0x08, 0xC0, 0x0C,
  0x03, 0x00, 0x80, 0x20, 0xE9, 0xCF, 0xC0, 0xC0, 0x48, 0x33, 0x08, 0x44,
  0x08, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x1F, 0xFF, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x32, 0x26, 0x64, 0x4C, 0xFF, 0xF8, 0x00, 0xC0, 0x20,
  0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x30,
  0x08, 0x02, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10,
  0x0C, 0x02, 0x00, 0x04, 0x01, 0xF8, 0x20, 0xC6, 0x04, 0x40, 0x6C, 0x02,
  0xC0, 0x28, 0x02, 0x80, 0x28, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x28, 0x02, 0x80, 0x2C, 0x02, 0x40, 0x64, 0x04,
  0x60, 0x43, 0x08, 0x1F, 0x00, 0x0C, 0x73, 0x59, 0x84, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x06,
  0x01, 0xFE, 0x18, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00,
  0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0x80,
  0x08, 0x00, 0xFF, 0xF8, 0x06, 0x03, 0xFC, 0xE0, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x18, 0x1F, 0x00,
  0x0C, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x2C, 0x06, 0x7F, 0x80, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x58, 0x03, 0x60, 0x09, 0x80, 0x66, 0x01, 0x18, 0x0C, 0x60, 0x21, 0x81,
  0x06, 0x04, 0x18, 0x20, 0x61, 0x81, 0x84, 0x06, 0x30, 0x18, 0x80, 0x63,
  0xFF, 0xF0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x7F, 0xC4, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x0C, 0x40, 0xFF, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x81, 0x8F, 0xF0,
  0x01, 0x00, 0xFE, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x08, 0x00, 0x8F, 0x0B, 0x1C, 0xA0, 0x6C, 0x02, 0xC0, 0x28, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x24, 0x02, 0x60, 0x63, 0x0C,
  0x1F, 0x80, 0xFF, 0xF0, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10,
  0x03, 0x00, 0x03, 0x00, 0xFE, 0x0C, 0x08, 0x40, 0x66, 0x01, 0x20, 0x09,
  0x00, 0x4C, 0x02, 0x20, 0x31, 0x81, 0x06, 0x30, 0x1F, 0x00, 0x70, 0x0C,
  0x60, 0xC1, 0x8C, 0x06, 0x40, 0x12, 0x00, 0xF0, 0x03, 0x80, 0x14, 0x01,
  0xA0, 0x09, 0x80, 0xC6, 0x0C, 0x1F, 0xC0, 0x03, 0x01, 0xFC, 0x30, 0x66,
  0x02, 0x40, 0x34, 0x01, 0x40, 0x1C, 0x01, 0xC0, 0x14, 0x01, 0x40, 0x14,
  0x01, 0x60, 0x32, 0x05, 0x1D, 0xD0, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x3F, 0x00, 0xDD, 0x00, 0x00,
  0x00, 0x00, 0x02, 0xF8, 0x27, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x32,
  0x26, 0x64, 0x4C, 0x00, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x04, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x60, 0x00, 0x10, 0x7F, 0x20, 0xC0, 0x30, 0x18, 0x04, 0x02, 0x03, 0x01,
  0x80, 0x80, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x03, 0xFC, 0x00, 0x60, 0x30,
  0x08, 0x01, 0x81, 0x00, 0x0C, 0x20, 0x00, 0x46, 0x00, 0x06, 0x40, 0x00,
  0x24, 0x0F, 0xC2, 0xC1, 0x04, 0x38, 0x30, 0xC1, 0x82, 0x0C, 0x18, 0x20,
  0xC1, 0x86, 0x0C, 0x18, 0x60, 0xC1, 0x86, 0x08, 0x18, 0x60, 0x83, 0x82,
  0x08, 0x28, 0x21, 0x42, 0x83, 0x14, 0x6C, 0x1E, 0x3C, 0x40, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x40,
  0x03, 0xF8, 0x00, 0x01, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x16, 0x00, 0x24,
  0x00, 0xC8, 0x01, 0x10, 0x02, 0x30, 0x0C, 0x20, 0x10, 0x40, 0x20, 0xC0,
  0x40, 0x81, 0x81, 0x02, 0x02, 0x07, 0xFE, 0x18, 0x04, 0x20, 0x08, 0x40,
  0x18, 0x80, 0x33, 0x00, 0x24, 0x00, 0x48, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xFF, 0x88, 0x0E, 0x80, 0x28, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x28, 0x06, 0x83, 0xCF, 0xF8, 0x80, 0x68, 0x02, 0x80, 0x38, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x06, 0x80, 0xCF, 0xF8,
  0x00, 0xC0, 0x3F, 0xC6, 0x02, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x81, 0x07, 0xF8, 0xFF, 0x82, 0x03, 0x08, 0x06, 0x20, 0x0C,
  0x80, 0x12, 0x00, 0x68, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x02, 0x80, 0x0A, 0x00,
  0x28, 0x01, 0xA0, 0x04, 0x80, 0x32, 0x01, 0x88, 0x1C, 0x3F, 0xC0, 0xFF,
  0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x03, 0xFF, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x03, 0xFF, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xE0, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x00,
  0x60, 0x07, 0xFE, 0x0C, 0x02, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x7F, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40,
  0x03, 0x40, 0x03, 0x60, 0x03, 0x30, 0x03, 0x18, 0x03, 0x0C, 0x03, 0x07,
  0xFE, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0xF8, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x3F, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x43, 0x9B, 0xC0, 0x80, 0x38, 0x06,
  0x80, 0xC8, 0x08, 0x81, 0x88, 0x30, 0x82, 0x08, 0x40, 0x8C, 0x09, 0x80,
  0x98, 0x0A, 0x80, 0xEC, 0x0C, 0x40, 0x86, 0x08, 0x20, 0x83, 0x08, 0x18,
  0x80, 0x88, 0x0C, 0x80, 0x48, 0x06, 0x80, 0x28, 0x03, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xD0, 0x00,
  0xFA, 0x00, 0x17, 0x60, 0x02, 0xE4, 0x00, 0xDC, 0x80, 0x13, 0x98, 0x02,
  0x71, 0x00, 0xCE, 0x20, 0x11, 0xC6, 0x02, 0x38, 0x40, 0xC7, 0x08, 0x10,
  0xE1, 0x82, 0x1C, 0x10, 0xC3, 0x82, 0x10, 0x70, 0x62, 0x0E, 0x04, 0xC1,
  0xC0, 0x90, 0x38, 0x1A, 0x07, 0x01, 0x40, 0xE0, 0x30, 0x1C, 0x06, 0x03,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xE8, 0x03, 0xB0, 0x0E, 0x40, 0x39, 0x80,
  0xE2, 0x03, 0x8C, 0x0E, 0x10, 0x38, 0x60, 0xE0, 0x83, 0x83, 0x0E, 0x04,
  0x38, 0x18, 0xE0, 0x23, 0x80, 0xCE, 0x01, 0x38, 0x06, 0xE0, 0x0B, 0x80,
  0x3E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x01, 0xC0, 0x0F, 0xF0, 0x18, 0x18,
  0x30, 0x0C, 0x60, 0x06, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x02, 0x60, 0x02,
  0x20, 0x04, 0x30, 0x0C, 0x18, 0x18, 0x0F, 0xF0, 0xFF, 0x10, 0x3A, 0x01,
  0x40, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x40,
  0x68, 0x79, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x01, 0xC0, 0x0F, 0xF0, 0x18, 0x18, 0x30,
  0x0C, 0x60, 0x06, 0x40, 0x02, 0x40, 0x02, 0xC0, 0x03, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x02, 0x60, 0x02, 0x20,
  0x04, 0x30, 0x0C, 0x18, 0x18, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0xFF, 0x08, 0x1C, 0x80, 0x48,
  0x06, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x06, 0x80, 0x48,
  0x18, 0xFF, 0x08, 0x20, 0x82, 0x08, 0x30, 0x81, 0x08, 0x18, 0x80, 0x88,
  0x0C, 0x80, 0x48, 0x06, 0x80, 0x28, 0x03, 0x06, 0x07, 0xFD, 0x80, 0xE0,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0xC0, 0x14, 0x0E, 0xFF, 0x00, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x01, 0xA0, 0x08, 0xC1, 0x83, 0xF8,
  0xC0, 0x07, 0x80, 0x09, 0x00, 0x12, 0x00, 0x26, 0x00, 0xC4, 0x01, 0x08,
  0x02, 0x10, 0x0C, 0x30, 0x10, 0x20, 0x20, 0x40, 0x40, 0xC1, 0x81, 0x82,
  0x01, 0x04, 0x02, 0x08, 0x06, 0x30, 0x04, 0x40, 0x08, 0x80, 0x13, 0x00,
  0x34, 0x00, 0x28, 0x00, 0x50, 0x00, 0xE0, 0x00, 0x80, 0xC0, 0x08, 0x01,
  0x40, 0x18, 0x01, 0x40, 0x1C, 0x03, 0x60, 0x14, 0x02, 0x20, 0x14, 0x02,
  0x20, 0x34, 0x02, 0x20, 0x24, 0x06, 0x30, 0x26, 0x06, 0x30, 0x22, 0x04,
  0x10, 0x22, 0x04, 0x10, 0x62, 0x0C, 0x10, 0x43, 0x0C, 0x18, 0x41, 0x08,
  0x08, 0x41, 0x08, 0x08, 0xC1, 0x08, 0x08, 0x81, 0x18, 0x0C, 0x81, 0x90,
  0x0C, 0x80, 0x90, 0x05, 0x80, 0x90, 0x05, 0x80, 0xB0, 0x05, 0x00, 0xF0,
  0x07, 0x00, 0x60, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x60, 0x19, 0x00,
  0x8C, 0x0C, 0x20, 0x41, 0x82, 0x04, 0x20, 0x21, 0x01, 0x98, 0x04, 0x80,
  0x3C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0xC0, 0x12, 0x01, 0x98, 0x08,
  0x40, 0xC2, 0x04, 0x08, 0x60, 0x42, 0x03, 0x30, 0x09, 0x00, 0x78, 0x01,
  0xC0, 0x1A, 0x00, 0x90, 0x04, 0x40, 0x62, 0x02, 0x18, 0x30, 0x41, 0x02,
  0x08, 0x08, 0xC0, 0x44, 0x03, 0x20, 0x0A, 0x00, 0x50, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x7F, 0xF0, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x0F, 0xFF, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0xFC, 0x80, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0x40, 0x10,
  0x06, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x01, 0x80, 0x20, 0x08, 0x03, 0xFE, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x58, 0x03, 0x20, 0x08, 0xC0, 0x61, 0x01, 0x06, 0x0C, 0x08, 0x20,
  0x31, 0x80, 0x44, 0x01, 0xB0, 0x02, 0x80, 0x0C, 0xFF, 0xFC, 0xC1, 0x83,
  0x04, 0x0C, 0x3F, 0x84, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x08,
  0x01, 0x0F, 0xE6, 0x05, 0x80, 0xA0, 0x1C, 0x07, 0x80, 0xF0, 0x1A, 0x05,
  0x60, 0xA7, 0xE4, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x9F, 0x8A, 0x0C, 0xC0, 0x4C, 0x06, 0x80, 0x28, 0x02,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x28, 0x02,
  0xC0, 0x6C, 0x04, 0xA0, 0xC9, 0xF8, 0x1F, 0xCC, 0x16, 0x01, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x30, 0x04,
  0x01, 0x80, 0x30, 0x47, 0xF0, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x1F, 0x33, 0x0F, 0x40, 0x54, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0xC0, 0x34, 0x05, 0x60, 0x91, 0xF1, 0x1F, 0x06, 0x11, 0x81,
  0x20, 0x2C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF, 0xF0, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x63, 0xF8, 0x07, 0x86, 0x46,
  0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0xFE, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x00, 0x1F, 0x93, 0x0D, 0x40, 0x54, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0xC0, 0x34, 0x07, 0x20, 0xB1, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02,
  0x00, 0x20, 0x06, 0xC0, 0xC7, 0xF8, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x9F, 0xA8, 0x2C, 0x0F, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x10, 0x74, 0x01, 0x55, 0x55, 0x55, 0x55, 0x40, 0x08, 0xC2,
  0x00, 0x00, 0x01, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x62, 0xF0, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x81, 0xA0, 0x48, 0x22, 0x18, 0x84, 0x22,
  0x09, 0x82, 0x40, 0xA8, 0x32, 0x0C, 0x42, 0x10, 0x82, 0x20, 0x88, 0x12,
  0x04, 0x80, 0xA0, 0x30, 0xFF, 0xFF, 0xFF, 0xC0, 0x9F, 0x1F, 0xA8, 0x6C,
  0x2C, 0x0A, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0x9F, 0xA8, 0x3C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10,
  0x1F, 0x82, 0x0C, 0x40, 0x6C, 0x02, 0x80, 0x38, 0x03, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x3C, 0x03, 0x40, 0x24, 0x06,
  0x30, 0xC1, 0xF8, 0x9F, 0x8A, 0x0C, 0xC0, 0x4C, 0x06, 0x80, 0x28, 0x02,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x28, 0x02,
  0xC0, 0x6C, 0x04, 0xA0, 0xC9, 0xF8, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x1F, 0x93, 0x0D, 0x60, 0x54, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0xC0, 0x34, 0x07, 0x60, 0xB1, 0xF3, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x9F, 0x43, 0x06,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x00, 0x3F, 0xD8, 0x14, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x10, 0x04, 0x03, 0xC1, 0x9F, 0xC0,
  0x20, 0x40, 0x81, 0x0F, 0xE4, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x03, 0xC0, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x02, 0x80, 0x50, 0x1A, 0x03, 0x60, 0xA7, 0xE4, 0xC0, 0x34, 0x02,
  0x40, 0x24, 0x06, 0x60, 0x42, 0x04, 0x20, 0x43, 0x0C, 0x10, 0x81, 0x08,
  0x10, 0x81, 0x90, 0x09, 0x00, 0x90, 0x0B, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0xC0, 0x60, 0x28, 0x0C, 0x05, 0x01, 0x80, 0xA0, 0x78, 0x36, 0x09, 0x04,
  0x41, 0x20, 0x88, 0x24, 0x11, 0x0C, 0xC6, 0x31, 0x08, 0x82, 0x21, 0x10,
  0x44, 0x22, 0x09, 0x86, 0x41, 0xB0, 0x58, 0x14, 0x0A, 0x02, 0x81, 0x40,
  0x50, 0x28, 0x0E, 0x03, 0x00, 0x80, 0x40, 0xC0, 0x68, 0x09, 0x83, 0x10,
  0x43, 0x10, 0x22, 0x06, 0x80, 0x50, 0x0C, 0x01, 0xC0, 0x28, 0x0D, 0x81,
  0x10, 0x43, 0x18, 0x22, 0x06, 0xC0, 0x50, 0x0C, 0xC0, 0x14, 0x03, 0x40,
  0x26, 0x02, 0x20, 0x22, 0x06, 0x30, 0x41, 0x04, 0x10, 0xC1, 0x08, 0x08,
  0x80, 0x88, 0x09, 0x80, 0xD0, 0x05, 0x00, 0x70, 0x06, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x0F, 0x00, 0x7F,
  0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x10, 0x08, 0x08, 0x04, 0x06, 0x02,
  0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x7F, 0xC0, 0x03, 0x83, 0x03, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x83,
  0x80, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x03, 0x00, 0x80, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x0C,
  0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x30, 0x06, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x06, 0x03, 0x03, 0x0F, 0x00, 0x10, 0x03, 0xF0, 0x60, 0x7E,
  0x00, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraLight34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 24, 7, 3, -24 },
  { 7, 7, 9, 11, 2, -24 },
  { 15, 15, 24, 17, 1, -24 },
  { 60, 13, 28, 15, 1, -26 },
  { 106, 19, 25, 22, 2, -25 },
  { 166, 16, 25, 17, 1, -25 },
  { 216, 2, 9, 6, 2, -24 },
  { 219, 6, 29, 9, 2, -24 },
  { 241, 6, 29, 9, 1, -24 },
  { 263, 10, 11, 14, 2, -26 },
  { 277, 13, 16, 15, 1, -20 },
  { 303, 4, 8, 6, 1, -4 },
  { 307, 8, 1, 10, 1, -10 },
  { 308, 3, 2, 7, 2, -2 },
  { 309, 10, 24, 11, 1, -24 },
  { 339, 12, 25, 15, 2, -25 },
  { 377, 6, 24, 15, 3, -24 },
  { 395, 13, 25, 15, 1, -25 },
  { 436, 12, 25, 15, 1, -25 },
  { 474, 14, 24, 15, 1, -24 },
  { 516, 12, 24, 15, 2, -24 },
  { 552, 12, 25, 15, 2, -25 },
  { 590, 12, 24, 15, 2, -24 },
  { 626, 13, 25, 15, 1, -25 },
  { 667, 12, 25, 15, 1, -25 },
  { 705, 3, 18, 7, 2, -18 },
  { 712, 4, 22, 7, 1, -18 },
  { 723, 13, 14, 15, 1, -19 },
  { 746, 13, 8, 15, 1, -16 },
  { 759, 13, 14, 15, 1, -19 },
  { 782, 9, 25, 11, 1, -25 },
  { 811, 20, 27, 24, 2, -24 },
  { 879, 15, 24, 15, 0, -24 },
  { 924, 12, 24, 17, 3, -24 },
  { 960, 13, 25, 16, 2, -25 },
  { 1001, 14, 24, 19, 3, -24 },
  { 1043, 10, 24, 15, 3, -24 },
  { 1073, 10, 24, 14, 3, -24 },
  { 1103, 16, 25, 20, 2, -25 },
  { 1153, 13, 24, 19, 3, -24 },
  { 1192, 6, 24, 9, 1, -24 },
  { 1210, 6, 30, 7, -2, -24 },
  { 1233, 12, 24, 15, 3, -24 },
  { 1269, 10, 24, 13, 3, -24 },
  { 1299, 19, 24, 25, 3, -24 },
  { 1356, 14, 24, 20, 3, -24 },
  { 1398, 16, 25, 20, 2, -25 },
  { 1448, 11, 24, 16, 3, -24 },
  { 1481, 16, 31, 20, 2, -25 },
  { 1543, 12, 24, 16, 3, -24 },
  { 1579, 11, 25, 15, 2, -25 },
  { 1614, 13, 24, 13, 0, -24 },
  { 1653, 13, 24, 19, 3, -24 },
  { 1692, 15, 24, 15, 0, -24 },
  { 1737, 24, 24, 25, 0, -24 },
  { 1809, 13, 24, 14, 0, -24 },
  { 1848, 13, 24, 13, 0, -24 },
  { 1887, 12, 24, 14, 1, -24 },
  { 1923, 6, 29, 11, 3, -24 },
  { 1945, 10, 24, 11, 1, -24 },
  { 1975, 7, 29, 11, 1, -24 },
  { 2001, 14, 13, 15, 1, -24 },
  { 2024, 14, 1, 14, 0, 3 },
  { 2026, 6, 5, 8, 1, -26 },
  { 2030, 11, 18, 14, 1, -18 },
  { 2055, 12, 26, 16, 3, -26 },
  { 2094, 10, 18, 12, 2, -18 },
  { 2117, 12, 26, 16, 2, -26 },
  { 2156, 11, 18, 15, 2, -18 },
  { 2181, 9, 26, 8, 0, -26 },
  { 2211, 12, 26, 16, 2, -18 },
  { 2250, 10, 26, 16, 3, -26 },
  { 2283, 2, 25, 7, 2, -25 },
  { 2290, 5, 33, 7, -1, -25 },
  { 2311, 10, 26, 13, 3, -26 },
  { 2344, 1, 26, 6, 3, -26 },
  { 2348, 18, 18, 24, 3, -18 },
  { 2389, 10, 18, 16, 3, -18 },
  { 2412, 12, 18, 16, 2, -18 },
  { 2439, 12, 26, 16, 3, -18 },
  { 2478, 12, 26, 16, 2, -18 },
  { 2517, 7, 18, 10, 3, -18 },
  { 2533, 10, 18, 12, 1, -18 },
  { 2556, 7, 22, 9, 1, -22 },
  { 2576, 11, 18, 16, 2, -18 },
  { 2601, 12, 18, 12, 0, -18 },
  { 2628, 19, 18, 20, 0, -18 },
  { 2671, 11, 18, 13, 1, -18 },
  { 2696, 12, 26, 12, 0, -18 },
  { 2735, 9, 18, 11, 1, -18 },
  { 2756, 9, 29, 12, 1, -24 },
  { 2789, 1, 34, 15, 7, -26 },
  { 2794, 9, 29, 12, 1, -24 },
  { 2827, 13, 4, 15, 1, -14 },
};

const GFXfont NotoSans_Condensed_ExtraLight34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight34pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT34PT7B_H_
