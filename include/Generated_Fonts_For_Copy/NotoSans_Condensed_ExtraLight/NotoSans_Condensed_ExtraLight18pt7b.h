#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT18PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xC8, 0x99, 0x99, 0x90, 0x12, 0x09, 0x04, 0x82, 0x47, 0xF9,
  0x10, 0x88, 0x48, 0xFF, 0x12, 0x09, 0x04, 0x82, 0x40, 0x20, 0xEE, 0x68,
  0xA2, 0x86, 0x0C, 0x28, 0x92, 0x49, 0xAD, 0xC2, 0x00, 0x61, 0x24, 0x89,
  0x22, 0x48, 0x94, 0x25, 0x69, 0xA5, 0xA9, 0x0A, 0x44, 0x91, 0x24, 0x89,
  0x21, 0x80, 0x30, 0x48, 0x48, 0x48, 0x48, 0x30, 0x60, 0x91, 0x8A, 0x8A,
  0x84, 0x86, 0x79, 0xF8, 0x29, 0x49, 0x24, 0x92, 0x48, 0x91, 0x91, 0x22,
  0x49, 0x24, 0x94, 0xA4, 0x20, 0x8E, 0xCC, 0x51, 0x20, 0x10, 0x20, 0x40,
  0x8F, 0xE2, 0x04, 0x08, 0x10, 0xF0, 0xF0, 0x80, 0x04, 0x20, 0x82, 0x10,
  0x41, 0x08, 0x21, 0x04, 0x10, 0x80, 0x39, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x51, 0x78, 0x13, 0xD1, 0x11, 0x11, 0x11, 0x11, 0x10, 0x7A,
  0x10, 0x41, 0x04, 0x10, 0x84, 0x10, 0x84, 0x20, 0xFC, 0x7A, 0x10, 0x41,
  0x04, 0x27, 0x81, 0x04, 0x10, 0x41, 0xF8, 0x04, 0x04, 0x0C, 0x14, 0x14,
  0x24, 0x24, 0x44, 0x44, 0xFF, 0x04, 0x04, 0x04, 0x7E, 0x08, 0x20, 0x83,
  0xC0, 0xC1, 0x04, 0x10, 0x41, 0xF8, 0x3D, 0x04, 0x20, 0x82, 0xEC, 0x61,
  0x86, 0x18, 0x61, 0x78, 0xFC, 0x10, 0x42, 0x08, 0x21, 0x04, 0x10, 0x82,
  0x08, 0x40, 0x7A, 0x18, 0x61, 0x85, 0x23, 0x12, 0x86, 0x18, 0x61, 0x78,
  0x7A, 0x28, 0x61, 0x86, 0x18, 0x5F, 0x04, 0x10, 0x42, 0xF0, 0xC0, 0x40,
  0xC0, 0xF0, 0x06, 0x31, 0x84, 0x06, 0x02, 0x03, 0x80, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x80, 0xC0, 0x60, 0x30, 0x86, 0x30, 0x00, 0xF0, 0x42, 0x10,
  0x88, 0x44, 0x21, 0x00, 0x02, 0x00, 0x1F, 0x04, 0x11, 0x01, 0x20, 0x28,
  0xF3, 0x24, 0x64, 0x8C, 0x91, 0x92, 0x32, 0x4A, 0x37, 0x40, 0x04, 0x00,
  0x42, 0x07, 0x80, 0x08, 0x18, 0x18, 0x14, 0x24, 0x24, 0x24, 0x7E, 0x42,
  0x42, 0x41, 0x81, 0x81, 0xF2, 0x38, 0x61, 0x86, 0x2F, 0xA1, 0x86, 0x18,
  0x61, 0xF8, 0x1E, 0xC1, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x01, 0x02,
  0x03, 0xE0, 0xF1, 0x12, 0x14, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x14,
  0x6F, 0x00, 0xFC, 0x21, 0x08, 0x43, 0xF0, 0x84, 0x21, 0x0F, 0x80, 0xFC,
  0x21, 0x08, 0x43, 0xF0, 0x84, 0x21, 0x08, 0x00, 0x1F, 0x20, 0x40, 0x80,
  0x80, 0x80, 0x86, 0x81, 0x81, 0x81, 0x41, 0x41, 0x3F, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x7F, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x20, 0xE9, 0x24, 0x92,
  0x49, 0x2E, 0x24, 0x92, 0x49, 0x24, 0x92, 0x4F, 0x86, 0x29, 0x24, 0xA3,
  0x0C, 0x28, 0x92, 0x48, 0xA2, 0x84, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x0F, 0x80, 0x80, 0xC0, 0x60, 0x78, 0x3C, 0x1E, 0x16, 0x8B, 0x45,
  0xA4, 0xCA, 0x65, 0x32, 0x98, 0x88, 0x83, 0x06, 0x0E, 0x1A, 0x34, 0x64,
  0xC9, 0x8B, 0x16, 0x1C, 0x38, 0x20, 0x3C, 0x21, 0x10, 0x50, 0x28, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x90, 0x48, 0x23, 0xE0, 0xF2, 0x28, 0x61,
  0x86, 0x29, 0xB8, 0x82, 0x08, 0x20, 0x80, 0x3C, 0x21, 0x10, 0x50, 0x28,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x90, 0x48, 0x23, 0xE0, 0x20, 0x08,
  0x04, 0xF2, 0x28, 0x61, 0x86, 0x2D, 0x28, 0x92, 0x48, 0xA2, 0x84, 0x7E,
  0x08, 0x20, 0x81, 0x03, 0x02, 0x04, 0x10, 0x41, 0xF8, 0xFE, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x00, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42, 0x3C, 0x81, 0x81,
  0x82, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x28, 0x18, 0x18, 0x10, 0x82,
  0x0C, 0x10, 0x51, 0x44, 0x8A, 0x24, 0x51, 0x22, 0x88, 0x94, 0x45, 0x14,
  0x28, 0xA1, 0x45, 0x0A, 0x28, 0x20, 0x81, 0x04, 0x00, 0x42, 0x89, 0x11,
  0x22, 0x82, 0x04, 0x0C, 0x28, 0x49, 0x12, 0x18, 0x20, 0x83, 0x05, 0x12,
  0x22, 0x85, 0x0A, 0x08, 0x10, 0x20, 0x40, 0x81, 0x00, 0xFC, 0x20, 0x82,
  0x10, 0x42, 0x08, 0x41, 0x08, 0x20, 0xFC, 0xF8, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x8F, 0x81, 0x04, 0x10, 0x20, 0x81, 0x04, 0x10, 0x20, 0x82,
  0x04, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x4F, 0x08, 0x18, 0x14, 0x24, 0x22,
  0x42, 0xC1, 0xFE, 0x91, 0x80, 0x74, 0x42, 0x13, 0xA6, 0x31, 0x8F, 0xC0,
  0x81, 0x02, 0x04, 0x0B, 0x98, 0xA0, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x57,
  0x00, 0x3A, 0x21, 0x08, 0x42, 0x10, 0x83, 0xC0, 0x04, 0x10, 0x41, 0x35,
  0x38, 0x61, 0x86, 0x18, 0x61, 0x85, 0xF0, 0x31, 0x28, 0x61, 0xFE, 0x08,
  0x20, 0x81, 0xF0, 0x19, 0x10, 0x8F, 0x21, 0x08, 0x42, 0x10, 0x84, 0x20,
  0x3D, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xF0, 0x41, 0x07, 0xE0, 0x82,
  0x08, 0x20, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x10, 0x9F, 0xF8,
  0x41, 0x55, 0x55, 0x55, 0xC0, 0x82, 0x08, 0x20, 0x86, 0x29, 0x28, 0xA3,
  0x49, 0x22, 0x8A, 0x10, 0xFF, 0xFC, 0xB1, 0xB2, 0x98, 0x46, 0x11, 0x84,
  0x61, 0x18, 0x46, 0x11, 0x84, 0x61, 0x10, 0xBB, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x10, 0x39, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE0, 0xB9,
  0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC5, 0x72, 0x04, 0x08, 0x10, 0x00,
  0x35, 0x38, 0x61, 0x86, 0x18, 0x61, 0x85, 0xF0, 0x41, 0x04, 0x10, 0xBC,
  0x88, 0x88, 0x88, 0x88, 0x7C, 0x21, 0x04, 0x18, 0x21, 0x0F, 0x80, 0x44,
  0xF4, 0x44, 0x44, 0x44, 0x43, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85,
  0xF0, 0x86, 0x18, 0x51, 0x49, 0x22, 0x8C, 0x30, 0x40, 0x84, 0x61, 0x14,
  0xC5, 0x29, 0x4A, 0x52, 0xA5, 0x28, 0xC6, 0x31, 0x08, 0x40, 0x85, 0x14,
  0x8A, 0x10, 0x42, 0x8A, 0x46, 0x10, 0x86, 0x14, 0x51, 0x48, 0xA2, 0x8A,
  0x10, 0x41, 0x08, 0x23, 0x00, 0xF1, 0x12, 0x24, 0x48, 0x8F, 0x12, 0x44,
  0x44, 0x4C, 0x44, 0x44, 0x44, 0x21, 0xFF, 0xFF, 0xC0, 0xC2, 0x22, 0x22,
  0x23, 0x22, 0x22, 0x22, 0x2C, 0xFE,
};

const GFXglyph NotoSans_Condensed_ExtraLight18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 13, 4, 1, -13 },
  { 3, 4, 5, 6, 1, -13 },
  { 6, 9, 13, 9, 0, -13 },
  { 21, 6, 15, 8, 1, -14 },
  { 33, 10, 13, 12, 1, -13 },
  { 50, 8, 13, 9, 1, -13 },
  { 63, 1, 5, 3, 1, -13 },
  { 64, 3, 16, 5, 1, -13 },
  { 70, 3, 16, 5, 1, -13 },
  { 76, 6, 6, 7, 1, -14 },
  { 81, 7, 9, 8, 1, -11 },
  { 89, 1, 4, 3, 1, -2 },
  { 90, 4, 1, 5, 1, -5 },
  { 91, 1, 1, 4, 1, -1 },
  { 92, 6, 13, 6, 0, -13 },
  { 102, 6, 13, 8, 1, -13 },
  { 112, 4, 13, 8, 1, -13 },
  { 119, 6, 13, 8, 1, -13 },
  { 129, 6, 13, 8, 1, -13 },
  { 139, 8, 13, 8, 0, -13 },
  { 152, 6, 13, 8, 1, -13 },
  { 162, 6, 13, 8, 1, -13 },
  { 172, 6, 13, 8, 1, -13 },
  { 182, 6, 13, 8, 1, -13 },
  { 192, 6, 13, 8, 1, -13 },
  { 202, 1, 10, 4, 1, -10 },
  { 204, 1, 12, 4, 1, -10 },
  { 206, 7, 7, 8, 1, -10 },
  { 213, 7, 5, 8, 1, -9 },
  { 218, 7, 7, 8, 1, -10 },
  { 225, 5, 13, 6, 0, -13 },
  { 234, 11, 15, 12, 1, -13 },
  { 255, 8, 13, 8, 0, -13 },
  { 268, 6, 13, 9, 2, -13 },
  { 278, 7, 13, 9, 1, -13 },
  { 290, 7, 13, 10, 2, -13 },
  { 302, 5, 13, 8, 2, -13 },
  { 311, 5, 13, 7, 2, -13 },
  { 320, 8, 13, 11, 1, -13 },
  { 333, 7, 13, 10, 2, -13 },
  { 345, 3, 13, 5, 1, -13 },
  { 350, 3, 16, 4, -1, -13 },
  { 356, 6, 13, 8, 2, -13 },
  { 366, 5, 13, 7, 2, -13 },
  { 375, 9, 13, 13, 2, -13 },
  { 390, 7, 13, 10, 2, -13 },
  { 402, 9, 13, 11, 1, -13 },
  { 417, 6, 13, 8, 2, -13 },
  { 427, 9, 16, 11, 1, -13 },
  { 445, 6, 13, 8, 2, -13 },
  { 455, 6, 13, 8, 1, -13 },
  { 465, 7, 13, 7, 0, -13 },
  { 477, 8, 13, 10, 1, -13 },
  { 490, 8, 13, 8, 0, -13 },
  { 503, 13, 13, 13, 0, -13 },
  { 525, 7, 13, 7, 0, -13 },
  { 537, 7, 13, 7, 0, -13 },
  { 549, 6, 13, 7, 1, -13 },
  { 559, 4, 16, 6, 1, -13 },
  { 567, 6, 13, 6, 0, -13 },
  { 577, 3, 16, 6, 1, -13 },
  { 583, 8, 7, 8, 0, -13 },
  { 590, 7, 1, 7, 0, 1 },
  { 591, 3, 3, 4, 1, -14 },
  { 593, 5, 10, 8, 1, -10 },
  { 600, 7, 14, 9, 1, -14 },
  { 613, 5, 10, 7, 1, -10 },
  { 620, 6, 14, 9, 1, -14 },
  { 631, 6, 10, 8, 1, -10 },
  { 639, 5, 14, 4, 0, -14 },
  { 648, 6, 14, 9, 1, -10 },
  { 659, 6, 14, 8, 1, -14 },
  { 670, 1, 13, 3, 1, -13 },
  { 672, 2, 17, 3, 0, -13 },
  { 677, 6, 14, 7, 1, -14 },
  { 688, 1, 14, 3, 1, -14 },
  { 690, 10, 10, 13, 1, -10 },
  { 703, 6, 10, 8, 1, -10 },
  { 711, 6, 10, 8, 1, -10 },
  { 719, 7, 14, 9, 1, -10 },
  { 732, 6, 14, 9, 1, -10 },
  { 743, 4, 10, 5, 1, -10 },
  { 748, 5, 10, 7, 1, -10 },
  { 755, 4, 12, 5, 0, -12 },
  { 761, 6, 10, 8, 1, -10 },
  { 769, 6, 10, 6, 0, -10 },
  { 777, 10, 10, 11, 0, -10 },
  { 790, 6, 10, 7, 0, -10 },
  { 798, 6, 14, 7, 0, -10 },
  { 809, 4, 10, 6, 1, -10 },
  { 814, 4, 16, 6, 1, -13 },
  { 822, 1, 18, 8, 3, -14 },
  { 825, 4, 16, 6, 1, -13 },
  { 833, 7, 1, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_ExtraLight18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight18pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT18PT7B_H_
