#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT15PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0xD0, 0x14, 0x48, 0x93, 0xF2, 0x44, 0x8A, 0x7F,
  0x48, 0x91, 0x20, 0x75, 0x69, 0x4A, 0x30, 0xC5, 0x29, 0x7C, 0x40, 0xC4,
  0xA4, 0xA4, 0xA8, 0xAA, 0xB5, 0xD5, 0x19, 0x29, 0x25, 0x47, 0x62, 0x49,
  0x24, 0x61, 0x0A, 0x65, 0x8A, 0x2F, 0x40, 0xF0, 0x5A, 0xAA, 0xA9, 0x40,
  0xA5, 0x55, 0x56, 0x80, 0x2F, 0x2D, 0x21, 0x09, 0xF2, 0x10, 0x80, 0xF0,
  0xF0, 0x80, 0x08, 0x44, 0x22, 0x10, 0x88, 0x42, 0x20, 0x74, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x5C, 0x2E, 0x92, 0x49, 0x24, 0x80, 0xF0, 0x42, 0x10,
  0x88, 0x44, 0x44, 0x3E, 0x74, 0x42, 0x11, 0x38, 0x21, 0x08, 0x7C, 0x08,
  0x10, 0x61, 0x42, 0x89, 0x12, 0x44, 0x7E, 0x10, 0x20, 0xF4, 0x21, 0x0E,
  0x08, 0x21, 0x08, 0x7C, 0x3A, 0x21, 0x0F, 0x46, 0x31, 0x8C, 0x5C, 0xF8,
  0x42, 0x21, 0x08, 0x84, 0x22, 0x10, 0x74, 0x63, 0x15, 0x32, 0x71, 0x8C,
  0x5C, 0x74, 0x63, 0x18, 0xC5, 0xE1, 0x08, 0xB8, 0x81, 0x83, 0xC0, 0x08,
  0x99, 0x04, 0x18, 0x20, 0xF8, 0x01, 0xF0, 0x82, 0x0C, 0x11, 0x32, 0x00,
  0xE1, 0x11, 0x12, 0x24, 0x00, 0x40, 0x1C, 0x31, 0x10, 0x53, 0x9A, 0x4D,
  0x26, 0x93, 0x49, 0xAD, 0x49, 0x20, 0x0F, 0xC0, 0x10, 0x60, 0xA1, 0x42,
  0x89, 0x1E, 0x22, 0x45, 0x06, 0x08, 0xF2, 0x28, 0x61, 0x8B, 0xE8, 0x61,
  0x86, 0x1F, 0x80, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81, 0x03, 0xC0,
  0xF2, 0x28, 0x61, 0x86, 0x18, 0x61, 0x86, 0x1F, 0x80, 0xFC, 0x21, 0x08,
  0x7E, 0x10, 0x84, 0x3E, 0xFC, 0x21, 0x08, 0x7E, 0x10, 0x84, 0x20, 0x3E,
  0x82, 0x04, 0x08, 0x11, 0xA0, 0xC1, 0x82, 0x84, 0xF8, 0x86, 0x18, 0x61,
  0x87, 0xF8, 0x61, 0x86, 0x18, 0x40, 0xEA, 0xAA, 0xAC, 0x24, 0x92, 0x49,
  0x24, 0x93, 0x80, 0x86, 0x29, 0x28, 0xA3, 0x8A, 0x24, 0x92, 0x28, 0x40,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x3E, 0x80, 0xE0, 0xF0, 0x78, 0x5A,
  0x2D, 0x16, 0x93, 0x29, 0x94, 0xCC, 0x62, 0x20, 0x87, 0x1C, 0x69, 0xA6,
  0x59, 0x63, 0x8E, 0x18, 0x40, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x09, 0xE0, 0xF4, 0x63, 0x18, 0xC7, 0xD0, 0x84, 0x20, 0x38, 0x8A,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x09, 0xE0, 0x40, 0x40, 0x80, 0xF2,
  0x28, 0xA2, 0x8B, 0xC9, 0x24, 0x8A, 0x28, 0x40, 0x7C, 0x21, 0x08, 0x30,
  0x41, 0x08, 0x7C, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x00,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x17, 0x80, 0x83, 0x0A, 0x12,
  0x24, 0x49, 0x12, 0x14, 0x28, 0x20, 0x40, 0x84, 0x30, 0x86, 0x31, 0x25,
  0x24, 0xA4, 0x94, 0x92, 0xA1, 0x8C, 0x31, 0x86, 0x30, 0x84, 0x00, 0x85,
  0x24, 0x8A, 0x30, 0x43, 0x0A, 0x49, 0x28, 0x40, 0x86, 0x14, 0x92, 0x50,
  0xC2, 0x08, 0x20, 0x82, 0x00, 0x7C, 0x20, 0x84, 0x10, 0x42, 0x08, 0x41,
  0x0F, 0xC0, 0xF2, 0x49, 0x24, 0x92, 0x4E, 0x82, 0x10, 0x82, 0x10, 0x82,
  0x10, 0x82, 0xE4, 0x92, 0x49, 0x24, 0x9E, 0x10, 0xA2, 0x92, 0x46, 0x10,
  0xFC, 0x90, 0xF1, 0x17, 0x99, 0x9F, 0x84, 0x21, 0xE8, 0xC6, 0x31, 0x8C,
  0x7C, 0x78, 0x88, 0x88, 0x87, 0x08, 0x42, 0xF8, 0xC6, 0x31, 0x8C, 0x5E,
  0x74, 0x63, 0xF8, 0x42, 0x0F, 0x74, 0x4E, 0x44, 0x44, 0x44, 0x40, 0x7C,
  0x63, 0x18, 0xC6, 0x2F, 0x08, 0x43, 0xE0, 0x84, 0x21, 0xE8, 0xC6, 0x31,
  0x8C, 0x62, 0x9F, 0xE0, 0x41, 0x55, 0x55, 0x58, 0x84, 0x21, 0x29, 0x53,
  0x14, 0x94, 0xA2, 0xFF, 0xE0, 0xF7, 0x89, 0x89, 0x89, 0x89, 0x89, 0x89,
  0x89, 0xF4, 0x63, 0x18, 0xC6, 0x31, 0x74, 0x63, 0x18, 0xC6, 0x2E, 0xF4,
  0x63, 0x18, 0xC6, 0x3E, 0x84, 0x21, 0x00, 0x7C, 0x63, 0x18, 0xC6, 0x2F,
  0x08, 0x42, 0x10, 0xF2, 0x49, 0x24, 0xF8, 0x8C, 0x21, 0x1E, 0x44, 0xF4,
  0x44, 0x44, 0x47, 0x8C, 0x63, 0x18, 0xC6, 0x2F, 0x8C, 0x52, 0xA5, 0x28,
  0x84, 0x88, 0xC4, 0x95, 0x4A, 0xA5, 0x52, 0xA9, 0x88, 0x44, 0x8A, 0x4C,
  0x42, 0x29, 0x31, 0x8C, 0x52, 0x95, 0x18, 0x84, 0x21, 0x11, 0x00, 0x71,
  0x12, 0x24, 0x4F, 0x34, 0x44, 0x44, 0x84, 0x44, 0x44, 0x70, 0xFF, 0xFE,
  0x84, 0x44, 0x44, 0x34, 0x44, 0x44, 0xC0, 0xF8,
};

const GFXglyph NotoSans_Condensed_ExtraLight15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 11, 3, 1, -11 },
  { 3, 3, 4, 5, 1, -11 },
  { 5, 7, 11, 7, 0, -11 },
  { 15, 5, 12, 7, 1, -11 },
  { 23, 8, 11, 10, 1, -11 },
  { 34, 6, 11, 7, 1, -11 },
  { 43, 1, 4, 3, 1, -11 },
  { 44, 2, 13, 4, 1, -11 },
  { 48, 2, 13, 4, 1, -11 },
  { 52, 4, 4, 6, 1, -11 },
  { 54, 5, 7, 7, 1, -9 },
  { 59, 1, 4, 3, 1, -2 },
  { 60, 4, 1, 4, 0, -5 },
  { 61, 1, 1, 3, 1, -1 },
  { 62, 5, 11, 5, 0, -11 },
  { 69, 5, 11, 7, 1, -11 },
  { 76, 3, 11, 7, 1, -11 },
  { 81, 5, 11, 7, 1, -11 },
  { 88, 5, 11, 7, 1, -11 },
  { 95, 7, 11, 7, 0, -11 },
  { 105, 5, 11, 7, 1, -11 },
  { 112, 5, 11, 7, 1, -11 },
  { 119, 5, 11, 7, 1, -11 },
  { 126, 5, 11, 7, 1, -11 },
  { 133, 5, 11, 7, 1, -11 },
  { 140, 1, 8, 3, 1, -8 },
  { 141, 1, 10, 3, 1, -8 },
  { 143, 5, 7, 7, 1, -9 },
  { 148, 5, 4, 7, 1, -7 },
  { 151, 5, 7, 7, 1, -9 },
  { 156, 4, 11, 5, 0, -11 },
  { 162, 9, 12, 10, 1, -11 },
  { 176, 7, 11, 7, 0, -11 },
  { 186, 6, 11, 7, 1, -11 },
  { 195, 6, 11, 7, 1, -11 },
  { 204, 6, 11, 8, 1, -11 },
  { 213, 5, 11, 7, 1, -11 },
  { 220, 5, 11, 6, 1, -11 },
  { 227, 7, 11, 9, 1, -11 },
  { 237, 6, 11, 8, 1, -11 },
  { 246, 2, 11, 4, 1, -11 },
  { 249, 3, 14, 3, -1, -11 },
  { 255, 6, 11, 7, 1, -11 },
  { 264, 5, 11, 6, 1, -11 },
  { 271, 9, 11, 11, 1, -11 },
  { 284, 6, 11, 9, 1, -11 },
  { 293, 7, 11, 9, 1, -11 },
  { 303, 5, 11, 7, 1, -11 },
  { 310, 7, 14, 9, 1, -11 },
  { 323, 6, 11, 7, 1, -11 },
  { 332, 5, 11, 7, 1, -11 },
  { 339, 6, 11, 6, 0, -11 },
  { 348, 6, 11, 8, 1, -11 },
  { 357, 7, 11, 7, 0, -11 },
  { 367, 11, 11, 11, 0, -11 },
  { 383, 6, 11, 6, 0, -11 },
  { 392, 6, 11, 6, 0, -11 },
  { 401, 6, 11, 6, 0, -11 },
  { 410, 3, 13, 5, 1, -11 },
  { 415, 5, 11, 5, 0, -11 },
  { 422, 3, 13, 5, 0, -11 },
  { 427, 6, 6, 7, 0, -11 },
  { 432, 6, 1, 6, 0, 1 },
  { 433, 2, 2, 4, 1, -11 },
  { 434, 4, 8, 6, 1, -8 },
  { 438, 5, 11, 7, 1, -11 },
  { 445, 4, 8, 5, 1, -8 },
  { 449, 5, 11, 7, 1, -11 },
  { 456, 5, 8, 7, 1, -8 },
  { 461, 4, 11, 4, 0, -11 },
  { 467, 5, 12, 7, 1, -8 },
  { 475, 5, 11, 7, 1, -11 },
  { 482, 1, 11, 3, 1, -11 },
  { 484, 2, 15, 3, 0, -11 },
  { 488, 5, 11, 6, 1, -11 },
  { 495, 1, 11, 3, 1, -11 },
  { 497, 8, 8, 10, 1, -8 },
  { 505, 5, 8, 7, 1, -8 },
  { 510, 5, 8, 7, 1, -8 },
  { 515, 5, 12, 7, 1, -8 },
  { 523, 5, 12, 7, 1, -8 },
  { 531, 3, 8, 5, 1, -8 },
  { 534, 4, 8, 5, 1, -8 },
  { 538, 4, 10, 4, 0, -10 },
  { 543, 5, 8, 7, 1, -8 },
  { 548, 5, 8, 5, 0, -8 },
  { 553, 9, 8, 9, 0, -8 },
  { 562, 5, 8, 6, 0, -8 },
  { 567, 5, 12, 5, 0, -8 },
  { 575, 4, 8, 5, 0, -8 },
  { 579, 4, 13, 5, 1, -11 },
  { 586, 1, 15, 6, 3, -11 },
  { 588, 4, 13, 5, 1, -11 },
  { 595, 5, 1, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_ExtraLight15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight15pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT15PT7B_H_
