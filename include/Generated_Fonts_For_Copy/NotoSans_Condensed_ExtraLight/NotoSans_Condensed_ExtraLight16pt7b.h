#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT16PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0xD0, 0x14, 0x14, 0x24, 0x7F, 0x24, 0x24, 0x24,
  0xFE, 0x28, 0x48, 0x48, 0x27, 0xE9, 0x4A, 0x30, 0xC5, 0x29, 0x6A, 0xE2,
  0x00, 0x40, 0x51, 0x29, 0x12, 0x89, 0x85, 0x5A, 0xB2, 0xA9, 0x14, 0x92,
  0x49, 0x24, 0x60, 0x20, 0xA2, 0x24, 0x85, 0x04, 0x18, 0x49, 0x95, 0x1A,
  0x37, 0x90, 0xF0, 0x6A, 0x49, 0x24, 0x92, 0x24, 0x40, 0x89, 0x22, 0x49,
  0x29, 0x29, 0x00, 0x25, 0x5C, 0xA9, 0x00, 0x20, 0x82, 0x3F, 0x20, 0x82,
  0x00, 0xF0, 0xF0, 0x80, 0x08, 0x44, 0x21, 0x10, 0x88, 0x42, 0x20, 0x32,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x62, 0xE0, 0x3C, 0x92, 0x49, 0x24, 0x80,
  0x74, 0x42, 0x10, 0x84, 0x42, 0x22, 0x21, 0xF0, 0x34, 0x42, 0x10, 0x89,
  0xC1, 0x08, 0x43, 0xE0, 0x08, 0x28, 0x51, 0x22, 0x48, 0x91, 0x7F, 0x04,
  0x08, 0x10, 0xFC, 0x21, 0x0F, 0x04, 0x21, 0x08, 0x7C, 0x3A, 0x21, 0x08,
  0x7A, 0x31, 0x8C, 0x62, 0xF0, 0xF8, 0x42, 0x21, 0x08, 0x84, 0x22, 0x10,
  0x72, 0x28, 0xA2, 0x89, 0xC5, 0x22, 0x86, 0x18, 0x9E, 0x74, 0x63, 0x18,
  0xC6, 0x2F, 0x08, 0x43, 0xE0, 0xC0, 0x80, 0xC1, 0xE0, 0x0C, 0xC4, 0x20,
  0x60, 0x60, 0x40, 0xFC, 0x00, 0x3F, 0x81, 0x81, 0x83, 0x31, 0x08, 0x00,
  0x64, 0x82, 0x10, 0x88, 0x84, 0x40, 0x00, 0x80, 0x3F, 0x20, 0xA0, 0x33,
  0xD9, 0x2D, 0x16, 0x93, 0x49, 0x9F, 0xC0, 0x10, 0x07, 0xC0, 0x10, 0x50,
  0xA1, 0x42, 0x48, 0x9F, 0x22, 0x43, 0x06, 0x08, 0xFA, 0x18, 0x61, 0x8B,
  0xE8, 0x61, 0x86, 0x1F, 0x80, 0x1D, 0x84, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x04, 0x0F, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x85, 0x0B, 0xE0,
  0xFC, 0x21, 0x08, 0x7E, 0x10, 0x84, 0x3E, 0xFC, 0x21, 0x08, 0x7E, 0x10,
  0x84, 0x20, 0x1C, 0x45, 0x04, 0x08, 0x10, 0x23, 0xC1, 0x83, 0x05, 0x09,
  0xF0, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x08, 0xD5,
  0x55, 0x5C, 0x24, 0x92, 0x49, 0x24, 0x93, 0x80, 0x8E, 0x29, 0x28, 0xA3,
  0x89, 0x24, 0x8A, 0x28, 0x40, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x3E,
  0xC0, 0xE0, 0xF0, 0x74, 0x3A, 0x2D, 0x16, 0x4B, 0x29, 0x94, 0xC6, 0x62,
  0x20, 0xC3, 0x86, 0x8D, 0x19, 0x32, 0x62, 0xC5, 0x87, 0x0E, 0x08, 0x38,
  0x44, 0x82, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x42, 0x3C, 0xFA,
  0x18, 0x61, 0x87, 0xE8, 0x20, 0x82, 0x08, 0x00, 0x38, 0x44, 0x82, 0x82,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x42, 0x3C, 0x08, 0x04, 0x06, 0xFA,
  0x18, 0x61, 0x8B, 0xC9, 0x22, 0x8A, 0x18, 0x40, 0x7C, 0x21, 0x08, 0x20,
  0xC1, 0x08, 0x43, 0xE0, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x00, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x09, 0xF0, 0x83,
  0x05, 0x12, 0x24, 0x48, 0x8A, 0x14, 0x28, 0x20, 0x40, 0x84, 0x30, 0xC5,
  0x18, 0xA5, 0x14, 0xA4, 0x92, 0x8A, 0x51, 0x4A, 0x31, 0x46, 0x30, 0x42,
  0x00, 0xC5, 0x22, 0x8A, 0x10, 0x43, 0x0A, 0x49, 0x18, 0x40, 0x85, 0x14,
  0x92, 0x30, 0xC1, 0x04, 0x10, 0x41, 0x00, 0x7C, 0x20, 0x82, 0x10, 0x42,
  0x08, 0x41, 0x0F, 0xC0, 0xF2, 0x49, 0x24, 0x92, 0x49, 0xC0, 0x82, 0x10,
  0x42, 0x10, 0x42, 0x10, 0x42, 0xE4, 0x92, 0x49, 0x24, 0x93, 0xC0, 0x10,
  0x50, 0x92, 0x24, 0x30, 0x40, 0xFC, 0x90, 0x64, 0x82, 0x17, 0xC6, 0x31,
  0xF8, 0x82, 0x08, 0x2C, 0xCA, 0x18, 0x61, 0x86, 0x18, 0x7E, 0x34, 0x88,
  0x88, 0x88, 0x70, 0x08, 0x42, 0xF8, 0xC6, 0x31, 0x8C, 0x62, 0xF0, 0x74,
  0x63, 0x1F, 0xC2, 0x10, 0x78, 0x34, 0x4E, 0x44, 0x44, 0x44, 0x44, 0x74,
  0x63, 0x18, 0xC6, 0x31, 0x78, 0x42, 0x1F, 0x00, 0x84, 0x21, 0x6C, 0xC6,
  0x31, 0x8C, 0x63, 0x10, 0xCF, 0xF0, 0x50, 0x55, 0x55, 0x56, 0x84, 0x21,
  0x19, 0x4A, 0x9C, 0xA4, 0xA5, 0x10, 0xFF, 0xF0, 0x33, 0x66, 0x62, 0x31,
  0x18, 0x8C, 0x46, 0x23, 0x11, 0x88, 0x80, 0x36, 0x63, 0x18, 0xC6, 0x31,
  0x88, 0x72, 0x28, 0x61, 0x86, 0x18, 0x62, 0x70, 0x33, 0x28, 0x61, 0x86,
  0x18, 0x61, 0xFA, 0x08, 0x20, 0x80, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x78,
  0x42, 0x10, 0x80, 0x3C, 0x88, 0x88, 0x88, 0x80, 0x78, 0x88, 0x61, 0x11,
  0xF0, 0x44, 0xF4, 0x44, 0x44, 0x44, 0x70, 0x8C, 0x63, 0x18, 0xC6, 0x2F,
  0x8E, 0x24, 0x92, 0x50, 0xC3, 0x08, 0x88, 0xC6, 0x55, 0x2A, 0xA5, 0x52,
  0x98, 0x8C, 0x44, 0xCD, 0x23, 0x04, 0x31, 0x24, 0xA1, 0x85, 0x24, 0x92,
  0x50, 0xC3, 0x08, 0x20, 0x82, 0x30, 0xF2, 0x24, 0x48, 0x8F, 0x34, 0x44,
  0x44, 0x84, 0x44, 0x44, 0x43, 0xFF, 0xFF, 0xC4, 0x44, 0x42, 0x12, 0x44,
  0x44, 0x48, 0xFC,
};

const GFXglyph NotoSans_Condensed_ExtraLight16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 11, 3, 1, -11 },
  { 3, 3, 4, 5, 1, -11 },
  { 5, 8, 11, 8, 0, -11 },
  { 16, 5, 13, 7, 1, -12 },
  { 25, 9, 12, 10, 1, -12 },
  { 39, 7, 12, 8, 1, -12 },
  { 50, 1, 4, 3, 1, -11 },
  { 51, 3, 14, 4, 1, -11 },
  { 57, 3, 14, 4, 1, -11 },
  { 63, 5, 5, 7, 1, -12 },
  { 67, 6, 7, 7, 1, -9 },
  { 73, 1, 4, 3, 1, -2 },
  { 74, 4, 1, 5, 0, -5 },
  { 75, 1, 1, 3, 1, -1 },
  { 76, 5, 11, 5, 0, -11 },
  { 83, 5, 12, 7, 1, -12 },
  { 91, 3, 11, 7, 1, -11 },
  { 96, 5, 12, 7, 1, -12 },
  { 104, 5, 12, 7, 1, -12 },
  { 112, 7, 11, 7, 0, -11 },
  { 122, 5, 11, 7, 1, -11 },
  { 129, 5, 12, 7, 1, -12 },
  { 137, 5, 11, 7, 1, -11 },
  { 144, 6, 12, 7, 1, -12 },
  { 153, 5, 12, 7, 1, -12 },
  { 161, 1, 9, 3, 1, -9 },
  { 163, 1, 11, 3, 1, -9 },
  { 165, 6, 7, 7, 1, -9 },
  { 171, 6, 4, 7, 1, -8 },
  { 174, 6, 7, 7, 1, -9 },
  { 180, 5, 12, 5, 0, -12 },
  { 188, 9, 12, 11, 1, -11 },
  { 202, 7, 11, 7, 0, -11 },
  { 212, 6, 11, 8, 1, -11 },
  { 221, 6, 12, 8, 1, -12 },
  { 230, 7, 11, 9, 1, -11 },
  { 240, 5, 11, 7, 1, -11 },
  { 247, 5, 11, 6, 1, -11 },
  { 254, 7, 12, 9, 1, -12 },
  { 265, 7, 11, 9, 1, -11 },
  { 275, 2, 11, 4, 1, -11 },
  { 278, 3, 14, 3, -1, -11 },
  { 284, 6, 11, 7, 1, -11 },
  { 293, 5, 11, 6, 1, -11 },
  { 300, 9, 11, 12, 1, -11 },
  { 313, 7, 11, 9, 1, -11 },
  { 323, 8, 12, 9, 1, -12 },
  { 335, 6, 11, 7, 1, -11 },
  { 344, 8, 15, 9, 1, -12 },
  { 359, 6, 11, 7, 1, -11 },
  { 368, 5, 12, 7, 1, -12 },
  { 376, 6, 11, 6, 0, -11 },
  { 385, 7, 11, 9, 1, -11 },
  { 395, 7, 11, 7, 0, -11 },
  { 405, 11, 11, 12, 0, -11 },
  { 421, 6, 11, 6, 0, -11 },
  { 430, 6, 11, 6, 0, -11 },
  { 439, 6, 11, 6, 0, -11 },
  { 448, 3, 14, 5, 1, -11 },
  { 454, 5, 11, 5, 0, -11 },
  { 461, 3, 14, 5, 1, -11 },
  { 467, 7, 6, 7, 0, -11 },
  { 473, 6, 1, 6, 0, 1 },
  { 474, 2, 2, 4, 1, -12 },
  { 475, 5, 9, 7, 1, -9 },
  { 481, 6, 12, 8, 1, -12 },
  { 490, 4, 9, 6, 1, -9 },
  { 495, 5, 12, 8, 1, -12 },
  { 503, 5, 9, 7, 1, -9 },
  { 509, 4, 12, 4, 0, -12 },
  { 515, 5, 13, 8, 1, -9 },
  { 524, 5, 12, 7, 1, -12 },
  { 532, 1, 12, 3, 1, -12 },
  { 534, 2, 16, 3, 0, -12 },
  { 538, 5, 12, 6, 1, -12 },
  { 546, 1, 12, 3, 1, -12 },
  { 548, 9, 9, 11, 1, -9 },
  { 559, 5, 9, 7, 1, -9 },
  { 565, 6, 9, 7, 1, -9 },
  { 572, 6, 13, 8, 1, -9 },
  { 582, 5, 13, 8, 1, -9 },
  { 591, 4, 9, 5, 1, -9 },
  { 596, 4, 9, 6, 1, -9 },
  { 601, 4, 11, 4, 0, -11 },
  { 607, 5, 8, 7, 1, -8 },
  { 612, 6, 8, 6, 0, -8 },
  { 618, 9, 8, 9, 0, -8 },
  { 627, 6, 8, 6, 0, -8 },
  { 633, 6, 12, 6, 0, -8 },
  { 642, 4, 8, 5, 1, -8 },
  { 646, 4, 14, 6, 1, -11 },
  { 653, 1, 16, 7, 3, -12 },
  { 655, 4, 14, 6, 1, -11 },
  { 662, 6, 1, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_ExtraLight16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight16pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT16PT7B_H_
