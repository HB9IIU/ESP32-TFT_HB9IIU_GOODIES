#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT68PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight68pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0xE0, 0x3B, 0x01, 0xD8, 0x0E, 0xC0, 0x76, 0x03, 0xB0, 0x1D,
  0x80, 0xEC, 0x07, 0x60, 0x3B, 0x01, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0xB0,
  0x0D, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x30, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x60, 0x06, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x06, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01,
  0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x30,
  0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80,
  0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x1F, 0x18, 0x7C, 0x3C, 0x18, 0x0C, 0x38, 0x18, 0x00,
  0x70, 0x18, 0x00, 0x60, 0x18, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x18, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00,
  0xE0, 0x18, 0x00, 0xE0, 0x18, 0x00, 0x70, 0x18, 0x00, 0x70, 0x18, 0x00,
  0x38, 0x18, 0x00, 0x1E, 0x18, 0x00, 0x0F, 0x18, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1B, 0xE0,
  0x00, 0x18, 0xF0, 0x00, 0x18, 0x78, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x0E,
  0x00, 0x18, 0x06, 0x00, 0x18, 0x07, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03,
  0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x07,
  0x00, 0x18, 0x07, 0x00, 0x18, 0x06, 0x00, 0x18, 0x0E, 0x80, 0x18, 0x1C,
  0xE0, 0x18, 0x38, 0xFC, 0x19, 0xF0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x07, 0xE0, 0x00, 0x0C, 0x00, 0x3F,
  0xC0, 0x00, 0x70, 0x01, 0xC3, 0x80, 0x01, 0x80, 0x0E, 0x07, 0x00, 0x06,
  0x00, 0x30, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0xE0, 0x07, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x0E, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x01,
  0x80, 0x70, 0x00, 0xE0, 0x06, 0x01, 0x80, 0x03, 0x80, 0x1C, 0x06, 0x00,
  0x0E, 0x00, 0x70, 0x30, 0x00, 0x38, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0x07,
  0x07, 0x00, 0x03, 0x80, 0x1C, 0x18, 0x00, 0x0E, 0x00, 0x60, 0x60, 0x00,
  0x38, 0x01, 0x83, 0x01, 0xE0, 0x60, 0x06, 0x0C, 0x1F, 0xC1, 0x80, 0x18,
  0x70, 0xE3, 0x86, 0x00, 0xE1, 0x87, 0x07, 0x1C, 0x03, 0x86, 0x18, 0x0E,
  0x70, 0x0C, 0x30, 0xE0, 0x38, 0xC0, 0x70, 0xC3, 0x00, 0x63, 0x81, 0xC7,
  0x0C, 0x01, 0x87, 0x0E, 0x18, 0x70, 0x07, 0x0F, 0xF0, 0x61, 0xC0, 0x1C,
  0x1F, 0x83, 0x86, 0x00, 0x30, 0x00, 0x0C, 0x18, 0x00, 0xC0, 0x00, 0x70,
  0x60, 0x03, 0x00, 0x01, 0x81, 0x80, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x30,
  0x00, 0x38, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x07, 0x01,
  0x80, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x30, 0x00, 0x60, 0x18, 0x00, 0xC0,
  0x03, 0x80, 0x60, 0x03, 0x00, 0x0C, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x03,
  0x00, 0x70, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x30, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0x01, 0x80, 0xC0, 0x07, 0x00, 0x07,
  0x07, 0x00, 0x18, 0x00, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x38,
  0x01, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x03, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x70, 0x00, 0x30, 0x01, 0xC0, 0x00, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x60, 0x00, 0x38, 0x01, 0x80, 0x00, 0x60, 0x0E, 0x00,
  0x01, 0x80, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x03, 0x80,
  0x0E, 0x38, 0x07, 0x00, 0x30, 0xC0, 0x0C, 0x00, 0xC7, 0x00, 0x38, 0x03,
  0x18, 0x00, 0x70, 0x0C, 0xE0, 0x00, 0xE0, 0x73, 0x80, 0x03, 0x81, 0x8C,
  0x00, 0x07, 0x06, 0x30, 0x00, 0x0E, 0x38, 0xC0, 0x00, 0x38, 0xC3, 0x00,
  0x00, 0x77, 0x0C, 0x00, 0x00, 0xFC, 0x30, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x1E, 0x06, 0x00, 0x00, 0xFC, 0x1C, 0x00, 0x07,
  0x70, 0x78, 0x00, 0x38, 0xE0, 0xF0, 0x01, 0xC1, 0xC1, 0xE0, 0x1E, 0x07,
  0x03, 0xFF, 0xF0, 0x0E, 0x07, 0xFF, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00,
  0xED, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x00, 0x38, 0x03, 0x80, 0x38,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x10, 0x0C,
  0x02, 0x78, 0x30, 0x7B, 0xF8, 0xC7, 0xF0, 0xFF, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0C, 0xC0, 0x00, 0x61, 0x80, 0x03,
  0x87, 0x00, 0x1C, 0x0E, 0x00, 0x60, 0x18, 0x03, 0x80, 0x70, 0x1C, 0x00,
  0xE0, 0x10, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x71, 0xCE, 0x38,
  0xE3, 0x8C, 0x71, 0xC7, 0x18, 0xE3, 0x8C, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xEF, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xC1, 0xE0, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x30, 0x00, 0x0E, 0x30,
  0x00, 0x06, 0x70, 0x00, 0x06, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60,
  0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x0C,
  0x00, 0x38, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x70, 0x03, 0xC1, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x03, 0xC0,
  0x3E, 0x03, 0xF0, 0x3B, 0x87, 0x9C, 0x78, 0xE7, 0x87, 0x78, 0x3F, 0x01,
  0xF0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0x03,
  0xE0, 0x78, 0x00, 0xF0, 0x30, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x3F, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0x40, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0xC0, 0x00,
  0x78, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x39, 0x80, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x1C,
  0x60, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x60, 0xC0,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x70, 0x30, 0x00, 0x03, 0x81, 0x80, 0x00,
  0x38, 0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x1C, 0x03, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x07, 0x00, 0x30,
  0x00, 0x70, 0x01, 0x80, 0x03, 0x80, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x0E, 0x00,
  0x06, 0x00, 0x60, 0x00, 0x30, 0x07, 0x00, 0x01, 0x80, 0x70, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0x60, 0x38, 0x00, 0x03, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x7F, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xC1, 0xF8, 0x10, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x10, 0x00, 0x3C, 0x3C,
  0x00, 0xF0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFC, 0x38, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x7E, 0x00, 0xC1,
  0xFF, 0xC0, 0xC7, 0xF7, 0xE0, 0xCF, 0x00, 0xF0, 0xCC, 0x00, 0x38, 0xD8,
  0x00, 0x1C, 0xD0, 0x00, 0x1C, 0xF0, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x01, 0xF0, 0x7C, 0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x01, 0xC1,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x06,
  0x38, 0x00, 0x03, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x63, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFF, 0x80, 0x01, 0xE1, 0xE0, 0x01, 0xE0, 0x78, 0x01, 0xC0, 0x0F, 0x01,
  0xC0, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x0E,
  0x60, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00,
  0x01, 0xC3, 0x80, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0x83, 0xE0, 0x1E, 0x00, 0xF0, 0x1C, 0x00, 0x70,
  0x38, 0x00, 0x38, 0x30, 0x00, 0x18, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x0C,
  0x60, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0x60, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x1F,
  0x38, 0x00, 0x37, 0x1C, 0x00, 0x77, 0x0F, 0x01, 0xE7, 0x07, 0xFF, 0xC7,
  0x03, 0xFF, 0x07, 0x00, 0x30, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x20, 0x0F, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0x3C, 0xF3, 0xCF,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x71, 0xC7, 0x38, 0xE3, 0x8E,
  0x31, 0xC7, 0x1C, 0x63, 0x8C, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x07, 0xFF, 0xC3, 0xF0, 0x7C, 0x30, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x1F, 0x80, 0x0C, 0x30,
  0x00, 0xFF, 0xF0, 0x0E, 0x70, 0x01, 0xF0, 0xF0, 0x0E, 0x70, 0x03, 0x80,
  0x70, 0x06, 0x60, 0x07, 0x00, 0x60, 0x06, 0x60, 0x06, 0x00, 0x60, 0x06,
  0xE0, 0x0E, 0x00, 0x60, 0x06, 0xE0, 0x0C, 0x00, 0x60, 0x07, 0xC0, 0x0C,
  0x00, 0x60, 0x07, 0xC0, 0x1C, 0x00, 0x60, 0x07, 0xC0, 0x18, 0x00, 0x60,
  0x07, 0xC0, 0x18, 0x00, 0x60, 0x07, 0xC0, 0x18, 0x00, 0x60, 0x07, 0xC0,
  0x18, 0x00, 0x60, 0x07, 0xC0, 0x18, 0x00, 0xE0, 0x07, 0xC0, 0x18, 0x00,
  0xE0, 0x07, 0xC0, 0x18, 0x00, 0xE0, 0x06, 0xC0, 0x18, 0x00, 0xE0, 0x06,
  0xC0, 0x18, 0x00, 0xE0, 0x06, 0xC0, 0x18, 0x00, 0xE0, 0x0E, 0xC0, 0x1C,
  0x01, 0xE0, 0x0E, 0xC0, 0x1C, 0x01, 0xE0, 0x0C, 0xE0, 0x0C, 0x01, 0xA0,
  0x1C, 0xE0, 0x0E, 0x03, 0x30, 0x18, 0xE0, 0x07, 0x06, 0x38, 0x78, 0x60,
  0x03, 0xFE, 0x1F, 0xF0, 0x60, 0x01, 0xFC, 0x0F, 0xE0, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x10, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x03, 0x83, 0x00, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0x80, 0x30, 0x00, 0x07, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x30, 0x01, 0x80,
  0x00, 0xE0, 0x03, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x06,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0x80, 0x38, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x1C, 0x0C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x0E, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x18, 0x00, 0x3F, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x00, 0xE3,
  0x00, 0x00, 0x79, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x03,
  0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x33, 0x00, 0x00, 0x19, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0x60, 0x00,
  0x07, 0x30, 0x00, 0x07, 0x18, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x86, 0x00,
  0x07, 0x83, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x60,
  0x00, 0x7C, 0x30, 0x00, 0x0F, 0x18, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x03,
  0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x0E, 0xC0, 0x00,
  0x07, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x98, 0x00, 0x03, 0xCC, 0x00,
  0x03, 0xC6, 0x00, 0x03, 0xC3, 0x00, 0x1F, 0xC1, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xF8,
  0x1F, 0x80, 0xF8, 0x00, 0x60, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x40, 0x3E, 0x00, 0x70, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x60, 0x01, 0xF8, 0x0C, 0x00, 0x07, 0x81, 0x80, 0x00, 0x78,
  0x30, 0x00, 0x07, 0x86, 0x00, 0x00, 0x78, 0xC0, 0x00, 0x07, 0x18, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03,
  0x30, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x07, 0x18, 0x00,
  0x01, 0xE3, 0x00, 0x00, 0x38, 0x60, 0x00, 0x0E, 0x0C, 0x00, 0x07, 0x81,
  0x80, 0x03, 0xE0, 0x30, 0x0F, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEC, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEC, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xC0, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x40, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x67, 0x00, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x06, 0x1C,
  0x00, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0x18, 0x3C, 0x00, 0x00, 0x30, 0x3C,
  0x00, 0x00, 0x60, 0x3C, 0x00, 0x00, 0xC0, 0x3F, 0x00, 0x0F, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xC0, 0xFF, 0xFF, 0xFC, 0x7C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x87, 0xFF, 0xFF, 0xE0, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x39, 0xF9, 0xFF, 0x8F,
  0xF0, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x1C, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xF0, 0xC0,
  0x00, 0xE0, 0xC0, 0x01, 0xC0, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x80, 0xC0,
  0x07, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x1E, 0x00, 0xC0, 0x1C, 0x00, 0xC0,
  0x38, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0xE0, 0x00, 0xC1,
  0xC0, 0x00, 0xC3, 0xC0, 0x00, 0xC3, 0x80, 0x00, 0xC7, 0xC0, 0x00, 0xCF,
  0xC0, 0x00, 0xCC, 0xE0, 0x00, 0xDC, 0xE0, 0x00, 0xF8, 0x70, 0x00, 0xF0,
  0x70, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x07, 0x00, 0xC0,
  0x03, 0x80, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xC0,
  0x00, 0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xEC, 0x00, 0x00, 0x00, 0x6F,
  0x70, 0x00, 0x00, 0x07, 0x7B, 0x80, 0x00, 0x00, 0x3B, 0xCC, 0x00, 0x00,
  0x01, 0x9E, 0x70, 0x00, 0x00, 0x1C, 0xF3, 0x80, 0x00, 0x00, 0xE7, 0x8C,
  0x00, 0x00, 0x06, 0x3C, 0x70, 0x00, 0x00, 0x71, 0xE3, 0x80, 0x00, 0x03,
  0x8F, 0x0C, 0x00, 0x00, 0x18, 0x78, 0x70, 0x00, 0x01, 0xC3, 0xC3, 0x80,
  0x00, 0x0E, 0x1E, 0x0C, 0x00, 0x00, 0x60, 0xF0, 0x70, 0x00, 0x07, 0x07,
  0x83, 0x80, 0x00, 0x38, 0x3C, 0x0C, 0x00, 0x01, 0x81, 0xE0, 0x70, 0x00,
  0x1C, 0x0F, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x0C, 0x00, 0x06, 0x03, 0xC0,
  0x70, 0x00, 0x70, 0x1E, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x0C, 0x00, 0x18,
  0x07, 0x80, 0x70, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x0E, 0x01, 0xE0, 0x0C,
  0x00, 0x60, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03,
  0xC0, 0x0C, 0x01, 0x80, 0x1E, 0x00, 0x70, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0xE0, 0x07, 0x80, 0x0C, 0x06, 0x00, 0x3C, 0x00, 0x70, 0x70, 0x01, 0xE0,
  0x03, 0x83, 0x80, 0x0F, 0x00, 0x0C, 0x18, 0x00, 0x78, 0x00, 0x71, 0xC0,
  0x03, 0xC0, 0x03, 0x8E, 0x00, 0x1E, 0x00, 0x0C, 0x60, 0x00, 0xF0, 0x00,
  0x77, 0x00, 0x07, 0x80, 0x03, 0xB8, 0x00, 0x3C, 0x00, 0x0D, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xB0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0x60, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0x78, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xE1, 0x80, 0x00, 0x3C,
  0x38, 0x00, 0x07, 0x83, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x06, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x78, 0x0C, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0,
  0x18, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x80, 0x30, 0x00, 0xF0, 0x07, 0x00,
  0x1E, 0x00, 0x60, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x00, 0xC0, 0x0F, 0x00,
  0x1C, 0x01, 0xE0, 0x01, 0x80, 0x3C, 0x00, 0x38, 0x07, 0x80, 0x03, 0x00,
  0xF0, 0x00, 0x70, 0x1E, 0x00, 0x06, 0x03, 0xC0, 0x00, 0xE0, 0x78, 0x00,
  0x0C, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x18, 0x3C, 0x00, 0x03, 0x87,
  0x80, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x73, 0xC0, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0x1C, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00,
  0x70, 0x07, 0x80, 0x00, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x07,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x30, 0x01, 0xF8,
  0xC0, 0x00, 0xF3, 0x00, 0x01, 0xCC, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1B, 0x00,
  0x00, 0xEC, 0x00, 0x03, 0xB0, 0x00, 0x1C, 0xC0, 0x01, 0xE3, 0x00, 0x1F,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0C,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x70,
  0x07, 0x80, 0x00, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0xFF, 0x40, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0x07, 0xE0, 0xC0, 0x00, 0xF0, 0xC0,
  0x00, 0x78, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x01, 0xE0, 0xC0, 0x07, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x07, 0x00, 0xC0,
  0x03, 0x80, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0xC0, 0xC0,
  0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x70, 0xC0,
  0x00, 0x38, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x1C, 0xC0,
  0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x07, 0xE0, 0xFE, 0x1F, 0x00, 0x0C, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x80, 0x00, 0x78, 0xF0, 0x01, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x70, 0x07, 0xC0, 0x1E, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x01, 0x81, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00,
  0x38, 0x1C, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0x80, 0x18, 0x00, 0x0E, 0x00,
  0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x01, 0x80,
  0x06, 0x00, 0x06, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03,
  0x00, 0x00, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0x80,
  0x00, 0x18, 0x06, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x03, 0x86, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x07, 0xC0,
  0x00, 0x0E, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x06, 0xC0,
  0x00, 0x0C, 0x70, 0x00, 0x06, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x06, 0xE0,
  0x00, 0x1C, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x60,
  0x00, 0x18, 0x38, 0x00, 0x0C, 0x60, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x70,
  0x00, 0x38, 0x18, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x30,
  0x00, 0x30, 0x1C, 0x00, 0x1C, 0x30, 0x00, 0x70, 0x1C, 0x00, 0x18, 0x30,
  0x00, 0x70, 0x0C, 0x00, 0x18, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0x60, 0x0E, 0x00, 0x38, 0x18, 0x00, 0x60, 0x0E, 0x00, 0x30, 0x18,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x07, 0x00, 0x70, 0x0C,
  0x01, 0xC0, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x03, 0x00, 0x60, 0x0E,
  0x01, 0xC0, 0x03, 0x80, 0xE0, 0x0E, 0x01, 0x80, 0x03, 0x80, 0xE0, 0x06,
  0x03, 0x80, 0x03, 0x80, 0xC0, 0x06, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x07,
  0x03, 0x80, 0x01, 0xC0, 0xC0, 0x07, 0x03, 0x00, 0x01, 0xC1, 0xC0, 0x03,
  0x07, 0x00, 0x01, 0xC1, 0xC0, 0x03, 0x07, 0x00, 0x00, 0xC1, 0x80, 0x03,
  0x87, 0x00, 0x00, 0xC1, 0x80, 0x03, 0x86, 0x00, 0x00, 0xE3, 0x80, 0x03,
  0x86, 0x00, 0x00, 0xE3, 0x80, 0x01, 0x8E, 0x00, 0x00, 0x63, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x63, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x77, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x77, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x36, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x36, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0x70, 0x00, 0x06,
  0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x30, 0x1C, 0x00, 0x0E, 0x01, 0x80,
  0x01, 0xC0, 0x38, 0x00, 0x70, 0x03, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0,
  0x60, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x06, 0x18, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0C, 0xC0,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x63, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03,
  0x07, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x18, 0x0E, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0xE0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xC0,
  0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x0E, 0x30, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xC0,
  0x38, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x03,
  0x80, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x60, 0x1C, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0x03, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x06, 0x1C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0E, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x86, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xE0, 0x18,
  0x00, 0x18, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x06, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0x81, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0C, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x00,
  0x78, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xF0, 0x38, 0x03, 0xC1, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0xC1, 0xFF,
  0x0E, 0x1F, 0x00, 0x73, 0xC0, 0x03, 0x9C, 0x00, 0x1D, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0x60,
  0x01, 0xBB, 0x80, 0x0D, 0xCE, 0x01, 0xCE, 0x3F, 0xFC, 0x30, 0xFF, 0xC1,
  0x80, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0xE0, 0xFF, 0xC0, 0xE3, 0xFF, 0xE0, 0xE7, 0x80, 0xF0,
  0xEE, 0x00, 0x38, 0xEC, 0x00, 0x1C, 0xF8, 0x00, 0x1C, 0xF8, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x06, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0C, 0xF8, 0x00, 0x1C,
  0xCC, 0x00, 0x38, 0xCE, 0x00, 0x78, 0xC7, 0x00, 0xF0, 0xC3, 0xFF, 0xE0,
  0xC1, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0x01,
  0xFF, 0xF0, 0x3C, 0x03, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x30, 0x3F, 0xFF,
  0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x3C, 0x03, 0x01, 0xFF, 0x83, 0x03, 0xFF, 0xE3, 0x07,
  0x80, 0xF3, 0x0E, 0x00, 0x33, 0x1C, 0x00, 0x1B, 0x1C, 0x00, 0x0F, 0x38,
  0x00, 0x0F, 0x38, 0x00, 0x07, 0x30, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x30, 0x00, 0x07, 0x38, 0x00, 0x0F, 0x38,
  0x00, 0x0B, 0x1C, 0x00, 0x1B, 0x0E, 0x00, 0x33, 0x0F, 0x00, 0xF3, 0x07,
  0xFF, 0xC3, 0x01, 0xFF, 0x83, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3C, 0x07, 0x80, 0xE0, 0x07, 0x03, 0x80,
  0x07, 0x07, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x60, 0x00,
  0x19, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x08, 0x1E, 0x00,
  0x70, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0xF0, 0x1E, 0x18, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xFF, 0xFC,
  0x3F, 0xFF, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF,
  0x83, 0x03, 0xFF, 0xE3, 0x07, 0x80, 0x73, 0x0E, 0x00, 0x3B, 0x1C, 0x00,
  0x1B, 0x1C, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x07, 0x30, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x30, 0x00,
  0x0F, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x1B, 0x1C, 0x00, 0x1B, 0x0E, 0x00,
  0x33, 0x0F, 0x00, 0xE3, 0x07, 0xFF, 0xC3, 0x01, 0xFF, 0x83, 0x00, 0x3C,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x30, 0x00,
  0x38, 0x3E, 0x01, 0xF0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0xE0, 0xFF, 0x83, 0x8F, 0xFF, 0x8E,
  0x78, 0x1F, 0x3B, 0x80, 0x1C, 0xEC, 0x00, 0x3B, 0xE0, 0x00, 0xEF, 0x80,
  0x01, 0xBC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xEF, 0xFF, 0x60,
  0x00, 0x00, 0x00, 0x0E, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x03, 0x80,
  0xF0, 0x3C, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x01, 0xC8, 0xF3, 0xF8, 0xFC, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0xE7, 0x00, 0x06, 0x38, 0x00, 0x71, 0xC0, 0x07,
  0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x38, 0x1C, 0x03, 0x80, 0xE0,
  0x1C, 0x07, 0x01, 0xC0, 0x38, 0x1C, 0x01, 0xC0, 0xC0, 0x0E, 0x0E, 0x00,
  0x70, 0xE0, 0x03, 0x8F, 0x00, 0x1C, 0x78, 0x00, 0xE7, 0xE0, 0x07, 0x77,
  0x00, 0x3B, 0x1C, 0x01, 0xF0, 0xE0, 0x0F, 0x83, 0x80, 0x78, 0x1C, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x01,
  0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x07, 0x1C,
  0x00, 0x38, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x1D, 0xC0, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x03, 0x07, 0xFC, 0x03, 0xFE, 0x0C, 0x3F, 0xF8, 0x1F, 0xFE, 0x31,
  0xC0, 0xF0, 0xE0, 0x38, 0xCC, 0x01, 0xC7, 0x00, 0x73, 0x60, 0x03, 0xB8,
  0x00, 0xCD, 0x80, 0x06, 0xC0, 0x03, 0xBC, 0x00, 0x1E, 0x00, 0x0E, 0xF0,
  0x00, 0x78, 0x00, 0x1B, 0x80, 0x01, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0x00,
  0x01, 0xB8, 0x00, 0x0C, 0x00, 0x06, 0xE0, 0x00, 0x30, 0x00, 0x1F, 0x80,
  0x00, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0x00, 0x01, 0xF8, 0x00, 0x0C, 0x00,
  0x07, 0xE0, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0x00, 0x01, 0xF8, 0x00, 0x0C, 0x00, 0x07, 0xE0, 0x00, 0x30, 0x00,
  0x1F, 0x80, 0x00, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0x00, 0x01, 0xF8, 0x00,
  0x0C, 0x00, 0x07, 0xE0, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x00, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0x00, 0x01, 0xF8, 0x00, 0x0C, 0x00, 0x07, 0xE0, 0x00,
  0x30, 0x00, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0x00, 0x01,
  0xF8, 0x00, 0x0C, 0x00, 0x07, 0xE0, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x00,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0x00, 0x01, 0xF8, 0x00, 0x0C, 0x00, 0x07,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x1E, 0x03, 0x03, 0xFE, 0x0C, 0x3F,
  0xFE, 0x31, 0xC0, 0x3C, 0xCE, 0x00, 0x73, 0x30, 0x00, 0xED, 0x80, 0x03,
  0xB4, 0x00, 0x06, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xCE, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0xC0,
  0x00, 0x07, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x18,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0xC0, 0xFF, 0xC0, 0xC3, 0xFF, 0xE0, 0xC7, 0x80, 0xF0, 0xC6, 0x00,
  0x38, 0xCC, 0x00, 0x1C, 0xD8, 0x00, 0x1C, 0xD8, 0x00, 0x0E, 0xD0, 0x00,
  0x0E, 0xF0, 0x00, 0x06, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x06, 0xF0, 0x00,
  0x0E, 0xF0, 0x00, 0x0E, 0xF8, 0x00, 0x0C, 0xF8, 0x00, 0x1C, 0xEC, 0x00,
  0x38, 0xEE, 0x00, 0x78, 0xE7, 0x80, 0xF0, 0xE3, 0xFF, 0xE0, 0xE0, 0xFF,
  0x80, 0xE0, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x83, 0x03, 0xFF, 0xE3, 0x07, 0x80,
  0xF3, 0x0E, 0x00, 0x33, 0x1E, 0x00, 0x1B, 0x1C, 0x00, 0x0B, 0x38, 0x00,
  0x0F, 0x38, 0x00, 0x07, 0x30, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x03, 0x60, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00,
  0x07, 0x70, 0x00, 0x07, 0x30, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x38, 0x00,
  0x1B, 0x1C, 0x00, 0x1B, 0x0E, 0x00, 0x33, 0x0F, 0x80, 0xE3, 0x07, 0xFF,
  0xC3, 0x01, 0xFF, 0x83, 0x00, 0x3C, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x19, 0x83, 0xFF, 0x0F, 0xFE, 0x3C, 0x1C,
  0x60, 0x19, 0x80, 0x32, 0x00, 0x6C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0x9E, 0x00, 0xE7,
  0x00, 0x04, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xD0, 0x00, 0x7B, 0x80,
  0x1E, 0x7F, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x0E, 0x00,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xF7, 0x00,
  0x07, 0xDC, 0x00, 0x37, 0x38, 0x01, 0x9C, 0xF0, 0x1E, 0x71, 0xFF, 0xF0,
  0xC3, 0xFF, 0x03, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x18, 0x00, 0x38, 0x18, 0x00, 0x38,
  0x1C, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x07, 0x00, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0x80,
  0x01, 0x81, 0x80, 0x01, 0x83, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x1F, 0x80,
  0x01, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x01, 0x98, 0x00, 0x1E, 0x00,
  0x06, 0x60, 0x00, 0x7C, 0x00, 0x39, 0xC0, 0x03, 0xB0, 0x00, 0xE7, 0x00,
  0x0C, 0xC0, 0x03, 0x0C, 0x00, 0x33, 0x00, 0x0C, 0x30, 0x00, 0xCE, 0x00,
  0x70, 0xE0, 0x07, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x60, 0x06, 0x06, 0x00,
  0x61, 0x80, 0x18, 0x18, 0x01, 0x87, 0x00, 0x60, 0x70, 0x0E, 0x1C, 0x03,
  0x81, 0xC0, 0x38, 0x30, 0x0E, 0x07, 0x00, 0xC0, 0xC0, 0x30, 0x0C, 0x03,
  0x03, 0x80, 0xC0, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x18, 0x1C,
  0x03, 0x81, 0x80, 0x60, 0x60, 0x06, 0x06, 0x01, 0x81, 0x80, 0x18, 0x38,
  0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0C, 0x38, 0x01, 0xC3, 0x00, 0x30, 0xC0,
  0x03, 0x0C, 0x00, 0xC3, 0x00, 0x0C, 0x70, 0x03, 0x8C, 0x00, 0x39, 0xC0,
  0x0E, 0x70, 0x00, 0xE6, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x66, 0x00,
  0x06, 0xE0, 0x01, 0xD8, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x38, 0xE0, 0x00, 0x60, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x01,
  0xC0, 0x0E, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x01, 0xC0, 0x07,
  0x03, 0x80, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x1B, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x1C, 0xC0,
  0x00, 0x71, 0xC0, 0x00, 0xE1, 0x80, 0x03, 0x83, 0x80, 0x07, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x0E, 0x07,
  0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x60, 0x00, 0x39, 0xC0,
  0x00, 0x77, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x30,
  0x00, 0x07, 0x38, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x18,
  0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x0E,
  0x00, 0x18, 0x0E, 0x00, 0x38, 0x06, 0x00, 0x38, 0x06, 0x00, 0x30, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x60, 0x03, 0x80, 0x60, 0x03,
  0x80, 0xE0, 0x01, 0x80, 0xE0, 0x01, 0x80, 0xC0, 0x01, 0xC1, 0xC0, 0x01,
  0xC1, 0xC0, 0x00, 0xC1, 0x80, 0x00, 0xE1, 0x80, 0x00, 0xE3, 0x80, 0x00,
  0x63, 0x80, 0x00, 0x63, 0x00, 0x00, 0x77, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x87, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x40, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x3F, 0x00, 0x0F,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0xBF, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x03, 0xF0, 0xF8, 0x00,
  0x7F, 0xF4, 0x00, 0x0F, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraLight68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 49, 14, 5, -49 },
  { 26, 13, 18, 22, 4, -49 },
  { 56, 31, 49, 34, 1, -49 },
  { 246, 24, 56, 31, 3, -52 },
  { 414, 38, 50, 44, 3, -49 },
  { 652, 30, 50, 34, 3, -49 },
  { 840, 3, 18, 12, 4, -49 },
  { 847, 13, 60, 18, 3, -49 },
  { 945, 12, 60, 18, 3, -49 },
  { 1035, 22, 22, 28, 3, -52 },
  { 1096, 25, 32, 31, 3, -40 },
  { 1196, 6, 16, 13, 3, -7 },
  { 1208, 15, 3, 19, 2, -20 },
  { 1214, 4, 5, 14, 5, -5 },
  { 1217, 21, 49, 23, 1, -49 },
  { 1346, 24, 50, 31, 3, -49 },
  { 1496, 13, 49, 31, 6, -49 },
  { 1576, 24, 49, 31, 3, -49 },
  { 1723, 24, 50, 31, 3, -49 },
  { 1873, 29, 49, 31, 1, -49 },
  { 2051, 23, 50, 31, 4, -49 },
  { 2195, 24, 50, 31, 4, -49 },
  { 2345, 24, 49, 31, 3, -49 },
  { 2492, 25, 50, 31, 3, -49 },
  { 2649, 24, 50, 31, 3, -49 },
  { 2799, 4, 36, 14, 5, -36 },
  { 2817, 6, 45, 14, 3, -36 },
  { 2851, 25, 29, 31, 3, -39 },
  { 2942, 25, 16, 31, 3, -32 },
  { 2992, 25, 29, 31, 3, -39 },
  { 3083, 19, 49, 22, 1, -49 },
  { 3200, 40, 55, 47, 4, -49 },
  { 3475, 31, 49, 31, 0, -49 },
  { 3665, 25, 49, 34, 6, -49 },
  { 3819, 27, 50, 33, 4, -49 },
  { 3988, 27, 49, 37, 6, -49 },
  { 4154, 20, 49, 30, 6, -49 },
  { 4277, 20, 49, 27, 6, -49 },
  { 4400, 31, 50, 40, 4, -49 },
  { 4594, 26, 49, 38, 6, -49 },
  { 4754, 11, 49, 17, 3, -49 },
  { 4822, 13, 61, 14, -4, -49 },
  { 4922, 24, 49, 30, 6, -49 },
  { 5069, 20, 49, 27, 6, -49 },
  { 5192, 37, 49, 49, 6, -49 },
  { 5419, 27, 49, 39, 6, -49 },
  { 5585, 32, 50, 40, 4, -49 },
  { 5785, 22, 49, 31, 6, -49 },
  { 5920, 32, 61, 40, 4, -49 },
  { 6164, 24, 49, 32, 6, -49 },
  { 6311, 24, 50, 30, 3, -49 },
  { 6461, 26, 49, 27, 0, -49 },
  { 6621, 28, 50, 38, 5, -49 },
  { 6796, 30, 49, 30, 0, -49 },
  { 6980, 48, 49, 50, 1, -49 },
  { 7274, 27, 49, 27, 0, -49 },
  { 7440, 26, 49, 26, 0, -49 },
  { 7600, 24, 49, 28, 2, -49 },
  { 7747, 13, 60, 21, 6, -49 },
  { 7845, 21, 49, 23, 1, -49 },
  { 7974, 13, 60, 21, 2, -49 },
  { 8072, 27, 26, 31, 2, -49 },
  { 8160, 27, 2, 27, 0, 6 },
  { 8167, 11, 11, 16, 3, -52 },
  { 8183, 21, 38, 29, 3, -37 },
  { 8283, 24, 53, 33, 5, -52 },
  { 8442, 20, 38, 25, 3, -37 },
  { 8537, 24, 53, 33, 3, -52 },
  { 8696, 23, 38, 30, 3, -37 },
  { 8806, 18, 52, 16, 1, -52 },
  { 8923, 24, 53, 33, 3, -37 },
  { 9082, 22, 52, 32, 5, -52 },
  { 9225, 4, 49, 13, 5, -49 },
  { 9250, 10, 65, 13, -1, -49 },
  { 9332, 21, 52, 26, 5, -52 },
  { 9469, 3, 52, 13, 5, -52 },
  { 9489, 38, 37, 47, 5, -37 },
  { 9665, 22, 37, 32, 5, -37 },
  { 9767, 25, 38, 31, 3, -37 },
  { 9886, 24, 53, 33, 5, -37 },
  { 10045, 24, 53, 33, 3, -37 },
  { 10204, 15, 37, 21, 5, -37 },
  { 10274, 19, 38, 25, 3, -37 },
  { 10365, 15, 46, 17, 1, -45 },
  { 10452, 22, 37, 32, 5, -36 },
  { 10554, 24, 36, 24, 0, -36 },
  { 10662, 38, 36, 40, 1, -36 },
  { 10833, 23, 36, 26, 1, -36 },
  { 10937, 24, 52, 25, 0, -36 },
  { 11093, 18, 36, 22, 2, -36 },
  { 11174, 18, 60, 24, 3, -49 },
  { 11309, 3, 69, 29, 13, -52 },
  { 11335, 18, 60, 24, 3, -49 },
  { 11470, 25, 6, 31, 3, -27 },
};

const GFXfont NotoSans_Condensed_ExtraLight68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight68pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT68PT7B_H_
