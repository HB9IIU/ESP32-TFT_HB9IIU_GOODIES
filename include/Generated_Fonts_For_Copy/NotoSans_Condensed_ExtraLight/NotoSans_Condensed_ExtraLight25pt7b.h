#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT25PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xC0, 0x99, 0x99, 0x99, 0x90, 0x08, 0x81, 0x10, 0x42,
  0x08, 0x41, 0x11, 0xFF, 0xC4, 0x40, 0x88, 0x11, 0x04, 0x20, 0x84, 0x7F,
  0xE2, 0x20, 0x44, 0x08, 0x81, 0x10, 0x42, 0x08, 0x40, 0x08, 0x04, 0x1F,
  0xC9, 0x08, 0x84, 0x42, 0x21, 0x90, 0x68, 0x1C, 0x03, 0x81, 0x20, 0x88,
  0x44, 0x22, 0x11, 0x09, 0x7F, 0x02, 0x01, 0x00, 0x70, 0x21, 0x20, 0x88,
  0x44, 0x21, 0x10, 0x84, 0x82, 0x12, 0x08, 0x48, 0x21, 0x4E, 0x85, 0x49,
  0x29, 0x13, 0x24, 0x40, 0xA1, 0x04, 0x84, 0x12, 0x10, 0x44, 0x42, 0x11,
  0x08, 0x44, 0x40, 0xE0, 0x1C, 0x04, 0x40, 0x88, 0x21, 0x02, 0x20, 0x44,
  0x09, 0x80, 0xE0, 0x18, 0x05, 0x01, 0x10, 0xC1, 0x28, 0x25, 0x02, 0xA0,
  0x24, 0x04, 0x41, 0x47, 0xC4, 0xFE, 0x18, 0x88, 0x44, 0x21, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x08, 0x42, 0x08, 0x41, 0x0C, 0x82, 0x10, 0x42, 0x08,
  0x42, 0x10, 0x86, 0x21, 0x08, 0x42, 0x11, 0x08, 0x84, 0x40, 0x08, 0x08,
  0x08, 0xFF, 0x08, 0x14, 0x24, 0x42, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x43, 0xFE, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x55, 0xA0, 0xF8, 0xC0,
  0x01, 0x01, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x40, 0x40, 0xC0, 0x1E, 0x11, 0x90, 0x48, 0x24, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0A, 0x05, 0x04, 0x82,
  0x23, 0x0F, 0x00, 0x09, 0xDB, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x40, 0x3E, 0x61, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x7F, 0xC0,
  0x3E, 0x61, 0x80, 0x40, 0x10, 0x08, 0x08, 0x04, 0x04, 0x3C, 0x03, 0x00,
  0x40, 0x10, 0x08, 0x04, 0x02, 0x02, 0x81, 0x7F, 0x00, 0x01, 0x80, 0x30,
  0x0A, 0x01, 0x40, 0x48, 0x11, 0x02, 0x20, 0x84, 0x10, 0x84, 0x10, 0x82,
  0x20, 0x44, 0x09, 0xFF, 0xC0, 0x20, 0x04, 0x00, 0x80, 0x10, 0x7F, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xF8, 0x43, 0x00, 0x80, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x02, 0x83, 0x7F, 0x00, 0x0F, 0x08, 0x08, 0x08, 0x04,
  0x02, 0x01, 0x01, 0x3C, 0xA1, 0x60, 0x70, 0x30, 0x18, 0x0A, 0x05, 0x02,
  0x81, 0x21, 0x1F, 0x00, 0xFF, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08,
  0x04, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10,
  0x00, 0x3E, 0x30, 0x90, 0x28, 0x14, 0x0A, 0x0D, 0x04, 0x64, 0x0C, 0x1B,
  0x10, 0x48, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x41, 0x1F, 0x00, 0x3E, 0x21,
  0x90, 0x50, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x41, 0xA0, 0xCF, 0x20, 0x10,
  0x08, 0x08, 0x04, 0x04, 0x02, 0x3E, 0x00, 0xC0, 0x18, 0x50, 0x00, 0x05,
  0x5A, 0x00, 0x81, 0x83, 0x06, 0x0C, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x40, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x80, 0x30, 0x06, 0x00,
  0x40, 0x18, 0x0C, 0x18, 0x10, 0x30, 0x60, 0x00, 0xFA, 0x30, 0x41, 0x04,
  0x10, 0x42, 0x10, 0xC2, 0x08, 0x20, 0x80, 0x00, 0x61, 0x80, 0x03, 0xE0,
  0x18, 0x20, 0x40, 0x21, 0x00, 0x22, 0x00, 0x48, 0x38, 0x50, 0x88, 0xA2,
  0x11, 0x84, 0x23, 0x10, 0x86, 0x21, 0x0C, 0x42, 0x18, 0x84, 0x30, 0x8C,
  0x91, 0xEF, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x7F, 0x00,
  0x04, 0x00, 0xC0, 0x28, 0x05, 0x00, 0x90, 0x12, 0x04, 0x40, 0x88, 0x10,
  0x84, 0x10, 0xFE, 0x10, 0x42, 0x04, 0x80, 0x90, 0x12, 0x01, 0x80, 0x30,
  0x04, 0xFC, 0x41, 0xA0, 0x70, 0x18, 0x0C, 0x06, 0x05, 0x02, 0xFE, 0x41,
  0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x7F, 0x00, 0x0F, 0xC4,
  0x12, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x10, 0x03, 0xF0, 0xFC, 0x20, 0xC8,
  0x1A, 0x02, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x0A, 0x06, 0x83, 0x3F, 0x00, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x07, 0xE1, 0x81, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x1F, 0x80,
  0x14, 0x01, 0x40, 0x14, 0x01, 0x60, 0x12, 0x01, 0x10, 0x10, 0xFF, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xFF, 0xE0, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0xF2, 0x22,
  0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x2F, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0x80, 0xC0, 0xA0,
  0x90, 0xC8, 0x44, 0x42, 0x41, 0x20, 0xB0, 0x68, 0x22, 0x11, 0x88, 0x44,
  0x12, 0x09, 0x02, 0x81, 0x40, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0xFC, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE8, 0x05, 0xA0, 0x16, 0x80, 0x59, 0x02, 0x64, 0x09,
  0x90, 0x26, 0x21, 0x18, 0x84, 0x62, 0x11, 0x84, 0x86, 0x12, 0x18, 0x48,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x80, 0x70, 0x1C, 0x06, 0x81, 0xA0,
  0x64, 0x19, 0x06, 0x21, 0x88, 0x61, 0x18, 0x46, 0x09, 0x82, 0x60, 0x58,
  0x16, 0x03, 0x80, 0xE0, 0x10, 0x0F, 0x81, 0x04, 0x20, 0x24, 0x02, 0x40,
  0x14, 0x01, 0x40, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40,
  0x14, 0x01, 0x40, 0x32, 0x02, 0x30, 0x40, 0xF8, 0xFC, 0x82, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x83, 0x8E, 0xF0, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x0F, 0x81, 0x04, 0x20, 0x24, 0x02, 0x40, 0x14, 0x01, 0x40,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x01, 0x40, 0x14, 0x01, 0x40,
  0x32, 0x02, 0x30, 0x40, 0xF8, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0xF8,
  0x41, 0x20, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x82, 0x7E, 0x22, 0x10,
  0x88, 0x44, 0x12, 0x09, 0x02, 0x81, 0x40, 0x40, 0x3F, 0x30, 0x50, 0x10,
  0x08, 0x04, 0x01, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x04,
  0x02, 0x02, 0x01, 0x7F, 0x00, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x03,
  0x40, 0x8F, 0xC0, 0x80, 0x30, 0x05, 0x01, 0x20, 0x24, 0x04, 0x81, 0x08,
  0x21, 0x04, 0x20, 0x82, 0x20, 0x44, 0x08, 0x81, 0x10, 0x14, 0x02, 0x80,
  0x50, 0x0C, 0x00, 0x80, 0x80, 0x40, 0x50, 0x30, 0x14, 0x0C, 0x09, 0x03,
  0x02, 0x40, 0xA0, 0x88, 0x48, 0x22, 0x12, 0x10, 0x84, 0x84, 0x21, 0x21,
  0x08, 0x84, 0x41, 0x21, 0x20, 0x48, 0x48, 0x12, 0x12, 0x04, 0x82, 0x80,
  0xC0, 0xA0, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0x40, 0xD0, 0x22,
  0x08, 0x84, 0x11, 0x04, 0x80, 0xA0, 0x30, 0x0C, 0x03, 0x00, 0xA0, 0x48,
  0x12, 0x08, 0x42, 0x11, 0x02, 0x40, 0xA0, 0x10, 0x80, 0x50, 0x24, 0x09,
  0x04, 0x21, 0x08, 0x41, 0x20, 0x48, 0x14, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0x01, 0x03, 0x02, 0x02,
  0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x60, 0x40, 0x40, 0x80,
  0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x7C, 0xC0, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08,
  0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x02, 0x01, 0xF8, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xFC, 0x08,
  0x03, 0x01, 0x40, 0x48, 0x22, 0x08, 0x44, 0x11, 0x02, 0x80, 0xA0, 0x10,
  0xFF, 0xC0, 0xC4, 0x21, 0x7E, 0x02, 0x01, 0x01, 0x01, 0x0F, 0x31, 0x41,
  0x81, 0x81, 0x83, 0x83, 0x7D, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x42,
  0xD9, 0x82, 0x81, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x02, 0x81,
  0x61, 0xAF, 0x80, 0x3F, 0x60, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x40, 0x40, 0x60, 0x3F, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x44, 0xDA,
  0x83, 0x40, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x81, 0x40, 0xA0,
  0xCF, 0xA0, 0x3E, 0x20, 0x90, 0x48, 0x18, 0x0F, 0xFE, 0x01, 0x00, 0x80,
  0x20, 0x10, 0x0C, 0x13, 0xF0, 0x1E, 0x20, 0x81, 0x02, 0x04, 0x3E, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x3E, 0xA0,
  0xD0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x50, 0x68, 0x33,
  0xE8, 0x04, 0x02, 0x01, 0x00, 0xA0, 0x9F, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x88, 0xB6, 0xC2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xC7, 0xFF, 0xC0, 0x24, 0x00, 0x49, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x4E, 0x81, 0x02, 0x04, 0x08, 0x10, 0x21, 0xC2, 0x89, 0x22,
  0x45, 0x8D, 0x11, 0x22, 0x42, 0x85, 0x06, 0x08, 0xFF, 0xFF, 0xE0, 0xBC,
  0xFB, 0x0C, 0x28, 0x30, 0x60, 0x81, 0x82, 0x06, 0x08, 0x18, 0x20, 0x60,
  0x81, 0x82, 0x06, 0x08, 0x18, 0x20, 0x60, 0x81, 0x82, 0x04, 0xBE, 0xC3,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x3F,
  0x20, 0x90, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xA0, 0x50, 0x2C,
  0x23, 0xE0, 0xBE, 0x60, 0xA0, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xB0, 0x58, 0x6B, 0xE4, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x00,
  0x3E, 0xA0, 0xD0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x50,
  0x6C, 0x33, 0xE8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0xBE, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x00, 0x7F, 0x02, 0x04, 0x0C, 0x0C,
  0x06, 0x02, 0x02, 0x04, 0x0C, 0x1F, 0xC0, 0x20, 0x82, 0x3F, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x07, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0x85, 0x79, 0x81, 0xA0, 0x90, 0x48,
  0x24, 0x21, 0x10, 0x88, 0x48, 0x14, 0x0A, 0x05, 0x03, 0x00, 0x80, 0x81,
  0x05, 0x0C, 0x14, 0x28, 0x50, 0xA2, 0x42, 0x88, 0x92, 0x22, 0x44, 0x89,
  0x12, 0x24, 0x50, 0x61, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x20, 0x41, 0x90,
  0x88, 0x82, 0x41, 0x40, 0x60, 0x20, 0x28, 0x16, 0x11, 0x08, 0x48, 0x2C,
  0x08, 0xC0, 0xA0, 0x90, 0x48, 0x22, 0x11, 0x10, 0x88, 0x24, 0x14, 0x0A,
  0x05, 0x01, 0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x18, 0x38, 0x00, 0xFC,
  0x10, 0x82, 0x10, 0x41, 0x08, 0x21, 0x04, 0x20, 0xFC, 0x0E, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x41, 0x87, 0x02, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x60, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x30, 0x71, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x83, 0x18, 0x00, 0x70, 0xC7, 0xC0,
};

const GFXglyph NotoSans_Condensed_ExtraLight25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 18, 5, 2, -18 },
  { 4, 4, 7, 8, 2, -18 },
  { 8, 11, 18, 12, 1, -18 },
  { 33, 9, 20, 11, 1, -19 },
  { 56, 14, 18, 16, 1, -18 },
  { 88, 11, 18, 12, 1, -18 },
  { 113, 1, 7, 4, 2, -18 },
  { 114, 5, 22, 7, 1, -18 },
  { 128, 5, 22, 7, 1, -18 },
  { 142, 8, 8, 10, 1, -19 },
  { 150, 9, 12, 11, 1, -15 },
  { 164, 2, 6, 5, 1, -3 },
  { 166, 5, 1, 7, 1, -7 },
  { 167, 1, 2, 5, 2, -2 },
  { 168, 8, 18, 8, 0, -18 },
  { 186, 9, 18, 11, 1, -18 },
  { 207, 5, 18, 11, 2, -18 },
  { 219, 9, 18, 11, 1, -18 },
  { 240, 9, 18, 11, 1, -18 },
  { 261, 11, 18, 11, 0, -18 },
  { 286, 9, 18, 11, 1, -18 },
  { 307, 9, 18, 11, 1, -18 },
  { 328, 9, 18, 11, 1, -18 },
  { 349, 9, 18, 11, 1, -18 },
  { 370, 9, 18, 11, 1, -18 },
  { 391, 1, 13, 5, 2, -13 },
  { 393, 2, 16, 5, 1, -13 },
  { 397, 9, 10, 11, 1, -14 },
  { 409, 9, 6, 11, 1, -12 },
  { 416, 9, 10, 11, 1, -14 },
  { 428, 6, 18, 8, 1, -18 },
  { 442, 15, 20, 17, 1, -18 },
  { 480, 11, 18, 11, 0, -18 },
  { 505, 9, 18, 12, 2, -18 },
  { 526, 10, 18, 12, 1, -18 },
  { 549, 10, 18, 14, 2, -18 },
  { 572, 8, 18, 11, 2, -18 },
  { 590, 8, 18, 10, 2, -18 },
  { 608, 12, 18, 15, 1, -18 },
  { 635, 10, 18, 14, 2, -18 },
  { 658, 4, 18, 6, 1, -18 },
  { 667, 5, 22, 5, -2, -18 },
  { 681, 9, 18, 11, 2, -18 },
  { 702, 7, 18, 10, 2, -18 },
  { 718, 14, 18, 18, 2, -18 },
  { 750, 10, 18, 14, 2, -18 },
  { 773, 12, 18, 15, 1, -18 },
  { 800, 8, 18, 11, 2, -18 },
  { 818, 12, 22, 15, 1, -18 },
  { 851, 9, 18, 12, 2, -18 },
  { 872, 9, 18, 11, 1, -18 },
  { 893, 10, 18, 10, 0, -18 },
  { 916, 10, 18, 14, 2, -18 },
  { 939, 11, 18, 11, 0, -18 },
  { 964, 18, 18, 18, 0, -18 },
  { 1005, 10, 18, 10, 0, -18 },
  { 1028, 10, 18, 10, 0, -18 },
  { 1051, 8, 18, 10, 1, -18 },
  { 1069, 5, 22, 8, 2, -18 },
  { 1083, 8, 18, 8, 0, -18 },
  { 1101, 5, 22, 8, 1, -18 },
  { 1115, 10, 10, 11, 1, -18 },
  { 1128, 10, 1, 10, 0, 2 },
  { 1130, 4, 4, 6, 1, -19 },
  { 1132, 8, 13, 11, 1, -13 },
  { 1145, 9, 19, 12, 2, -19 },
  { 1167, 8, 13, 9, 1, -13 },
  { 1180, 9, 19, 12, 1, -19 },
  { 1202, 9, 13, 11, 1, -13 },
  { 1217, 7, 19, 6, 0, -19 },
  { 1234, 9, 19, 12, 1, -13 },
  { 1256, 8, 19, 12, 2, -19 },
  { 1275, 1, 18, 5, 2, -18 },
  { 1278, 3, 24, 5, 0, -18 },
  { 1287, 7, 19, 9, 2, -19 },
  { 1304, 1, 19, 5, 2, -19 },
  { 1307, 14, 13, 17, 2, -13 },
  { 1330, 8, 13, 12, 2, -13 },
  { 1343, 9, 13, 12, 1, -13 },
  { 1358, 9, 19, 12, 2, -13 },
  { 1380, 9, 19, 12, 1, -13 },
  { 1402, 5, 13, 8, 2, -13 },
  { 1411, 7, 13, 9, 1, -13 },
  { 1423, 6, 16, 6, 0, -16 },
  { 1435, 8, 13, 12, 2, -13 },
  { 1448, 9, 13, 9, 0, -13 },
  { 1463, 14, 13, 15, 0, -13 },
  { 1486, 9, 13, 9, 0, -13 },
  { 1501, 9, 19, 9, 0, -13 },
  { 1523, 6, 13, 8, 1, -13 },
  { 1533, 7, 22, 9, 1, -18 },
  { 1553, 1, 25, 11, 5, -19 },
  { 1557, 7, 22, 9, 1, -18 },
  { 1577, 9, 2, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_ExtraLight25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight25pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT25PT7B_H_
