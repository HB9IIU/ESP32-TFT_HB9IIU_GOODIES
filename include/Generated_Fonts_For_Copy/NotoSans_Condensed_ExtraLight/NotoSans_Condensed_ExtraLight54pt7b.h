#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT54PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight54pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0x00, 0x00, 0x3F, 0xF8, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x06, 0xC0, 0xB0, 0x2C, 0x0B, 0x02, 0xC0, 0xB0, 0x20, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x08, 0x00, 0x18, 0x04, 0x00, 0x0C, 0x06, 0x00, 0x06,
  0x03, 0x00, 0x02, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00,
  0xC0, 0x20, 0x00, 0x60, 0x10, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x03,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0,
  0x01, 0x80, 0x40, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x30, 0x00, 0x20, 0x18,
  0x00, 0x10, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01,
  0x00, 0x03, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x80, 0x40,
  0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C,
  0x02, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01, 0x00, 0xC0, 0x00,
  0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x1F, 0x80, 0x07, 0xFF,
  0x81, 0xE6, 0x7C, 0x38, 0x60, 0xC7, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06,
  0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00, 0xE0,
  0x60, 0x06, 0x06, 0x00, 0x70, 0x60, 0x03, 0x86, 0x00, 0x1C, 0x60, 0x00,
  0xF6, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x06, 0xF0,
  0x00, 0x63, 0x80, 0x06, 0x1C, 0x00, 0x60, 0xE0, 0x06, 0x06, 0x00, 0x60,
  0x60, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x70, 0x06,
  0x06, 0x00, 0x60, 0x60, 0x06, 0x0C, 0xC0, 0x61, 0xCF, 0xC6, 0xF0, 0x3F,
  0xFE, 0x00, 0x3E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x1F, 0x00, 0x06, 0x00, 0xFE, 0x00, 0x18, 0x07, 0x0C, 0x00,
  0x40, 0x18, 0x30, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x0C, 0x06, 0x01, 0x80, 0x30, 0x08, 0x04, 0x00, 0xC0, 0x30, 0x30, 0x02,
  0x00, 0xC0, 0xC0, 0x08, 0x03, 0x06, 0x00, 0x20, 0x0C, 0x18, 0x00, 0x80,
  0x30, 0x40, 0x02, 0x00, 0xC3, 0x00, 0x08, 0x03, 0x0C, 0x00, 0x30, 0x0C,
  0x60, 0xE0, 0xC0, 0x21, 0x87, 0xE3, 0x01, 0x84, 0x31, 0xCC, 0x06, 0x31,
  0x83, 0x10, 0x18, 0xC6, 0x06, 0x60, 0xC6, 0x30, 0x19, 0xC3, 0x18, 0xC0,
  0x63, 0xF8, 0x43, 0x01, 0x87, 0xC3, 0x0C, 0x03, 0x00, 0x0C, 0x30, 0x0C,
  0x00, 0x60, 0x80, 0x30, 0x01, 0x82, 0x00, 0xC0, 0x04, 0x08, 0x03, 0x00,
  0x30, 0x20, 0x0C, 0x00, 0xC0, 0x80, 0x30, 0x06, 0x03, 0x00, 0xC0, 0x18,
  0x0C, 0x03, 0x00, 0x60, 0x30, 0x18, 0x03, 0x00, 0xC0, 0x60, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x06, 0x06, 0x01, 0x80, 0x18, 0x30, 0x06, 0x00, 0x31,
  0x80, 0x30, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x06,
  0x0E, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x18,
  0x03, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03, 0x00, 0x08, 0x03, 0x00, 0x0C,
  0x03, 0x00, 0x0C, 0x07, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x0E, 0x00, 0x06,
  0x0C, 0x00, 0x03, 0x18, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x38,
  0x38, 0x06, 0x30, 0x18, 0x06, 0x60, 0x0C, 0x06, 0x60, 0x06, 0x06, 0xE0,
  0x07, 0x0C, 0xC0, 0x03, 0x0C, 0xC0, 0x01, 0x8C, 0xC0, 0x01, 0xD8, 0xC0,
  0x00, 0xD8, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x70, 0x60,
  0x00, 0xD8, 0x30, 0x01, 0x8C, 0x38, 0x07, 0x0E, 0x1E, 0x3E, 0x06, 0x07,
  0xFC, 0x03, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0xC0,
  0xC0, 0xC0, 0x60, 0x60, 0x70, 0x30, 0x18, 0x18, 0x0C, 0x0E, 0x06, 0x03,
  0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18,
  0x0C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x60,
  0x18, 0x0E, 0x03, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C,
  0x03, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x1C,
  0x06, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x04, 0x0C, 0x0B, 0x86, 0x1C, 0xFB, 0x7D, 0x0F, 0xF0, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0xCC, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x60, 0x60, 0x60,
  0x18, 0x10, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x18, 0xCE,
  0x73, 0x18, 0xCE, 0x63, 0x19, 0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x38,
  0x38, 0x0C, 0x03, 0x83, 0x80, 0x30, 0x60, 0x07, 0x1C, 0x00, 0x63, 0x00,
  0x0C, 0x60, 0x00, 0xCC, 0x00, 0x1B, 0x80, 0x03, 0x60, 0x00, 0x6C, 0x00,
  0x0D, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00,
  0x6C, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x0C, 0x60, 0x01,
  0x86, 0x00, 0x30, 0xC0, 0x0C, 0x0C, 0x03, 0x81, 0xC0, 0xE0, 0x1F, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x60, 0x1C, 0x07, 0x83, 0xB0, 0xE6, 0x38, 0xCE,
  0x1F, 0x83, 0x40, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xF8, 0x03,
  0xFF, 0xC1, 0xF0, 0x1C, 0x18, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xC1, 0xE0,
  0x1C, 0x70, 0x01, 0xC4, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xCC, 0x00, 0x79, 0xF8, 0x7E,
  0x0F, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x34, 0x00, 0x00, 0x78, 0x00, 0x01, 0xB0, 0x00, 0x03,
  0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC6,
  0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00, 0x60, 0x60,
  0x00, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x18, 0x06, 0x00,
  0x70, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x18,
  0x00, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x06, 0x00,
  0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xFF,
  0x87, 0xFF, 0xF0, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x6F, 0xF8, 0x0F, 0xFF, 0xC1, 0x80, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x8C,
  0x00, 0xE1, 0xF0, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0,
  0x0E, 0x02, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x07, 0x80, 0xC7, 0xFE, 0x19,
  0xC1, 0xE3, 0x60, 0x0E, 0x68, 0x00, 0xCE, 0x00, 0x0D, 0xC0, 0x01, 0xB8,
  0x00, 0x36, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xD8, 0x00, 0x3B, 0x00, 0x06, 0x60,
  0x00, 0xCE, 0x00, 0x18, 0xC0, 0x06, 0x1C, 0x00, 0xC1, 0xC0, 0x30, 0x1E,
  0x1C, 0x01, 0xFF, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xF0, 0x0E, 0x03, 0x81, 0x80, 0x1C, 0x38, 0x00, 0xC3, 0x00, 0x0E, 0x30,
  0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x70, 0x00, 0x63,
  0x00, 0x06, 0x30, 0x00, 0xC1, 0x80, 0x1C, 0x1C, 0x01, 0x80, 0xE0, 0x70,
  0x07, 0x0E, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0x0E,
  0x00, 0xE0, 0x70, 0x1C, 0x03, 0x83, 0x80, 0x1C, 0x30, 0x00, 0xE6, 0x00,
  0x06, 0x60, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0x60, 0x00, 0x76, 0x00, 0x06, 0x70, 0x00, 0x63,
  0x80, 0x0C, 0x1C, 0x01, 0x80, 0xF0, 0xF0, 0x07, 0xFE, 0x00, 0x02, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x78, 0x1C, 0x0C, 0x01, 0x83, 0x00, 0x18,
  0x60, 0x03, 0x98, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xEC, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1B,
  0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x1D, 0x80, 0x03, 0x98, 0x00, 0xF3,
  0x80, 0x16, 0x38, 0x0E, 0xC3, 0xFF, 0x98, 0x3F, 0xC3, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x61, 0xF0, 0x0F, 0xFC, 0x00, 0x10, 0x00, 0xFF,
  0xF4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x19, 0xCE,
  0x71, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x19, 0xCE, 0x63, 0x19, 0xCC, 0x63, 0x31, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0xFF, 0xE3, 0x80, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x60, 0x0E, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0xE0, 0x06, 0x60, 0x07, 0xFC, 0x06, 0x60, 0x0E, 0x0C, 0x06, 0x60, 0x18,
  0x0C, 0x06, 0x60, 0x38, 0x0C, 0x06, 0xC0, 0x30, 0x0C, 0x03, 0xC0, 0x60,
  0x0C, 0x03, 0xC0, 0x60, 0x0C, 0x03, 0xC0, 0x60, 0x0C, 0x03, 0xC0, 0x60,
  0x0C, 0x03, 0xC0, 0x60, 0x0C, 0x03, 0xC0, 0x60, 0x0C, 0x03, 0xC0, 0x60,
  0x0C, 0x03, 0xC0, 0x60, 0x1C, 0x02, 0xC0, 0x60, 0x1C, 0x06, 0xC0, 0x60,
  0x1C, 0x06, 0xC0, 0x60, 0x1C, 0x06, 0xC0, 0x60, 0x3C, 0x04, 0xC0, 0x30,
  0x24, 0x0C, 0xC0, 0x38, 0x66, 0x18, 0x60, 0x1F, 0xC3, 0xF8, 0x60, 0x0F,
  0x81, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x80, 0x02, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x66, 0x00, 0x00, 0x63, 0x00, 0x00, 0x63,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC1, 0x80, 0x00, 0xC1,
  0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x03, 0x00,
  0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x03, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x0C, 0x00, 0x38, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x0E, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x83,
  0x01, 0xFC, 0x60, 0x03, 0xCC, 0x00, 0x19, 0x80, 0x03, 0xB0, 0x00, 0x36,
  0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C,
  0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x66, 0x00, 0x1C, 0xC0, 0x07, 0x18,
  0x03, 0xC3, 0xFF, 0xE0, 0x7F, 0xFF, 0x0C, 0x00, 0x71, 0x80, 0x03, 0x30,
  0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1B, 0x00, 0x07, 0x60, 0x01, 0xCC, 0x00, 0xF1, 0xFF,
  0xFC, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x3C, 0x01,
  0x81, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x08, 0x07, 0xE7,
  0xE0, 0x07, 0xFF, 0x00, 0x01, 0xC0, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x30,
  0x1F, 0x81, 0x80, 0x0E, 0x0C, 0x00, 0x38, 0x60, 0x00, 0xE3, 0x00, 0x03,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x76, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0x60, 0x00,
  0x1B, 0x00, 0x01, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0xE6, 0x00, 0x06, 0x30,
  0x00, 0x61, 0x80, 0x0F, 0x0C, 0x01, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x78, 0x03, 0xE0, 0x70,
  0x00, 0x20, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0C, 0xC0,
  0x00, 0x06, 0x70, 0x00, 0x03, 0x18, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0x60, 0xE0, 0x00, 0x30, 0x3C, 0x00, 0x38, 0x0F, 0xC3, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x60, 0xFF, 0xFF, 0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC1, 0xFB, 0xFE, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xEC, 0xF3, 0xF8, 0x30, 0x00, 0xC0,
  0x00, 0xF8, 0x00, 0x3B, 0x00, 0x06, 0x60, 0x01, 0xCC, 0x00, 0x71, 0x80,
  0x0C, 0x30, 0x03, 0x06, 0x00, 0xE0, 0xC0, 0x38, 0x18, 0x06, 0x03, 0x01,
  0xC0, 0x60, 0x70, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x30, 0xE0, 0x06, 0x38,
  0x00, 0xC6, 0x00, 0x19, 0xC0, 0x03, 0x7C, 0x00, 0x6D, 0x80, 0x0F, 0x38,
  0x01, 0xC3, 0x00, 0x38, 0x70, 0x06, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x0E,
  0x03, 0x00, 0xC0, 0x60, 0x1C, 0x0C, 0x01, 0x81, 0x80, 0x38, 0x30, 0x03,
  0x06, 0x00, 0x30, 0xC0, 0x07, 0x18, 0x00, 0x63, 0x00, 0x0E, 0x60, 0x00,
  0xCC, 0x00, 0x1D, 0x80, 0x01, 0xB0, 0x00, 0x18, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x60, 0x00, 0x00,
  0xFB, 0x00, 0x00, 0x07, 0xD8, 0x00, 0x00, 0x3F, 0x60, 0x00, 0x03, 0x7B,
  0x00, 0x00, 0x1B, 0xD8, 0x00, 0x00, 0xDE, 0x60, 0x00, 0x0C, 0xF3, 0x00,
  0x00, 0x67, 0x98, 0x00, 0x03, 0x3C, 0x60, 0x00, 0x31, 0xE3, 0x00, 0x01,
  0x8F, 0x18, 0x00, 0x0C, 0x78, 0x60, 0x00, 0xC3, 0xC3, 0x00, 0x06, 0x1E,
  0x18, 0x00, 0x30, 0xF0, 0x60, 0x03, 0x07, 0x83, 0x00, 0x18, 0x3C, 0x18,
  0x00, 0xC1, 0xE0, 0x60, 0x0C, 0x0F, 0x03, 0x00, 0x60, 0x78, 0x18, 0x03,
  0x03, 0xC0, 0xE0, 0x30, 0x1E, 0x03, 0x01, 0x80, 0xF0, 0x18, 0x0C, 0x07,
  0x80, 0xE0, 0xC0, 0x3C, 0x03, 0x06, 0x01, 0xE0, 0x18, 0x30, 0x0F, 0x00,
  0xE3, 0x00, 0x78, 0x03, 0x18, 0x03, 0xC0, 0x18, 0xC0, 0x1E, 0x00, 0xEC,
  0x00, 0xF0, 0x03, 0x60, 0x07, 0x80, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x60, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xB0, 0x00, 0x0F, 0xC0, 0x00,
  0x3D, 0x80, 0x00, 0xF6, 0x00, 0x03, 0xCC, 0x00, 0x0F, 0x30, 0x00, 0x3C,
  0x60, 0x00, 0xF1, 0x80, 0x03, 0xC3, 0x00, 0x0F, 0x0E, 0x00, 0x3C, 0x18,
  0x00, 0xF0, 0x70, 0x03, 0xC0, 0xC0, 0x0F, 0x03, 0x80, 0x3C, 0x06, 0x00,
  0xF0, 0x1C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xE0, 0x3C, 0x01, 0x80, 0xF0,
  0x07, 0x03, 0xC0, 0x0C, 0x0F, 0x00, 0x38, 0x3C, 0x00, 0x60, 0xF0, 0x01,
  0xC3, 0xC0, 0x03, 0x0F, 0x00, 0x0E, 0x3C, 0x00, 0x18, 0xF0, 0x00, 0x73,
  0xC0, 0x00, 0xCF, 0x00, 0x03, 0xBC, 0x00, 0x06, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x38, 0x07, 0x00, 0x3C, 0x00, 0x60, 0x0C, 0x00, 0x0C,
  0x06, 0x00, 0x03, 0x83, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x0C, 0x30, 0x00,
  0x03, 0x18, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x60,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x63, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x06, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0xC0, 0x38, 0x00, 0x70, 0x07, 0x80, 0x38, 0x00, 0xFC, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x0C, 0x0F,
  0xC3, 0x00, 0x38, 0xC0, 0x07, 0x30, 0x00, 0xEC, 0x00, 0x1B, 0x00, 0x06,
  0xC0, 0x01, 0xB0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03, 0xB0, 0x00, 0xCC, 0x00,
  0x73, 0x00, 0x38, 0xC0, 0x3C, 0x3F, 0xFE, 0x0F, 0xF8, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x38, 0x07, 0x80, 0x3C, 0x00, 0x70, 0x0C,
  0x00, 0x0C, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0x60, 0xC0, 0x00, 0x0C,
  0x30, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x06, 0x60, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x06, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x07, 0x80, 0x38, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x70, 0xFE, 0x00,
  0x1F, 0xFE, 0x03, 0x03, 0xF0, 0x60, 0x07, 0x0C, 0x00, 0x71, 0x80, 0x07,
  0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x98, 0x00, 0x3B, 0x00, 0x07,
  0x60, 0x00, 0xEC, 0x00, 0x1D, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C,
  0xC0, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x38, 0x60, 0x1E, 0x0F, 0xFF, 0x81,
  0xFF, 0x80, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x03,
  0x00, 0x60, 0x60, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x01, 0x86,
  0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0xCC,
  0x00, 0x1D, 0x80, 0x01, 0xB0, 0x00, 0x38, 0x01, 0xFF, 0x00, 0xFF, 0xFC,
  0x38, 0x07, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xCC, 0x00, 0x79, 0xFE,
  0x7E, 0x0F, 0xFF, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x63, 0x00,
  0x03, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x3F, 0x3F, 0x00, 0x3F, 0xF0,
  0x00, 0x04, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x38, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30,
  0x0C, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x07, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x01, 0xC0,
  0x03, 0x01, 0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01, 0x83, 0x00,
  0x01, 0x83, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x6C, 0x00, 0x07,
  0x00, 0x01, 0xB0, 0x00, 0x1C, 0x00, 0x06, 0x60, 0x00, 0x50, 0x00, 0x19,
  0x80, 0x03, 0x60, 0x00, 0xC6, 0x00, 0x0D, 0x80, 0x03, 0x18, 0x00, 0x36,
  0x00, 0x0C, 0x70, 0x00, 0xD8, 0x00, 0x30, 0xC0, 0x03, 0x30, 0x01, 0xC3,
  0x00, 0x18, 0xC0, 0x06, 0x0C, 0x00, 0x63, 0x00, 0x18, 0x38, 0x01, 0x8C,
  0x00, 0x60, 0x60, 0x06, 0x10, 0x03, 0x81, 0x80, 0x30, 0x60, 0x0C, 0x06,
  0x00, 0xC1, 0x80, 0x30, 0x18, 0x03, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x18,
  0x03, 0x00, 0xC0, 0x30, 0x30, 0x18, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x38, 0x18, 0x0C, 0x06, 0x00, 0x60, 0x60, 0x18,
  0x38, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x18,
  0x30, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x31,
  0x80, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x03, 0x18, 0x00, 0x19,
  0x80, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x13, 0x00, 0x01, 0xB0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x19, 0x80, 0x01, 0x8E,
  0x00, 0x0C, 0x30, 0x00, 0xC1, 0xC0, 0x06, 0x06, 0x00, 0x70, 0x30, 0x03,
  0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0xC0, 0x03,
  0x06, 0x00, 0x18, 0x60, 0x00, 0xE3, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x01, 0x86, 0x00,
  0x0C, 0x30, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x60, 0x38, 0x03, 0x00,
  0xC0, 0x38, 0x06, 0x01, 0x80, 0x18, 0x1C, 0x00, 0xC0, 0xC0, 0x03, 0x0E,
  0x00, 0x18, 0x60, 0x00, 0xE7, 0x00, 0x03, 0x30, 0x00, 0x1F, 0x80, 0x00,
  0x60, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xE3,
  0x00, 0x06, 0x18, 0x00, 0x30, 0xE0, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00,
  0xC0, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x1C, 0x06, 0x00, 0x60, 0x30, 0x03,
  0x01, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x8E, 0x00, 0x0C, 0x60,
  0x00, 0x63, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1B, 0x00, 0x00,
  0x6C, 0x00, 0x03, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x60, 0xC0, 0x01, 0x83,
  0x00, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x30, 0x01, 0x80, 0xC0, 0x06, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x30, 0xC0,
  0x00, 0xE3, 0x00, 0x01, 0x98, 0x00, 0x07, 0xE0, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x07, 0xF8, 0x0F, 0xFE, 0x0E, 0x03, 0x82, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x0F, 0xFC, 0x3F, 0x06, 0x38, 0x03, 0x38,
  0x01, 0xB8, 0x00, 0xD8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x60, 0x07, 0xB0, 0x02, 0xDC, 0x03, 0x67, 0x87,
  0x31, 0xFE, 0x18, 0x08, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x1F, 0x81,
  0x8F, 0xFC, 0x33, 0x81, 0xC6, 0xC0, 0x1C, 0xD0, 0x01, 0x9E, 0x00, 0x1B,
  0x80, 0x03, 0x70, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0x70, 0x00, 0x6F, 0x00, 0x19, 0xB0, 0x07, 0x33,
  0x01, 0xC6, 0x78, 0xF0, 0xC3, 0xFC, 0x00, 0x08, 0x00, 0x01, 0xFC, 0x07,
  0xFF, 0x0E, 0x02, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0F, 0x8E, 0x07, 0xFE, 0x00, 0x40, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x3F, 0x06, 0x1F, 0xF8, 0xC7, 0x01, 0x99, 0xC0, 0x1B, 0x30,
  0x01, 0x6C, 0x00, 0x3D, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1D, 0x80, 0x03, 0xB0, 0x00, 0x77, 0x00,
  0x16, 0x60, 0x06, 0xCE, 0x01, 0x98, 0xF8, 0xE3, 0x07, 0xF8, 0x60, 0x10,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xC0, 0xE0, 0xE0, 0x1C, 0x30, 0x03,
  0x18, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x18, 0x3C, 0x3E, 0x07, 0xFE, 0x00, 0x0C, 0x00, 0x01, 0xFC, 0x0F,
  0xF0, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1F, 0xE3, 0xFF, 0x80, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x03, 0xF8, 0x61,
  0xFF, 0x8C, 0x70, 0x19, 0x9C, 0x01, 0xB3, 0x00, 0x16, 0xC0, 0x03, 0xD8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xD8, 0x00, 0x3B, 0x00, 0x0F, 0x70, 0x01, 0x66, 0x00, 0x6C, 0xE0,
  0x19, 0x8F, 0x0E, 0x30, 0x7F, 0x86, 0x01, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x10, 0x00, 0xE3, 0x80, 0x78, 0x7F, 0xFE, 0x01, 0xFE,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x1F, 0x86, 0x3F, 0xF3, 0x38, 0x3D, 0xB0, 0x06, 0xD0,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0x80, 0xFF, 0xE0, 0x00, 0x03, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB0, 0x07, 0x07, 0x07, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0xFC, 0xF8,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x30,
  0xC0, 0x60, 0xC0, 0xC0, 0xC1, 0xC0, 0xC1, 0x80, 0xC3, 0x00, 0xC7, 0x00,
  0xC7, 0x00, 0xCF, 0x00, 0xD9, 0x80, 0xD9, 0x80, 0xF0, 0xC0, 0xE0, 0xC0,
  0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x18,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC3, 0xF0, 0x0F,
  0xC3, 0x1F, 0xE0, 0xFF, 0x8C, 0xC1, 0xC7, 0x07, 0x36, 0x03, 0xB0, 0x0E,
  0xF0, 0x06, 0xC0, 0x1B, 0x80, 0x1E, 0x00, 0x6E, 0x00, 0x38, 0x01, 0xF8,
  0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00,
  0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C,
  0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00,
  0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03,
  0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xF0,
  0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x3C, 0x00,
  0x30, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0C, 0xC1, 0xF8,
  0x63, 0xFF, 0x33, 0x81, 0xDB, 0x00, 0x6D, 0x00, 0x3F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x18,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x70, 0x1C, 0x1C, 0x01, 0xC3, 0x00, 0x18,
  0xC0, 0x01, 0x98, 0x00, 0x37, 0x00, 0x06, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0xD8, 0x00, 0x33, 0x00, 0x06, 0x70, 0x01, 0xC7,
  0x00, 0x30, 0x70, 0x0C, 0x07, 0x8F, 0x00, 0x7F, 0xC0, 0x01, 0x80, 0x00,
  0xC1, 0xF8, 0x18, 0xFF, 0xC3, 0x38, 0x1C, 0x6C, 0x01, 0xCD, 0x00, 0x19,
  0xE0, 0x01, 0xB8, 0x00, 0x37, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x37, 0x80, 0x06, 0xD0, 0x01, 0x9B,
  0x00, 0x73, 0x30, 0x1C, 0x63, 0x8F, 0x0C, 0x3F, 0xC1, 0x80, 0x80, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0x03, 0xF0, 0x61, 0xFF, 0x8C, 0x70, 0x39, 0x9C,
  0x01, 0xB3, 0x00, 0x16, 0xE0, 0x03, 0xD8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3B, 0x00,
  0x0F, 0x70, 0x01, 0x66, 0x00, 0x6C, 0xE0, 0x19, 0x8F, 0x1E, 0x30, 0x7F,
  0x86, 0x01, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0xC3, 0xFC, 0x7F, 0xCE,
  0x0D, 0x80, 0xD0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xFC, 0xE0, 0x1B, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1F, 0x00, 0x77, 0xC7, 0xC7, 0xFF, 0x00, 0xE0,
  0x00, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x3F, 0xFF,
  0xFF, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0xF3, 0x07, 0xF0, 0x08, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x07,
  0xB0, 0x02, 0xDC, 0x07, 0x67, 0x8F, 0x31, 0xFE, 0x18, 0x08, 0x00, 0xC0,
  0x00, 0x7C, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x1C, 0x60,
  0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x38, 0x03, 0x03, 0x00, 0x60, 0x60,
  0x0C, 0x0C, 0x03, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x01, 0x8C, 0x00, 0x31,
  0x80, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x36,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x00, 0x0F,
  0x00, 0x0C, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xB0, 0x01, 0xE0, 0x06, 0x60,
  0x07, 0x80, 0x19, 0x80, 0x16, 0x00, 0x66, 0x00, 0xCC, 0x03, 0x18, 0x03,
  0x30, 0x0C, 0x30, 0x0C, 0xC0, 0x30, 0xC0, 0x33, 0x00, 0xC3, 0x01, 0x86,
  0x03, 0x0C, 0x06, 0x18, 0x18, 0x18, 0x18, 0x60, 0x60, 0x60, 0x61, 0x81,
  0x81, 0x83, 0x02, 0x06, 0x06, 0x0C, 0x0C, 0x30, 0x18, 0x30, 0x30, 0xC0,
  0x30, 0xC0, 0xC3, 0x00, 0xC6, 0x01, 0x0C, 0x03, 0x18, 0x06, 0x20, 0x0C,
  0x60, 0x19, 0x80, 0x19, 0x80, 0x66, 0x00, 0x6C, 0x01, 0x98, 0x01, 0xB0,
  0x03, 0x40, 0x06, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x60, 0x00, 0xD8,
  0x00, 0x63, 0x00, 0x38, 0xC0, 0x0C, 0x18, 0x07, 0x06, 0x01, 0x80, 0xC0,
  0xE0, 0x30, 0x30, 0x06, 0x1C, 0x01, 0x86, 0x00, 0x33, 0x00, 0x0E, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0xCC, 0x00, 0x33, 0x80, 0x18, 0x60, 0x06, 0x1C, 0x03, 0x03, 0x01, 0xC0,
  0x60, 0x60, 0x18, 0x38, 0x03, 0x0C, 0x00, 0xC7, 0x00, 0x19, 0x80, 0x06,
  0xE0, 0x00, 0xC0, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0x98, 0x00,
  0x63, 0x00, 0x0C, 0x60, 0x01, 0x8E, 0x00, 0x70, 0xC0, 0x0C, 0x18, 0x01,
  0x83, 0x00, 0x30, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x0C,
  0x01, 0x81, 0x80, 0x30, 0x30, 0x06, 0x06, 0x00, 0x61, 0x80, 0x0C, 0x30,
  0x01, 0x86, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x04,
  0x01, 0xF0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x3E, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x03, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x3C, 0x03, 0x80, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x78, 0x0F, 0xC0, 0x30, 0x00,
  0x04, 0x00, 0x01, 0xFE, 0x00, 0x7C, 0x7C, 0x07, 0x80, 0x7D, 0xE8, 0x01,
  0xFE, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLight54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 39, 11, 4, -39 },
  { 16, 10, 14, 17, 4, -39 },
  { 34, 25, 39, 27, 1, -39 },
  { 156, 20, 44, 24, 2, -41 },
  { 266, 30, 39, 35, 3, -39 },
  { 413, 24, 40, 27, 2, -39 },
  { 533, 2, 14, 9, 4, -39 },
  { 537, 9, 48, 14, 3, -39 },
  { 591, 10, 48, 14, 2, -39 },
  { 651, 17, 17, 22, 3, -41 },
  { 688, 21, 25, 25, 2, -32 },
  { 754, 5, 13, 10, 2, -6 },
  { 763, 12, 2, 15, 2, -16 },
  { 766, 3, 4, 11, 4, -4 },
  { 768, 16, 39, 18, 1, -39 },
  { 846, 19, 39, 24, 3, -39 },
  { 939, 11, 39, 24, 4, -39 },
  { 993, 19, 39, 24, 2, -39 },
  { 1086, 19, 40, 24, 2, -39 },
  { 1181, 23, 39, 24, 1, -39 },
  { 1294, 19, 39, 24, 3, -39 },
  { 1387, 19, 40, 24, 3, -39 },
  { 1482, 20, 39, 24, 2, -39 },
  { 1580, 20, 40, 24, 2, -39 },
  { 1680, 19, 40, 24, 2, -39 },
  { 1775, 3, 29, 11, 4, -29 },
  { 1786, 5, 36, 11, 2, -29 },
  { 1809, 21, 23, 25, 2, -31 },
  { 1870, 21, 14, 25, 2, -26 },
  { 1907, 21, 23, 25, 2, -31 },
  { 1968, 15, 39, 17, 1, -39 },
  { 2042, 32, 44, 37, 3, -39 },
  { 2218, 24, 39, 24, 0, -39 },
  { 2335, 19, 39, 27, 5, -39 },
  { 2428, 22, 40, 26, 3, -39 },
  { 2538, 21, 39, 30, 5, -39 },
  { 2641, 16, 39, 23, 5, -39 },
  { 2719, 16, 39, 22, 5, -39 },
  { 2797, 25, 40, 32, 3, -39 },
  { 2922, 21, 39, 30, 5, -39 },
  { 3025, 9, 39, 14, 2, -39 },
  { 3069, 10, 49, 11, -3, -39 },
  { 3131, 19, 39, 24, 5, -39 },
  { 3224, 15, 39, 21, 5, -39 },
  { 3298, 29, 39, 39, 5, -39 },
  { 3440, 22, 39, 31, 5, -39 },
  { 3548, 26, 40, 32, 3, -39 },
  { 3678, 18, 39, 25, 5, -39 },
  { 3766, 26, 48, 32, 3, -39 },
  { 3922, 19, 39, 25, 5, -39 },
  { 4015, 19, 40, 24, 2, -39 },
  { 4110, 21, 39, 21, 0, -39 },
  { 4213, 22, 40, 30, 4, -39 },
  { 4323, 24, 39, 24, 0, -39 },
  { 4440, 38, 39, 39, 1, -39 },
  { 4626, 21, 39, 22, 0, -39 },
  { 4729, 21, 39, 21, 0, -39 },
  { 4832, 18, 39, 22, 2, -39 },
  { 4920, 11, 48, 17, 4, -39 },
  { 4986, 16, 39, 18, 1, -39 },
  { 5064, 10, 48, 17, 2, -39 },
  { 5124, 22, 21, 25, 1, -39 },
  { 5182, 22, 2, 22, 0, 5 },
  { 5188, 9, 8, 13, 2, -41 },
  { 5197, 17, 30, 23, 2, -29 },
  { 5261, 19, 42, 26, 4, -41 },
  { 5361, 16, 30, 20, 3, -29 },
  { 5421, 19, 42, 26, 3, -41 },
  { 5521, 18, 30, 23, 3, -29 },
  { 5589, 14, 41, 13, 1, -41 },
  { 5661, 19, 42, 26, 3, -29 },
  { 5761, 17, 41, 25, 4, -41 },
  { 5849, 3, 39, 10, 4, -39 },
  { 5864, 8, 52, 10, -1, -39 },
  { 5916, 16, 41, 20, 4, -41 },
  { 5998, 2, 41, 10, 4, -41 },
  { 6009, 30, 29, 38, 4, -29 },
  { 6118, 17, 29, 25, 4, -29 },
  { 6180, 19, 30, 25, 3, -29 },
  { 6252, 19, 42, 26, 4, -29 },
  { 6352, 19, 42, 26, 3, -29 },
  { 6452, 12, 29, 16, 4, -29 },
  { 6496, 15, 30, 20, 2, -29 },
  { 6553, 12, 36, 14, 1, -35 },
  { 6607, 17, 30, 25, 4, -29 },
  { 6671, 19, 29, 19, 0, -29 },
  { 6740, 30, 29, 31, 1, -29 },
  { 6849, 18, 29, 20, 1, -29 },
  { 6915, 19, 42, 20, 0, -29 },
  { 7015, 14, 29, 18, 2, -29 },
  { 7066, 14, 48, 19, 2, -39 },
  { 7150, 2, 54, 23, 11, -41 },
  { 7164, 14, 48, 19, 2, -39 },
  { 7248, 21, 5, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_ExtraLight54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight54pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT54PT7B_H_
