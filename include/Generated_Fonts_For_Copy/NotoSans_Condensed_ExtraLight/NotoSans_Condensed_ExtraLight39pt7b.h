#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT39PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0x40, 0x3F, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x03, 0x06, 0x01, 0x82, 0x00, 0x81, 0x00,
  0x40, 0x80, 0x20, 0x40, 0x10, 0x20, 0x08, 0x30, 0x0C, 0x18, 0x7F, 0xFF,
  0xBF, 0xFF, 0xC1, 0x02, 0x00, 0x81, 0x00, 0x40, 0x80, 0x20, 0x40, 0x30,
  0x60, 0x18, 0x30, 0x0C, 0x10, 0x04, 0x08, 0x3F, 0xFF, 0xC1, 0x02, 0x00,
  0x81, 0x00, 0x41, 0x80, 0x60, 0xC0, 0x30, 0x40, 0x10, 0x20, 0x08, 0x10,
  0x04, 0x08, 0x02, 0x0C, 0x00, 0x02, 0x00, 0x08, 0x00, 0x20, 0x07, 0xF8,
  0x32, 0x39, 0x88, 0x0C, 0x20, 0x20, 0x80, 0x82, 0x02, 0x08, 0x08, 0x20,
  0x30, 0x80, 0xC2, 0x01, 0x88, 0x03, 0xA0, 0x03, 0x80, 0x03, 0x80, 0x0B,
  0x80, 0x23, 0x00, 0x86, 0x02, 0x08, 0x08, 0x30, 0x20, 0xC0, 0x83, 0x02,
  0x08, 0x08, 0x68, 0x23, 0x3C, 0xB8, 0x3F, 0x80, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x3C, 0x01, 0x81, 0x88, 0x04, 0x04, 0x30, 0x10, 0x30, 0x40, 0xC0,
  0xC1, 0x02, 0x02, 0x04, 0x18, 0x08, 0x18, 0x40, 0x20, 0x61, 0x00, 0x81,
  0x8C, 0x02, 0x06, 0x20, 0x08, 0x19, 0x80, 0x20, 0x44, 0x78, 0xC1, 0x13,
  0x33, 0x04, 0xC8, 0x64, 0x32, 0x60, 0x98, 0x99, 0x82, 0x3C, 0x44, 0x08,
  0x01, 0x10, 0x30, 0x0C, 0x40, 0xC0, 0x21, 0x03, 0x01, 0x84, 0x0C, 0x04,
  0x10, 0x30, 0x10, 0x40, 0x80, 0xC1, 0x82, 0x02, 0x06, 0x08, 0x08, 0x08,
  0x60, 0x40, 0x31, 0x01, 0x00, 0x7C, 0x0F, 0x80, 0x0C, 0x60, 0x0C, 0x18,
  0x06, 0x0C, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x60, 0xC0, 0x30,
  0x60, 0x08, 0x60, 0x06, 0x20, 0x01, 0xB0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xEC, 0x00, 0xC2, 0x00, 0x41, 0x81, 0x60, 0x61, 0xA0, 0x10, 0xD0, 0x0C,
  0x48, 0x03, 0x24, 0x00, 0xB2, 0x00, 0x71, 0x00, 0x18, 0xC0, 0x1E, 0x20,
  0x19, 0x1C, 0x38, 0xC7, 0xF0, 0x30, 0xFF, 0xC0, 0x06, 0x18, 0x20, 0xC1,
  0x06, 0x08, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x0C, 0x18, 0x30, 0x60, 0x40, 0xC1, 0x81, 0x03, 0x02, 0x06, 0x04,
  0x0C, 0x0C, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x0C, 0x04, 0x06,
  0x06, 0x02, 0x02, 0x02, 0x02, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02,
  0x02, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0xC0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x86, 0x1F, 0x2F, 0x1F, 0x80, 0x60,
  0x09, 0x01, 0x98, 0x10, 0x82, 0x04, 0x20, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x81, 0xFF, 0xFC, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x33, 0x32, 0x26, 0x64, 0xC0, 0xFF,
  0x80, 0xFC, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x40, 0x00, 0x0F, 0xC0, 0x61, 0x83, 0x03, 0x08, 0x0C,
  0x60, 0x11, 0x00, 0x64, 0x00, 0xB0, 0x02, 0xC0, 0x0B, 0x00, 0x2C, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xB0, 0x02, 0xC0, 0x09, 0x00, 0x24, 0x01, 0x98, 0x04, 0x20,
  0x10, 0xC0, 0xC1, 0x86, 0x03, 0xF0, 0x03, 0x07, 0x0F, 0x3B, 0x63, 0xC3,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x1F, 0x87,
  0x87, 0x10, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0xFF, 0xF0, 0x3F, 0xC3, 0x87, 0x30,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0xC0, 0x1C, 0x0F, 0x80, 0x07, 0x00, 0x06, 0x00, 0x10,
  0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00,
  0x18, 0x01, 0xB0, 0x18, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x50, 0x00, 0xD0, 0x00, 0x90, 0x01, 0x90, 0x01, 0x10, 0x02, 0x10,
  0x06, 0x10, 0x04, 0x10, 0x0C, 0x10, 0x08, 0x10, 0x18, 0x10, 0x10, 0x10,
  0x30, 0x10, 0x20, 0x10, 0x40, 0x10, 0xC0, 0x10, 0x80, 0x10, 0xFF, 0xFF,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10,
  0x00, 0x10, 0x3F, 0xF1, 0xFF, 0xC6, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x13, 0xC0, 0x7F,
  0xE0, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x12, 0x00, 0xCC,
  0x0E, 0x1F, 0xE0, 0x03, 0xF0, 0x38, 0x41, 0x80, 0x04, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x33, 0xF0,
  0xD8, 0x73, 0xC0, 0x4E, 0x01, 0xB0, 0x02, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0D, 0x00, 0x34, 0x00, 0xD8, 0x02, 0x60, 0x18, 0xC0,
  0x41, 0x83, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x80, 0x06, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x20, 0x01, 0x80, 0x06, 0x00, 0x0F, 0xC0, 0xE1, 0x86, 0x03, 0x10, 0x06,
  0x40, 0x1B, 0x00, 0x2C, 0x00, 0x90, 0x02, 0x40, 0x19, 0x80, 0x43, 0x03,
  0x06, 0x38, 0x0F, 0x80, 0x1C, 0x01, 0xCC, 0x0C, 0x18, 0x60, 0x31, 0x00,
  0x6C, 0x00, 0xA0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0,
  0x09, 0x80, 0x63, 0x07, 0x07, 0xF0, 0x1F, 0x81, 0xC7, 0x18, 0x08, 0x80,
  0x6C, 0x01, 0x60, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x1C, 0x01, 0xE0, 0x0D, 0x80, 0xA6, 0x0D, 0x1F, 0x88, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x33, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x33, 0x22, 0x66, 0x4C, 0x00,
  0x02, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x00, 0x80, 0x00, 0x7F, 0x30,
  0xE0, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x08,
  0x06, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x01, 0x80, 0x60, 0x00, 0x7E, 0x00,
  0x03, 0xCF, 0x00, 0x1C, 0x01, 0x80, 0x60, 0x01, 0x81, 0x80, 0x01, 0x82,
  0x00, 0x01, 0x0C, 0x00, 0x03, 0x10, 0x00, 0x02, 0x60, 0x3F, 0x04, 0x80,
  0xC6, 0x0D, 0x03, 0x04, 0x1E, 0x0C, 0x08, 0x1C, 0x10, 0x10, 0x38, 0x20,
  0x20, 0x70, 0x40, 0xC0, 0xC1, 0x81, 0x81, 0x83, 0x03, 0x03, 0x06, 0x06,
  0x06, 0x0C, 0x0C, 0x1E, 0x08, 0x18, 0x2C, 0x10, 0x50, 0x58, 0x30, 0xA1,
  0x90, 0x3E, 0x3E, 0x20, 0x18, 0x30, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x05, 0x80, 0x01, 0x20, 0x00, 0xC8, 0x00, 0x33, 0x00, 0x08, 0xC0, 0x02,
  0x10, 0x01, 0x84, 0x00, 0x41, 0x80, 0x10, 0x60, 0x0C, 0x08, 0x03, 0x03,
  0x00, 0x80, 0xC0, 0x20, 0x10, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0x00, 0x60,
  0xC0, 0x08, 0x30, 0x02, 0x08, 0x00, 0xC2, 0x00, 0x11, 0x80, 0x04, 0x60,
  0x01, 0x90, 0x00, 0x6C, 0x00, 0x0B, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xE3,
  0x00, 0x66, 0x00, 0x4C, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0,
  0x0D, 0x80, 0x13, 0x00, 0x66, 0x00, 0x8C, 0x0E, 0x1F, 0xF8, 0x30, 0x1C,
  0x60, 0x0C, 0xC0, 0x0D, 0x80, 0x0B, 0x00, 0x16, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xB0, 0x01, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x33, 0x03, 0xC7, 0xFE,
  0x00, 0x01, 0xFE, 0x07, 0x07, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x02, 0x03, 0xFE, 0xFF, 0x80, 0xFF,
  0xE0, 0xC0, 0x38, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x18, 0xC0,
  0x38, 0xC1, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0F, 0xFE, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xEC, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0xFF, 0x01, 0xE0, 0xF0, 0xE0, 0x04,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x01, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x14, 0x00, 0x05,
  0x00, 0x01, 0x60, 0x00, 0x58, 0x00, 0x12, 0x00, 0x04, 0xC0, 0x01, 0x18,
  0x00, 0x43, 0x00, 0x10, 0x70, 0x1C, 0x07, 0xFE, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x3F, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0xFB, 0xC0, 0xC0, 0x0F, 0x00, 0x6C,
  0x01, 0x30, 0x0C, 0xC0, 0x63, 0x01, 0x0C, 0x0C, 0x30, 0x60, 0xC3, 0x03,
  0x08, 0x0C, 0x60, 0x33, 0x00, 0xCC, 0x03, 0x70, 0x0F, 0x60, 0x38, 0x80,
  0xC3, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x30, 0xC0, 0x43, 0x01, 0x8C, 0x02,
  0x30, 0x0C, 0xC0, 0x13, 0x00, 0x6C, 0x00, 0xF0, 0x03, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x40, 0x00, 0xBD, 0x80, 0x02, 0xF6, 0x00,
  0x1B, 0xC8, 0x00, 0x4F, 0x30, 0x01, 0x3C, 0xC0, 0x0C, 0xF1, 0x00, 0x23,
  0xC6, 0x00, 0x8F, 0x18, 0x06, 0x3C, 0x20, 0x10, 0xF0, 0xC0, 0x43, 0xC3,
  0x03, 0x0F, 0x04, 0x08, 0x3C, 0x18, 0x20, 0xF0, 0x61, 0x83, 0xC0, 0x84,
  0x0F, 0x03, 0x10, 0x3C, 0x0C, 0xC0, 0xF0, 0x12, 0x03, 0xC0, 0x68, 0x0F,
  0x01, 0xE0, 0x3C, 0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x01, 0xD0, 0x01, 0xD8, 0x01, 0xC8, 0x01, 0xCC, 0x01,
  0xC4, 0x01, 0xC6, 0x01, 0xC2, 0x01, 0xC3, 0x01, 0xC1, 0x01, 0xC1, 0x81,
  0xC0, 0x81, 0xC0, 0xC1, 0xC0, 0x41, 0xC0, 0x61, 0xC0, 0x21, 0xC0, 0x31,
  0xC0, 0x11, 0xC0, 0x19, 0xC0, 0x09, 0xC0, 0x0D, 0xC0, 0x05, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0x03, 0xF8, 0x01, 0xC1, 0xC0, 0x60, 0x0C, 0x08,
  0x00, 0xC3, 0x00, 0x18, 0x40, 0x01, 0x18, 0x00, 0x32, 0x00, 0x02, 0x40,
  0x00, 0x58, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0D, 0x00,
  0x01, 0xA0, 0x00, 0x24, 0x00, 0x04, 0xC0, 0x01, 0x88, 0x00, 0x31, 0x80,
  0x0C, 0x30, 0x01, 0x83, 0x00, 0x60, 0x38, 0x38, 0x01, 0xFE, 0x00, 0xFF,
  0x07, 0xFF, 0x30, 0x1D, 0x80, 0x2C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0x60, 0x1B, 0x03, 0x9F,
  0xF0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0xF8, 0x01,
  0xC1, 0xC0, 0x60, 0x0C, 0x08, 0x00, 0xC3, 0x00, 0x18, 0x40, 0x01, 0x98,
  0x00, 0x32, 0x00, 0x02, 0x40, 0x00, 0x58, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xA0, 0x00, 0x24, 0x00, 0x04, 0xC0,
  0x01, 0x88, 0x00, 0x31, 0x80, 0x0C, 0x10, 0x01, 0x83, 0x00, 0x60, 0x38,
  0x38, 0x01, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0xFF, 0x03, 0xFF,
  0x8C, 0x03, 0x30, 0x04, 0xC0, 0x1B, 0x00, 0x2C, 0x00, 0xB0, 0x02, 0xC0,
  0x0B, 0x00, 0x2C, 0x01, 0xB0, 0x06, 0xC0, 0x33, 0x01, 0x8F, 0xFC, 0x3F,
  0xC0, 0xC1, 0x83, 0x02, 0x0C, 0x0C, 0x30, 0x10, 0xC0, 0x63, 0x01, 0x8C,
  0x03, 0x30, 0x0C, 0xC0, 0x1B, 0x00, 0x6C, 0x00, 0xF0, 0x03, 0x0F, 0xF1,
  0xC1, 0xD8, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x03, 0x00, 0x18, 0x01, 0xB0, 0x39, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0x40,
  0x02, 0x60, 0x06, 0x30, 0x0C, 0x38, 0x18, 0x0F, 0xF0, 0xC0, 0x01, 0xE0,
  0x00, 0xD0, 0x00, 0x48, 0x00, 0x26, 0x00, 0x33, 0x00, 0x18, 0x80, 0x08,
  0x60, 0x04, 0x30, 0x06, 0x08, 0x03, 0x04, 0x01, 0x03, 0x01, 0x81, 0x80,
  0xC0, 0x40, 0x40, 0x20, 0x20, 0x18, 0x30, 0x0C, 0x18, 0x02, 0x08, 0x01,
  0x84, 0x00, 0xC6, 0x00, 0x22, 0x00, 0x11, 0x00, 0x0D, 0x80, 0x06, 0xC0,
  0x01, 0x40, 0x00, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00,
  0x34, 0x00, 0x60, 0x03, 0x60, 0x06, 0x00, 0x26, 0x00, 0x70, 0x02, 0x60,
  0x0F, 0x00, 0x62, 0x00, 0xD0, 0x06, 0x20, 0x09, 0x00, 0x43, 0x00, 0x98,
  0x04, 0x30, 0x09, 0x80, 0xC1, 0x01, 0x88, 0x0C, 0x10, 0x18, 0x80, 0xC1,
  0x81, 0x08, 0x08, 0x18, 0x10, 0xC1, 0x80, 0x83, 0x0C, 0x18, 0x08, 0x30,
  0x41, 0x80, 0xC2, 0x04, 0x10, 0x0C, 0x20, 0x61, 0x00, 0xC2, 0x06, 0x30,
  0x04, 0x60, 0x23, 0x00, 0x46, 0x02, 0x20, 0x06, 0x40, 0x22, 0x00, 0x64,
  0x03, 0x60, 0x02, 0xC0, 0x36, 0x00, 0x2C, 0x01, 0x40, 0x03, 0x80, 0x14,
  0x00, 0x38, 0x01, 0x40, 0x01, 0x80, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0x60,
  0x06, 0x40, 0x08, 0xC0, 0x30, 0x80, 0x61, 0x81, 0x81, 0x03, 0x03, 0x04,
  0x06, 0x18, 0x04, 0x20, 0x0C, 0xC0, 0x09, 0x00, 0x1E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xE0, 0x02, 0x40, 0x0C, 0xC0, 0x10, 0x80, 0x61,
  0x80, 0x83, 0x03, 0x02, 0x04, 0x06, 0x18, 0x04, 0x20, 0x0C, 0xC0, 0x09,
  0x80, 0x1E, 0x00, 0x30, 0xC0, 0x06, 0x80, 0x0D, 0x80, 0x13, 0x00, 0x62,
  0x00, 0x86, 0x03, 0x04, 0x06, 0x08, 0x08, 0x18, 0x30, 0x10, 0x40, 0x31,
  0x80, 0x23, 0x00, 0x44, 0x00, 0xD8, 0x00, 0xA0, 0x01, 0xC0, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x7F, 0xF9, 0xFF,
  0xE0, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0x80, 0x18, 0x01, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10, 0xFF,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0x01, 0x80, 0x01,
  0x80, 0x03, 0xC0, 0x02, 0x40, 0x06, 0x60, 0x04, 0x20, 0x0C, 0x30, 0x08,
  0x10, 0x18, 0x18, 0x10, 0x08, 0x30, 0x0C, 0x20, 0x04, 0x60, 0x06, 0x40,
  0x02, 0xC0, 0x03, 0xFF, 0xFF, 0xC3, 0x06, 0x0C, 0x10, 0x30, 0x1F, 0x87,
  0x9C, 0x40, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x3F, 0x1E, 0x36, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x07, 0xC0, 0x76, 0x1B, 0x3F, 0x30, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x1F, 0x09,
  0xCE, 0x2C, 0x0C, 0xA0, 0x1B, 0x00, 0x6C, 0x00, 0xB0, 0x02, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03,
  0xC0, 0x0B, 0x00, 0x6A, 0x01, 0xA8, 0x0C, 0x98, 0x62, 0x3F, 0x00, 0x07,
  0xE3, 0xCC, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x1C, 0x10, 0xFE, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x3E, 0x31, 0xCE, 0xCC,
  0x0F, 0x60, 0x1D, 0x00, 0x74, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0D,
  0x00, 0x36, 0x01, 0xD8, 0x0F, 0x30, 0x64, 0x7F, 0x10, 0x0F, 0x80, 0xE7,
  0x0C, 0x08, 0xC0, 0x64, 0x01, 0x20, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x20, 0xFF, 0x00, 0x03, 0xC0, 0xFC, 0x30,
  0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0xF3, 0xFE, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x00, 0x0F, 0x84, 0x73, 0xB3, 0x03, 0xD8, 0x07, 0x40, 0x0D, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x40, 0x1D, 0x80, 0x76, 0x03, 0xCC,
  0x1B, 0x1F, 0xCC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x01, 0x80, 0x04, 0x60, 0x71, 0xFF, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x78, 0x9C, 0xEB,
  0x03, 0xA0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C,
  0x30, 0x80, 0x00, 0x00, 0x02, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x86, 0xF0, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x06, 0x80, 0x48, 0x0C, 0x81, 0x88, 0x30,
  0x82, 0x08, 0x60, 0x8C, 0x08, 0x80, 0x9C, 0x0B, 0x40, 0xA6, 0x0C, 0x20,
  0x83, 0x08, 0x10, 0x81, 0x88, 0x08, 0x80, 0xC8, 0x04, 0x80, 0x68, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x8F, 0x83, 0xE4, 0xCE, 0x33, 0xA8, 0x1A, 0x07,
  0x40, 0xE0, 0x3C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x80, 0x30, 0x04,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80,
  0x8F, 0xC9, 0xCE, 0xB0, 0x3A, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x0F, 0xC0, 0x73, 0x83,
  0x03, 0x18, 0x06, 0x40, 0x0B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x40, 0x09, 0x80, 0x62, 0x01, 0x0E, 0x1C, 0x0F, 0xE0, 0x87, 0xC2, 0x73,
  0x8B, 0x03, 0x28, 0x06, 0xC0, 0x1B, 0x00, 0x2C, 0x00, 0xB0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xB0,
  0x02, 0xC0, 0x1A, 0x80, 0x6A, 0x03, 0x26, 0x18, 0x8F, 0xC2, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x00, 0x0F, 0x84, 0x73, 0xB3, 0x03, 0xD8, 0x07, 0x40, 0x1D, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x40, 0x1D, 0x80, 0x76, 0x03, 0xCE,
  0x1B, 0x1F, 0xCC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x8F, 0x9F, 0xB0, 0xA0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x0F, 0xC3, 0x8E, 0x60, 0x04, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x02, 0x00, 0x6C, 0x0C, 0x7F, 0x80,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x7F, 0xFF, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x30, 0x30,
  0x30, 0x1F, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x3C, 0x03, 0x40, 0x56, 0x09, 0x3F, 0x10, 0xC0, 0x0F,
  0x00, 0x24, 0x01, 0x98, 0x06, 0x60, 0x10, 0x80, 0x42, 0x03, 0x0C, 0x08,
  0x30, 0x20, 0x41, 0x81, 0x06, 0x06, 0x10, 0x08, 0x40, 0x23, 0x00, 0xC8,
  0x03, 0x20, 0x05, 0x80, 0x16, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x10, 0x05, 0x00, 0xE0, 0x14, 0x03, 0x80, 0xD8, 0x0A, 0x03, 0x60, 0x28,
  0x08, 0x81, 0xB0, 0x22, 0x06, 0xC1, 0x8C, 0x11, 0x06, 0x30, 0x44, 0x10,
  0x43, 0x18, 0x41, 0x0C, 0x61, 0x06, 0x20, 0x8C, 0x18, 0x82, 0x20, 0x26,
  0x0C, 0x80, 0x98, 0x32, 0x03, 0x40, 0x58, 0x0D, 0x01, 0x60, 0x14, 0x05,
  0x00, 0x70, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0xC0, 0x1A, 0x01,
  0x98, 0x08, 0x40, 0xC3, 0x04, 0x08, 0x60, 0x62, 0x01, 0x30, 0x0D, 0x00,
  0x38, 0x01, 0x80, 0x0E, 0x00, 0xD0, 0x04, 0xC0, 0x62, 0x02, 0x18, 0x30,
  0x41, 0x03, 0x18, 0x0C, 0x80, 0x6C, 0x01, 0x80, 0xC0, 0x0D, 0x00, 0x36,
  0x00, 0x98, 0x06, 0x20, 0x18, 0xC0, 0x43, 0x01, 0x04, 0x0C, 0x10, 0x30,
  0x60, 0x81, 0x86, 0x02, 0x18, 0x0C, 0x40, 0x31, 0x00, 0x4C, 0x01, 0x30,
  0x06, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x03, 0xC0,
  0x00, 0x7F, 0xCF, 0xF8, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20,
  0x0C, 0x01, 0x00, 0x60, 0x0F, 0xFE, 0x01, 0xC1, 0xE0, 0xC0, 0x30, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x60, 0xF0, 0x38, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x30, 0x06, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x3C, 0x01, 0x80, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x40, 0x18, 0x03, 0xC0, 0xF0, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x38, 0x38,
  0x00, 0x18, 0x00, 0xFE, 0x07, 0x07, 0x1C, 0x03, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraLight39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 28, 8, 3, -28 },
  { 8, 7, 10, 12, 3, -28 },
  { 17, 17, 28, 19, 1, -28 },
  { 77, 14, 32, 18, 2, -30 },
  { 133, 22, 28, 26, 2, -28 },
  { 210, 17, 28, 19, 2, -28 },
  { 270, 1, 10, 7, 3, -28 },
  { 272, 7, 34, 10, 2, -28 },
  { 302, 8, 34, 10, 1, -28 },
  { 336, 12, 13, 16, 2, -30 },
  { 356, 15, 18, 18, 1, -23 },
  { 390, 4, 9, 7, 1, -4 },
  { 395, 9, 1, 11, 1, -11 },
  { 397, 2, 3, 8, 3, -3 },
  { 398, 11, 28, 13, 1, -28 },
  { 437, 14, 28, 18, 2, -28 },
  { 486, 8, 28, 18, 3, -28 },
  { 514, 13, 28, 18, 2, -28 },
  { 560, 13, 28, 18, 2, -28 },
  { 606, 16, 28, 18, 1, -28 },
  { 662, 14, 28, 18, 2, -28 },
  { 711, 14, 28, 18, 2, -28 },
  { 760, 14, 28, 18, 2, -28 },
  { 809, 14, 28, 18, 2, -28 },
  { 858, 13, 28, 18, 2, -28 },
  { 904, 2, 21, 8, 3, -21 },
  { 910, 4, 26, 8, 1, -21 },
  { 923, 15, 17, 18, 1, -22 },
  { 955, 15, 10, 18, 1, -19 },
  { 974, 15, 17, 18, 1, -22 },
  { 1006, 10, 28, 12, 1, -28 },
  { 1041, 23, 32, 27, 2, -28 },
  { 1133, 18, 28, 18, 0, -28 },
  { 1196, 15, 28, 19, 3, -28 },
  { 1249, 16, 28, 19, 2, -28 },
  { 1305, 16, 28, 21, 3, -28 },
  { 1361, 12, 28, 17, 3, -28 },
  { 1403, 12, 28, 16, 3, -28 },
  { 1445, 18, 28, 23, 2, -28 },
  { 1508, 16, 28, 22, 3, -28 },
  { 1564, 6, 28, 10, 2, -28 },
  { 1585, 7, 35, 8, -2, -28 },
  { 1616, 14, 28, 17, 3, -28 },
  { 1665, 12, 28, 15, 3, -28 },
  { 1707, 22, 28, 28, 3, -28 },
  { 1784, 16, 28, 22, 3, -28 },
  { 1840, 19, 28, 23, 2, -28 },
  { 1907, 13, 28, 18, 3, -28 },
  { 1953, 19, 35, 23, 2, -28 },
  { 2037, 14, 28, 18, 3, -28 },
  { 2086, 13, 28, 17, 2, -28 },
  { 2132, 15, 28, 15, 0, -28 },
  { 2185, 16, 28, 22, 3, -28 },
  { 2241, 17, 28, 17, 0, -28 },
  { 2301, 28, 28, 28, 0, -28 },
  { 2399, 15, 28, 16, 0, -28 },
  { 2452, 15, 28, 15, 0, -28 },
  { 2505, 14, 28, 16, 1, -28 },
  { 2554, 8, 34, 12, 3, -28 },
  { 2588, 11, 28, 13, 1, -28 },
  { 2627, 8, 34, 12, 1, -28 },
  { 2661, 16, 15, 18, 1, -28 },
  { 2691, 16, 1, 16, 0, 4 },
  { 2693, 6, 6, 9, 2, -30 },
  { 2698, 12, 21, 16, 2, -21 },
  { 2730, 14, 30, 19, 3, -30 },
  { 2783, 11, 21, 14, 2, -21 },
  { 2812, 14, 30, 19, 2, -30 },
  { 2865, 13, 21, 17, 2, -21 },
  { 2900, 11, 30, 9, 0, -30 },
  { 2942, 14, 30, 19, 2, -21 },
  { 2995, 12, 30, 18, 3, -30 },
  { 3040, 2, 28, 8, 3, -28 },
  { 3047, 6, 37, 8, -1, -28 },
  { 3075, 12, 30, 15, 3, -30 },
  { 3120, 1, 30, 7, 3, -30 },
  { 3124, 21, 21, 27, 3, -21 },
  { 3180, 12, 21, 18, 3, -21 },
  { 3212, 14, 21, 18, 2, -21 },
  { 3249, 14, 30, 19, 3, -21 },
  { 3302, 14, 30, 19, 2, -21 },
  { 3355, 8, 21, 12, 3, -21 },
  { 3376, 12, 21, 14, 1, -21 },
  { 3408, 8, 26, 10, 1, -26 },
  { 3434, 12, 21, 18, 3, -21 },
  { 3466, 14, 21, 14, 0, -21 },
  { 3503, 22, 21, 23, 0, -21 },
  { 3561, 13, 21, 15, 1, -21 },
  { 3596, 14, 30, 14, 0, -21 },
  { 3649, 11, 21, 13, 1, -21 },
  { 3678, 10, 34, 14, 2, -28 },
  { 3721, 1, 39, 17, 8, -30 },
  { 3726, 10, 34, 14, 2, -28 },
  { 3769, 15, 4, 18, 1, -16 },
};

const GFXfont NotoSans_Condensed_ExtraLight39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight39pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT39PT7B_H_
