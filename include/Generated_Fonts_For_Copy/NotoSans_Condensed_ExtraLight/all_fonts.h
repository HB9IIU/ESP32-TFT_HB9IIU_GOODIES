#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_Condensed_ExtraLight
// Headers: 67

#include "NotoSans_Condensed_ExtraLight6pt7b.h"
#include "NotoSans_Condensed_ExtraLight7pt7b.h"
#include "NotoSans_Condensed_ExtraLight8pt7b.h"
#include "NotoSans_Condensed_ExtraLight9pt7b.h"
#include "NotoSans_Condensed_ExtraLight10pt7b.h"
#include "NotoSans_Condensed_ExtraLight11pt7b.h"
#include "NotoSans_Condensed_ExtraLight12pt7b.h"
#include "NotoSans_Condensed_ExtraLight13pt7b.h"
#include "NotoSans_Condensed_ExtraLight14pt7b.h"
#include "NotoSans_Condensed_ExtraLight15pt7b.h"
#include "NotoSans_Condensed_ExtraLight16pt7b.h"
#include "NotoSans_Condensed_ExtraLight17pt7b.h"
#include "NotoSans_Condensed_ExtraLight18pt7b.h"
#include "NotoSans_Condensed_ExtraLight19pt7b.h"
#include "NotoSans_Condensed_ExtraLight20pt7b.h"
#include "NotoSans_Condensed_ExtraLight21pt7b.h"
#include "NotoSans_Condensed_ExtraLight22pt7b.h"
#include "NotoSans_Condensed_ExtraLight23pt7b.h"
#include "NotoSans_Condensed_ExtraLight24pt7b.h"
#include "NotoSans_Condensed_ExtraLight25pt7b.h"
#include "NotoSans_Condensed_ExtraLight26pt7b.h"
#include "NotoSans_Condensed_ExtraLight27pt7b.h"
#include "NotoSans_Condensed_ExtraLight28pt7b.h"
#include "NotoSans_Condensed_ExtraLight29pt7b.h"
#include "NotoSans_Condensed_ExtraLight30pt7b.h"
#include "NotoSans_Condensed_ExtraLight31pt7b.h"
#include "NotoSans_Condensed_ExtraLight32pt7b.h"
#include "NotoSans_Condensed_ExtraLight33pt7b.h"
#include "NotoSans_Condensed_ExtraLight34pt7b.h"
#include "NotoSans_Condensed_ExtraLight35pt7b.h"
#include "NotoSans_Condensed_ExtraLight36pt7b.h"
#include "NotoSans_Condensed_ExtraLight37pt7b.h"
#include "NotoSans_Condensed_ExtraLight38pt7b.h"
#include "NotoSans_Condensed_ExtraLight39pt7b.h"
#include "NotoSans_Condensed_ExtraLight40pt7b.h"
#include "NotoSans_Condensed_ExtraLight41pt7b.h"
#include "NotoSans_Condensed_ExtraLight42pt7b.h"
#include "NotoSans_Condensed_ExtraLight43pt7b.h"
#include "NotoSans_Condensed_ExtraLight44pt7b.h"
#include "NotoSans_Condensed_ExtraLight45pt7b.h"
#include "NotoSans_Condensed_ExtraLight46pt7b.h"
#include "NotoSans_Condensed_ExtraLight47pt7b.h"
#include "NotoSans_Condensed_ExtraLight48pt7b.h"
#include "NotoSans_Condensed_ExtraLight49pt7b.h"
#include "NotoSans_Condensed_ExtraLight50pt7b.h"
#include "NotoSans_Condensed_ExtraLight51pt7b.h"
#include "NotoSans_Condensed_ExtraLight52pt7b.h"
#include "NotoSans_Condensed_ExtraLight53pt7b.h"
#include "NotoSans_Condensed_ExtraLight54pt7b.h"
#include "NotoSans_Condensed_ExtraLight55pt7b.h"
#include "NotoSans_Condensed_ExtraLight56pt7b.h"
#include "NotoSans_Condensed_ExtraLight57pt7b.h"
#include "NotoSans_Condensed_ExtraLight58pt7b.h"
#include "NotoSans_Condensed_ExtraLight59pt7b.h"
#include "NotoSans_Condensed_ExtraLight60pt7b.h"
#include "NotoSans_Condensed_ExtraLight61pt7b.h"
#include "NotoSans_Condensed_ExtraLight62pt7b.h"
#include "NotoSans_Condensed_ExtraLight63pt7b.h"
#include "NotoSans_Condensed_ExtraLight64pt7b.h"
#include "NotoSans_Condensed_ExtraLight65pt7b.h"
#include "NotoSans_Condensed_ExtraLight66pt7b.h"
#include "NotoSans_Condensed_ExtraLight67pt7b.h"
#include "NotoSans_Condensed_ExtraLight68pt7b.h"
#include "NotoSans_Condensed_ExtraLight69pt7b.h"
#include "NotoSans_Condensed_ExtraLight70pt7b.h"
#include "NotoSans_Condensed_ExtraLight71pt7b.h"
#include "NotoSans_Condensed_ExtraLight72pt7b.h"
