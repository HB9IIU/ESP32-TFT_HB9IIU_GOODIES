#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT59PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight59pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x76, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x7F, 0xF7, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x18, 0x00, 0x30, 0x06, 0x00, 0x06,
  0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0,
  0x00, 0x40, 0x18, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60,
  0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x03,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC0, 0x30, 0x06, 0x00, 0x06, 0x00,
  0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x60, 0x18, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x0C,
  0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06,
  0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0xC0,
  0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60,
  0x18, 0x00, 0x08, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x60, 0x0C, 0x00,
  0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01,
  0x80, 0x01, 0x80, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xE3, 0x0F,
  0x0E, 0x0C, 0x04, 0x30, 0x30, 0x01, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x18,
  0x0C, 0x00, 0x60, 0x30, 0x03, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0C,
  0x00, 0x60, 0x30, 0x01, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0E, 0x0C, 0x00,
  0x1E, 0x30, 0x00, 0x1E, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xDE, 0x00, 0x03, 0x3C, 0x00, 0x0C, 0x38, 0x00, 0x30,
  0x70, 0x00, 0xC0, 0xE0, 0x03, 0x01, 0x80, 0x0C, 0x07, 0x00, 0x30, 0x1C,
  0x00, 0xC0, 0x30, 0x03, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x30, 0x18, 0x00,
  0xC0, 0x60, 0x03, 0x03, 0xA0, 0x0C, 0x1C, 0x70, 0x31, 0xE1, 0xFF, 0xFF,
  0x01, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xE0, 0x0E, 0x38, 0x00, 0x60, 0x06, 0x0C, 0x00, 0x30, 0x06, 0x03, 0x00,
  0x30, 0x03, 0x01, 0x80, 0x18, 0x03, 0x80, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x0C, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x06, 0x00, 0x30, 0x06,
  0x03, 0x00, 0x18, 0x03, 0x03, 0x00, 0x0C, 0x01, 0x81, 0x80, 0x06, 0x00,
  0xC0, 0xC0, 0x03, 0x00, 0x60, 0xC0, 0x01, 0x80, 0x30, 0x60, 0x00, 0xC0,
  0x18, 0x60, 0x00, 0x60, 0x0C, 0x30, 0x78, 0x30, 0x06, 0x18, 0x7F, 0x18,
  0x03, 0x18, 0x61, 0xCE, 0x03, 0x0C, 0x60, 0x63, 0x01, 0x8C, 0x30, 0x39,
  0x80, 0xC6, 0x30, 0x0C, 0x60, 0xC3, 0x18, 0x06, 0x38, 0xE3, 0x0C, 0x03,
  0x0F, 0xE1, 0x86, 0x01, 0x81, 0xC1, 0x83, 0x00, 0x60, 0x00, 0xC1, 0x80,
  0x30, 0x00, 0x60, 0xC0, 0x18, 0x00, 0x60, 0x40, 0x0C, 0x00, 0x30, 0x20,
  0x06, 0x00, 0x38, 0x10, 0x03, 0x00, 0x18, 0x0C, 0x01, 0x80, 0x0C, 0x06,
  0x00, 0xC0, 0x0C, 0x03, 0x00, 0xE0, 0x06, 0x01, 0x80, 0x60, 0x07, 0x00,
  0xC0, 0x30, 0x03, 0x00, 0x60, 0x18, 0x01, 0x80, 0x18, 0x0C, 0x01, 0x80,
  0x0C, 0x0C, 0x00, 0xC0, 0x07, 0x06, 0x00, 0xE0, 0x01, 0xCE, 0x00, 0x60,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x18, 0x00,
  0x1C, 0x03, 0x00, 0x03, 0x00, 0x70, 0x00, 0x60, 0x0E, 0x00, 0x0C, 0x00,
  0xC0, 0x01, 0x80, 0x18, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0xE0, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x18, 0x18,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x1C, 0x1C, 0x01, 0x87, 0x01, 0xC0, 0x30, 0xC0,
  0x18, 0x06, 0x38, 0x03, 0x80, 0xC6, 0x00, 0x38, 0x18, 0xC0, 0x03, 0x06,
  0x38, 0x00, 0x70, 0xC7, 0x00, 0x07, 0x18, 0xE0, 0x00, 0x66, 0x1C, 0x00,
  0x06, 0xC3, 0x80, 0x00, 0xF0, 0x30, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x7C, 0x0C, 0x00, 0x1D, 0xC1, 0xC0, 0x07, 0x18, 0x1C, 0x03,
  0xC3, 0x81, 0xFF, 0xE0, 0x38, 0x1F, 0xF8, 0x03, 0x80, 0x30, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x30, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x08, 0x0C, 0x07, 0xC3, 0x0F, 0x7E, 0xDF, 0x81, 0xFE,
  0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0x30, 0x01, 0xC6, 0x00, 0x61, 0xC0,
  0x30, 0x30, 0x1C, 0x06, 0x0E, 0x01, 0xC1, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x0C, 0x31, 0xC6, 0x18,
  0x43, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF0,
  0x01, 0xE3, 0xC0, 0x1C, 0x07, 0x01, 0xC0, 0x1C, 0x0C, 0x00, 0x60, 0xE0,
  0x03, 0x86, 0x00, 0x0C, 0x70, 0x00, 0x63, 0x80, 0x03, 0x18, 0x00, 0x1C,
  0xC0, 0x00, 0x66, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x80, 0x00, 0xDC, 0x00,
  0x06, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x6E, 0x00, 0x03, 0x70,
  0x00, 0x1B, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x03,
  0x9C, 0x00, 0x18, 0x60, 0x00, 0xC3, 0x00, 0x0E, 0x1C, 0x00, 0x60, 0x60,
  0x07, 0x03, 0x80, 0x30, 0x0E, 0x03, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0xE0, 0x3C, 0x0F, 0x83, 0xB0, 0xE6, 0x38, 0xDE, 0x1F, 0x03, 0xC0,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xE0,
  0x00, 0xFF, 0xC0, 0x3F, 0x1F, 0x0F, 0x00, 0x38, 0x60, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8,
  0x00, 0x7F, 0xF8, 0x07, 0xE3, 0xE0, 0xF0, 0x03, 0x8E, 0x00, 0x0E, 0x20,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xD0, 0x00, 0x1C, 0xE0, 0x03, 0xC7, 0xFD, 0xFC,
  0x07, 0xFF, 0x80, 0x01, 0xA0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0x60, 0x00, 0x0E,
  0x30, 0x00, 0x06, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x03, 0x00, 0x03, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x00,
  0xC0, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x38, 0x00, 0xC0, 0x18, 0x00, 0x60,
  0x1C, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0x0C, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x7F, 0xE0, 0x1F, 0xFF, 0xC0, 0x60, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x62, 0x00, 0x07,
  0x1C, 0x00, 0xF0, 0xFF, 0x7F, 0x01, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00,
  0x0E, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x07, 0xE0, 0x38, 0xFF,
  0xC1, 0xCE, 0x07, 0x8C, 0xC0, 0x1C, 0x6C, 0x00, 0x73, 0x40, 0x01, 0xDE,
  0x00, 0x06, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60,
  0x00, 0x3B, 0x00, 0x01, 0xD8, 0x00, 0x0C, 0xE0, 0x00, 0x63, 0x00, 0x03,
  0x18, 0x00, 0x38, 0x60, 0x01, 0x83, 0x80, 0x1C, 0x0E, 0x01, 0xC0, 0x3E,
  0x7C, 0x00, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x3F, 0xF8, 0x03, 0xE3, 0xE0, 0x38, 0x03, 0x83, 0x80, 0x0E, 0x18,
  0x00, 0x31, 0xC0, 0x01, 0xCC, 0x00, 0x0E, 0x60, 0x00, 0x33, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x07, 0x38, 0x00, 0x30, 0xC0,
  0x01, 0x87, 0x00, 0x18, 0x1C, 0x01, 0xC0, 0x70, 0x1C, 0x01, 0xE3, 0xC0,
  0x07, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x1E, 0x78, 0x01, 0xC0,
  0xE0, 0x1C, 0x03, 0xC1, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0xC0, 0x00, 0xEE,
  0x00, 0x03, 0x60, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0x70,
  0x00, 0x19, 0xC0, 0x01, 0xCE, 0x00, 0x1C, 0x3C, 0x01, 0xC0, 0xFC, 0xFC,
  0x01, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xC0, 0x0F,
  0x1F, 0x01, 0xC0, 0x38, 0x38, 0x01, 0x87, 0x00, 0x1C, 0x60, 0x00, 0xCE,
  0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00,
  0x0F, 0x70, 0x01, 0xB3, 0x80, 0x3B, 0x1E, 0x0F, 0x30, 0xFF, 0xC3, 0x03,
  0xF0, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x03, 0xDF, 0x80, 0x3F, 0xF0, 0x00, 0x60, 0x00, 0x4F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x08, 0xF3, 0xCF, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x18, 0x63, 0x8E,
  0x30, 0xC3, 0x1C, 0x61, 0x84, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0xF0, 0xFC, 0xFC, 0x40,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x07, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x70, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x03, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x60, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x00, 0xC3,
  0x00, 0x1F, 0xF0, 0x0C, 0x60, 0x07, 0xFE, 0x01, 0x9C, 0x01, 0xC0, 0xC0,
  0x33, 0x00, 0x70, 0x18, 0x06, 0x60, 0x1C, 0x03, 0x00, 0x6C, 0x03, 0x00,
  0x60, 0x0D, 0x80, 0x60, 0x0C, 0x01, 0xF0, 0x18, 0x01, 0x80, 0x3C, 0x03,
  0x00, 0x30, 0x07, 0x80, 0x60, 0x06, 0x00, 0xF0, 0x0C, 0x00, 0xC0, 0x1E,
  0x01, 0x80, 0x18, 0x03, 0xC0, 0x30, 0x03, 0x00, 0x78, 0x06, 0x00, 0x60,
  0x0F, 0x00, 0xC0, 0x1C, 0x01, 0xE0, 0x18, 0x03, 0x80, 0x6C, 0x03, 0x00,
  0x70, 0x0D, 0x80, 0x60, 0x0E, 0x01, 0xB8, 0x0E, 0x03, 0x40, 0x73, 0x00,
  0xC0, 0x68, 0x0C, 0x60, 0x1C, 0x19, 0x83, 0x8C, 0x01, 0xFE, 0x1F, 0xE1,
  0x80, 0x1F, 0x83, 0xF8, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x1E, 0x00, 0x18, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x31, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x30, 0x18, 0x00,
  0x06, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x00,
  0xC0, 0x01, 0xC0, 0x18, 0x00, 0x30, 0x03, 0x80, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x38, 0x00, 0x30, 0x06, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x0C, 0x07, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x38, 0x18, 0x00, 0x03,
  0x07, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0E, 0x18, 0x00, 0x01, 0xC3, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x73, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x1C, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x0C, 0x00, 0x7C, 0x30, 0x00, 0x38, 0xC0, 0x00, 0x73, 0x00, 0x01, 0xCC,
  0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0xEC, 0x00,
  0x03, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x07,
  0x30, 0x00, 0x18, 0xC0, 0x00, 0xE3, 0x00, 0x07, 0x0C, 0x00, 0xF8, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x03, 0x00, 0x0F, 0x0C, 0x00, 0x0E, 0x30, 0x00,
  0x1C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xB0, 0x00, 0x06,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x0E, 0xC0, 0x00,
  0x33, 0x00, 0x01, 0xCC, 0x00, 0x1E, 0x30, 0x01, 0xF0, 0xFF, 0xFF, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFE, 0x7F,
  0x01, 0xE0, 0x06, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x02, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xC0, 0x0F, 0x80,
  0xC0, 0x01, 0xE0, 0xC0, 0x00, 0xF0, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0x38,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E,
  0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E,
  0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x18,
  0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xE0, 0xC0, 0x03, 0xC0,
  0xC0, 0x0F, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xB0, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0x00, 0x0E, 0x03, 0xC0, 0x00,
  0x20, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30,
  0x3C, 0x00, 0x03, 0x01, 0xF0, 0x00, 0xF0, 0x07, 0xFB, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0xFF, 0xBF, 0x87, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xE0, 0x3B, 0xFE, 0x7F, 0x81, 0x80, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xB0, 0x00, 0x39, 0x80, 0x01, 0x8C, 0x00, 0x1C, 0x60, 0x01, 0xC3, 0x00,
  0x1C, 0x18, 0x00, 0xC0, 0xC0, 0x0E, 0x06, 0x00, 0xE0, 0x30, 0x06, 0x01,
  0x80, 0x70, 0x0C, 0x07, 0x00, 0x60, 0x70, 0x03, 0x03, 0x80, 0x18, 0x38,
  0x00, 0xC3, 0x80, 0x06, 0x18, 0x00, 0x31, 0xC0, 0x01, 0x9F, 0x00, 0x0C,
  0xD8, 0x00, 0x6C, 0xE0, 0x03, 0xC3, 0x00, 0x1E, 0x1C, 0x00, 0xE0, 0x70,
  0x06, 0x03, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x0C, 0x01, 0xC0, 0x60,
  0x06, 0x03, 0x00, 0x38, 0x18, 0x00, 0xC0, 0xC0, 0x07, 0x06, 0x00, 0x1C,
  0x30, 0x00, 0x61, 0x80, 0x03, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x73, 0x00,
  0x01, 0x98, 0x00, 0x0E, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFD, 0x80, 0x00, 0x00,
  0xFE, 0xC0, 0x00, 0x00, 0xFF, 0x70, 0x00, 0x00, 0x6F, 0x98, 0x00, 0x00,
  0x37, 0xCC, 0x00, 0x00, 0x3B, 0xE6, 0x00, 0x00, 0x19, 0xF1, 0x80, 0x00,
  0x0C, 0xF8, 0xC0, 0x00, 0x0E, 0x7C, 0x70, 0x00, 0x06, 0x3E, 0x18, 0x00,
  0x03, 0x1F, 0x0C, 0x00, 0x03, 0x8F, 0x86, 0x00, 0x01, 0x87, 0xC1, 0x80,
  0x00, 0xC3, 0xE0, 0xC0, 0x00, 0xE1, 0xF0, 0x60, 0x00, 0x60, 0xF8, 0x18,
  0x00, 0x30, 0x7C, 0x0C, 0x00, 0x38, 0x3E, 0x06, 0x00, 0x18, 0x1F, 0x01,
  0x80, 0x0C, 0x0F, 0x80, 0xC0, 0x0E, 0x07, 0xC0, 0x60, 0x06, 0x03, 0xE0,
  0x18, 0x03, 0x01, 0xF0, 0x0C, 0x03, 0x80, 0xF8, 0x06, 0x01, 0x80, 0x7C,
  0x01, 0x80, 0xC0, 0x3E, 0x00, 0xC0, 0xE0, 0x1F, 0x00, 0x60, 0x60, 0x0F,
  0x80, 0x18, 0x30, 0x07, 0xC0, 0x0C, 0x38, 0x03, 0xE0, 0x06, 0x18, 0x01,
  0xF0, 0x01, 0x8C, 0x00, 0xF8, 0x00, 0xCE, 0x00, 0x7C, 0x00, 0x66, 0x00,
  0x3E, 0x00, 0x1B, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xD8, 0x00,
  0x03, 0xD8, 0x00, 0x03, 0xCC, 0x00, 0x03, 0xCC, 0x00, 0x03, 0xC6, 0x00,
  0x03, 0xC6, 0x00, 0x03, 0xC3, 0x00, 0x03, 0xC3, 0x00, 0x03, 0xC1, 0x80,
  0x03, 0xC1, 0x80, 0x03, 0xC0, 0xC0, 0x03, 0xC0, 0xC0, 0x03, 0xC0, 0x60,
  0x03, 0xC0, 0x60, 0x03, 0xC0, 0x30, 0x03, 0xC0, 0x30, 0x03, 0xC0, 0x18,
  0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x0C, 0x03, 0xC0, 0x0E, 0x03, 0xC0, 0x06,
  0x03, 0xC0, 0x07, 0x03, 0xC0, 0x03, 0x03, 0xC0, 0x03, 0x83, 0xC0, 0x01,
  0x83, 0xC0, 0x01, 0xC3, 0xC0, 0x00, 0xC3, 0xC0, 0x00, 0xE3, 0xC0, 0x00,
  0x63, 0xC0, 0x00, 0x73, 0xC0, 0x00, 0x33, 0xC0, 0x00, 0x3B, 0xC0, 0x00,
  0x1B, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7E, 0x3F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00,
  0x01, 0xC0, 0x30, 0x00, 0x06, 0x03, 0x80, 0x00, 0x38, 0x18, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xC7,
  0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x37, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x0D, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x38, 0x30,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xC0, 0x38, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x14, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0xC0, 0x0F, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0xCC, 0x00, 0x0E, 0xC0,
  0x00, 0xEC, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x03,
  0x8C, 0x00, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7E, 0x3F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x70, 0x00, 0x70, 0x07,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x06, 0x03, 0x80, 0x00, 0x38, 0x38, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x37, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x38,
  0x30, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xC0, 0x38,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x17, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x30,
  0x03, 0xE1, 0x80, 0x07, 0x0C, 0x00, 0x1C, 0x60, 0x00, 0x73, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0xB0, 0x00, 0x1D, 0x80,
  0x00, 0xEC, 0x00, 0x07, 0x60, 0x00, 0x3B, 0x00, 0x01, 0x98, 0x00, 0x0C,
  0xC0, 0x00, 0xE6, 0x00, 0x06, 0x30, 0x00, 0x71, 0x80, 0x07, 0x0C, 0x00,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x30, 0x07, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xE0, 0x60, 0x03,
  0x03, 0x00, 0x1C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x86, 0x00, 0x0C, 0x30,
  0x00, 0x71, 0x80, 0x01, 0x8C, 0x00, 0x0E, 0x60, 0x00, 0x33, 0x00, 0x01,
  0xD8, 0x00, 0x0E, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00,
  0x7F, 0xFC, 0x0F, 0xCF, 0xF1, 0xC0, 0x06, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0xC0, 0x07, 0x8F, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x1E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x67, 0x00, 0x01, 0xC6, 0x00,
  0x03, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x78, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x06, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC3,
  0x00, 0x00, 0x30, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x06, 0x06, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x70, 0x06, 0x00, 0x18, 0x01,
  0x80, 0x06, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x03, 0x00, 0x30,
  0x00, 0xC0, 0x0C, 0x00, 0x30, 0x07, 0x00, 0x0E, 0x01, 0x80, 0x01, 0x80,
  0x60, 0x00, 0x60, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x00,
  0xC0, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x0E, 0x18, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x18, 0xE0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x00,
  0xEC, 0x00, 0x07, 0x80, 0x00, 0x66, 0x00, 0x03, 0xE0, 0x00, 0x33, 0x00,
  0x01, 0xB0, 0x00, 0x19, 0xC0, 0x00, 0xD8, 0x00, 0x1C, 0xE0, 0x00, 0x6C,
  0x00, 0x0C, 0x30, 0x00, 0x76, 0x00, 0x06, 0x18, 0x00, 0x33, 0x80, 0x03,
  0x0C, 0x00, 0x18, 0xC0, 0x03, 0x87, 0x00, 0x0C, 0x60, 0x01, 0xC1, 0x80,
  0x0E, 0x30, 0x00, 0xC0, 0xC0, 0x06, 0x1C, 0x00, 0x60, 0x60, 0x03, 0x06,
  0x00, 0x70, 0x38, 0x01, 0x83, 0x00, 0x38, 0x0C, 0x00, 0xC1, 0x80, 0x18,
  0x06, 0x00, 0xE0, 0xC0, 0x0C, 0x03, 0x00, 0x60, 0x70, 0x06, 0x01, 0xC0,
  0x30, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x0C, 0x03, 0x00, 0x30, 0x1C, 0x06,
  0x01, 0x80, 0x18, 0x0C, 0x03, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0xE0,
  0x07, 0x03, 0x00, 0x60, 0x70, 0x01, 0x81, 0x80, 0x30, 0x30, 0x00, 0xC1,
  0xC0, 0x18, 0x18, 0x00, 0x60, 0xC0, 0x0E, 0x1C, 0x00, 0x38, 0x60, 0x03,
  0x0E, 0x00, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x06, 0x18, 0x00, 0xC3, 0x00,
  0x03, 0x18, 0x00, 0x71, 0x80, 0x01, 0x8C, 0x00, 0x19, 0xC0, 0x00, 0xE6,
  0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0x1B, 0x80, 0x03,
  0x30, 0x00, 0x0D, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x70, 0x00, 0x18, 0x60, 0x00, 0x70, 0xE0, 0x00, 0xC0, 0xC0, 0x03, 0x81,
  0xC0, 0x06, 0x01, 0x80, 0x1C, 0x03, 0x80, 0x30, 0x03, 0x00, 0xE0, 0x06,
  0x01, 0x80, 0x0E, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x18,
  0x70, 0x00, 0x38, 0xC0, 0x00, 0x33, 0x80, 0x00, 0x76, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66, 0x00, 0x01, 0xC6, 0x00,
  0x03, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x70, 0x38, 0x00,
  0xC0, 0x30, 0x03, 0x80, 0x70, 0x06, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x30,
  0x01, 0xC0, 0xE0, 0x01, 0x81, 0x80, 0x03, 0x87, 0x00, 0x03, 0x0C, 0x00,
  0x07, 0x18, 0x00, 0x06, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0xE0, 0x00,
  0x0E, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x73, 0x80, 0x00, 0xC3, 0x00, 0x01,
  0x87, 0x00, 0x07, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x60,
  0x18, 0x00, 0xC0, 0x38, 0x03, 0x80, 0x30, 0x06, 0x00, 0x60, 0x1C, 0x00,
  0xE0, 0x30, 0x00, 0xC0, 0x60, 0x01, 0xC1, 0xC0, 0x01, 0x83, 0x00, 0x03,
  0x06, 0x00, 0x07, 0x18, 0x00, 0x06, 0x30, 0x00, 0x0E, 0xE0, 0x00, 0x0D,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x36, 0x00, 0x00, 0x73, 0x00, 0x00, 0x63, 0x00, 0x00,
  0xE1, 0x80, 0x00, 0xC1, 0x80, 0x01, 0xC0, 0xC0, 0x01, 0x80, 0xC0, 0x03,
  0x80, 0xE0, 0x03, 0x00, 0x60, 0x07, 0x00, 0x70, 0x06, 0x00, 0x30, 0x0E,
  0x00, 0x38, 0x0C, 0x00, 0x18, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x38,
  0x00, 0x0E, 0x30, 0x00, 0x06, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0xF8, 0x03, 0xFF, 0x81, 0xF0, 0xF0,
  0x60, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x03, 0xFC, 0x0F, 0xFF, 0x0F, 0x80, 0xC7, 0x00, 0x33, 0x80, 0x0D,
  0xC0, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x0D, 0x70, 0x02, 0x4E, 0x01,
  0x91, 0xE3, 0xC4, 0x3F, 0xE1, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x3E, 0x03, 0x87, 0xFC, 0x1C,
  0xF0, 0xF0, 0xEE, 0x01, 0xC7, 0x60, 0x07, 0x3E, 0x00, 0x1D, 0xE0, 0x00,
  0x6F, 0x00, 0x03, 0x78, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1B,
  0xC0, 0x00, 0xDE, 0x00, 0x0E, 0xF8, 0x00, 0x66, 0x60, 0x07, 0x33, 0x80,
  0x71, 0x8F, 0xBF, 0x0C, 0x1F, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x01,
  0xFF, 0xC1, 0xF0, 0xE1, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x04, 0x1F, 0xBE, 0x07, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x7C, 0x0C, 0x1F, 0xF8, 0x61,
  0xE0, 0xE3, 0x1C, 0x01, 0x98, 0xC0, 0x06, 0xCE, 0x00, 0x16, 0x60, 0x00,
  0xF7, 0x00, 0x03, 0xB0, 0x00, 0x1D, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x76, 0x00, 0x03, 0xB0, 0x00, 0x1D,
  0x80, 0x01, 0xEE, 0x00, 0x0F, 0x30, 0x00, 0xD9, 0xC0, 0x06, 0xC7, 0x00,
  0xE6, 0x1F, 0xBE, 0x30, 0x7F, 0xE1, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x3F, 0xE0, 0x0F, 0x0F, 0x01, 0xC0, 0x38, 0x18, 0x01, 0xC3, 0x80, 0x0C,
  0x30, 0x00, 0xE7, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x20, 0xE0, 0x06,
  0x07, 0xE7, 0xE0, 0x3F, 0xF8, 0x00, 0x38, 0x00, 0x00, 0xFE, 0x07, 0xFC,
  0x0E, 0x08, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x3F, 0xFC,
  0x7F, 0xF8, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x3F, 0xF0, 0xC3, 0xE1, 0xC6, 0x38, 0x03, 0x33, 0x80, 0x0D, 0x9C, 0x00,
  0x2D, 0xC0, 0x01, 0xEE, 0x00, 0x07, 0x60, 0x00, 0x3B, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xEC, 0x00, 0x07,
  0x60, 0x00, 0x3B, 0x00, 0x03, 0xDC, 0x00, 0x16, 0x60, 0x01, 0xB3, 0x80,
  0x19, 0x8E, 0x01, 0xCC, 0x3F, 0x7C, 0x60, 0x7F, 0x83, 0x00, 0x60, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x10,
  0x00, 0x70, 0xF0, 0x07, 0x07, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0xF8, 0x38, 0xFF, 0xC7, 0x3C, 0x3C,
  0xEE, 0x01, 0xDD, 0x80, 0x1B, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x06, 0x6E, 0xFE, 0x60,
  0x00, 0x00, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x03, 0x03, 0x81, 0xE0, 0xE0,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x39, 0xF8, 0xF8, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x3B, 0x80, 0x0C,
  0xE0, 0x06, 0x38, 0x03, 0x8E, 0x01, 0xC3, 0x80, 0x60, 0xE0, 0x38, 0x38,
  0x1C, 0x0E, 0x06, 0x03, 0x83, 0x00, 0xE1, 0xC0, 0x38, 0x60, 0x0E, 0x38,
  0x03, 0x9E, 0x00, 0xEF, 0xC0, 0x3B, 0x30, 0x0F, 0x8E, 0x03, 0xC1, 0x80,
  0xF0, 0x70, 0x38, 0x0C, 0x0E, 0x03, 0x83, 0x80, 0x60, 0xE0, 0x1C, 0x38,
  0x03, 0x0E, 0x00, 0xE3, 0x80, 0x18, 0xE0, 0x07, 0x38, 0x00, 0xCE, 0x00,
  0x3B, 0x80, 0x06, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xF0, 0x01, 0xE0, 0x61, 0xFF, 0x03, 0xFE, 0x31, 0xC3, 0x83, 0x8F, 0x99,
  0x80, 0xE3, 0x01, 0xCD, 0x80, 0x3B, 0x00, 0x76, 0x80, 0x0D, 0x00, 0x1B,
  0xC0, 0x07, 0x80, 0x0F, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0x01,
  0xF0, 0x00, 0x60, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x18, 0x00,
  0x3E, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x06, 0x00, 0x0F, 0x80, 0x03, 0x00,
  0x07, 0xC0, 0x01, 0x80, 0x03, 0xE0, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x60,
  0x00, 0xF8, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x3E, 0x00, 0x0C,
  0x00, 0x1F, 0x00, 0x06, 0x00, 0x0F, 0x80, 0x03, 0x00, 0x07, 0xC0, 0x01,
  0x80, 0x03, 0xE0, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x60, 0x00, 0xF8, 0x00,
  0x30, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x1F, 0x00,
  0x06, 0x00, 0x0F, 0x80, 0x03, 0x00, 0x07, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x7C, 0x18, 0x7F, 0xE3, 0x1E, 0x1E, 0x67, 0x00, 0xEC, 0xC0, 0x0D, 0xB0,
  0x01, 0xF4, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0x00, 0x78, 0x00, 0x1F, 0xF8, 0x03, 0xC1, 0xE0, 0x38,
  0x03, 0x81, 0x80, 0x0E, 0x18, 0x00, 0x31, 0xC0, 0x01, 0xCC, 0x00, 0x06,
  0x60, 0x00, 0x33, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x6C, 0x00, 0x07, 0x60, 0x00, 0x33, 0x80, 0x01, 0x8C,
  0x00, 0x1C, 0x70, 0x00, 0xC1, 0x80, 0x0E, 0x07, 0x00, 0xE0, 0x1F, 0x7E,
  0x00, 0x7F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x7C, 0x06, 0x0F, 0xF8, 0x31,
  0xE1, 0xE1, 0x9C, 0x03, 0x8C, 0xC0, 0x0E, 0x6C, 0x00, 0x3B, 0x40, 0x00,
  0xDE, 0x00, 0x06, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x37,
  0x80, 0x01, 0xBC, 0x00, 0x1D, 0xF0, 0x00, 0xCE, 0xC0, 0x0E, 0x73, 0x00,
  0xE3, 0x9F, 0x7E, 0x1C, 0x3F, 0xC0, 0xE0, 0x30, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF0,
  0xC3, 0xE3, 0xC6, 0x38, 0x03, 0x31, 0x80, 0x0D, 0x9C, 0x00, 0x2C, 0xC0,
  0x01, 0xEE, 0x00, 0x0F, 0x60, 0x00, 0x3B, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x60, 0x00,
  0x3B, 0x00, 0x03, 0xDC, 0x00, 0x16, 0x70, 0x01, 0xB3, 0x80, 0x19, 0x8E,
  0x01, 0xCC, 0x3F, 0x7C, 0x60, 0xFF, 0x83, 0x00, 0x60, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0xF6, 0x1F, 0xF1,
  0xFF, 0x9C, 0x0C, 0xC0, 0x6C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0x01, 0xF0, 0x07, 0xFF, 0x87, 0x83, 0xE7, 0x00, 0x27, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x77, 0x00, 0x7B, 0xFB, 0xF8, 0x7F, 0xF0, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xC7, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0xDC, 0x0F, 0xE0, 0x1C, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0x60, 0x00, 0xEC, 0x00, 0x3D, 0xC0, 0x05, 0xB8, 0x01, 0xB3, 0x80,
  0x66, 0x3E, 0xF8, 0xC3, 0xFE, 0x18, 0x04, 0x00, 0xE0, 0x00, 0x36, 0x00,
  0x03, 0x60, 0x00, 0x77, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0E, 0x30,
  0x00, 0xE3, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x1C, 0x18, 0x01, 0x81,
  0xC0, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x38, 0x0E, 0x03, 0x00, 0x60, 0x30,
  0x06, 0x07, 0x00, 0x60, 0x60, 0x07, 0x06, 0x00, 0x30, 0x60, 0x03, 0x0E,
  0x00, 0x38, 0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x1D,
  0x80, 0x00, 0xD8, 0x00, 0x0D, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x01, 0xB8, 0x00,
  0x70, 0x00, 0xCC, 0x00, 0x6C, 0x00, 0x66, 0x00, 0x36, 0x00, 0x73, 0x00,
  0x1B, 0x00, 0x31, 0xC0, 0x0D, 0x80, 0x18, 0x60, 0x0C, 0xE0, 0x0C, 0x30,
  0x06, 0x30, 0x06, 0x18, 0x03, 0x18, 0x06, 0x0C, 0x01, 0x8C, 0x03, 0x07,
  0x01, 0x87, 0x01, 0x81, 0x80, 0xC1, 0x80, 0xC0, 0xC0, 0x60, 0xC0, 0xE0,
  0x60, 0x30, 0x60, 0x60, 0x38, 0x30, 0x30, 0x30, 0x0C, 0x18, 0x0C, 0x18,
  0x06, 0x0C, 0x06, 0x1C, 0x03, 0x06, 0x03, 0x0C, 0x01, 0xC6, 0x01, 0x86,
  0x00, 0x63, 0x00, 0x63, 0x00, 0x31, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x19,
  0x80, 0x0E, 0xC0, 0x0C, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x01, 0xB0, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x73, 0x00, 0x0E, 0x38, 0x00, 0xC1, 0x80, 0x1C, 0x1C, 0x01, 0x80, 0xC0,
  0x38, 0x0E, 0x03, 0x00, 0x60, 0x60, 0x07, 0x06, 0x00, 0x30, 0xC0, 0x03,
  0x9C, 0x00, 0x19, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0x98, 0x00, 0x39, 0xC0,
  0x03, 0x0C, 0x00, 0x70, 0x60, 0x06, 0x06, 0x00, 0xE0, 0x30, 0x0C, 0x03,
  0x01, 0x80, 0x18, 0x18, 0x01, 0xC3, 0x00, 0x0C, 0x70, 0x00, 0xE6, 0x00,
  0x06, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x1B, 0x80, 0x01, 0xCC, 0x00, 0x0C,
  0x60, 0x00, 0x63, 0x00, 0x07, 0x1C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00,
  0x0C, 0x1C, 0x00, 0xE0, 0x60, 0x06, 0x03, 0x00, 0x30, 0x18, 0x03, 0x80,
  0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xE0, 0x60, 0x03, 0x03,
  0x00, 0x18, 0x18, 0x00, 0xC1, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00,
  0xC7, 0x00, 0x07, 0x30, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0x80, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x7C,
  0x01, 0xE0, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xFC,
  0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xC0, 0x05, 0xE7,
  0xC0, 0x1F, 0x01, 0xF0, 0xE8, 0x00, 0xFF, 0x90, 0x00, 0x7C, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLight59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 42, 12, 4, -42 },
  { 22, 11, 15, 19, 4, -42 },
  { 43, 27, 42, 29, 1, -42 },
  { 185, 22, 48, 27, 2, -45 },
  { 317, 33, 44, 39, 3, -43 },
  { 499, 27, 44, 29, 2, -43 },
  { 648, 2, 15, 10, 4, -42 },
  { 652, 11, 51, 16, 3, -42 },
  { 723, 11, 51, 16, 2, -42 },
  { 794, 18, 19, 24, 3, -45 },
  { 837, 23, 27, 27, 2, -34 },
  { 915, 6, 14, 11, 2, -6 },
  { 926, 13, 2, 17, 2, -17 },
  { 930, 4, 4, 12, 4, -4 },
  { 932, 18, 42, 20, 1, -42 },
  { 1027, 21, 43, 27, 3, -43 },
  { 1140, 11, 42, 27, 5, -42 },
  { 1198, 20, 43, 27, 3, -43 },
  { 1306, 21, 44, 27, 2, -43 },
  { 1422, 25, 42, 27, 1, -42 },
  { 1554, 21, 43, 27, 3, -42 },
  { 1667, 21, 44, 27, 3, -43 },
  { 1783, 21, 42, 27, 3, -42 },
  { 1894, 21, 44, 27, 3, -43 },
  { 2010, 20, 44, 27, 3, -43 },
  { 2120, 4, 32, 12, 4, -32 },
  { 2136, 6, 40, 12, 2, -32 },
  { 2166, 23, 26, 27, 2, -34 },
  { 2241, 23, 14, 27, 2, -28 },
  { 2282, 23, 26, 27, 2, -34 },
  { 2357, 16, 43, 19, 1, -43 },
  { 2443, 35, 47, 41, 3, -42 },
  { 2649, 27, 42, 27, 0, -42 },
  { 2791, 22, 42, 29, 5, -42 },
  { 2907, 24, 44, 28, 3, -43 },
  { 3039, 24, 42, 32, 5, -42 },
  { 3165, 18, 42, 26, 5, -42 },
  { 3260, 18, 42, 24, 5, -42 },
  { 3355, 28, 44, 34, 3, -43 },
  { 3509, 23, 42, 33, 5, -42 },
  { 3630, 9, 42, 15, 3, -42 },
  { 3678, 11, 53, 12, -4, -42 },
  { 3751, 21, 42, 26, 5, -42 },
  { 3862, 17, 42, 23, 5, -42 },
  { 3952, 33, 42, 43, 5, -42 },
  { 4126, 24, 42, 34, 5, -42 },
  { 4252, 29, 44, 35, 3, -43 },
  { 4412, 20, 42, 27, 5, -42 },
  { 4517, 29, 53, 35, 3, -43 },
  { 4710, 21, 42, 28, 5, -42 },
  { 4821, 20, 44, 26, 3, -43 },
  { 4931, 23, 42, 23, 0, -42 },
  { 5052, 23, 43, 33, 5, -42 },
  { 5176, 26, 42, 26, 0, -42 },
  { 5313, 41, 42, 43, 1, -42 },
  { 5529, 23, 42, 24, 0, -42 },
  { 5650, 23, 42, 23, 0, -42 },
  { 5771, 20, 42, 24, 2, -42 },
  { 5876, 11, 51, 18, 5, -42 },
  { 5947, 18, 42, 20, 1, -42 },
  { 6042, 11, 51, 18, 2, -42 },
  { 6113, 24, 22, 27, 1, -42 },
  { 6179, 24, 2, 24, 0, 5 },
  { 6185, 10, 9, 14, 2, -45 },
  { 6197, 18, 33, 25, 2, -32 },
  { 6272, 21, 46, 28, 4, -45 },
  { 6393, 17, 33, 22, 3, -32 },
  { 6464, 21, 46, 28, 3, -45 },
  { 6585, 20, 33, 26, 3, -32 },
  { 6668, 15, 45, 14, 1, -45 },
  { 6753, 21, 46, 28, 3, -32 },
  { 6874, 19, 45, 28, 4, -45 },
  { 6981, 4, 43, 11, 4, -43 },
  { 7003, 9, 57, 11, -1, -43 },
  { 7068, 18, 45, 22, 4, -45 },
  { 7170, 3, 45, 11, 4, -45 },
  { 7187, 33, 32, 41, 4, -32 },
  { 7319, 19, 32, 28, 4, -32 },
  { 7395, 21, 33, 27, 3, -32 },
  { 7482, 21, 46, 28, 4, -32 },
  { 7603, 21, 46, 28, 3, -32 },
  { 7724, 13, 32, 18, 4, -32 },
  { 7776, 17, 33, 21, 2, -32 },
  { 7847, 13, 40, 15, 1, -39 },
  { 7912, 19, 32, 28, 4, -31 },
  { 7988, 20, 31, 21, 0, -31 },
  { 8066, 33, 31, 34, 1, -31 },
  { 8194, 20, 31, 22, 1, -31 },
  { 8272, 21, 45, 21, 0, -31 },
  { 8391, 15, 31, 19, 2, -31 },
  { 8450, 15, 51, 21, 3, -42 },
  { 8546, 2, 59, 25, 12, -45 },
  { 8561, 15, 51, 21, 3, -42 },
  { 8657, 23, 6, 27, 2, -24 },
};

const GFXfont NotoSans_Condensed_ExtraLight59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight59pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT59PT7B_H_
