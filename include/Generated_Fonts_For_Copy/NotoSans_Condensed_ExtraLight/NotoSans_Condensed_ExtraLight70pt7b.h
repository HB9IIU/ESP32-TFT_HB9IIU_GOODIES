#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT70PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight70pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x3B, 0xFF, 0xFB, 0x80, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x36,
  0x01, 0xB0, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0,
  0x36, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x38, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x30, 0x03, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x01,
  0x80, 0x1C, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x80, 0x18, 0x00, 0x03,
  0x80, 0x18, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xEF, 0xF8, 0x3C, 0x30, 0x3C,
  0x3C, 0x18, 0x04, 0x1C, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x0C, 0x03, 0x00,
  0x0E, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x30,
  0x00, 0xE0, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x03,
  0x00, 0x07, 0x01, 0x80, 0x03, 0xC0, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x3C,
  0x30, 0x00, 0x0F, 0x18, 0x00, 0x03, 0xEC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x67, 0xC0,
  0x00, 0x30, 0xF8, 0x00, 0x18, 0x1E, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x01,
  0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x38, 0x00, 0xC0, 0x1C, 0x00, 0x60,
  0x0E, 0x00, 0x30, 0x03, 0x00, 0x18, 0x03, 0x80, 0x0C, 0x01, 0xC0, 0x06,
  0x00, 0xE0, 0x03, 0x00, 0x70, 0x01, 0x80, 0x70, 0x00, 0xC0, 0x3A, 0x00,
  0x60, 0x79, 0xC0, 0x30, 0x78, 0xFE, 0x19, 0xF8, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1C, 0x00, 0x7D, 0xE0, 0x00, 0x30,
  0x00, 0xE0, 0xE0, 0x00, 0x60, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x06, 0x01,
  0xC0, 0x03, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x01, 0x80,
  0x1C, 0x01, 0x80, 0x03, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x00, 0x30, 0x0C,
  0x00, 0x1C, 0x00, 0x60, 0x18, 0x00, 0x38, 0x00, 0xC0, 0x70, 0x00, 0x70,
  0x01, 0x80, 0xC0, 0x00, 0xE0, 0x03, 0x03, 0x80, 0x01, 0xC0, 0x06, 0x06,
  0x00, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x07, 0x00, 0x18, 0x38, 0x00, 0x06,
  0x00, 0x70, 0x60, 0x38, 0x0C, 0x00, 0xE1, 0xC1, 0xFC, 0x18, 0x01, 0xC3,
  0x07, 0xBC, 0x30, 0x03, 0x06, 0x1C, 0x1C, 0x70, 0x06, 0x1C, 0x30, 0x1C,
  0xE0, 0x1C, 0x30, 0xE0, 0x38, 0xC0, 0x38, 0xE1, 0x80, 0x31, 0xC0, 0x61,
  0xC3, 0x00, 0x71, 0xC1, 0xC3, 0x0E, 0x00, 0xE3, 0xFF, 0x0E, 0x18, 0x00,
  0xC1, 0xFC, 0x18, 0x30, 0x01, 0x80, 0xC0, 0x70, 0x60, 0x03, 0x00, 0x00,
  0xE0, 0xC0, 0x06, 0x00, 0x01, 0x81, 0x80, 0x0C, 0x00, 0x07, 0x03, 0x00,
  0x18, 0x00, 0x0C, 0x06, 0x00, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x60, 0x00,
  0x70, 0x18, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x03, 0x80, 0x60,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x1C, 0x01, 0x80, 0x0C, 0x00,
  0x38, 0x03, 0x00, 0x38, 0x00, 0x60, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0E, 0x00, 0x1C, 0x07, 0x00,
  0x1C, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x00,
  0x3F, 0xE0, 0x01, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x07, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x60, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x70, 0x01, 0x80, 0x00, 0xE0,
  0x03, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x1C, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x60, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x1D, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x43, 0x80, 0xE0, 0x03, 0x0E, 0x00, 0xE0, 0x06,
  0x38, 0x01, 0xC0, 0x0C, 0x70, 0x01, 0xC0, 0x38, 0xC0, 0x01, 0xC0, 0x73,
  0x80, 0x01, 0xC0, 0xE7, 0x00, 0x03, 0x81, 0x8E, 0x00, 0x03, 0x87, 0x18,
  0x00, 0x03, 0x8E, 0x30, 0x00, 0x07, 0x38, 0x60, 0x00, 0x07, 0x70, 0xE0,
  0x00, 0x07, 0xC1, 0xC0, 0x00, 0x0F, 0x83, 0x80, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x3E, 0x07, 0x00, 0x00, 0xFE, 0x0E, 0x00, 0x01, 0xDC, 0x0E, 0x00,
  0x0F, 0x1C, 0x1E, 0x00, 0x3C, 0x1C, 0x1F, 0x01, 0xF0, 0x38, 0x1F, 0xFF,
  0xC0, 0x38, 0x0F, 0xFE, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xDB, 0x6D, 0xB6, 0xD8, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x70, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x18, 0x0C, 0x03, 0xFC, 0x10, 0x7D, 0xFC, 0x4F, 0xE0, 0x7F, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0xE0, 0x00, 0x71,
  0xC0, 0x03, 0x83, 0x00, 0x0C, 0x06, 0x00, 0x70, 0x1C, 0x03, 0x80, 0x38,
  0x1C, 0x00, 0x60, 0x10, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x1C, 0x71, 0xC7, 0x38, 0xE3, 0x8E, 0x31, 0xC7, 0x18, 0x63,
  0x8C, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x78, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x18, 0x1C, 0x00,
  0x0E, 0x0C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x87, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x06, 0x70,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0E, 0xC0, 0x00,
  0x07, 0x60, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x33, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x1C, 0x60,
  0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x06, 0x00, 0x03, 0x83,
  0x80, 0x01, 0xC1, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0xE0, 0x3C, 0x00, 0xE0,
  0x0F, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x3E, 0x03, 0xB0, 0x39,
  0x87, 0x9C, 0x78, 0xE7, 0x87, 0x78, 0x3F, 0x01, 0xD0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x07,
  0xC0, 0x3E, 0x07, 0x80, 0x07, 0x81, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x07, 0x87, 0x00, 0x00,
  0xE1, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x71, 0x80, 0x00, 0xF0,
  0xF8, 0x01, 0xF0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x33, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x06, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x18, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x80, 0x0E, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x00, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x63, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x30, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0xC0, 0x00, 0xF0, 0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xFC, 0x01, 0xF8, 0x04, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x3E, 0x00, 0xE1, 0xFF, 0xC0,
  0xE3, 0xFF, 0xF0, 0xE7, 0x00, 0x78, 0xCE, 0x00, 0x3C, 0xDC, 0x00, 0x1C,
  0xD8, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x06, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x06, 0x30, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x0F, 0x80, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x07,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x30, 0x00, 0x07,
  0x1C, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0C, 0x70, 0x00,
  0x03, 0x1C, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x06, 0x07, 0x00, 0x03, 0x81, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x0F,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x01, 0xC0, 0x01, 0xE0,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x7C, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x07, 0x80,
  0xE0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x18, 0x70, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x18, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x06, 0xE0, 0x00,
  0x03, 0x70, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3D, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0x9C, 0x00, 0x07, 0xCE, 0x00, 0x06, 0xE3, 0x80, 0x06, 0x71,
  0xE0, 0x0F, 0x38, 0x7F, 0xFF, 0x18, 0x0F, 0xFE, 0x0C, 0x01, 0xFC, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x20, 0x0F, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x3C, 0x78,
  0xF9, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xC1, 0x87,
  0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0xFC, 0x3C, 0x07,
  0xC4, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x7F, 0x00, 0x1C, 0x60, 0x00,
  0xFF, 0xF0, 0x0E, 0x70, 0x00, 0xF8, 0xF8, 0x03, 0x38, 0x00, 0xE0, 0x18,
  0x01, 0x98, 0x00, 0xE0, 0x0C, 0x00, 0xCC, 0x00, 0xE0, 0x06, 0x00, 0x7E,
  0x00, 0x70, 0x03, 0x00, 0x3F, 0x00, 0x70, 0x01, 0x80, 0x1F, 0x80, 0x38,
  0x00, 0xC0, 0x0F, 0xC0, 0x18, 0x00, 0x60, 0x07, 0xC0, 0x0C, 0x00, 0x30,
  0x01, 0xE0, 0x0E, 0x00, 0x18, 0x00, 0xF0, 0x07, 0x00, 0x0C, 0x00, 0x78,
  0x03, 0x80, 0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x00, 0x3E, 0x00, 0xE0,
  0x03, 0x80, 0x1F, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x80, 0x38, 0x00, 0xE0,
  0x07, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0x60, 0x0E, 0x00, 0x38, 0x01, 0xB0,
  0x07, 0x00, 0x3C, 0x00, 0xD8, 0x01, 0x80, 0x1E, 0x00, 0xEE, 0x00, 0xE0,
  0x0F, 0x00, 0x67, 0x00, 0x70, 0x0D, 0xC0, 0x73, 0x80, 0x1C, 0x0E, 0x60,
  0x70, 0xC0, 0x0F, 0x0E, 0x38, 0x78, 0x60, 0x03, 0xFE, 0x0F, 0xF8, 0x38,
  0x00, 0x7E, 0x03, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x80,
  0x00, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x18,
  0x38, 0x00, 0x00, 0x38, 0x18, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x30,
  0x1C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x01, 0xC0,
  0x03, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x60, 0x0E, 0x00,
  0x00, 0x70, 0x0C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x30, 0x1C, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x00, 0x18, 0x38, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x0E, 0x01, 0xFF, 0x83, 0x80, 0x01, 0xF0, 0xE0, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x33, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x03,
  0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00,
  0x07, 0x38, 0x00, 0x01, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0xE0,
  0x00, 0x3C, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0xFE, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x3E, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x38, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x8E,
  0x00, 0x07, 0xC3, 0x80, 0x3F, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x00, 0x20, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x02, 0x00, 0xFC, 0x00, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xC0, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xE0, 0x3F,
  0xF0, 0x0E, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x06, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x01, 0xF8, 0x0E,
  0x07, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x06, 0x01, 0xE0, 0x00, 0x02, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x03, 0x38, 0x00, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x03, 0x38, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x03, 0x1E, 0x00,
  0x00, 0x03, 0x0E, 0x00, 0x00, 0x03, 0x07, 0x00, 0x00, 0x03, 0x07, 0x80,
  0x00, 0x03, 0x03, 0xC0, 0x00, 0x03, 0x01, 0xF0, 0x00, 0x03, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x39, 0x03, 0xCF, 0xFC, 0x7F, 0xC0, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xB8, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x8E,
  0x00, 0x03, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xC0,
  0xE0, 0x01, 0xE0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0xF0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x78,
  0x00, 0xE0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x1E, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xCF,
  0x80, 0x00, 0xEE, 0xE0, 0x00, 0x76, 0x78, 0x00, 0x3F, 0x1C, 0x00, 0x1F,
  0x07, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0xE0,
  0x1C, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x03,
  0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x38, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x39, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFD, 0x80, 0x00, 0x00, 0x07, 0xFB, 0x80, 0x00, 0x00, 0x0D, 0xF7, 0x00,
  0x00, 0x00, 0x3B, 0xE6, 0x00, 0x00, 0x00, 0x77, 0xCE, 0x00, 0x00, 0x00,
  0xCF, 0xDC, 0x00, 0x00, 0x03, 0x9F, 0x98, 0x00, 0x00, 0x07, 0x3F, 0x38,
  0x00, 0x00, 0x0C, 0x7E, 0x70, 0x00, 0x00, 0x38, 0xFC, 0x60, 0x00, 0x00,
  0x71, 0xF8, 0xE0, 0x00, 0x00, 0xC3, 0xF1, 0xC0, 0x00, 0x03, 0x87, 0xE1,
  0x80, 0x00, 0x07, 0x0F, 0xC3, 0x80, 0x00, 0x0C, 0x1F, 0x87, 0x00, 0x00,
  0x38, 0x3F, 0x06, 0x00, 0x00, 0x70, 0x7E, 0x0E, 0x00, 0x00, 0xC0, 0xFC,
  0x1C, 0x00, 0x03, 0x81, 0xF8, 0x18, 0x00, 0x07, 0x03, 0xF0, 0x38, 0x00,
  0x0C, 0x07, 0xE0, 0x70, 0x00, 0x38, 0x0F, 0xC0, 0x60, 0x00, 0x70, 0x1F,
  0x80, 0xE0, 0x00, 0xC0, 0x3F, 0x01, 0xC0, 0x03, 0x80, 0x7E, 0x01, 0x80,
  0x07, 0x00, 0xFC, 0x03, 0x80, 0x0C, 0x01, 0xF8, 0x07, 0x00, 0x38, 0x03,
  0xF0, 0x06, 0x00, 0x70, 0x07, 0xE0, 0x0E, 0x00, 0xC0, 0x0F, 0xC0, 0x1C,
  0x03, 0x80, 0x1F, 0x80, 0x18, 0x07, 0x00, 0x3F, 0x00, 0x38, 0x0C, 0x00,
  0x7E, 0x00, 0x70, 0x38, 0x00, 0xFC, 0x00, 0x60, 0x70, 0x01, 0xF8, 0x00,
  0xE0, 0xC0, 0x03, 0xF0, 0x01, 0xC1, 0x80, 0x07, 0xE0, 0x01, 0x87, 0x00,
  0x0F, 0xC0, 0x03, 0x8C, 0x00, 0x1F, 0x80, 0x07, 0x18, 0x00, 0x3F, 0x00,
  0x06, 0x70, 0x00, 0x7E, 0x00, 0x0E, 0xE0, 0x00, 0xFC, 0x00, 0x1D, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x3E,
  0x38, 0x00, 0x03, 0xE3, 0x80, 0x00, 0x3E, 0x1C, 0x00, 0x03, 0xE1, 0xC0,
  0x00, 0x3E, 0x0E, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x3E, 0x07, 0x00, 0x03,
  0xE0, 0x70, 0x00, 0x3E, 0x03, 0x80, 0x03, 0xE0, 0x38, 0x00, 0x3E, 0x01,
  0xC0, 0x03, 0xE0, 0x0C, 0x00, 0x3E, 0x00, 0xE0, 0x03, 0xE0, 0x06, 0x00,
  0x3E, 0x00, 0x70, 0x03, 0xE0, 0x03, 0x00, 0x3E, 0x00, 0x38, 0x03, 0xE0,
  0x01, 0x80, 0x3E, 0x00, 0x1C, 0x03, 0xE0, 0x00, 0xC0, 0x3E, 0x00, 0x0E,
  0x03, 0xE0, 0x00, 0x60, 0x3E, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x30, 0x3E,
  0x00, 0x03, 0x83, 0xE0, 0x00, 0x18, 0x3E, 0x00, 0x01, 0xC3, 0xE0, 0x00,
  0x0C, 0x3E, 0x00, 0x00, 0xE3, 0xE0, 0x00, 0x07, 0x3E, 0x00, 0x00, 0x73,
  0xE0, 0x00, 0x03, 0xBE, 0x00, 0x00, 0x3B, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x0E, 0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x01, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF8,
  0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0x81, 0xFF, 0x87,
  0x00, 0x0F, 0x8E, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x07, 0x70,
  0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0xF1, 0xC0, 0x03, 0xC3, 0x81, 0xFF, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x01,
  0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF8, 0x07,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x38, 0x3F, 0xF8, 0x1C, 0x00, 0x3E, 0x0E,
  0x00, 0x07, 0x87, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38,
  0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x67, 0x00, 0x00, 0x33, 0x80, 0x00, 0x39, 0xC0, 0x00,
  0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00,
  0x01, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0,
  0x01, 0xE0, 0xE0, 0x03, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0x70,
  0x1C, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x01,
  0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x0F, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x3D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xC1, 0xF8, 0x03,
  0xC1, 0xE0, 0x00, 0x20, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x71, 0x80, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x03, 0xB0, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x18, 0x70, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x07,
  0x0C, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x30,
  0x30, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x60, 0x06, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0x80,
  0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x07, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0x80, 0x00, 0x38, 0x03,
  0x00, 0x00, 0x30, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x07, 0x06, 0x00, 0x00, 0x06, 0x1C, 0x00, 0x00, 0x0C, 0x38, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1C, 0x60, 0x00,
  0x0E, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x1C, 0x00,
  0x03, 0xB8, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x9C, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0x81, 0x80, 0x00, 0xE3, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x71, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x30, 0xE0, 0x00, 0x70, 0x38,
  0x00, 0x18, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x01,
  0xC0, 0x03, 0x03, 0x80, 0x07, 0x00, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x00,
  0x30, 0x01, 0xC0, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x06, 0x00, 0x70, 0x0C,
  0x00, 0x0C, 0x03, 0x00, 0x18, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x0C, 0x07,
  0x00, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xC0, 0x03, 0x81,
  0xC0, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x70, 0x00, 0x60,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x0C, 0x00, 0x0E, 0x18, 0x00, 0x01, 0x86, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0xE7, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x73, 0x80, 0x00,
  0xE7, 0x00, 0x00, 0x39, 0x80, 0x00, 0x73, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x06, 0x60, 0x00, 0x0D, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x06, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x18,
  0x0E, 0x00, 0x03, 0x80, 0x60, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x1C,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x60, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x07,
  0x06, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x38, 0x01, 0xC0, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x70, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81,
  0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x06, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0xC0, 0x38, 0x00, 0x38, 0x03, 0x00, 0x07, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x06, 0x00, 0x1C, 0x01, 0xC0, 0x01,
  0x80, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x30,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x31, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x30,
  0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x38, 0x01, 0xC0, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x70, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x00, 0x7C, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xF0, 0x3C, 0x03, 0xC1, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xC0,
  0x31, 0xF0, 0x01, 0x9E, 0x00, 0x0D, 0xE0, 0x00, 0x6E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x5B, 0x80,
  0x06, 0xDC, 0x00, 0x66, 0x78, 0x07, 0x31, 0xFF, 0xF1, 0x87, 0xFE, 0x0C,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0xE0, 0xFF, 0xC0, 0x70, 0xFF, 0xF8, 0x39,
  0xE0, 0x1E, 0x1C, 0xC0, 0x07, 0x8E, 0xC0, 0x01, 0xC7, 0x60, 0x00, 0x73,
  0xE0, 0x00, 0x39, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x01,
  0xBC, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xDE, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x33, 0xE0, 0x00, 0x39, 0xF0, 0x00, 0x1C, 0xEC, 0x00, 0x1C,
  0x73, 0x00, 0x1C, 0x39, 0xE0, 0x3E, 0x18, 0x7F, 0xFE, 0x0C, 0x0F, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xC0, 0x7F, 0xFE,
  0x07, 0xC0, 0x20, 0x78, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x30, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x7C,
  0x03, 0x00, 0xFF, 0xC1, 0x81, 0xFF, 0xF0, 0xC1, 0xE0, 0x1C, 0x61, 0xE0,
  0x07, 0x30, 0xE0, 0x01, 0xD8, 0xE0, 0x00, 0x6C, 0xE0, 0x00, 0x1E, 0x70,
  0x00, 0x0F, 0x38, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x73, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x3C, 0xE0,
  0x00, 0x1E, 0x38, 0x00, 0x1B, 0x1C, 0x00, 0x1D, 0x87, 0x00, 0x1C, 0xC1,
  0xE0, 0x1C, 0x60, 0x7F, 0xFC, 0x30, 0x1F, 0xFC, 0x18, 0x00, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0x80, 0xF0,
  0x0F, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x0C,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x06, 0x07, 0xC0, 0x1E,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x04, 0x00,
  0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0x81, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0xE0, 0xC0, 0xFF, 0xF8, 0x60, 0xF0, 0x0E, 0x30,
  0xF0, 0x01, 0x98, 0xF0, 0x00, 0x6C, 0x70, 0x00, 0x36, 0x70, 0x00, 0x0F,
  0x38, 0x00, 0x07, 0x98, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0x80, 0x00, 0x0E, 0xC0, 0x00,
  0x03, 0x60, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x07, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x39, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x1E,
  0x70, 0x00, 0x0B, 0x1C, 0x00, 0x0D, 0x8E, 0x00, 0x0C, 0xC3, 0x80, 0x0E,
  0x60, 0xF0, 0x0E, 0x30, 0x3F, 0xFE, 0x18, 0x0F, 0xFC, 0x0C, 0x00, 0xF0,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x08,
  0x00, 0x07, 0x07, 0x80, 0x0F, 0x83, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0xE0, 0xFF, 0xC1, 0xC7, 0xFF, 0xC3, 0x9E, 0x03, 0xC7, 0x30, 0x03,
  0xCE, 0xC0, 0x03, 0x9F, 0x80, 0x03, 0xBE, 0x00, 0x07, 0x78, 0x00, 0x06,
  0xF0, 0x00, 0x0D, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE0,
  0x6F, 0xFF, 0xF4, 0x00, 0x00, 0x00, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x60, 0x01, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x3F,
  0xCF, 0xE3, 0xE0, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x77,
  0x00, 0x07, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x03,
  0x83, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x38,
  0x0E, 0x01, 0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x87, 0x00,
  0x1C, 0x78, 0x00, 0xE3, 0xE0, 0x07, 0x3B, 0x00, 0x3B, 0x9C, 0x01, 0xD8,
  0x60, 0x0F, 0x83, 0x80, 0x7C, 0x0C, 0x03, 0xC0, 0x70, 0x1C, 0x01, 0x80,
  0xE0, 0x0E, 0x07, 0x00, 0x30, 0x38, 0x01, 0xC1, 0xC0, 0x06, 0x0E, 0x00,
  0x38, 0x70, 0x00, 0xC3, 0x80, 0x07, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0xE7,
  0x00, 0x03, 0x38, 0x00, 0x1D, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x0F, 0x01,
  0x83, 0xFF, 0x00, 0xFF, 0x83, 0x0F, 0xFF, 0x03, 0xFF, 0xC6, 0x38, 0x0F,
  0x0E, 0x03, 0xCC, 0xE0, 0x0E, 0x30, 0x03, 0x9D, 0x80, 0x0E, 0xC0, 0x03,
  0xBE, 0x00, 0x1D, 0x80, 0x07, 0x78, 0x00, 0x1E, 0x00, 0x0E, 0xF0, 0x00,
  0x3C, 0x00, 0x0D, 0xE0, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x80,
  0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0x70,
  0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x0E,
  0x00, 0x03, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0xC0, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x1F, 0x01, 0x81, 0xFF, 0x83, 0x0F, 0xFF, 0x86, 0x3C, 0x07,
  0x8C, 0x60, 0x03, 0x9D, 0x80, 0x07, 0xBE, 0x00, 0x07, 0x7C, 0x00, 0x0E,
  0xF0, 0x00, 0x0D, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x03, 0x81, 0xC0,
  0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x0E, 0x70, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x1C,
  0x00, 0x06, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0x1E, 0x01, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x60, 0x7F, 0xE0, 0x30, 0x7F, 0xFC, 0x18, 0x70, 0x0F, 0x0C, 0x70,
  0x03, 0xC7, 0x70, 0x00, 0xE3, 0xB0, 0x00, 0x39, 0xF0, 0x00, 0x1C, 0xF8,
  0x00, 0x07, 0x78, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xDE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x6F, 0x00, 0x00, 0x77, 0x80, 0x00, 0x3B, 0xE0, 0x00, 0x19, 0xF0,
  0x00, 0x1C, 0xEC, 0x00, 0x0E, 0x76, 0x00, 0x0E, 0x39, 0xC0, 0x0E, 0x1C,
  0x70, 0x1F, 0x0E, 0x1F, 0xFE, 0x07, 0x07, 0xFE, 0x03, 0x80, 0x78, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0xE0, 0xC0, 0xFF, 0xF8, 0x60, 0xF0, 0x0E, 0x30,
  0xF0, 0x03, 0x98, 0x70, 0x00, 0xEC, 0x70, 0x00, 0x36, 0x70, 0x00, 0x0F,
  0x38, 0x00, 0x07, 0x9C, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0x80, 0x00, 0x0E, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x39, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x1E,
  0x70, 0x00, 0x1B, 0x1C, 0x00, 0x0D, 0x8F, 0x00, 0x0C, 0xC3, 0xC0, 0x0E,
  0x60, 0xF0, 0x1E, 0x30, 0x3F, 0xFE, 0x18, 0x0F, 0xFC, 0x0C, 0x00, 0xF0,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x18, 0xC0, 0xFF, 0xC3, 0xFE, 0xE3, 0x82, 0xE7, 0x00, 0xEE, 0x00,
  0xEC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0xE3,
  0xC0, 0x0E, 0x78, 0x00, 0x27, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x80, 0x01, 0xCF, 0x00, 0x78, 0xFF, 0xFF,
  0x03, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x1E, 0x00, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xF6, 0x00, 0x03,
  0xDC, 0x00, 0x1B, 0x70, 0x00, 0xEC, 0xE0, 0x07, 0x33, 0xE0, 0x38, 0xC7,
  0xFF, 0xC3, 0x07, 0xFE, 0x0C, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0x60,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x30,
  0x00, 0x0E, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0C, 0x00, 0x38, 0x0E,
  0x00, 0x30, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x07, 0x00, 0xE0, 0x03, 0x00, 0xE0, 0x03, 0x80, 0xC0, 0x03,
  0x81, 0xC0, 0x01, 0x81, 0xC0, 0x01, 0x81, 0xC0, 0x01, 0xC1, 0x80, 0x01,
  0xC3, 0x80, 0x00, 0xC3, 0x80, 0x00, 0xE3, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x67, 0x00, 0x00, 0x76, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x00, 0xF0,
  0x00, 0x33, 0x00, 0x03, 0xE0, 0x00, 0x67, 0x00, 0x07, 0xC0, 0x01, 0xCE,
  0x00, 0x0D, 0x80, 0x03, 0x9C, 0x00, 0x1B, 0x80, 0x07, 0x18, 0x00, 0x73,
  0x00, 0x0C, 0x30, 0x00, 0xE6, 0x00, 0x38, 0x70, 0x01, 0x8C, 0x00, 0x70,
  0xE0, 0x03, 0x1C, 0x00, 0xE0, 0xC0, 0x0E, 0x38, 0x01, 0x81, 0x80, 0x1C,
  0x30, 0x03, 0x03, 0x80, 0x30, 0x60, 0x0E, 0x07, 0x00, 0x60, 0xE0, 0x1C,
  0x06, 0x01, 0xC1, 0xC0, 0x30, 0x0C, 0x03, 0x81, 0x80, 0x60, 0x1C, 0x06,
  0x03, 0x01, 0xC0, 0x38, 0x0C, 0x07, 0x03, 0x80, 0x70, 0x38, 0x0E, 0x06,
  0x00, 0x60, 0x70, 0x0C, 0x0C, 0x00, 0xE0, 0xC0, 0x18, 0x18, 0x01, 0xC1,
  0x80, 0x38, 0x70, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x03, 0x0E, 0x00, 0x61,
  0x80, 0x07, 0x18, 0x00, 0xC3, 0x00, 0x0E, 0x30, 0x01, 0xCE, 0x00, 0x1C,
  0xE0, 0x03, 0x9C, 0x00, 0x19, 0xC0, 0x03, 0x30, 0x00, 0x33, 0x00, 0x06,
  0x60, 0x00, 0x76, 0x00, 0x0D, 0xC0, 0x00, 0xEC, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x03, 0x00, 0xE0, 0x03, 0x81, 0xC0, 0x01, 0x81, 0xC0, 0x01, 0xC3, 0x80,
  0x00, 0xC3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0x67, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x67, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xC3, 0x80,
  0x01, 0xC3, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x00, 0xE0,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x30, 0x1C, 0x00, 0x38,
  0x1C, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x30, 0x70, 0x00,
  0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x06, 0x00, 0x06, 0x03, 0x80,
  0x07, 0x01, 0xC0, 0x03, 0x80, 0x60, 0x01, 0x80, 0x38, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0xC0, 0x38, 0x00,
  0xE0, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0x03, 0x00, 0x01, 0x83, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x18, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xDC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x4F, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x0F,
  0x80, 0x7C, 0x0F, 0x80, 0x07, 0xFF, 0xA0, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLight70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 50, 15, 5, -50 },
  { 33, 13, 18, 22, 5, -50 },
  { 63, 32, 50, 35, 1, -50 },
  { 263, 25, 57, 32, 3, -53 },
  { 442, 39, 52, 46, 3, -51 },
  { 696, 31, 52, 35, 3, -51 },
  { 898, 3, 18, 12, 5, -50 },
  { 905, 13, 61, 19, 3, -50 },
  { 1005, 12, 61, 19, 3, -50 },
  { 1097, 22, 22, 29, 3, -53 },
  { 1158, 26, 32, 32, 3, -41 },
  { 1262, 6, 16, 13, 3, -7 },
  { 1274, 16, 2, 20, 2, -20 },
  { 1278, 4, 5, 14, 5, -5 },
  { 1281, 21, 50, 23, 1, -50 },
  { 1413, 25, 52, 32, 3, -51 },
  { 1576, 13, 50, 32, 6, -50 },
  { 1658, 25, 51, 32, 3, -51 },
  { 1818, 25, 52, 32, 3, -51 },
  { 1981, 30, 50, 32, 1, -50 },
  { 2169, 24, 51, 32, 4, -50 },
  { 2322, 24, 52, 32, 4, -51 },
  { 2478, 25, 50, 32, 3, -50 },
  { 2635, 26, 52, 32, 3, -51 },
  { 2804, 25, 52, 32, 3, -51 },
  { 2967, 4, 37, 14, 5, -37 },
  { 2986, 7, 46, 14, 3, -37 },
  { 3027, 26, 30, 32, 3, -40 },
  { 3125, 26, 17, 32, 3, -33 },
  { 3181, 26, 30, 32, 3, -40 },
  { 3279, 19, 51, 22, 1, -51 },
  { 3401, 41, 57, 49, 4, -50 },
  { 3694, 32, 50, 32, 0, -50 },
  { 3894, 26, 50, 35, 6, -50 },
  { 4057, 28, 52, 34, 4, -51 },
  { 4239, 28, 50, 38, 6, -50 },
  { 4414, 21, 50, 30, 6, -50 },
  { 4546, 21, 50, 28, 6, -50 },
  { 4678, 32, 52, 41, 4, -51 },
  { 4886, 27, 50, 39, 6, -50 },
  { 5055, 12, 50, 18, 3, -50 },
  { 5130, 13, 62, 14, -4, -50 },
  { 5231, 25, 50, 31, 6, -50 },
  { 5388, 20, 50, 28, 6, -50 },
  { 5513, 39, 50, 50, 6, -50 },
  { 5757, 28, 50, 40, 6, -50 },
  { 5932, 33, 52, 41, 4, -51 },
  { 6147, 23, 50, 32, 6, -50 },
  { 6291, 33, 63, 41, 4, -51 },
  { 6551, 25, 50, 33, 6, -50 },
  { 6708, 25, 52, 31, 3, -51 },
  { 6871, 27, 50, 28, 0, -50 },
  { 7040, 29, 51, 39, 5, -50 },
  { 7225, 31, 50, 31, 0, -50 },
  { 7419, 49, 50, 51, 1, -50 },
  { 7726, 28, 50, 28, 0, -50 },
  { 7901, 27, 50, 27, 0, -50 },
  { 8070, 25, 50, 28, 2, -50 },
  { 8227, 13, 61, 22, 6, -50 },
  { 8327, 21, 50, 23, 1, -50 },
  { 8459, 14, 61, 22, 2, -50 },
  { 8566, 28, 26, 32, 2, -50 },
  { 8657, 28, 3, 28, 0, 6 },
  { 8668, 11, 11, 17, 3, -53 },
  { 8684, 21, 39, 29, 3, -38 },
  { 8787, 25, 54, 34, 5, -53 },
  { 8956, 21, 39, 26, 3, -38 },
  { 9059, 25, 54, 34, 3, -53 },
  { 9228, 24, 39, 30, 3, -38 },
  { 9345, 18, 54, 17, 1, -54 },
  { 9467, 25, 55, 33, 3, -38 },
  { 9639, 23, 53, 33, 5, -53 },
  { 9792, 4, 51, 14, 5, -51 },
  { 9818, 10, 68, 14, -1, -51 },
  { 9903, 21, 53, 27, 5, -53 },
  { 10043, 3, 53, 13, 5, -53 },
  { 10063, 39, 38, 49, 5, -38 },
  { 10249, 23, 38, 33, 5, -38 },
  { 10359, 26, 39, 32, 3, -38 },
  { 10486, 25, 54, 33, 5, -38 },
  { 10655, 25, 54, 33, 3, -38 },
  { 10824, 16, 38, 21, 5, -38 },
  { 10900, 20, 39, 25, 3, -38 },
  { 10998, 15, 47, 18, 1, -46 },
  { 11087, 22, 38, 33, 5, -37 },
  { 11192, 24, 37, 25, 0, -37 },
  { 11303, 39, 37, 41, 1, -37 },
  { 11484, 24, 37, 26, 1, -37 },
  { 11595, 25, 54, 25, 0, -37 },
  { 11764, 19, 37, 23, 2, -37 },
  { 11852, 18, 61, 24, 3, -50 },
  { 11990, 2, 70, 30, 14, -53 },
  { 12008, 18, 61, 24, 3, -50 },
  { 12146, 26, 7, 32, 3, -28 },
};

const GFXfont NotoSans_Condensed_ExtraLight70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight70pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT70PT7B_H_
