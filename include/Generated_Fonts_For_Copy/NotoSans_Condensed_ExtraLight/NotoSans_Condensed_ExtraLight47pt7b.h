#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT47PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight47pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x00,
  0x03, 0xEC, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x18, 0x00, 0xC0, 0xC0, 0x04, 0x06, 0x00, 0x20,
  0x20, 0x01, 0x01, 0x00, 0x18, 0x08, 0x00, 0xC0, 0x40, 0x06, 0x06, 0x00,
  0x30, 0x30, 0x01, 0x01, 0x80, 0x08, 0x0C, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF0, 0x30, 0x10, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x40, 0x60, 0x02,
  0x03, 0x00, 0x10, 0x10, 0x01, 0x80, 0x80, 0x0C, 0x04, 0x00, 0x60, 0x20,
  0x03, 0x03, 0x03, 0xFF, 0xFF, 0xC0, 0x80, 0xC0, 0x04, 0x06, 0x00, 0x20,
  0x20, 0x03, 0x01, 0x00, 0x18, 0x08, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00,
  0x20, 0x30, 0x01, 0x01, 0x80, 0x08, 0x08, 0x00, 0xC0, 0x40, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0xFE, 0x01, 0xFF, 0xF1, 0xCC, 0x31,
  0x86, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x30,
  0x0C, 0x18, 0x06, 0x0C, 0x01, 0x86, 0x00, 0xE3, 0x00, 0x39, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1B, 0x80, 0x0C, 0x60, 0x06, 0x18,
  0x03, 0x06, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18,
  0x18, 0x0C, 0x0C, 0x06, 0x0D, 0x03, 0x0E, 0xE1, 0x8E, 0x7F, 0xFC, 0x03,
  0xF8, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x1F, 0x00,
  0x18, 0x0E, 0xE0, 0x04, 0x02, 0x08, 0x03, 0x01, 0x83, 0x00, 0xC0, 0x60,
  0x40, 0x20, 0x10, 0x10, 0x18, 0x0C, 0x06, 0x04, 0x03, 0x01, 0x83, 0x00,
  0xC0, 0x60, 0xC0, 0x30, 0x18, 0x20, 0x0C, 0x06, 0x18, 0x03, 0x01, 0x84,
  0x00, 0xC0, 0x63, 0x00, 0x30, 0x18, 0xC3, 0x0C, 0x06, 0x23, 0xF1, 0x01,
  0x18, 0xC6, 0x60, 0xC4, 0x60, 0x98, 0x33, 0x10, 0x33, 0x08, 0xCC, 0x0C,
  0xEE, 0x23, 0x01, 0x1F, 0x18, 0xC0, 0x40, 0x04, 0x30, 0x10, 0x03, 0x0C,
  0x04, 0x00, 0xC3, 0x01, 0x00, 0x20, 0xC0, 0x40, 0x18, 0x30, 0x10, 0x04,
  0x0C, 0x04, 0x03, 0x03, 0x01, 0x00, 0xC0, 0xC0, 0xC0, 0x20, 0x30, 0x30,
  0x18, 0x04, 0x0C, 0x06, 0x01, 0x82, 0x03, 0x00, 0x31, 0x80, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0x06, 0x00, 0x30, 0x30, 0x01,
  0x80, 0x80, 0x08, 0x06, 0x00, 0x40, 0x30, 0x02, 0x01, 0x80, 0x18, 0x0C,
  0x00, 0xC0, 0x40, 0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC3, 0x00, 0x03,
  0x30, 0x00, 0x1B, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x6C, 0x00,
  0x06, 0x30, 0x00, 0x60, 0xC0, 0x66, 0x06, 0x03, 0x30, 0x18, 0x1B, 0x00,
  0x60, 0x98, 0x01, 0x8C, 0xC0, 0x0C, 0x66, 0x00, 0x36, 0x30, 0x00, 0xF1,
  0x80, 0x07, 0x0C, 0x00, 0x18, 0x60, 0x01, 0xE1, 0x80, 0x1B, 0x0E, 0x01,
  0x8C, 0x3C, 0x38, 0x30, 0x7F, 0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x04, 0x03, 0x80, 0xC0, 0x40,
  0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x30,
  0x30, 0x60, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x08, 0x20, 0xFE, 0x4F, 0x8F, 0xF8, 0x01, 0x80, 0x05, 0x00, 0x19, 0x00,
  0x63, 0x01, 0x83, 0x03, 0x03, 0x0C, 0x04, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x0F, 0xFF, 0xFC, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x33, 0x33, 0x66, 0x66,
  0xCC, 0x80, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x03,
  0x07, 0x03, 0x01, 0x83, 0x00, 0x61, 0x80, 0x10, 0x80, 0x0C, 0xC0, 0x06,
  0x60, 0x03, 0x30, 0x00, 0x98, 0x00, 0x48, 0x00, 0x34, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0D, 0x00, 0x06, 0xC0, 0x03, 0x60, 0x01,
  0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x21, 0x80, 0x30, 0x60,
  0x18, 0x38, 0x18, 0x0F, 0x38, 0x03, 0xF8, 0x00, 0x01, 0x81, 0xC1, 0xE1,
  0xB1, 0x9B, 0x8F, 0x87, 0x83, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x07,
  0xE0, 0x1F, 0xFC, 0x1C, 0x07, 0x08, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xE0, 0x1F, 0xFC, 0x1C, 0x07, 0x18, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x19, 0x00, 0x1C, 0xF0, 0x3C, 0x3F, 0xF8,
  0x00, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x16, 0x00, 0x03, 0x60, 0x00, 0x26, 0x00, 0x06, 0x60, 0x00, 0x46, 0x00,
  0x0C, 0x60, 0x01, 0x86, 0x00, 0x18, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60,
  0x06, 0x06, 0x00, 0x40, 0x60, 0x0C, 0x06, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x00, 0x60, 0x30, 0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x0C, 0x00,
  0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x7F, 0xFC, 0x7F, 0xFC, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xDF, 0xE0, 0xFF, 0xF8, 0x40, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x80, 0x18, 0xE0, 0x70, 0x7F, 0xE0, 0x00, 0x7E,
  0x01, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x07, 0x01, 0x1F, 0xE0, 0x98, 0x1C, 0x58, 0x06, 0x28, 0x01,
  0xB8, 0x00, 0xDC, 0x00, 0x3E, 0x00, 0x1B, 0x00, 0x0D, 0x00, 0x06, 0x80,
  0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x32, 0x00, 0x11,
  0x80, 0x18, 0xC0, 0x0C, 0x30, 0x0C, 0x0E, 0x1C, 0x03, 0xFC, 0x00, 0x10,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x06, 0x03, 0x86, 0x00, 0xC6, 0x00,
  0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98,
  0x00, 0xC6, 0x00, 0xC1, 0x80, 0x60, 0xE0, 0x60, 0x38, 0xE0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xB8, 0x07, 0x07, 0x07, 0x01, 0xC3, 0x00, 0x63, 0x00,
  0x19, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1B, 0x00, 0x19, 0x80, 0x0C, 0x60, 0x0C, 0x1C, 0x1C,
  0x07, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0E, 0x07, 0x06, 0x01, 0x86,
  0x00, 0x63, 0x00, 0x31, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01,
  0xB0, 0x00, 0x58, 0x00, 0x2C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0E, 0xC0,
  0x07, 0x60, 0x07, 0xB0, 0x02, 0xCC, 0x03, 0x43, 0xCF, 0x20, 0xFE, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x20,
  0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xB0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x37, 0x73, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x33, 0x33, 0x66, 0x64, 0xCC, 0x80, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x02, 0x00,
  0x00, 0x3F, 0x87, 0xFE, 0x30, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x18, 0x00, 0x60, 0x07,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x0C, 0x18, 0x00, 0x00, 0x63, 0x00, 0x00, 0x06, 0x30, 0x07, 0xE0, 0x22,
  0x01, 0xE7, 0x03, 0x60, 0x30, 0x30, 0x36, 0x03, 0x03, 0x03, 0x60, 0x60,
  0x30, 0x34, 0x06, 0x03, 0x03, 0x40, 0x40, 0x30, 0x14, 0x0C, 0x03, 0x01,
  0x40, 0xC0, 0x30, 0x1C, 0x0C, 0x02, 0x01, 0xC0, 0xC0, 0x20, 0x3C, 0x0C,
  0x06, 0x03, 0x40, 0xC0, 0x60, 0x34, 0x0C, 0x06, 0x03, 0x40, 0x40, 0x60,
  0x26, 0x06, 0x0F, 0x06, 0x60, 0x71, 0x90, 0xC6, 0x03, 0xF1, 0xF8, 0x20,
  0x0E, 0x07, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xB0, 0x00, 0x0D, 0x80, 0x00,
  0x64, 0x00, 0x03, 0x20, 0x00, 0x11, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x20,
  0x00, 0x41, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x81, 0x00, 0x08,
  0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x30, 0x0C, 0x03, 0x00, 0x60,
  0x18, 0x03, 0x00, 0xFF, 0xF8, 0x04, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00,
  0x18, 0x18, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x00, 0x42,
  0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xC0, 0xFF, 0x00, 0x7F, 0xFC, 0x30, 0x07, 0x18, 0x00,
  0xCC, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x33, 0x00, 0x31,
  0x81, 0xF0, 0xFF, 0xF0, 0x60, 0x1E, 0x30, 0x01, 0x98, 0x00, 0x6C, 0x00,
  0x36, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1B, 0x00, 0x1D, 0x80, 0x1C,
  0xFF, 0xFC, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xF0, 0x70, 0x0C,
  0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x01, 0x03, 0xC3, 0xC0, 0x7F, 0xE0, 0xFE, 0x00,
  0x1F, 0xFE, 0x03, 0x00, 0xF0, 0x60, 0x07, 0x0C, 0x00, 0x71, 0x80, 0x07,
  0x30, 0x00, 0x66, 0x00, 0x0E, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x01,
  0x60, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x02, 0xC0, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x03, 0x60, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x06, 0x30, 0x01, 0x86,
  0x00, 0xE0, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF,
  0xFB, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0xFF, 0xEF, 0xFF, 0xB0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF,
  0x81, 0xE0, 0x0E, 0x1C, 0x00, 0x11, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0B, 0x00, 0x00, 0x58, 0x00, 0x02, 0x60, 0x00, 0x13, 0x00, 0x00, 0x8C,
  0x00, 0x04, 0x30, 0x00, 0x21, 0xE0, 0x01, 0x03, 0xE0, 0xF8, 0x07, 0xFF,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x10, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04,
  0x06, 0xC7, 0x7F, 0x00, 0xC0, 0x03, 0xE0, 0x01, 0xB0, 0x01, 0x98, 0x01,
  0x8C, 0x00, 0xC6, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0xE0, 0xC0, 0x60, 0x60,
  0x60, 0x30, 0x70, 0x18, 0x30, 0x0C, 0x30, 0x06, 0x30, 0x03, 0x38, 0x01,
  0x9C, 0x00, 0xDE, 0x00, 0x79, 0x80, 0x3C, 0xC0, 0x1C, 0x30, 0x0C, 0x18,
  0x06, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0xC0, 0x30, 0x60, 0x18, 0x30,
  0x06, 0x18, 0x03, 0x0C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x19, 0x80, 0x06,
  0xC0, 0x03, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xBD, 0x80, 0x00, 0x6F, 0x60, 0x00, 0x1B, 0xD8, 0x00, 0x04, 0xF3, 0x00,
  0x03, 0x3C, 0xC0, 0x00, 0xCF, 0x30, 0x00, 0x23, 0xC6, 0x00, 0x18, 0xF1,
  0x80, 0x06, 0x3C, 0x60, 0x01, 0x0F, 0x0C, 0x00, 0xC3, 0xC3, 0x00, 0x30,
  0xF0, 0xC0, 0x08, 0x3C, 0x18, 0x06, 0x0F, 0x06, 0x01, 0x83, 0xC1, 0x80,
  0x40, 0xF0, 0x30, 0x30, 0x3C, 0x0C, 0x0C, 0x0F, 0x03, 0x02, 0x03, 0xC0,
  0x61, 0x80, 0xF0, 0x18, 0x60, 0x3C, 0x06, 0x10, 0x0F, 0x00, 0xCC, 0x03,
  0xC0, 0x33, 0x00, 0xF0, 0x0C, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x03, 0x00, 0x30, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xB0, 0x00, 0xF6, 0x00,
  0x1E, 0x60, 0x03, 0xCC, 0x00, 0x78, 0xC0, 0x0F, 0x18, 0x01, 0xE1, 0x80,
  0x3C, 0x30, 0x07, 0x83, 0x00, 0xF0, 0x60, 0x1E, 0x06, 0x03, 0xC0, 0xC0,
  0x78, 0x0C, 0x0F, 0x01, 0x81, 0xE0, 0x18, 0x3C, 0x03, 0x07, 0x80, 0x30,
  0xF0, 0x06, 0x1E, 0x00, 0x63, 0xC0, 0x0C, 0x78, 0x00, 0xCF, 0x00, 0x19,
  0xE0, 0x01, 0xBC, 0x00, 0x37, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0x38, 0x38, 0x00, 0x60, 0xC0, 0x00, 0xC6, 0x00, 0x03,
  0x18, 0x00, 0x06, 0x60, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x09, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x30, 0x00,
  0x30, 0xC0, 0x01, 0xC1, 0x80, 0x06, 0x03, 0x00, 0x70, 0x07, 0x87, 0x80,
  0x0F, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0xC0, 0x78, 0xC0, 0x1C, 0xC0,
  0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0,
  0x0C, 0xC0, 0x38, 0xFF, 0xF0, 0xFF, 0x80, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x38, 0x38, 0x00,
  0x60, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x06, 0x60, 0x00, 0x1B,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x09, 0x80, 0x00, 0x66, 0x00,
  0x01, 0x98, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x01, 0xC1, 0x80, 0x06,
  0x03, 0x00, 0x70, 0x07, 0x87, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0xFC, 0x00, 0x7F, 0xF8, 0x30,
  0x1E, 0x18, 0x03, 0x8C, 0x00, 0x66, 0x00, 0x33, 0x00, 0x19, 0x80, 0x06,
  0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x66, 0x00,
  0x33, 0x00, 0x19, 0x80, 0x18, 0xC0, 0x18, 0x7F, 0xF8, 0x3F, 0xF0, 0x18,
  0x18, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x30,
  0x60, 0x0C, 0x30, 0x06, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x33, 0x00,
  0x19, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x00, 0xC0, 0x03, 0xF8, 0x07, 0xFF,
  0x87, 0x00, 0xC6, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x19, 0x00, 0x1C, 0xF8, 0x3C, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0x60, 0x00, 0x6C, 0x00, 0x0C, 0xC0,
  0x01, 0x98, 0x00, 0x61, 0xC0, 0x18, 0x1E, 0x0E, 0x01, 0xFF, 0x80, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0x90, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x02,
  0x30, 0x00, 0x30, 0x80, 0x01, 0x86, 0x00, 0x0C, 0x30, 0x00, 0x41, 0x80,
  0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x18, 0x04, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x20, 0x18, 0x01, 0x80,
  0xC0, 0x0C, 0x04, 0x00, 0x20, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x10, 0x00,
  0x61, 0x80, 0x01, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x62, 0x00, 0x03, 0x30,
  0x00, 0x09, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x40, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x80, 0x01, 0x80, 0x01, 0xE0, 0x00, 0xC0,
  0x00, 0xB0, 0x00, 0x60, 0x00, 0xD8, 0x00, 0x78, 0x00, 0x64, 0x00, 0x3C,
  0x00, 0x33, 0x00, 0x1E, 0x00, 0x11, 0x80, 0x0D, 0x00, 0x18, 0xC0, 0x04,
  0x80, 0x0C, 0x60, 0x06, 0x60, 0x06, 0x10, 0x03, 0x30, 0x03, 0x0C, 0x01,
  0x98, 0x03, 0x06, 0x00, 0x84, 0x01, 0x83, 0x00, 0xC3, 0x00, 0xC0, 0x80,
  0x61, 0x80, 0x60, 0x60, 0x30, 0xC0, 0x60, 0x30, 0x18, 0x20, 0x30, 0x18,
  0x08, 0x10, 0x18, 0x0C, 0x0C, 0x0C, 0x0C, 0x03, 0x06, 0x06, 0x04, 0x01,
  0x83, 0x03, 0x06, 0x00, 0xC1, 0x00, 0x83, 0x00, 0x61, 0x80, 0x61, 0x80,
  0x10, 0xC0, 0x30, 0xC0, 0x0C, 0x60, 0x18, 0xC0, 0x06, 0x30, 0x04, 0x60,
  0x03, 0x10, 0x03, 0x30, 0x00, 0x98, 0x01, 0x98, 0x00, 0x6C, 0x00, 0xD8,
  0x00, 0x36, 0x00, 0x6C, 0x00, 0x1A, 0x00, 0x16, 0x00, 0x0D, 0x00, 0x0B,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x18, 0x60, 0x06, 0x18,
  0x03, 0x03, 0x00, 0xC0, 0xC0, 0x60, 0x10, 0x18, 0x06, 0x04, 0x01, 0x83,
  0x00, 0x30, 0xC0, 0x0C, 0x60, 0x01, 0x98, 0x00, 0x6C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0B, 0x00, 0x06, 0xC0, 0x01,
  0x90, 0x00, 0xC6, 0x00, 0x30, 0x80, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x60, 0x0C, 0x18, 0x03, 0x0C, 0x00, 0x43, 0x00, 0x19,
  0x80, 0x06, 0x60, 0x00, 0xF0, 0x00, 0x30, 0xC0, 0x00, 0xF0, 0x00, 0x36,
  0x00, 0x19, 0x80, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x30, 0x60,
  0x08, 0x18, 0x06, 0x02, 0x01, 0x80, 0xC0, 0xC0, 0x30, 0x30, 0x06, 0x08,
  0x01, 0x86, 0x00, 0x21, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0x68, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0x80,
  0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01,
  0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30,
  0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00,
  0x58, 0x00, 0x19, 0x80, 0x02, 0x30, 0x00, 0xC3, 0x00, 0x10, 0x60, 0x06,
  0x06, 0x00, 0x80, 0xC0, 0x30, 0x0C, 0x04, 0x01, 0x81, 0x80, 0x10, 0x20,
  0x03, 0x0C, 0x00, 0x21, 0x00, 0x06, 0x60, 0x00, 0xD8, 0x00, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0xC1, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x0F,
  0xE0, 0xF1, 0xE2, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0xFF, 0x1F, 0x04, 0xE0, 0x16,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x56, 0x03, 0x5C, 0x19, 0x1F, 0xC4, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x87, 0xF0, 0x9C, 0x38, 0xB0, 0x0C, 0xA0,
  0x06, 0xE0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xE0, 0x06, 0xA0,
  0x0C, 0xB0, 0x1C, 0x9C, 0x38, 0x8F, 0xF0, 0x03, 0xFC, 0x3E, 0x71, 0xC0,
  0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x83, 0x07, 0xFC, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0xFE, 0x30, 0xE3, 0x98, 0xC0, 0x6C, 0xC0, 0x1E, 0x60,
  0x07, 0x60, 0x03, 0xB0, 0x00, 0xD8, 0x00, 0x68, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x0E, 0xC0, 0x07, 0x30,
  0x07, 0x9C, 0x02, 0xC7, 0x06, 0x60, 0xFE, 0x10, 0x07, 0xF0, 0x0E, 0x38,
  0x18, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x60, 0x02, 0x60, 0x03, 0x60, 0x03,
  0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x02, 0x0E, 0x0E, 0x07, 0xFC, 0x01, 0xF0,
  0x1F, 0xC1, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0xFF, 0x8F, 0xFC, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x07, 0xF1, 0x87,
  0x1C, 0xC6, 0x01, 0x66, 0x00, 0xF3, 0x00, 0x3B, 0x00, 0x1D, 0x80, 0x06,
  0xC0, 0x03, 0x40, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xA0, 0x00, 0xD8,
  0x00, 0x6C, 0x00, 0x76, 0x00, 0x39, 0x80, 0x3C, 0x60, 0x36, 0x38, 0x33,
  0x07, 0xF1, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x07, 0x20, 0x07, 0x1F, 0x0F, 0x03,
  0xFE, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x3F,
  0x09, 0xE7, 0x96, 0x03, 0x28, 0x03, 0x70, 0x06, 0xC0, 0x05, 0x80, 0x0B,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0xFF, 0x80,
  0x00, 0x09, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x48, 0x0E,
  0x1C, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x18,
  0x34, 0xEF, 0x80, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x06,
  0x80, 0x32, 0x01, 0x88, 0x06, 0x20, 0x30, 0x81, 0x82, 0x0C, 0x08, 0x30,
  0x21, 0x80, 0x8C, 0x02, 0x30, 0x09, 0xE0, 0x2D, 0x80, 0xA3, 0x03, 0x0C,
  0x0C, 0x18, 0x20, 0x60, 0x80, 0xC2, 0x03, 0x08, 0x06, 0x20, 0x18, 0x80,
  0x32, 0x00, 0xC8, 0x01, 0xA0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x8F,
  0xC0, 0xFE, 0x4E, 0x38, 0xE7, 0xAC, 0x0C, 0xC0, 0xD4, 0x03, 0xC0, 0x3C,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x87, 0xF1, 0x38, 0xF2, 0xC0, 0x65,
  0x00, 0x6E, 0x00, 0xD8, 0x00, 0xB0, 0x01, 0x60, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x07, 0xF8, 0x07, 0x1E, 0x06, 0x01, 0x86,
  0x00, 0x63, 0x00, 0x33, 0x00, 0x09, 0x80, 0x06, 0xC0, 0x03, 0x40, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0x40, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x23,
  0x00, 0x31, 0x80, 0x18, 0x60, 0x18, 0x1C, 0x38, 0x07, 0xF8, 0x00, 0x87,
  0xF0, 0x9E, 0x38, 0x90, 0x0C, 0xA0, 0x0E, 0xA0, 0x06, 0xC0, 0x06, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x06, 0xE0, 0x06, 0xA0, 0x0C, 0xB0, 0x1C, 0x9C, 0x38, 0x8F,
  0xF0, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x07,
  0xF1, 0x87, 0x1C, 0xC6, 0x03, 0x66, 0x00, 0xF3, 0x00, 0x3B, 0x00, 0x1D,
  0x80, 0x06, 0xC0, 0x03, 0x40, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xB0,
  0x00, 0xD8, 0x00, 0x6C, 0x00, 0x76, 0x00, 0x39, 0x80, 0x3C, 0xE0, 0x36,
  0x38, 0x33, 0x07, 0xF1, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x87, 0xE7, 0xE9, 0x02, 0xC0, 0xA0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00,
  0x1F, 0xF1, 0xC3, 0xD8, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E,
  0x00, 0xDE, 0x1E, 0x7F, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x0F, 0xFF, 0xFF, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x60, 0x18, 0x07, 0x10, 0xFC, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1A, 0x00, 0x36, 0x00, 0xEC,
  0x01, 0x5C, 0x06, 0x9C, 0x39, 0x1F, 0xE2, 0xC0, 0x03, 0x40, 0x03, 0x60,
  0x03, 0x60, 0x06, 0x60, 0x06, 0x20, 0x06, 0x30, 0x04, 0x30, 0x0C, 0x10,
  0x0C, 0x18, 0x0C, 0x18, 0x08, 0x18, 0x18, 0x08, 0x18, 0x0C, 0x10, 0x0C,
  0x30, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x20, 0x06, 0x60, 0x02, 0x60, 0x03,
  0x40, 0x03, 0x40, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x80, 0x0C, 0x00,
  0xF0, 0x03, 0x00, 0x3C, 0x01, 0xC0, 0x0B, 0x00, 0x78, 0x06, 0x40, 0x16,
  0x01, 0x98, 0x04, 0x80, 0x66, 0x03, 0x20, 0x11, 0x80, 0xCC, 0x0C, 0x20,
  0x33, 0x03, 0x0C, 0x08, 0xC0, 0xC3, 0x06, 0x10, 0x20, 0xC1, 0x86, 0x08,
  0x10, 0x61, 0x86, 0x06, 0x10, 0x61, 0x81, 0x8C, 0x08, 0x60, 0x63, 0x03,
  0x10, 0x18, 0xC0, 0xCC, 0x02, 0x20, 0x33, 0x00, 0xD8, 0x04, 0xC0, 0x36,
  0x01, 0xA0, 0x0D, 0x80, 0x78, 0x01, 0x40, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x07, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x60, 0x06, 0x30,
  0x0C, 0x30, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x30, 0x0C, 0x20, 0x06,
  0x60, 0x06, 0x40, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x06,
  0xC0, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x30, 0x18, 0x30, 0x18, 0x18, 0x30,
  0x18, 0x30, 0x0C, 0x60, 0x0C, 0x60, 0x06, 0xC0, 0x07, 0x60, 0x01, 0xB0,
  0x00, 0x98, 0x00, 0xC4, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30, 0xC0, 0x18,
  0x30, 0x0C, 0x18, 0x04, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x81, 0x00, 0xC1,
  0x80, 0x20, 0xC0, 0x18, 0x60, 0x0C, 0x20, 0x06, 0x30, 0x01, 0x18, 0x00,
  0xC8, 0x00, 0x6C, 0x00, 0x16, 0x00, 0x0B, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x27, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x10, 0x1F, 0x03, 0x80,
  0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x01,
  0xC0, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x3C, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x0F, 0x80,
  0x1C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x00, 0xF0, 0x0F, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0xF8, 0x00, 0x1C,
  0x00, 0x1F, 0xE0, 0x1C, 0x1E, 0x1E, 0x01, 0xFC, 0x00, 0x04, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLight47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 34, 10, 3, -34 },
  { 14, 9, 13, 15, 3, -34 },
  { 29, 21, 34, 23, 1, -34 },
  { 119, 17, 39, 21, 2, -36 },
  { 202, 26, 34, 31, 2, -34 },
  { 313, 21, 34, 23, 2, -34 },
  { 403, 2, 13, 8, 3, -34 },
  { 407, 9, 41, 13, 2, -34 },
  { 454, 8, 41, 13, 2, -34 },
  { 495, 15, 15, 19, 2, -36 },
  { 524, 18, 21, 21, 2, -27 },
  { 572, 4, 11, 9, 2, -5 },
  { 578, 11, 2, 13, 1, -14 },
  { 581, 3, 3, 9, 3, -3 },
  { 583, 14, 34, 16, 1, -34 },
  { 643, 17, 34, 21, 2, -34 },
  { 716, 9, 34, 21, 4, -34 },
  { 755, 17, 34, 21, 2, -34 },
  { 828, 17, 34, 21, 2, -34 },
  { 901, 20, 34, 21, 1, -34 },
  { 986, 16, 34, 21, 3, -34 },
  { 1054, 17, 35, 21, 2, -34 },
  { 1129, 17, 34, 21, 2, -34 },
  { 1202, 17, 34, 21, 2, -34 },
  { 1275, 17, 34, 21, 2, -34 },
  { 1348, 3, 25, 10, 3, -25 },
  { 1358, 4, 31, 9, 2, -25 },
  { 1374, 18, 20, 21, 2, -27 },
  { 1419, 18, 11, 21, 2, -22 },
  { 1444, 18, 20, 21, 2, -27 },
  { 1489, 13, 34, 15, 1, -34 },
  { 1545, 28, 38, 33, 2, -34 },
  { 1678, 21, 34, 21, 0, -34 },
  { 1768, 17, 34, 23, 4, -34 },
  { 1841, 18, 34, 23, 3, -34 },
  { 1918, 19, 34, 26, 4, -34 },
  { 1999, 14, 34, 20, 4, -34 },
  { 2059, 14, 34, 19, 4, -34 },
  { 2119, 21, 34, 27, 3, -34 },
  { 2209, 18, 34, 26, 4, -34 },
  { 2286, 8, 34, 12, 2, -34 },
  { 2320, 9, 42, 10, -3, -34 },
  { 2368, 17, 34, 21, 4, -34 },
  { 2441, 14, 34, 19, 4, -34 },
  { 2501, 26, 34, 34, 4, -34 },
  { 2612, 19, 34, 27, 4, -34 },
  { 2693, 22, 34, 28, 3, -34 },
  { 2787, 16, 34, 21, 4, -34 },
  { 2855, 22, 42, 28, 3, -34 },
  { 2971, 17, 34, 22, 4, -34 },
  { 3044, 17, 34, 21, 2, -34 },
  { 3117, 18, 34, 19, 0, -34 },
  { 3194, 19, 34, 26, 4, -34 },
  { 3275, 21, 34, 21, 0, -34 },
  { 3365, 33, 34, 34, 1, -34 },
  { 3506, 18, 34, 19, 0, -34 },
  { 3583, 18, 34, 18, 0, -34 },
  { 3660, 17, 34, 19, 1, -34 },
  { 3733, 9, 41, 15, 4, -34 },
  { 3780, 14, 34, 16, 1, -34 },
  { 3840, 10, 41, 15, 1, -34 },
  { 3892, 19, 18, 21, 1, -34 },
  { 3935, 19, 2, 19, 0, 4 },
  { 3940, 7, 8, 11, 2, -36 },
  { 3947, 14, 25, 20, 2, -25 },
  { 3991, 16, 36, 23, 4, -36 },
  { 4063, 14, 25, 17, 2, -25 },
  { 4107, 17, 36, 23, 2, -36 },
  { 4184, 16, 25, 20, 2, -25 },
  { 4234, 13, 36, 11, 0, -36 },
  { 4293, 17, 36, 22, 2, -25 },
  { 4370, 15, 36, 22, 4, -36 },
  { 4438, 3, 34, 9, 3, -34 },
  { 4451, 7, 45, 9, -1, -34 },
  { 4491, 14, 36, 18, 4, -36 },
  { 4554, 1, 36, 9, 4, -36 },
  { 4559, 25, 25, 33, 4, -25 },
  { 4638, 15, 25, 22, 4, -25 },
  { 4685, 17, 25, 22, 2, -25 },
  { 4739, 16, 36, 22, 4, -25 },
  { 4811, 17, 36, 22, 2, -25 },
  { 4888, 10, 25, 14, 4, -25 },
  { 4920, 13, 25, 17, 2, -25 },
  { 4961, 10, 31, 12, 1, -31 },
  { 5000, 15, 25, 22, 3, -25 },
  { 5047, 16, 25, 16, 0, -25 },
  { 5097, 26, 25, 27, 1, -25 },
  { 5179, 16, 25, 18, 1, -25 },
  { 5229, 17, 36, 17, 0, -25 },
  { 5306, 13, 25, 15, 1, -25 },
  { 5347, 12, 41, 16, 2, -34 },
  { 5409, 2, 47, 20, 9, -36 },
  { 5421, 12, 41, 16, 2, -34 },
  { 5483, 18, 5, 21, 2, -19 },
};

const GFXfont NotoSans_Condensed_ExtraLight47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight47pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT47PT7B_H_
