#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT37PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x02, 0xF0, 0xC3, 0x85, 0x0A, 0x14,
  0x28, 0x50, 0xA1, 0x42, 0x02, 0x0C, 0x01, 0x06, 0x00, 0x82, 0x00, 0x41,
  0x00, 0x60, 0x80, 0x30, 0x40, 0x10, 0x20, 0xFF, 0xFF, 0x7F, 0xFF, 0x82,
  0x08, 0x01, 0x04, 0x01, 0x82, 0x00, 0xC1, 0x00, 0x40, 0x80, 0x20, 0x40,
  0x10, 0x60, 0xFF, 0xFE, 0x7F, 0xFF, 0x06, 0x08, 0x03, 0x04, 0x01, 0x02,
  0x00, 0x81, 0x00, 0x41, 0x80, 0x20, 0xC0, 0x10, 0x40, 0x18, 0x20, 0x00,
  0x06, 0x00, 0x30, 0x03, 0xE0, 0x7F, 0xE6, 0x61, 0x63, 0x02, 0x18, 0x10,
  0xC0, 0x86, 0x04, 0x30, 0x21, 0x81, 0x8C, 0x06, 0x60, 0x1F, 0x00, 0x38,
  0x00, 0xF0, 0x06, 0x60, 0x31, 0x81, 0x84, 0x0C, 0x30, 0x61, 0x83, 0x0C,
  0x18, 0x60, 0xC2, 0x86, 0x37, 0x37, 0x1F, 0xE0, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x06, 0xE0, 0x30, 0x42, 0x02, 0x0C, 0x20, 0x20, 0x83,
  0x04, 0x08, 0x10, 0x40, 0x81, 0x0C, 0x08, 0x10, 0x80, 0x81, 0x08, 0x08,
  0x11, 0x00, 0x81, 0x10, 0x08, 0x13, 0x3C, 0x83, 0x26, 0x2C, 0x22, 0x43,
  0x42, 0x44, 0x17, 0xE4, 0xC1, 0x18, 0xC8, 0x10, 0x08, 0x81, 0x00, 0x88,
  0x10, 0x10, 0x81, 0x01, 0x08, 0x10, 0x30, 0x81, 0x02, 0x0C, 0x10, 0x20,
  0x41, 0x04, 0x04, 0x30, 0x40, 0x62, 0x0C, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0xE0, 0x06, 0x18, 0x02, 0x04, 0x01, 0x02, 0x00, 0x81, 0x00, 0x40, 0x80,
  0x20, 0x40, 0x18, 0x60, 0x04, 0x20, 0x03, 0x30, 0x00, 0xB0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x64, 0x00, 0x63, 0x02, 0x60, 0xC1, 0x20, 0x21, 0x90,
  0x08, 0xC8, 0x06, 0x4C, 0x01, 0x62, 0x00, 0x61, 0x00, 0x30, 0x80, 0x3C,
  0x60, 0x32, 0x18, 0x31, 0x87, 0xF0, 0x60, 0xD5, 0x55, 0x40, 0x0E, 0x10,
  0x60, 0x83, 0x04, 0x18, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x0C, 0x18, 0x10, 0x20, 0x60, 0xC0, 0x81, 0x81, 0x03,
  0x03, 0x03, 0xE0, 0x40, 0xC0, 0x81, 0x81, 0x03, 0x06, 0x04, 0x08, 0x18,
  0x30, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x02, 0x0C,
  0x10, 0x60, 0xC1, 0x04, 0x18, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x0E,
  0x46, 0x7F, 0x01, 0x80, 0x50, 0x11, 0x06, 0x31, 0x83, 0x10, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x33, 0x32, 0x66, 0x44, 0xC0, 0xFF, 0xFF,
  0xBC, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x10,
  0x00, 0x07, 0x00, 0xFE, 0x0C, 0x18, 0x40, 0x46, 0x03, 0x20, 0x09, 0x00,
  0x58, 0x02, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x2C, 0x01, 0x20,
  0x09, 0x00, 0xCC, 0x04, 0x20, 0x60, 0xC6, 0x03, 0xE0, 0x06, 0x1C, 0xCB,
  0x1C, 0x30, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0F, 0x03, 0xFE, 0x30,
  0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x01, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x3F, 0xFE, 0x1E, 0x03, 0xFE, 0x30, 0x19, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x0F, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x26, 0x07, 0x3F, 0xE0,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x80, 0x0B, 0x00, 0x36, 0x00,
  0x4C, 0x01, 0x98, 0x02, 0x30, 0x0C, 0x60, 0x30, 0xC0, 0x41, 0x81, 0x83,
  0x02, 0x06, 0x0C, 0x0C, 0x10, 0x18, 0x60, 0x30, 0x80, 0x63, 0x00, 0xC7,
  0xFF, 0xF0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x7F, 0xE3, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x17, 0xC1, 0xF7, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0xC0, 0xC3, 0xFC, 0x00, 0x01, 0xE0,
  0x7F, 0x86, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x9F, 0x89, 0x86, 0x50, 0x1B, 0x00, 0x58, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x01, 0xA0, 0x0D, 0x00, 0x6C,
  0x02, 0x20, 0x31, 0x83, 0x07, 0xF0, 0xFF, 0xF8, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x00, 0x0F, 0x01, 0xFE, 0x18, 0x18, 0x80, 0x6C, 0x01, 0x60, 0x0B, 0x00,
  0x58, 0x02, 0x40, 0x13, 0x01, 0x8C, 0x18, 0x31, 0x80, 0xF0, 0x07, 0x80,
  0x63, 0x04, 0x0C, 0x40, 0x36, 0x00, 0xA0, 0x07, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x78, 0x03, 0x40, 0x33, 0x83, 0x07, 0xF0, 0x0F, 0x01, 0xFE,
  0x18, 0x18, 0x80, 0x4C, 0x03, 0x40, 0x1A, 0x00, 0x50, 0x02, 0x80, 0x14,
  0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x1D, 0x81, 0x67, 0x3B, 0x1F,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0xC0, 0x0C, 0x1F, 0xC0, 0xBC, 0x00, 0x00, 0x00, 0x2F, 0x23, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0x32, 0x66, 0x44, 0xC0, 0x00,
  0x04, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x1C, 0x01,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x3C,
  0x3F, 0xC8, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x18, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x0E, 0x03, 0x80, 0x01, 0xFF, 0x00,
  0x1C, 0x06, 0x00, 0xC0, 0x04, 0x06, 0x00, 0x08, 0x10, 0x00, 0x30, 0x80,
  0x00, 0x42, 0x00, 0x01, 0x98, 0x0F, 0x82, 0x40, 0xC2, 0x09, 0x06, 0x08,
  0x3C, 0x10, 0x20, 0xF0, 0xC0, 0x83, 0x83, 0x02, 0x0E, 0x08, 0x08, 0x38,
  0x20, 0x20, 0xE0, 0x81, 0x83, 0x82, 0x06, 0x0E, 0x08, 0x18, 0x28, 0x30,
  0x60, 0xB0, 0x42, 0x86, 0xC1, 0xD9, 0x31, 0x03, 0xC7, 0x84, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0xA0, 0x00, 0x50, 0x00,
  0x68, 0x00, 0x26, 0x00, 0x11, 0x00, 0x08, 0x80, 0x0C, 0x40, 0x04, 0x30,
  0x02, 0x08, 0x03, 0x04, 0x01, 0x83, 0x00, 0x81, 0x80, 0x40, 0x40, 0x60,
  0x20, 0x3F, 0xF8, 0x10, 0x04, 0x18, 0x02, 0x0C, 0x01, 0x84, 0x00, 0xC2,
  0x00, 0x23, 0x00, 0x11, 0x00, 0x0C, 0x80, 0x02, 0xC0, 0x01, 0x60, 0x00,
  0xC0, 0xFF, 0xC3, 0x01, 0xCC, 0x01, 0x30, 0x06, 0xC0, 0x1B, 0x00, 0x2C,
  0x00, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x4C, 0x03, 0x3F, 0xF0, 0xFF, 0xC3,
  0x00, 0xCC, 0x01, 0xB0, 0x02, 0xC0, 0x0B, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x2C, 0x01, 0xB0, 0x0C, 0xC0, 0xE3, 0xFE, 0x00, 0x00,
  0xF0, 0x0F, 0xFC, 0x30, 0x08, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x0C,
  0x0F, 0xF0, 0xFF, 0xC1, 0x80, 0xC3, 0x00, 0xC6, 0x00, 0xCC, 0x00, 0xD8,
  0x00, 0xB0, 0x01, 0x60, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x16, 0x00, 0x2C, 0x00, 0xD8, 0x01, 0x30, 0x06, 0x60, 0x18, 0xC1,
  0xE1, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x1F, 0xFC, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF, 0xF0, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x78, 0x01, 0xFF, 0x83, 0x80, 0x63, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0xFF, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x16, 0x00, 0x0B,
  0x00, 0x04, 0xC0, 0x02, 0x20, 0x01, 0x18, 0x00, 0x87, 0x00, 0xC0, 0xFF,
  0xC0, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0C, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x23, 0xF0, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0x83, 0x7C, 0x60, 0xC0, 0x1B, 0x00, 0xCC, 0x06, 0x30, 0x10, 0xC0, 0xC3,
  0x06, 0x0C, 0x10, 0x30, 0xC0, 0xC6, 0x03, 0x30, 0x0C, 0xC0, 0x36, 0x00,
  0xFC, 0x03, 0x98, 0x0C, 0x60, 0x30, 0xC0, 0xC1, 0x03, 0x06, 0x0C, 0x08,
  0x30, 0x30, 0xC0, 0x43, 0x01, 0x8C, 0x03, 0x30, 0x04, 0xC0, 0x1B, 0x00,
  0x30, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F,
  0xFC, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xE8, 0x00, 0x1F, 0x60, 0x00, 0xFF,
  0x00, 0x05, 0xE8, 0x00, 0x6F, 0x60, 0x03, 0x7B, 0x00, 0x13, 0xC8, 0x01,
  0x9E, 0x60, 0x0C, 0xF3, 0x00, 0x47, 0x88, 0x06, 0x3C, 0x60, 0x31, 0xE3,
  0x01, 0x0F, 0x08, 0x18, 0x78, 0x40, 0xC3, 0xC3, 0x04, 0x1E, 0x08, 0x20,
  0xF0, 0x43, 0x07, 0x83, 0x10, 0x3C, 0x08, 0x81, 0xE0, 0x4C, 0x0F, 0x03,
  0x40, 0x78, 0x0A, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x00, 0xC0, 0xC0, 0x03,
  0xC0, 0x06, 0x80, 0x0D, 0x80, 0x19, 0x00, 0x3B, 0x00, 0x72, 0x00, 0xE6,
  0x01, 0xC4, 0x03, 0x8C, 0x07, 0x08, 0x0E, 0x18, 0x1C, 0x10, 0x38, 0x30,
  0x70, 0x20, 0xE0, 0x61, 0xC0, 0x43, 0x80, 0xC7, 0x00, 0x8E, 0x01, 0x9C,
  0x01, 0x38, 0x03, 0x70, 0x02, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0C, 0x01,
  0xE0, 0x03, 0xFE, 0x01, 0x80, 0xE0, 0xC0, 0x08, 0x30, 0x03, 0x18, 0x00,
  0x46, 0x00, 0x19, 0x00, 0x02, 0x40, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x09, 0x00, 0x02, 0x40, 0x01, 0x98, 0x00,
  0x62, 0x00, 0x10, 0xC0, 0x0C, 0x18, 0x06, 0x03, 0x03, 0x00, 0x7F, 0x80,
  0xFF, 0x8C, 0x0E, 0xC0, 0x2C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x6C, 0x3C, 0xFF, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x01, 0xE0, 0x01, 0xFE, 0x01, 0xC0, 0x60, 0xC0, 0x08,
  0x30, 0x03, 0x18, 0x00, 0x46, 0x00, 0x19, 0x00, 0x02, 0x40, 0x00, 0xB0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x09, 0x00, 0x02,
  0x40, 0x01, 0x98, 0x00, 0x62, 0x00, 0x10, 0xC0, 0x0C, 0x18, 0x06, 0x03,
  0x03, 0x00, 0x7F, 0x80, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0xFF, 0x83, 0x03, 0x8C, 0x03, 0x30,
  0x0C, 0xC0, 0x13, 0x00, 0x4C, 0x01, 0x30, 0x04, 0xC0, 0x13, 0x00, 0x4C,
  0x03, 0x30, 0x18, 0xC0, 0xC3, 0xFE, 0x0C, 0x30, 0x30, 0x40, 0xC1, 0x83,
  0x02, 0x0C, 0x0C, 0x30, 0x10, 0xC0, 0x63, 0x00, 0x8C, 0x03, 0x30, 0x04,
  0xC0, 0x1B, 0x00, 0x30, 0x07, 0xC1, 0xFF, 0x98, 0x04, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0xC0, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00,
  0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x26, 0x07, 0x3F, 0xE0,
  0xFF, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x90, 0x03, 0x30, 0x04, 0x38, 0x38, 0x3F, 0xC0, 0xC0,
  0x01, 0x40, 0x03, 0x40, 0x02, 0x60, 0x02, 0x60, 0x06, 0x20, 0x06, 0x20,
  0x04, 0x30, 0x04, 0x30, 0x0C, 0x10, 0x08, 0x10, 0x08, 0x18, 0x18, 0x08,
  0x18, 0x08, 0x10, 0x08, 0x10, 0x0C, 0x30, 0x04, 0x30, 0x04, 0x20, 0x06,
  0x20, 0x06, 0x60, 0x02, 0x40, 0x02, 0x40, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0xC0, 0x04, 0x00, 0x50, 0x03, 0x80, 0x16, 0x00, 0xE0,
  0x0D, 0x80, 0x28, 0x03, 0x20, 0x0A, 0x00, 0x88, 0x06, 0x80, 0x22, 0x01,
  0xB0, 0x18, 0xC0, 0x44, 0x06, 0x30, 0x11, 0x01, 0x04, 0x04, 0x40, 0x41,
  0x03, 0x18, 0x30, 0x60, 0x86, 0x0C, 0x18, 0x20, 0x82, 0x02, 0x08, 0x20,
  0x80, 0x86, 0x08, 0x20, 0x31, 0x83, 0x18, 0x0C, 0x40, 0x46, 0x01, 0x10,
  0x11, 0x00, 0x44, 0x04, 0x40, 0x13, 0x01, 0xB0, 0x06, 0x80, 0x6C, 0x01,
  0xA0, 0x0A, 0x00, 0x28, 0x02, 0x80, 0x0A, 0x00, 0xA0, 0x03, 0x80, 0x38,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x0C, 0x40, 0x10, 0xC0, 0x60, 0x80, 0xC1,
  0x81, 0x01, 0x06, 0x03, 0x08, 0x02, 0x30, 0x06, 0x40, 0x05, 0x80, 0x0A,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xA0, 0x03, 0x60, 0x04, 0x40,
  0x18, 0xC0, 0x20, 0x80, 0xC1, 0x81, 0x01, 0x06, 0x03, 0x08, 0x06, 0x30,
  0x04, 0x40, 0x0D, 0x80, 0x0C, 0xC0, 0x0D, 0x00, 0x36, 0x00, 0x88, 0x06,
  0x20, 0x10, 0xC0, 0xC1, 0x03, 0x06, 0x08, 0x08, 0x60, 0x21, 0x00, 0xC4,
  0x01, 0x30, 0x06, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x7F, 0xF8, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x7F, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10,
  0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00,
  0x40, 0x0C, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0xFF, 0x01, 0x80, 0x05, 0x00, 0x0B, 0x00,
  0x22, 0x00, 0x46, 0x01, 0x04, 0x06, 0x0C, 0x08, 0x08, 0x30, 0x10, 0x40,
  0x31, 0x80, 0x22, 0x00, 0x6C, 0x00, 0x50, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0xE0, 0x83, 0x06, 0x0C, 0x10, 0x0F, 0x83, 0x8C, 0x20, 0x60, 0x02,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x7F, 0x18, 0x32, 0x03,
  0x60, 0x34, 0x03, 0xC0, 0x3C, 0x03, 0x40, 0x34, 0x05, 0x60, 0xD3, 0xF1,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x8F, 0x84, 0xC6, 0x28, 0x09, 0x80, 0x6C, 0x01, 0x60, 0x0A, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0x00, 0x78, 0x02, 0xC0, 0x35, 0x01, 0x2C, 0x19, 0x3F, 0x80, 0x07, 0xC3,
  0x8C, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x8F, 0xF0, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x0F, 0x08, 0xC6, 0x48, 0x0A, 0xC0, 0x54, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0F, 0x00, 0x78, 0x03, 0x40, 0x1B, 0x01, 0x4C, 0x12, 0x3F, 0x10,
  0x0F, 0x81, 0xDC, 0x20, 0x66, 0x02, 0x40, 0x3C, 0x01, 0xC0, 0x18, 0x01,
  0x80, 0x1F, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x31, 0xFE, 0x07, 0xC3, 0x00, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x3F, 0x3F, 0xC1, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x0F, 0x89, 0xC6, 0x48, 0x0A, 0xC0, 0x54,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0x40, 0x2B, 0x01, 0x4C, 0x16,
  0x3F, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0xA0,
  0x08, 0xF3, 0xC1, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x8F, 0x89, 0x9C, 0xA0, 0x6C, 0x02, 0xC0,
  0x2C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xBC,
  0x02, 0xAA, 0xAA, 0xAA, 0xAA, 0xA8, 0x08, 0x70, 0x80, 0x00, 0x00, 0x02,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x6B, 0xB8, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x50, 0x1A, 0x06,
  0x40, 0x88, 0x21, 0x0C, 0x23, 0x04, 0x40, 0x98, 0x17, 0x82, 0x90, 0x63,
  0x0C, 0x21, 0x06, 0x20, 0x44, 0x0C, 0x80, 0x90, 0x1A, 0x01, 0x40, 0x30,
  0xFF, 0xFF, 0xFF, 0xF0, 0x8F, 0x07, 0x89, 0x98, 0xCE, 0xA0, 0xD0, 0x2C,
  0x05, 0x03, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x8F, 0x89, 0xDC, 0xA0, 0x6C, 0x02,
  0xC0, 0x2C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x0F, 0x80, 0xC7, 0x08, 0x0C, 0xC0, 0x24, 0x01, 0x60, 0x0F, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00,
  0x78, 0x03, 0x40, 0x13, 0x01, 0x8C, 0x18, 0x3F, 0x80, 0x8F, 0x84, 0xC6,
  0x28, 0x19, 0x40, 0x6C, 0x01, 0x60, 0x0A, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x02, 0xC0,
  0x35, 0x01, 0x2C, 0x19, 0x3F, 0x88, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x88, 0xC6,
  0x4C, 0x0A, 0xC0, 0x54, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0x40,
  0x2B, 0x01, 0x4C, 0x16, 0x3F, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x8F, 0x9F, 0xA0,
  0xA0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0x87, 0x1D, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x00, 0x60, 0x0F, 0x03, 0x3F, 0xC0, 0x20, 0x20, 0x20,
  0x20, 0x7F, 0xFF, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x30, 0x30, 0x1F, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x78, 0x1D, 0x86, 0x9F,
  0x90, 0xC0, 0x1E, 0x00, 0xD0, 0x04, 0x80, 0x66, 0x03, 0x10, 0x10, 0x80,
  0x86, 0x0C, 0x30, 0x60, 0x82, 0x04, 0x10, 0x31, 0x80, 0x88, 0x04, 0x40,
  0x26, 0x01, 0xB0, 0x05, 0x00, 0x28, 0x01, 0xC0, 0x04, 0x00, 0xC0, 0x30,
  0x0A, 0x01, 0x80, 0x50, 0x0C, 0x06, 0xC0, 0xE0, 0x26, 0x05, 0x81, 0x10,
  0x24, 0x08, 0x81, 0x20, 0xC6, 0x19, 0x06, 0x30, 0xCC, 0x20, 0x84, 0x21,
  0x04, 0x21, 0x18, 0x23, 0x08, 0xC1, 0x98, 0x64, 0x04, 0x81, 0x20, 0x24,
  0x09, 0x01, 0x60, 0x58, 0x0F, 0x03, 0x80, 0x30, 0x1C, 0x01, 0x80, 0x60,
  0x0C, 0x03, 0x00, 0xC0, 0x34, 0x02, 0x60, 0x62, 0x04, 0x30, 0xC1, 0x08,
  0x19, 0x80, 0x90, 0x0F, 0x00, 0x60, 0x06, 0x00, 0xF0, 0x09, 0x01, 0x98,
  0x10, 0x83, 0x0C, 0x20, 0x46, 0x06, 0xC0, 0x2C, 0x03, 0xC0, 0x0A, 0x00,
  0xD8, 0x06, 0xC0, 0x22, 0x01, 0x10, 0x18, 0xC0, 0x82, 0x04, 0x10, 0x60,
  0xC3, 0x06, 0x10, 0x10, 0x80, 0x8C, 0x06, 0x40, 0x12, 0x00, 0xB0, 0x05,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0x80,
  0x04, 0x00, 0x60, 0x02, 0x01, 0x70, 0x0F, 0x00, 0x00, 0x7F, 0xDF, 0xF0,
  0x08, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20,
  0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x03, 0xFF, 0x07, 0x86,
  0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0xC1, 0x80, 0x70, 0x08, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x60, 0x1C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x0C, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xC0, 0x60,
  0x18, 0x07, 0x07, 0x06, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0xC3, 0xC1, 0x80, 0x1C, 0x05, 0xFC, 0x18,
  0x1F, 0xE0, 0x18,
};

const GFXglyph NotoSans_Condensed_ExtraLight37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 26, 8, 3, -26 },
  { 8, 7, 9, 12, 2, -26 },
  { 16, 17, 26, 18, 1, -26 },
  { 72, 13, 30, 17, 2, -28 },
  { 121, 20, 27, 24, 2, -27 },
  { 189, 17, 27, 18, 1, -27 },
  { 247, 2, 9, 6, 2, -26 },
  { 250, 7, 32, 10, 2, -26 },
  { 278, 7, 32, 10, 1, -26 },
  { 306, 11, 12, 15, 2, -28 },
  { 323, 14, 17, 17, 1, -22 },
  { 353, 4, 9, 7, 1, -4 },
  { 358, 8, 2, 10, 1, -11 },
  { 360, 2, 3, 7, 3, -3 },
  { 361, 11, 26, 12, 1, -26 },
  { 397, 13, 27, 17, 2, -27 },
  { 441, 7, 26, 17, 3, -26 },
  { 464, 13, 27, 17, 2, -27 },
  { 508, 13, 27, 17, 2, -27 },
  { 552, 15, 27, 17, 1, -27 },
  { 603, 13, 26, 17, 2, -26 },
  { 646, 13, 27, 17, 2, -27 },
  { 690, 13, 26, 17, 2, -26 },
  { 733, 13, 27, 17, 2, -27 },
  { 777, 13, 27, 17, 2, -27 },
  { 821, 2, 20, 7, 3, -20 },
  { 826, 4, 25, 7, 1, -20 },
  { 839, 14, 16, 17, 1, -21 },
  { 867, 14, 9, 17, 1, -18 },
  { 883, 14, 16, 17, 1, -21 },
  { 911, 10, 27, 12, 1, -27 },
  { 945, 22, 29, 26, 2, -26 },
  { 1025, 17, 26, 17, 0, -26 },
  { 1081, 14, 26, 18, 3, -26 },
  { 1127, 15, 27, 18, 2, -27 },
  { 1178, 15, 26, 20, 3, -26 },
  { 1227, 11, 26, 16, 3, -26 },
  { 1263, 11, 26, 15, 3, -26 },
  { 1299, 17, 27, 22, 2, -27 },
  { 1357, 15, 26, 21, 3, -26 },
  { 1406, 6, 26, 9, 2, -26 },
  { 1426, 7, 33, 8, -2, -26 },
  { 1455, 14, 26, 17, 3, -26 },
  { 1501, 11, 26, 15, 3, -26 },
  { 1537, 21, 26, 27, 3, -26 },
  { 1606, 15, 26, 21, 3, -26 },
  { 1655, 18, 27, 22, 2, -27 },
  { 1716, 12, 26, 17, 3, -26 },
  { 1755, 18, 33, 22, 2, -27 },
  { 1830, 14, 26, 17, 3, -26 },
  { 1876, 13, 27, 16, 2, -27 },
  { 1920, 14, 26, 15, 0, -26 },
  { 1966, 15, 26, 21, 3, -26 },
  { 2015, 16, 26, 16, 0, -26 },
  { 2067, 26, 26, 27, 0, -26 },
  { 2152, 15, 26, 15, 0, -26 },
  { 2201, 14, 26, 14, 0, -26 },
  { 2247, 13, 26, 15, 1, -26 },
  { 2290, 7, 32, 11, 3, -26 },
  { 2318, 11, 26, 12, 1, -26 },
  { 2354, 7, 32, 11, 1, -26 },
  { 2382, 15, 14, 17, 1, -26 },
  { 2409, 15, 2, 15, 0, 3 },
  { 2413, 6, 6, 9, 1, -28 },
  { 2418, 12, 20, 16, 1, -20 },
  { 2448, 13, 28, 18, 3, -28 },
  { 2494, 11, 20, 14, 2, -20 },
  { 2522, 13, 28, 18, 2, -28 },
  { 2568, 12, 20, 16, 2, -20 },
  { 2598, 10, 28, 9, 0, -28 },
  { 2633, 13, 29, 18, 2, -20 },
  { 2681, 12, 28, 17, 3, -28 },
  { 2723, 2, 27, 7, 3, -27 },
  { 2730, 6, 36, 7, -1, -27 },
  { 2757, 11, 28, 14, 3, -28 },
  { 2796, 1, 28, 7, 3, -28 },
  { 2800, 20, 20, 26, 3, -20 },
  { 2850, 12, 20, 17, 3, -20 },
  { 2880, 13, 20, 17, 2, -20 },
  { 2913, 13, 29, 18, 3, -20 },
  { 2961, 13, 29, 18, 2, -20 },
  { 3009, 8, 20, 11, 3, -20 },
  { 3029, 11, 20, 13, 1, -20 },
  { 3057, 8, 24, 9, 1, -24 },
  { 3081, 11, 20, 17, 3, -20 },
  { 3109, 13, 20, 13, 0, -20 },
  { 3142, 21, 20, 22, 0, -20 },
  { 3195, 12, 20, 14, 1, -20 },
  { 3225, 13, 29, 13, 0, -20 },
  { 3273, 10, 20, 12, 1, -20 },
  { 3298, 9, 32, 13, 2, -26 },
  { 3334, 2, 37, 16, 7, -28 },
  { 3344, 9, 32, 13, 2, -26 },
  { 3380, 14, 4, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_ExtraLight37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight37pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT37PT7B_H_
