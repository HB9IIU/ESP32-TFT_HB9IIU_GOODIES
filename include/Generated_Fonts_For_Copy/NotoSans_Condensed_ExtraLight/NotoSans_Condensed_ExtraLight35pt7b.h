#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT35PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xAA, 0xAA, 0xAA, 0xA8, 0x0B, 0xC0, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF0, 0xA1, 0x42, 0x02, 0x08, 0x06, 0x08, 0x06, 0x18, 0x04, 0x18,
  0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x7F, 0xFF, 0x7F, 0xFF, 0x0C, 0x10,
  0x08, 0x30, 0x08, 0x20, 0x08, 0x20, 0x08, 0x20, 0x08, 0x20, 0x08, 0x20,
  0xFF, 0xFE, 0x10, 0x60, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40,
  0x10, 0x40, 0x30, 0x40, 0x20, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x3F,
  0xE3, 0x21, 0x31, 0x01, 0x08, 0x18, 0x40, 0xC2, 0x02, 0x10, 0x10, 0x80,
  0xC4, 0x03, 0x20, 0x07, 0x00, 0x1E, 0x00, 0x58, 0x02, 0x30, 0x10, 0x80,
  0x86, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x60, 0x42, 0x62, 0x61, 0xFE,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x7C, 0x02, 0x08, 0x80, 0x83, 0x08,
  0x10, 0x41, 0x06, 0x08, 0x20, 0x81, 0x04, 0x10, 0x20, 0xC4, 0x04, 0x18,
  0x80, 0x83, 0x30, 0x10, 0x44, 0x02, 0x08, 0x9E, 0x41, 0x26, 0x2C, 0x24,
  0x86, 0x89, 0x90, 0x5F, 0x22, 0x08, 0x04, 0xC1, 0x01, 0x18, 0x20, 0x23,
  0x04, 0x0C, 0x60, 0x81, 0x0C, 0x10, 0x20, 0x82, 0x08, 0x10, 0x41, 0x02,
  0x18, 0x60, 0x62, 0x08, 0x07, 0x80, 0x0F, 0x80, 0x18, 0xC0, 0x10, 0x40,
  0x10, 0x60, 0x10, 0x60, 0x10, 0x60, 0x10, 0x60, 0x10, 0x40, 0x18, 0xC0,
  0x08, 0x80, 0x0F, 0x00, 0x06, 0x00, 0x1A, 0x00, 0x31, 0x00, 0x21, 0x82,
  0x40, 0x82, 0x40, 0x42, 0xC0, 0x66, 0xC0, 0x34, 0xC0, 0x1C, 0x40, 0x18,
  0x40, 0x1C, 0x60, 0x34, 0x30, 0x66, 0x1F, 0x83, 0xFF, 0xF5, 0x40, 0x0C,
  0x21, 0x0C, 0x21, 0x84, 0x10, 0xC3, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0xC3, 0x04, 0x10, 0x60, 0x83, 0x04, 0x18, 0x20, 0x40, 0xC0,
  0xC0, 0x81, 0x81, 0x03, 0x02, 0x06, 0x0C, 0x08, 0x10, 0x20, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x20, 0x40, 0x83, 0x04, 0x08, 0x30, 0x41, 0x82,
  0x08, 0x30, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02, 0x0C, 0x46, 0xEF, 0x03,
  0x00, 0x50, 0x12, 0x04, 0x21, 0x82, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x32,
  0x22, 0x64, 0x44, 0x80, 0xFF, 0x5D, 0x80, 0x00, 0x40, 0x30, 0x08, 0x02,
  0x01, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x02,
  0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x03,
  0x00, 0x80, 0x00, 0x1F, 0x83, 0x0C, 0x60, 0x44, 0x06, 0x40, 0x2C, 0x02,
  0xC0, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x02, 0x40, 0x24, 0x06,
  0x20, 0x43, 0x0C, 0x1F, 0x80, 0x06, 0x1C, 0x5B, 0x3C, 0x70, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x3F, 0x8E, 0x0C, 0x80, 0x40, 0x06, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x40, 0x08, 0x00, 0xFF, 0xF0, 0x1F, 0xC7, 0x03, 0x10, 0x0C, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x3F,
  0x01, 0xF8, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xD8, 0x0C, 0x7F, 0xC0, 0x00, 0x60,
  0x01, 0x80, 0x0A, 0x00, 0x68, 0x01, 0x20, 0x0C, 0x80, 0x22, 0x01, 0x88,
  0x04, 0x20, 0x30, 0x80, 0x82, 0x04, 0x08, 0x30, 0x20, 0x80, 0x86, 0x02,
  0x10, 0x08, 0xC0, 0x22, 0x00, 0x8F, 0xFF, 0xC0, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x7F, 0xE4, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xFF, 0x06, 0x1C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x68, 0x0C, 0xFF, 0x00, 0x07, 0xE1, 0xC0, 0x30,
  0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x9F,
  0xCB, 0x06, 0xA0, 0x2C, 0x03, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x1C, 0x01, 0x40, 0x34, 0x03, 0x60, 0x23, 0x04, 0x1F, 0x80, 0xFF, 0xF0,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x00,
  0x0F, 0xC1, 0x83, 0x08, 0x0C, 0xC0, 0x26, 0x01, 0xB0, 0x0D, 0x80, 0x64,
  0x02, 0x30, 0x30, 0xC3, 0x03, 0x30, 0x0E, 0x00, 0xF8, 0x0C, 0x30, 0xC0,
  0xCC, 0x02, 0x40, 0x1A, 0x00, 0x70, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x0D,
  0x80, 0x46, 0x0E, 0x1F, 0xC0, 0x3F, 0x86, 0x0C, 0x40, 0x4C, 0x06, 0x80,
  0x28, 0x02, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0,
  0x76, 0x0F, 0x3F, 0xB0, 0x03, 0x00, 0x20, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x30, 0x7E, 0x00, 0x5D, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x5D, 0x80, 0x23, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x22,
  0x26, 0x44, 0x48, 0x00, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00,
  0x00, 0xFE, 0x41, 0x80, 0x60, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x80,
  0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x60, 0x30, 0x00, 0x01, 0xFC, 0x00, 0x38, 0x38, 0x03,
  0x00, 0x60, 0x30, 0x01, 0x83, 0x00, 0x06, 0x10, 0x00, 0x11, 0x80, 0x00,
  0x88, 0x0F, 0x82, 0x40, 0x84, 0x16, 0x08, 0x20, 0xA0, 0xC1, 0x05, 0x04,
  0x08, 0x28, 0x20, 0x41, 0xC1, 0x02, 0x0A, 0x08, 0x10, 0x50, 0x40, 0x82,
  0x82, 0x0C, 0x14, 0x10, 0x60, 0xA0, 0x83, 0x0D, 0x82, 0x2C, 0xCC, 0x0E,
  0x3C, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x81, 0x80, 0x07, 0xF8, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x06, 0x60, 0x04, 0x20,
  0x04, 0x20, 0x0C, 0x20, 0x08, 0x30, 0x08, 0x10, 0x08, 0x10, 0x18, 0x18,
  0x1F, 0xF8, 0x1F, 0xF8, 0x30, 0x08, 0x30, 0x0C, 0x20, 0x04, 0x20, 0x04,
  0x60, 0x06, 0x40, 0x06, 0x40, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xFF, 0x84,
  0x07, 0x20, 0x09, 0x00, 0x68, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80,
  0x34, 0x01, 0x20, 0x19, 0xFF, 0x08, 0x3C, 0x40, 0x32, 0x00, 0xD0, 0x02,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x40, 0x0A, 0x00, 0xD0,
  0x1C, 0xFF, 0x80, 0x07, 0xF8, 0x30, 0x31, 0x80, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x01, 0x07, 0xF8, 0xFF,
  0x02, 0x07, 0x08, 0x06, 0x20, 0x0C, 0x80, 0x1A, 0x00, 0x28, 0x00, 0xA0,
  0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xA0, 0x02, 0x80, 0x1A,
  0x00, 0xC8, 0x06, 0x20, 0x70, 0xFF, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFF, 0xFF, 0xE0,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x03,
  0xFE, 0x0E, 0x03, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x7F, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x40,
  0x01, 0x60, 0x01, 0x20, 0x01, 0x30, 0x01, 0x18, 0x01, 0x0E, 0x03, 0x03,
  0xFE, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0xFC, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0xFC, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x3F, 0x80, 0x80, 0x34, 0x01, 0x20, 0x19, 0x01, 0x88, 0x08,
  0x40, 0x82, 0x0C, 0x10, 0xC0, 0x84, 0x04, 0x60, 0x26, 0x01, 0x30, 0x0A,
  0xC0, 0x72, 0x03, 0x18, 0x10, 0x40, 0x83, 0x04, 0x08, 0x20, 0x61, 0x01,
  0x88, 0x04, 0x40, 0x32, 0x00, 0x90, 0x06, 0x80, 0x18, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0xFF, 0xC0, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x03,
  0xD0, 0x00, 0x5A, 0x00, 0x0B, 0x60, 0x03, 0x64, 0x00, 0x4C, 0x80, 0x09,
  0x98, 0x03, 0x31, 0x00, 0x46, 0x20, 0x08, 0xC6, 0x03, 0x18, 0x40, 0x43,
  0x08, 0x08, 0x61, 0x83, 0x0C, 0x10, 0x41, 0x82, 0x08, 0x30, 0x63, 0x06,
  0x04, 0x40, 0xC0, 0x88, 0x18, 0x19, 0x03, 0x01, 0x40, 0x60, 0x28, 0x0C,
  0x07, 0x01, 0x80, 0x60, 0x20, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x68, 0x01,
  0xB0, 0x06, 0x40, 0x19, 0x80, 0x62, 0x01, 0x8C, 0x06, 0x10, 0x18, 0x60,
  0x60, 0x81, 0x83, 0x06, 0x04, 0x18, 0x18, 0x60, 0x21, 0x80, 0xC6, 0x01,
  0x18, 0x06, 0x60, 0x09, 0x80, 0x36, 0x00, 0x58, 0x01, 0xE0, 0x03, 0x80,
  0x0C, 0x07, 0xF0, 0x0E, 0x0C, 0x0C, 0x01, 0x04, 0x00, 0xC6, 0x00, 0x22,
  0x00, 0x19, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x01, 0x40, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x01, 0x60, 0x00, 0x90, 0x00, 0x48, 0x00, 0x66, 0x00, 0x21, 0x00, 0x30,
  0xC0, 0x30, 0x38, 0x30, 0x07, 0xF0, 0x00, 0xFF, 0x08, 0x3C, 0x80, 0x68,
  0x06, 0x80, 0x28, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x02, 0x80, 0x28,
  0x06, 0x80, 0xCF, 0xF8, 0xF8, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x07, 0xF0, 0x0E,
  0x0C, 0x0C, 0x01, 0x04, 0x00, 0xC6, 0x00, 0x22, 0x00, 0x19, 0x00, 0x05,
  0x80, 0x02, 0xC0, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0x60, 0x00, 0x90,
  0x00, 0x48, 0x00, 0x66, 0x00, 0x21, 0x00, 0x30, 0x40, 0x30, 0x38, 0x30,
  0x07, 0xF0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x10, 0xFF, 0x04, 0x1E, 0x20, 0x19, 0x00, 0x48, 0x02, 0x40,
  0x1A, 0x00, 0xD0, 0x06, 0x80, 0x34, 0x01, 0x20, 0x19, 0x01, 0x88, 0x38,
  0x7F, 0x02, 0x08, 0x10, 0x60, 0x81, 0x04, 0x0C, 0x20, 0x21, 0x01, 0x88,
  0x04, 0x40, 0x32, 0x00, 0x90, 0x06, 0x80, 0x18, 0x1F, 0xE7, 0x02, 0x40,
  0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x02, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x68, 0x0C, 0xFF, 0x80, 0xFF, 0xFC,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0xC0, 0x0B, 0x00, 0x26, 0x01, 0x8C, 0x0C,
  0x1F, 0xC0, 0x80, 0x03, 0x80, 0x05, 0x00, 0x1A, 0x00, 0x26, 0x00, 0x44,
  0x01, 0x88, 0x03, 0x10, 0x04, 0x30, 0x08, 0x20, 0x30, 0x40, 0x40, 0x80,
  0x81, 0x81, 0x01, 0x06, 0x02, 0x08, 0x06, 0x10, 0x04, 0x60, 0x08, 0x80,
  0x11, 0x00, 0x32, 0x00, 0x2C, 0x00, 0x50, 0x00, 0xA0, 0x01, 0xC0, 0x01,
  0x80, 0xC0, 0x08, 0x00, 0xA0, 0x06, 0x00, 0xD0, 0x07, 0x00, 0x6C, 0x02,
  0x80, 0x26, 0x01, 0x40, 0x11, 0x00, 0xB0, 0x18, 0x80, 0x58, 0x0C, 0x40,
  0x64, 0x04, 0x30, 0x22, 0x02, 0x08, 0x11, 0x03, 0x04, 0x08, 0xC1, 0x82,
  0x0C, 0x20, 0x81, 0x86, 0x10, 0x40, 0x42, 0x08, 0x20, 0x21, 0x06, 0x30,
  0x10, 0x81, 0x10, 0x0C, 0xC0, 0x88, 0x06, 0x40, 0x44, 0x01, 0x20, 0x26,
  0x00, 0x90, 0x1B, 0x00, 0x58, 0x05, 0x00, 0x3C, 0x02, 0x80, 0x0C, 0x01,
  0x40, 0x06, 0x00, 0xE0, 0x03, 0x00, 0x20, 0x00, 0x60, 0x0C, 0x80, 0x63,
  0x01, 0x04, 0x0C, 0x10, 0x20, 0x60, 0x80, 0x86, 0x03, 0x10, 0x04, 0xC0,
  0x1A, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x68, 0x01, 0x30,
  0x0C, 0x40, 0x21, 0x01, 0x86, 0x04, 0x08, 0x30, 0x30, 0x80, 0x46, 0x01,
  0x90, 0x02, 0xC0, 0x0C, 0xC0, 0x0D, 0x00, 0x24, 0x01, 0x98, 0x04, 0x20,
  0x30, 0xC0, 0x81, 0x02, 0x04, 0x18, 0x18, 0x40, 0x23, 0x00, 0xC8, 0x01,
  0x20, 0x05, 0x80, 0x1C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x7F, 0xF0, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xFF, 0xF0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x1F, 0xFF, 0x80, 0x80, 0x30, 0x04, 0x01, 0x00, 0x60,
  0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00,
  0x40, 0x18, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x08, 0x03,
  0x00, 0x40, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x3F, 0xFF, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x68, 0x01,
  0x20, 0x0C, 0xC0, 0x21, 0x01, 0x86, 0x04, 0x08, 0x30, 0x30, 0x80, 0x46,
  0x01, 0x90, 0x02, 0xC0, 0x0C, 0xFF, 0xFC, 0xC1, 0x83, 0x04, 0x08, 0x10,
  0x0F, 0x07, 0x38, 0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x08, 0x01, 0x01,
  0xE3, 0xE4, 0xC0, 0xB0, 0x14, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x40, 0x6C,
  0x14, 0xFC, 0x80, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x8F, 0x0B, 0x9C, 0xA0, 0x6C, 0x02, 0xC0, 0x28, 0x03,
  0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x80, 0x2C, 0x02, 0xC0, 0x6A, 0x0C, 0x9F, 0x80, 0x07, 0x87, 0x33, 0x01,
  0x80, 0x40, 0x30, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x11, 0xFC, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x0F, 0x13, 0x99, 0x60,
  0x54, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x34, 0x03, 0x60, 0x53, 0x0D, 0x1F,
  0x90, 0x0F, 0x03, 0x98, 0x60, 0x44, 0x06, 0x40, 0x2C, 0x02, 0x80, 0x28,
  0x02, 0xFF, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x03, 0x02, 0x1F, 0xC0, 0x03, 0xC3, 0xA0, 0x80, 0x60, 0x18,
  0x04, 0x01, 0x00, 0x40, 0x1F, 0x3F, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x0F, 0x13, 0x99, 0x60, 0x54, 0x03, 0xC0, 0x3C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0xC0, 0x34, 0x03, 0x60, 0x53, 0x0D, 0x1F, 0x90, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x2C, 0x0C, 0x7F, 0x80, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x8F, 0x17, 0x32, 0x83,
  0x60, 0x2C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0xF8,
  0x00, 0x12, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x40, 0x18, 0xC0, 0x00,
  0x00, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x23, 0xF0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0xE0, 0x68, 0x12, 0x08, 0x86, 0x21, 0x08,
  0x82, 0x60, 0xB8, 0x2A, 0x0C, 0xC3, 0x10, 0x86, 0x20, 0x88, 0x32, 0x04,
  0x81, 0xA0, 0x28, 0x0C, 0xFF, 0xFF, 0xFF, 0xE0, 0x8E, 0x0F, 0x16, 0x73,
  0x3B, 0x82, 0x81, 0x60, 0x70, 0x38, 0x0C, 0x07, 0x00, 0x80, 0x60, 0x10,
  0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20,
  0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40,
  0x30, 0x08, 0x06, 0x01, 0x00, 0x80, 0x8F, 0x17, 0x32, 0x83, 0x60, 0x3C,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x0F, 0x03, 0x9C,
  0x60, 0x64, 0x02, 0xC0, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x14, 0x03, 0x60, 0x23, 0x04,
  0x1F, 0x80, 0x8F, 0x09, 0x9C, 0xA0, 0x6C, 0x02, 0xC0, 0x28, 0x03, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x2C, 0x02, 0xE0, 0x6B, 0x0C, 0x9F, 0x88, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x0F, 0x13, 0x99, 0x60, 0x54,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x03, 0xC0, 0x3C, 0x03, 0x60, 0x53, 0x0D, 0x1F, 0x90,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x8F, 0x3E, 0x86, 0x0C, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x00, 0x1F, 0x0E, 0x76, 0x01, 0x00, 0xC0, 0x10,
  0x04, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x02, 0x00, 0xC0, 0x10, 0x04,
  0x01, 0x00, 0xF0, 0x67, 0xF0, 0x20, 0x40, 0x81, 0x07, 0xFF, 0xC8, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x06,
  0x07, 0x80, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x05,
  0xC0, 0xB8, 0x25, 0xF8, 0x80, 0x80, 0x1C, 0x03, 0x40, 0x34, 0x02, 0x60,
  0x22, 0x06, 0x20, 0x42, 0x04, 0x30, 0x41, 0x0C, 0x10, 0x81, 0x88, 0x09,
  0x80, 0x90, 0x09, 0x00, 0xD0, 0x07, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x20,
  0x14, 0x06, 0x03, 0x40, 0x70, 0x34, 0x05, 0x02, 0x60, 0x50, 0x22, 0x0D,
  0x02, 0x20, 0x98, 0x62, 0x08, 0x84, 0x30, 0x88, 0x41, 0x18, 0x84, 0x11,
  0x08, 0xC1, 0x10, 0xC8, 0x19, 0x04, 0x80, 0xB0, 0x48, 0x0A, 0x05, 0x80,
  0xA0, 0x78, 0x0A, 0x03, 0x00, 0xE0, 0x30, 0x04, 0x03, 0x00, 0x80, 0x28,
  0x0D, 0x81, 0x10, 0x63, 0x08, 0x23, 0x06, 0x40, 0x50, 0x0E, 0x00, 0x80,
  0x38, 0x05, 0x01, 0x90, 0x22, 0x08, 0x21, 0x06, 0x40, 0x58, 0x0E, 0x00,
  0x80, 0xC0, 0x1A, 0x00, 0x90, 0x04, 0xC0, 0x62, 0x02, 0x10, 0x10, 0xC1,
  0x82, 0x08, 0x10, 0x40, 0x82, 0x06, 0x30, 0x11, 0x00, 0x88, 0x06, 0xC0,
  0x14, 0x00, 0xA0, 0x05, 0x00, 0x38, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x3C, 0x00, 0x7F, 0xBF, 0xC0,
  0x60, 0x20, 0x30, 0x10, 0x08, 0x08, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01,
  0x80, 0x80, 0xC0, 0x40, 0x60, 0x3F, 0xE0, 0x01, 0xC1, 0xC0, 0xC0, 0x30,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x03, 0x03, 0x80, 0x18, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x04, 0x00, 0xF0, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x18, 0x06, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x60, 0x18, 0x07, 0x0C, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x07,
  0x82, 0x00, 0x3C, 0x07, 0x9C, 0x38, 0x1F, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraLight35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 25, 7, 3, -25 },
  { 8, 7, 9, 11, 2, -25 },
  { 16, 16, 25, 17, 1, -25 },
  { 66, 13, 29, 16, 1, -27 },
  { 114, 19, 25, 23, 2, -25 },
  { 174, 16, 25, 17, 1, -25 },
  { 224, 2, 9, 6, 2, -25 },
  { 227, 6, 31, 9, 2, -25 },
  { 251, 7, 31, 9, 1, -25 },
  { 279, 11, 11, 14, 2, -27 },
  { 295, 14, 16, 16, 1, -20 },
  { 323, 4, 9, 7, 1, -4 },
  { 328, 8, 1, 10, 1, -10 },
  { 329, 3, 3, 7, 2, -3 },
  { 331, 10, 25, 12, 1, -25 },
  { 363, 12, 25, 16, 2, -25 },
  { 401, 7, 25, 16, 3, -25 },
  { 423, 12, 25, 16, 2, -25 },
  { 461, 13, 25, 16, 1, -25 },
  { 502, 14, 25, 16, 1, -25 },
  { 546, 12, 25, 16, 2, -25 },
  { 584, 12, 25, 16, 2, -25 },
  { 622, 12, 25, 16, 2, -25 },
  { 660, 13, 25, 16, 1, -25 },
  { 701, 12, 25, 16, 2, -25 },
  { 739, 3, 19, 7, 2, -19 },
  { 747, 4, 24, 7, 1, -19 },
  { 759, 14, 15, 16, 1, -20 },
  { 786, 14, 9, 16, 1, -17 },
  { 802, 14, 15, 16, 1, -20 },
  { 829, 9, 25, 11, 1, -25 },
  { 858, 21, 28, 24, 2, -25 },
  { 932, 16, 25, 16, 0, -25 },
  { 982, 13, 25, 17, 3, -25 },
  { 1023, 14, 25, 17, 2, -25 },
  { 1067, 14, 25, 19, 3, -25 },
  { 1111, 10, 25, 15, 3, -25 },
  { 1143, 10, 25, 14, 3, -25 },
  { 1175, 16, 25, 20, 2, -25 },
  { 1225, 14, 25, 20, 3, -25 },
  { 1269, 6, 25, 9, 1, -25 },
  { 1288, 6, 31, 7, -2, -25 },
  { 1312, 13, 25, 16, 3, -25 },
  { 1353, 10, 25, 14, 3, -25 },
  { 1385, 19, 25, 25, 3, -25 },
  { 1445, 14, 25, 20, 3, -25 },
  { 1489, 17, 25, 21, 2, -25 },
  { 1543, 12, 25, 16, 3, -25 },
  { 1581, 17, 31, 21, 2, -25 },
  { 1647, 13, 25, 16, 3, -25 },
  { 1688, 12, 25, 15, 2, -25 },
  { 1726, 14, 25, 14, 0, -25 },
  { 1770, 14, 25, 20, 3, -25 },
  { 1814, 15, 25, 15, 0, -25 },
  { 1861, 25, 25, 25, 0, -25 },
  { 1940, 14, 25, 14, 0, -25 },
  { 1984, 14, 25, 14, 0, -25 },
  { 2028, 12, 25, 14, 1, -25 },
  { 2066, 7, 31, 11, 3, -25 },
  { 2094, 10, 25, 12, 1, -25 },
  { 2126, 7, 31, 11, 1, -25 },
  { 2154, 14, 13, 16, 1, -25 },
  { 2177, 14, 1, 14, 0, 3 },
  { 2179, 6, 6, 8, 1, -27 },
  { 2184, 11, 19, 15, 1, -19 },
  { 2211, 12, 27, 17, 3, -27 },
  { 2252, 10, 19, 13, 2, -19 },
  { 2276, 12, 27, 17, 2, -27 },
  { 2317, 12, 19, 15, 2, -19 },
  { 2346, 10, 27, 8, 0, -27 },
  { 2380, 12, 27, 17, 2, -19 },
  { 2421, 11, 27, 16, 3, -27 },
  { 2459, 3, 25, 7, 2, -25 },
  { 2469, 5, 33, 7, -1, -25 },
  { 2490, 10, 27, 13, 3, -27 },
  { 2524, 1, 27, 7, 3, -27 },
  { 2528, 19, 19, 24, 3, -19 },
  { 2574, 11, 19, 16, 3, -19 },
  { 2601, 12, 19, 16, 2, -19 },
  { 2630, 12, 27, 17, 3, -19 },
  { 2671, 12, 27, 17, 2, -19 },
  { 2712, 7, 19, 11, 3, -19 },
  { 2729, 10, 19, 13, 1, -19 },
  { 2753, 7, 23, 9, 1, -23 },
  { 2774, 11, 19, 16, 3, -19 },
  { 2801, 12, 19, 12, 0, -19 },
  { 2830, 20, 19, 20, 0, -19 },
  { 2878, 11, 19, 13, 1, -19 },
  { 2905, 13, 27, 13, 0, -19 },
  { 2949, 9, 19, 11, 1, -19 },
  { 2971, 10, 31, 12, 1, -25 },
  { 3010, 1, 36, 15, 7, -27 },
  { 3015, 9, 31, 12, 2, -25 },
  { 3050, 14, 3, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_ExtraLight35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight35pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT35PT7B_H_
