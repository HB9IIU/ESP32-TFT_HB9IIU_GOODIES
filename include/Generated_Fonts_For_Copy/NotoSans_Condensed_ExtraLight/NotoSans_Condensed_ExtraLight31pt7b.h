#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT31PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight31pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x40, 0xF0, 0x8E, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x04, 0x20, 0x10, 0x80, 0x42, 0x02, 0x08, 0x08, 0x20, 0x20, 0x87,
  0xFF, 0xC2, 0x10, 0x08, 0x40, 0x21, 0x01, 0x04, 0x04, 0x10, 0x10, 0x40,
  0x41, 0x0F, 0xFF, 0x84, 0x20, 0x10, 0x80, 0xC2, 0x02, 0x08, 0x08, 0x20,
  0x20, 0x80, 0x84, 0x00, 0x04, 0x00, 0x80, 0x3C, 0x1E, 0xF6, 0x40, 0x88,
  0x31, 0x04, 0x20, 0xC4, 0x08, 0x81, 0x90, 0x1A, 0x00, 0xC0, 0x0E, 0x01,
  0x30, 0x23, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0x43, 0x89, 0x9F, 0xE0,
  0x20, 0x04, 0x00, 0x80, 0x3C, 0x04, 0x11, 0x82, 0x04, 0x20, 0x81, 0x08,
  0x20, 0x42, 0x10, 0x30, 0x84, 0x0C, 0x22, 0x03, 0x08, 0x80, 0x42, 0x22,
  0x10, 0x93, 0x44, 0x24, 0x89, 0x1A, 0x42, 0x3C, 0x90, 0xC0, 0x24, 0x10,
  0x11, 0x04, 0x04, 0x41, 0x02, 0x10, 0x40, 0x84, 0x10, 0x21, 0x0C, 0x10,
  0x42, 0x04, 0x08, 0x82, 0x03, 0xC0, 0x1F, 0x00, 0x42, 0x02, 0x08, 0x08,
  0x20, 0x20, 0x80, 0x82, 0x01, 0x08, 0x04, 0x60, 0x1B, 0x00, 0x38, 0x01,
  0xC0, 0x0D, 0x80, 0x62, 0x09, 0x04, 0x2C, 0x08, 0xA0, 0x32, 0x80, 0x52,
  0x00, 0xCC, 0x03, 0x10, 0x14, 0x60, 0xC8, 0xFC, 0x30, 0xFF, 0x0C, 0x21,
  0x04, 0x20, 0x86, 0x10, 0x41, 0x04, 0x10, 0xC3, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x20, 0x83, 0x04, 0x18, 0x20, 0x40, 0xC1, 0x82, 0x0C, 0x10, 0x40,
  0x82, 0x08, 0x30, 0xC1, 0x04, 0x10, 0x43, 0x0C, 0x20, 0x82, 0x18, 0x41,
  0x0C, 0x21, 0x0C, 0x00, 0x04, 0x01, 0x00, 0x40, 0x10, 0xE5, 0xC7, 0x80,
  0xA0, 0x68, 0x11, 0x08, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x0F, 0xFF, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x2D, 0xA4, 0xA0, 0xFE, 0xF0, 0x00, 0x80, 0x80, 0x40, 0x60,
  0x20, 0x10, 0x18, 0x08, 0x04, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0xC0,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x00, 0x3F, 0x18, 0x64, 0x0B,
  0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x09, 0x02, 0x21, 0x07, 0xC0,
  0x08, 0xDB, 0x98, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x3F, 0x88, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x20,
  0x08, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0xFF, 0xC0, 0x3F, 0x98, 0x18,
  0x01, 0x00, 0x30, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x78,
  0x00, 0xC0, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x28, 0x0C, 0xFF, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x05, 0x80, 0x2C,
  0x02, 0x60, 0x13, 0x01, 0x18, 0x18, 0xC0, 0x86, 0x0C, 0x30, 0x41, 0x84,
  0x0C, 0x20, 0x62, 0x03, 0x1F, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x7F, 0x90, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08,
  0x02, 0x00, 0x80, 0x3F, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x02, 0x81, 0xBF, 0x80, 0x0F, 0x86, 0x00, 0x80,
  0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x8E, 0x17, 0x73, 0x02, 0x60,
  0x28, 0x05, 0x00, 0xA0, 0x1C, 0x03, 0x80, 0x50, 0x0B, 0x01, 0x20, 0x66,
  0x08, 0x7E, 0x00, 0xFF, 0xE0, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80,
  0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x20, 0x00, 0x1F, 0x82,
  0x04, 0x60, 0x64, 0x02, 0x40, 0x24, 0x02, 0x40, 0x22, 0x04, 0x10, 0x80,
  0xF0, 0x0E, 0x01, 0x98, 0x20, 0xC4, 0x06, 0x40, 0x2C, 0x03, 0xC0, 0x3C,
  0x03, 0x40, 0x24, 0x02, 0x20, 0x41, 0xF8, 0x1F, 0x84, 0x19, 0x01, 0x20,
  0x24, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x28, 0x05, 0x01, 0xB0, 0x53,
  0xFA, 0x18, 0x40, 0x08, 0x01, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x10,
  0xFC, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x2D, 0x80, 0x00, 0x00, 0x00,
  0x0B, 0x69, 0x28, 0x00, 0x10, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x06,
  0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x08, 0x00, 0xFC, 0x82, 0x03,
  0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x18, 0x10, 0x30, 0x20,
  0x20, 0x20, 0x00, 0x00, 0x00, 0x30, 0x30, 0x03, 0xF8, 0x03, 0x03, 0x01,
  0x80, 0x20, 0xC0, 0x04, 0x20, 0x01, 0x90, 0x00, 0x24, 0x0F, 0x0A, 0x0C,
  0x43, 0x82, 0x10, 0x61, 0x04, 0x18, 0x41, 0x06, 0x10, 0x41, 0x84, 0x10,
  0x61, 0x04, 0x18, 0x41, 0x06, 0x10, 0xC2, 0x84, 0x30, 0xA0, 0xF3, 0xCC,
  0x08, 0x21, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x60, 0x03, 0xE0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x01, 0x20, 0x04,
  0x80, 0x12, 0x00, 0xCC, 0x02, 0x10, 0x08, 0x40, 0x21, 0x01, 0x02, 0x04,
  0x08, 0x10, 0x20, 0xFF, 0xC2, 0x01, 0x08, 0x04, 0x20, 0x11, 0x80, 0x24,
  0x00, 0x90, 0x02, 0xC0, 0x0E, 0x00, 0x10, 0xFF, 0x10, 0x32, 0x01, 0x40,
  0x28, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0xD0, 0x33, 0xF8, 0x40, 0xC8,
  0x05, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x28, 0x19,
  0xFE, 0x00, 0x0F, 0xF1, 0x81, 0x30, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x10, 0xFF, 0xFE,
  0x08, 0x18, 0x80, 0xC8, 0x06, 0x80, 0x28, 0x03, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x28, 0x02, 0x80, 0x68, 0x0C, 0x83, 0x8F, 0xE0, 0xFF, 0xC0, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0xD0, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x07, 0xFC, 0xFF, 0xC0, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x1F, 0xE8, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x07, 0xF8,
  0x60, 0x13, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x3F, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x40, 0x05, 0x00, 0x16, 0x00, 0x4C, 0x01, 0x18, 0x04, 0x1F,
  0xE0, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0xFF, 0xF8, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xF9, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x7C,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x0C, 0x2F, 0x98, 0x80, 0x70, 0x12,
  0x06, 0x40, 0x88, 0x21, 0x0C, 0x23, 0x04, 0x40, 0x90, 0x16, 0x02, 0xC0,
  0x64, 0x08, 0xC1, 0x08, 0x21, 0x84, 0x10, 0x83, 0x10, 0x22, 0x02, 0x40,
  0x48, 0x05, 0x00, 0xC0, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x07, 0xFC, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xBC,
  0x00, 0x5A, 0x00, 0x6D, 0x00, 0x26, 0xC0, 0x13, 0x20, 0x19, 0x90, 0x08,
  0xCC, 0x04, 0x62, 0x06, 0x31, 0x02, 0x18, 0xC1, 0x0C, 0x21, 0x86, 0x10,
  0x83, 0x0C, 0x41, 0x82, 0x60, 0xC1, 0x20, 0x60, 0xD0, 0x30, 0x38, 0x18,
  0x18, 0x0C, 0x0C, 0x04, 0x80, 0x1C, 0x01, 0xC0, 0x1A, 0x01, 0xA0, 0x19,
  0x01, 0x90, 0x18, 0x81, 0x88, 0x18, 0x41, 0x84, 0x18, 0x21, 0x82, 0x18,
  0x11, 0x81, 0x18, 0x09, 0x80, 0x98, 0x05, 0x80, 0x58, 0x03, 0x80, 0x38,
  0x01, 0x0F, 0xE0, 0x60, 0x60, 0x80, 0x62, 0x00, 0x44, 0x00, 0xD8, 0x00,
  0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xA0, 0x01, 0x40, 0x02, 0xC0, 0x04, 0x80, 0x19, 0x80,
  0x21, 0x00, 0xC1, 0x03, 0x01, 0xFC, 0x00, 0xFE, 0x20, 0xE8, 0x0A, 0x03,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x28, 0x1A, 0x1C, 0xFC, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00, 0x0F,
  0xE0, 0x60, 0x60, 0x80, 0x62, 0x00, 0x44, 0x00, 0xD8, 0x00, 0xA0, 0x01,
  0x40, 0x02, 0x80, 0x05, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xA0, 0x01, 0x40, 0x02, 0xC0, 0x04, 0x80, 0x19, 0x80, 0x21, 0x00,
  0xC1, 0x03, 0x01, 0xF8, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x60, 0xFE, 0x10, 0x72, 0x02, 0x40, 0x68, 0x05, 0x00, 0xA0, 0x14,
  0x02, 0x80, 0xD0, 0x12, 0x0C, 0x7F, 0x08, 0x41, 0x0C, 0x20, 0x84, 0x18,
  0x81, 0x10, 0x32, 0x02, 0x40, 0x68, 0x05, 0x00, 0xC0, 0x1F, 0xE6, 0x05,
  0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x38, 0x0D, 0xFF, 0x00, 0xFF, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0A, 0x00, 0xD0, 0x04, 0xC0, 0x23, 0x06, 0x0F,
  0xE0, 0x80, 0x0F, 0x00, 0x24, 0x00, 0x90, 0x06, 0x40, 0x10, 0x80, 0x42,
  0x01, 0x08, 0x08, 0x30, 0x20, 0x40, 0x81, 0x06, 0x04, 0x10, 0x18, 0x40,
  0x21, 0x00, 0x8C, 0x02, 0x20, 0x04, 0x80, 0x12, 0x00, 0x50, 0x01, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x10, 0x05, 0x00, 0xC0, 0x14, 0x03, 0x00,
  0xD0, 0x0E, 0x02, 0x60, 0x28, 0x08, 0x81, 0xA0, 0x22, 0x04, 0x81, 0x88,
  0x13, 0x04, 0x30, 0x44, 0x10, 0x41, 0x10, 0x41, 0x08, 0x43, 0x04, 0x21,
  0x08, 0x10, 0x82, 0x20, 0x22, 0x08, 0x80, 0x98, 0x22, 0x02, 0x40, 0x98,
  0x09, 0x03, 0x40, 0x34, 0x05, 0x00, 0x50, 0x14, 0x01, 0x80, 0x70, 0x06,
  0x01, 0x80, 0x18, 0x02, 0x00, 0x40, 0x32, 0x02, 0x20, 0x61, 0x04, 0x10,
  0x41, 0x88, 0x08, 0x80, 0xD0, 0x05, 0x00, 0x70, 0x02, 0x00, 0x70, 0x05,
  0x00, 0x90, 0x08, 0x81, 0x88, 0x10, 0xC3, 0x04, 0x20, 0x66, 0x02, 0x40,
  0x3C, 0x01, 0xC0, 0x34, 0x02, 0x40, 0x26, 0x06, 0x20, 0x42, 0x04, 0x10,
  0x81, 0x08, 0x19, 0x80, 0x90, 0x09, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF,
  0xC0, 0x08, 0x03, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x04, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0xFF, 0xC0, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x0F, 0xC0, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80, 0x60,
  0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x00,
  0xC0, 0x20, 0x10, 0x04, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x1F,
  0xC0, 0x06, 0x00, 0x60, 0x0D, 0x00, 0x90, 0x18, 0x81, 0x08, 0x30, 0x42,
  0x04, 0x60, 0x24, 0x02, 0xC0, 0x18, 0x01, 0xFF, 0xF8, 0xC2, 0x08, 0x20,
  0x80, 0x0E, 0x1C, 0xE0, 0x08, 0x03, 0x00, 0x40, 0x10, 0x04, 0x03, 0x1F,
  0x58, 0x14, 0x07, 0x01, 0x80, 0xE0, 0x3C, 0x0D, 0x05, 0x3E, 0x40, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x38, 0xD9, 0x94,
  0x0A, 0x81, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x40, 0xAC, 0x34, 0xFC, 0x0E, 0x1C, 0xD8, 0x08,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x01,
  0x00, 0xC0, 0x3F, 0x80, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x63, 0x33, 0x68, 0x1F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x81, 0xD8, 0x69,
  0xF9, 0x0C, 0x0C, 0xC4, 0x1B, 0x02, 0x80, 0xE0, 0x18, 0x06, 0x01, 0xFF,
  0xE0, 0x08, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x81, 0x3F, 0x80, 0x07,
  0x86, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0xFE, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x0E, 0x06, 0x6D, 0x03, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x3B, 0x0B,
  0x3F, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0xA0, 0x27, 0xF8, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x18, 0xDB, 0xA8, 0x3C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x08,
  0xC6, 0x00, 0x00, 0x03, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x78, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC1, 0xB0, 0x4C, 0x23, 0x10, 0xCC, 0x22, 0x09,
  0x82, 0xA0, 0xA4, 0x31, 0x0C, 0x23, 0x08, 0xC1, 0x30, 0x4C, 0x0B, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x49, 0x9D, 0xA8, 0x28,
  0x78, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x02, 0x03, 0x81, 0x01, 0xC0,
  0x80, 0xE0, 0x40, 0x70, 0x20, 0x38, 0x10, 0x1C, 0x08, 0x0E, 0x04, 0x07,
  0x02, 0x03, 0x81, 0x01, 0xC0, 0x80, 0x80, 0x06, 0x26, 0x6A, 0x0F, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x40, 0x0E, 0x07, 0x71, 0x02, 0x60, 0x28, 0x05,
  0x00, 0xA0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x05, 0x00,
  0x90, 0x33, 0x04, 0x3F, 0x00, 0x07, 0x13, 0x32, 0x81, 0x50, 0x3C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0xE8, 0x15, 0x86, 0xDF, 0x98, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0x06, 0x01, 0xDB, 0x20, 0x76, 0x07, 0x40, 0x34, 0x03, 0x40,
  0x34, 0x03, 0xC0, 0x3C, 0x03, 0x40, 0x34, 0x03, 0x40, 0x34, 0x03, 0x60,
  0x73, 0x0B, 0x1F, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x0F, 0x3E, 0x85, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC0, 0x0E, 0x39, 0xD0, 0x18, 0x08, 0x06, 0x01,
  0x00, 0x60, 0x1C, 0x03, 0x00, 0x40, 0x10, 0x08, 0x04, 0x03, 0x02, 0xFE,
  0x00, 0x20, 0x86, 0x18, 0xFD, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x82, 0x0F, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0xD0, 0x36, 0x14, 0xF9,
  0xC0, 0x68, 0x09, 0x01, 0x20, 0x66, 0x08, 0x41, 0x08, 0x21, 0x88, 0x11,
  0x02, 0x20, 0x4C, 0x0D, 0x00, 0xA0, 0x14, 0x03, 0x00, 0x20, 0xC0, 0xC0,
  0xD0, 0x30, 0x24, 0x0E, 0x09, 0x02, 0x82, 0x21, 0x21, 0x88, 0x48, 0x42,
  0x12, 0x10, 0x84, 0x44, 0x32, 0x11, 0x04, 0x84, 0x81, 0x21, 0x20, 0x48,
  0x28, 0x1C, 0x0A, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x10, 0xC0, 0xD0,
  0x26, 0x10, 0x8C, 0x32, 0x05, 0x80, 0xC0, 0x30, 0x0C, 0x05, 0x81, 0x20,
  0x8C, 0x61, 0x10, 0x6C, 0x0A, 0x03, 0xC0, 0x28, 0x0D, 0x01, 0x10, 0x22,
  0x0C, 0x41, 0x0C, 0x20, 0x84, 0x11, 0x02, 0x20, 0x24, 0x05, 0x80, 0xA0,
  0x1C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x20,
  0x3C, 0x02, 0x00, 0x7F, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x40, 0x40, 0xC0, 0xFF, 0x07, 0x0C, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x30, 0xE0, 0x10, 0x18, 0x18,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x0C, 0x04, 0x03, 0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x10, 0xE0, 0x7C, 0x18, 0x3F,
};

const GFXglyph NotoSans_Condensed_ExtraLight31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 22, 7, 2, -22 },
  { 7, 6, 8, 10, 2, -22 },
  { 13, 14, 22, 15, 1, -22 },
  { 52, 11, 26, 14, 1, -24 },
  { 88, 18, 22, 20, 1, -22 },
  { 138, 14, 22, 15, 1, -22 },
  { 177, 1, 8, 5, 2, -22 },
  { 178, 6, 27, 8, 1, -22 },
  { 199, 6, 27, 8, 1, -22 },
  { 220, 10, 10, 13, 1, -24 },
  { 233, 12, 14, 14, 1, -18 },
  { 254, 3, 7, 6, 1, -3 },
  { 257, 7, 1, 9, 1, -9 },
  { 258, 2, 2, 6, 2, -2 },
  { 259, 9, 22, 10, 1, -22 },
  { 284, 10, 22, 14, 2, -22 },
  { 312, 5, 22, 14, 3, -22 },
  { 326, 11, 22, 14, 1, -22 },
  { 357, 11, 22, 14, 1, -22 },
  { 388, 13, 22, 14, 1, -22 },
  { 424, 10, 22, 14, 2, -22 },
  { 452, 11, 22, 14, 2, -22 },
  { 483, 11, 22, 14, 1, -22 },
  { 514, 12, 22, 14, 1, -22 },
  { 547, 11, 22, 14, 1, -22 },
  { 578, 2, 17, 6, 2, -17 },
  { 583, 3, 21, 6, 1, -17 },
  { 591, 12, 14, 14, 1, -18 },
  { 612, 12, 8, 14, 1, -15 },
  { 624, 12, 14, 14, 1, -18 },
  { 645, 8, 22, 10, 1, -22 },
  { 667, 18, 25, 22, 2, -22 },
  { 724, 14, 22, 14, 0, -22 },
  { 763, 11, 22, 15, 3, -22 },
  { 794, 12, 22, 15, 2, -22 },
  { 827, 12, 22, 17, 3, -22 },
  { 860, 9, 22, 13, 3, -22 },
  { 885, 9, 22, 12, 3, -22 },
  { 910, 14, 22, 18, 2, -22 },
  { 949, 12, 22, 17, 3, -22 },
  { 982, 5, 22, 8, 1, -22 },
  { 996, 6, 28, 6, -2, -22 },
  { 1017, 11, 22, 14, 3, -22 },
  { 1048, 9, 22, 12, 3, -22 },
  { 1073, 17, 22, 22, 3, -22 },
  { 1120, 12, 22, 18, 3, -22 },
  { 1153, 15, 22, 18, 2, -22 },
  { 1195, 10, 22, 14, 3, -22 },
  { 1223, 15, 27, 18, 2, -22 },
  { 1274, 11, 22, 14, 3, -22 },
  { 1305, 11, 22, 14, 1, -22 },
  { 1336, 12, 22, 12, 0, -22 },
  { 1369, 13, 22, 17, 2, -22 },
  { 1405, 14, 22, 14, 0, -22 },
  { 1444, 22, 22, 23, 0, -22 },
  { 1505, 12, 22, 12, 0, -22 },
  { 1538, 12, 22, 12, 0, -22 },
  { 1571, 11, 22, 13, 1, -22 },
  { 1602, 6, 27, 10, 3, -22 },
  { 1623, 9, 22, 10, 1, -22 },
  { 1648, 6, 27, 10, 1, -22 },
  { 1669, 12, 12, 14, 1, -22 },
  { 1687, 13, 1, 12, 0, 3 },
  { 1689, 5, 5, 7, 1, -24 },
  { 1693, 10, 17, 13, 1, -17 },
  { 1715, 11, 24, 15, 2, -24 },
  { 1748, 9, 17, 11, 2, -17 },
  { 1768, 11, 24, 15, 2, -24 },
  { 1801, 10, 17, 13, 2, -17 },
  { 1823, 9, 24, 7, 0, -24 },
  { 1850, 11, 24, 15, 2, -17 },
  { 1883, 10, 24, 14, 2, -24 },
  { 1913, 2, 23, 6, 2, -23 },
  { 1919, 5, 30, 6, -1, -23 },
  { 1938, 10, 24, 12, 2, -24 },
  { 1968, 2, 24, 6, 2, -24 },
  { 1974, 17, 17, 22, 2, -17 },
  { 2011, 10, 17, 14, 2, -17 },
  { 2033, 11, 17, 14, 2, -17 },
  { 2057, 11, 24, 15, 2, -17 },
  { 2090, 12, 24, 15, 1, -17 },
  { 2126, 7, 17, 9, 2, -17 },
  { 2141, 9, 17, 11, 1, -17 },
  { 2161, 6, 20, 8, 1, -20 },
  { 2176, 10, 16, 14, 2, -16 },
  { 2196, 11, 16, 11, 0, -16 },
  { 2218, 18, 16, 18, 0, -16 },
  { 2254, 10, 16, 12, 1, -16 },
  { 2274, 11, 24, 11, 0, -16 },
  { 2307, 8, 16, 10, 1, -16 },
  { 2323, 8, 27, 11, 1, -22 },
  { 2350, 1, 32, 13, 6, -24 },
  { 2354, 8, 27, 11, 1, -22 },
  { 2381, 12, 2, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_ExtraLight31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight31pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT31PT7B_H_
