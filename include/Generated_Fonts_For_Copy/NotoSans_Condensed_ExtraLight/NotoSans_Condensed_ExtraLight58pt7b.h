#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT58PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight58pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x07, 0xFF, 0x70, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x36, 0x06, 0xC0, 0xD8, 0x1B,
  0x03, 0x60, 0x6C, 0x05, 0x80, 0xB0, 0x10, 0x00, 0x30, 0x0C, 0x00, 0x0C,
  0x03, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x80, 0x30, 0x00, 0x60, 0x08, 0x00,
  0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18,
  0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x03, 0x00, 0x60, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x06, 0x00, 0x80,
  0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01,
  0x80, 0x01, 0x80, 0x60, 0x00, 0x40, 0x18, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00,
  0x0C, 0x03, 0x00, 0x02, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x60, 0x18,
  0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60,
  0x18, 0x00, 0x10, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xF8, 0x07, 0xF7,
  0xF8, 0x70, 0x81, 0x87, 0x04, 0x00, 0x70, 0x20, 0x03, 0x01, 0x00, 0x18,
  0x08, 0x00, 0xC0, 0x40, 0x0E, 0x02, 0x00, 0x70, 0x10, 0x01, 0x80, 0x80,
  0x0C, 0x04, 0x00, 0x60, 0x20, 0x03, 0x81, 0x00, 0x0E, 0x08, 0x00, 0x38,
  0x40, 0x00, 0xF2, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x2F, 0x00, 0x01, 0x1E, 0x00, 0x08, 0x78, 0x00, 0x40, 0xE0, 0x02,
  0x03, 0x00, 0x10, 0x1C, 0x00, 0x80, 0x60, 0x04, 0x03, 0x00, 0x20, 0x18,
  0x01, 0x00, 0xC0, 0x08, 0x06, 0x00, 0x40, 0x30, 0x02, 0x03, 0x80, 0x10,
  0x1A, 0x00, 0x81, 0xCC, 0x04, 0x3C, 0x7F, 0xBF, 0xC0, 0xFF, 0xF8, 0x00,
  0x38, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x80, 0x30, 0xE0, 0x03,
  0x00, 0x70, 0x60, 0x03, 0x00, 0x60, 0x30, 0x03, 0x00, 0x60, 0x30, 0x06,
  0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0xC0, 0x18, 0x0C,
  0x00, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0x18, 0x18, 0x00, 0xC0, 0x18, 0x18,
  0x00, 0xC0, 0x18, 0x30, 0x00, 0xC0, 0x18, 0x30, 0x00, 0xC0, 0x18, 0x30,
  0x00, 0xC0, 0x18, 0x60, 0x00, 0xC0, 0x18, 0x60, 0x00, 0xC0, 0x18, 0xC1,
  0xF8, 0xC0, 0x30, 0xC3, 0x9C, 0xC0, 0x30, 0xC6, 0x0C, 0x60, 0x31, 0x8E,
  0x06, 0x60, 0x31, 0x8C, 0x06, 0x70, 0x63, 0x0C, 0x06, 0x30, 0xE3, 0x0C,
  0x03, 0x1F, 0xC3, 0x18, 0x03, 0x0F, 0x86, 0x18, 0x03, 0x00, 0x06, 0x18,
  0x03, 0x00, 0x0E, 0x18, 0x03, 0x00, 0x0C, 0x18, 0x03, 0x00, 0x0C, 0x18,
  0x03, 0x00, 0x18, 0x18, 0x03, 0x00, 0x18, 0x18, 0x03, 0x00, 0x38, 0x18,
  0x03, 0x00, 0x30, 0x18, 0x03, 0x00, 0x30, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x0C, 0x06, 0x00, 0xE0, 0x0C, 0x06, 0x00, 0xC0, 0x0E,
  0x06, 0x00, 0xC0, 0x06, 0x0C, 0x01, 0x80, 0x03, 0x9C, 0x01, 0x80, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x40, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x70, 0x70, 0x00, 0x18, 0x0C, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x00, 0x60,
  0x00, 0xC0, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00,
  0x60, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x06, 0x00, 0x0E, 0x01, 0x80, 0x01,
  0x80, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0x60, 0x06, 0x38,
  0x0C, 0x01, 0x8C, 0x03, 0x80, 0x67, 0x00, 0x60, 0x39, 0x80, 0x0C, 0x0C,
  0x60, 0x03, 0x83, 0x38, 0x00, 0x60, 0xCE, 0x00, 0x0C, 0x63, 0x80, 0x03,
  0x98, 0xE0, 0x00, 0x7E, 0x38, 0x00, 0x0F, 0x06, 0x00, 0x01, 0xC1, 0x80,
  0x00, 0xF0, 0x60, 0x00, 0x3C, 0x1C, 0x00, 0x19, 0x83, 0x80, 0x0E, 0x70,
  0x70, 0x0E, 0x0E, 0x0F, 0xBF, 0x01, 0x81, 0xFF, 0x80, 0x70, 0x06, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03,
  0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06,
  0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30,
  0x0E, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0xE0, 0x06, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06,
  0x01, 0x80, 0x70, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x0C, 0x1F, 0xE3, 0x1F, 0x1F,
  0xFE, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x05, 0x80, 0x03, 0x30, 0x01, 0x86,
  0x00, 0xC1, 0xC0, 0x70, 0x30, 0x38, 0x07, 0x04, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x0C, 0x31, 0x86, 0x18, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xEF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0x0F, 0x00, 0xC0, 0x38,
  0x18, 0x01, 0x83, 0x80, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0E, 0x70, 0x00,
  0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00,
  0x66, 0x00, 0x06, 0x70, 0x00, 0x63, 0x00, 0x0C, 0x38, 0x00, 0xC1, 0x80,
  0x1C, 0x1C, 0x03, 0x80, 0xE0, 0x70, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0xE0, 0x3C, 0x0D, 0x87, 0x31, 0xC6, 0x70, 0xDC, 0x1F, 0x03, 0x40, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x03, 0xF8, 0x01, 0xFF,
  0xE0, 0x7C, 0x0F, 0x0F, 0x00, 0x38, 0x40, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0x81,
  0xE1, 0xE0, 0x03, 0x86, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x32, 0x00, 0x03, 0x9C,
  0x00, 0x78, 0xFF, 0x3F, 0x80, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x19, 0x80, 0x00, 0x1C, 0xC0, 0x00,
  0x0C, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x18, 0x00, 0x06, 0x0C, 0x00,
  0x03, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x01, 0x80, 0xC0,
  0x01, 0xC0, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x60, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x18, 0x00, 0x60, 0x1C, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x0E, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x63, 0xF0, 0x07, 0xFF, 0xE0, 0x7C, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC8, 0x00, 0x38, 0xE0, 0x07, 0x0F,
  0xEF, 0xE0, 0x3F, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFC,
  0x01, 0xE0, 0x40, 0x78, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x30, 0x0E, 0x1F, 0xE0, 0xC7, 0xFF, 0x8C, 0xE0, 0x1C, 0xD8, 0x00, 0xCD,
  0x00, 0x06, 0xF0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x33, 0x00,
  0x07, 0x30, 0x00, 0x63, 0x80, 0x0E, 0x1C, 0x00, 0xC0, 0xE0, 0x1C, 0x07,
  0x8F, 0x80, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0xF0, 0x3C, 0x07, 0x00,
  0x38, 0x18, 0x00, 0x60, 0xE0, 0x01, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x38, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x8C, 0x00, 0x0C, 0x30,
  0x00, 0x30, 0xE0, 0x01, 0xC1, 0x80, 0x06, 0x03, 0x00, 0x38, 0x0E, 0x01,
  0xC0, 0x1E, 0x0E, 0x00, 0x1C, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0x38, 0x00, 0x78, 0x78, 0x03, 0x80, 0x70, 0x1C, 0x00, 0xE0, 0xE0,
  0x01, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x0E, 0x60, 0x00, 0x19, 0x80, 0x00,
  0x66, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x76,
  0x00, 0x01, 0x98, 0x00, 0x06, 0x70, 0x00, 0x38, 0xC0, 0x00, 0xC3, 0x80,
  0x07, 0x07, 0x80, 0x78, 0x0F, 0xCF, 0xC0, 0x0F, 0xFC, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1E, 0x0F, 0x03, 0x80, 0x38, 0x30,
  0x01, 0x86, 0x00, 0x1C, 0x60, 0x00, 0xCE, 0x00, 0x0E, 0xC0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0x60, 0x00, 0xF7, 0x00, 0x1B, 0x38, 0x03, 0x31, 0xC0,
  0x73, 0x0F, 0xFE, 0x30, 0x7F, 0x87, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x79, 0xF8, 0x07, 0xFE, 0x00, 0x06, 0x00,
  0x00, 0x6F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0xFF, 0xE0, 0x18, 0xF3, 0xCF, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x71, 0xC6, 0x18, 0xE3, 0x8C, 0x30, 0xC6, 0x18, 0x63, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x7F, 0xF0, 0xF0, 0x3C, 0x40, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x18, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x00, 0x18, 0xC0, 0x01, 0xE0,
  0x06, 0x30, 0x03, 0xFF, 0x01, 0x9C, 0x01, 0xC0, 0xC0, 0x76, 0x00, 0xE0,
  0x30, 0x0D, 0x80, 0x70, 0x0C, 0x03, 0x60, 0x18, 0x03, 0x00, 0xD8, 0x06,
  0x00, 0xC0, 0x3C, 0x03, 0x00, 0x30, 0x0F, 0x00, 0xC0, 0x0C, 0x03, 0xC0,
  0x30, 0x07, 0x00, 0xF0, 0x0C, 0x01, 0xC0, 0x3C, 0x03, 0x00, 0x70, 0x0F,
  0x00, 0xC0, 0x18, 0x03, 0xC0, 0x30, 0x06, 0x00, 0xF0, 0x0C, 0x01, 0x80,
  0x3C, 0x03, 0x00, 0x60, 0x0F, 0x00, 0xC0, 0x18, 0x03, 0xC0, 0x30, 0x0E,
  0x01, 0xB0, 0x0C, 0x03, 0xC0, 0x66, 0x03, 0x80, 0xB0, 0x39, 0x80, 0x60,
  0x64, 0x0C, 0x60, 0x0E, 0x71, 0xCE, 0x18, 0x01, 0xF8, 0x3F, 0x07, 0x00,
  0x10, 0x02, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x08,
  0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x06,
  0x1C, 0x00, 0x03, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00,
  0x0C, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x1C,
  0x00, 0x38, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x01, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x38, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x0E, 0x70,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x30, 0x00, 0xF1,
  0x80, 0x01, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x3B, 0x00, 0x01, 0xD8, 0x00,
  0x06, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C,
  0x00, 0x07, 0x60, 0x00, 0x3B, 0x00, 0x01, 0x98, 0x00, 0x1C, 0xC0, 0x01,
  0xC6, 0x00, 0x3C, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0C, 0x00, 0xF8, 0x60,
  0x00, 0xE3, 0x00, 0x03, 0x98, 0x00, 0x0E, 0xC0, 0x00, 0x36, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0D,
  0x80, 0x00, 0xEC, 0x00, 0x0E, 0x60, 0x00, 0xF3, 0x00, 0x1F, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xC0,
  0x78, 0x1E, 0x00, 0x10, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x03, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x0C, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x03, 0x00, 0x1E, 0x06, 0x00, 0x0F, 0x0C, 0x00, 0x0E, 0x18, 0x00,
  0x0E, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x1D, 0x80, 0x00,
  0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xB0, 0x00,
  0x03, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x73, 0x00, 0x00,
  0xC6, 0x00, 0x03, 0x8C, 0x00, 0x0E, 0x18, 0x00, 0x78, 0x30, 0x07, 0xE0,
  0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xDF, 0xFF,
  0xEC, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xE0, 0x1F,
  0x80, 0xF0, 0x00, 0x60, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x19, 0x80,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x0E, 0x00, 0x00, 0xC0, 0xE0,
  0x00, 0x18, 0x0F, 0x00, 0x07, 0x00, 0xFF, 0x7F, 0xE0, 0x07, 0xFF, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0E, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC1, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x03, 0xBF, 0xCF, 0xE0, 0xC0, 0x00,
  0x76, 0x00, 0x07, 0x30, 0x00, 0x31, 0x80, 0x03, 0x8C, 0x00, 0x38, 0x60,
  0x01, 0x83, 0x00, 0x1C, 0x18, 0x01, 0xC0, 0xC0, 0x1C, 0x06, 0x00, 0xC0,
  0x30, 0x0E, 0x01, 0x80, 0xE0, 0x0C, 0x06, 0x00, 0x60, 0x70, 0x03, 0x07,
  0x00, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x06, 0x38, 0x00, 0x33, 0xC0, 0x01,
  0x9F, 0x00, 0x0D, 0x98, 0x00, 0x7C, 0xE0, 0x03, 0xC3, 0x80, 0x1C, 0x0C,
  0x00, 0xC0, 0x70, 0x06, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x38, 0x18, 0x00, 0xE0, 0xC0, 0x03,
  0x06, 0x00, 0x1C, 0x30, 0x00, 0x61, 0x80, 0x03, 0x8C, 0x00, 0x0C, 0x60,
  0x00, 0x73, 0x00, 0x01, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x38, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1B, 0xD8, 0x00, 0x00, 0x1B, 0xD8, 0x00,
  0x00, 0x1B, 0xD8, 0x00, 0x00, 0x3B, 0xCC, 0x00, 0x00, 0x33, 0xCC, 0x00,
  0x00, 0x33, 0xCC, 0x00, 0x00, 0x73, 0xC6, 0x00, 0x00, 0x63, 0xC6, 0x00,
  0x00, 0x63, 0xC6, 0x00, 0x00, 0xE3, 0xC3, 0x00, 0x00, 0xC3, 0xC3, 0x00,
  0x00, 0xC3, 0xC3, 0x00, 0x01, 0xC3, 0xC1, 0x80, 0x01, 0x83, 0xC1, 0x80,
  0x01, 0x83, 0xC1, 0x80, 0x03, 0x83, 0xC0, 0xC0, 0x03, 0x03, 0xC0, 0xC0,
  0x03, 0x03, 0xC0, 0xC0, 0x07, 0x03, 0xC0, 0x60, 0x06, 0x03, 0xC0, 0x60,
  0x06, 0x03, 0xC0, 0x60, 0x0E, 0x03, 0xC0, 0x30, 0x0C, 0x03, 0xC0, 0x30,
  0x0C, 0x03, 0xC0, 0x30, 0x1C, 0x03, 0xC0, 0x18, 0x18, 0x03, 0xC0, 0x18,
  0x18, 0x03, 0xC0, 0x18, 0x38, 0x03, 0xC0, 0x0C, 0x30, 0x03, 0xC0, 0x0C,
  0x30, 0x03, 0xC0, 0x0C, 0x70, 0x03, 0xC0, 0x0E, 0x60, 0x03, 0xC0, 0x06,
  0x60, 0x03, 0xC0, 0x06, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3D, 0x80, 0x00,
  0x7B, 0x00, 0x00, 0xF3, 0x00, 0x01, 0xE6, 0x00, 0x03, 0xC6, 0x00, 0x07,
  0x8C, 0x00, 0x0F, 0x0C, 0x00, 0x1E, 0x18, 0x00, 0x3C, 0x18, 0x00, 0x78,
  0x30, 0x00, 0xF0, 0x30, 0x01, 0xE0, 0x60, 0x03, 0xC0, 0x60, 0x07, 0x80,
  0xC0, 0x0F, 0x00, 0xC0, 0x1E, 0x01, 0xC0, 0x3C, 0x01, 0x80, 0x78, 0x03,
  0x80, 0xF0, 0x03, 0x01, 0xE0, 0x07, 0x03, 0xC0, 0x06, 0x07, 0x80, 0x0E,
  0x0F, 0x00, 0x0C, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x18, 0x78, 0x00, 0x38,
  0xF0, 0x00, 0x31, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0x67, 0x80, 0x00, 0xEF,
  0x00, 0x00, 0xDE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x30, 0x1C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x67, 0x00, 0x00, 0x06,
  0x30, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x01, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x02, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0x00, 0x3C, 0x60, 0x01,
  0xCC, 0x00, 0x1D, 0x80, 0x01, 0xB0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x00, 0x07,
  0x60, 0x01, 0xCC, 0x00, 0x71, 0x81, 0xFC, 0x3F, 0xFE, 0x07, 0xF8, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x38, 0x1C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x67, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x18, 0x0C,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x01,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x30, 0x03, 0xE1, 0x80, 0x07, 0x0C, 0x00, 0x1C, 0x60, 0x00, 0x63, 0x00,
  0x03, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x19,
  0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00,
  0x1C, 0xC0, 0x00, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0xE1, 0x80, 0x0E, 0x0C,
  0x07, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x30, 0x07, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xE0, 0x60,
  0x03, 0x03, 0x00, 0x1C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x86, 0x00, 0x0C,
  0x30, 0x00, 0x71, 0x80, 0x01, 0x8C, 0x00, 0x0E, 0x60, 0x00, 0x33, 0x00,
  0x01, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x38, 0x01, 0xFE, 0x00, 0x7F, 0xFC,
  0x1F, 0x01, 0xE3, 0xC0, 0x02, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xCC, 0x00, 0x78, 0xFF,
  0xFF, 0x07, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1B, 0x80, 0x00, 0x33, 0x00, 0x00,
  0xE7, 0x00, 0x03, 0x87, 0x00, 0x0E, 0x07, 0x80, 0x3C, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x67, 0x00, 0x00, 0x31, 0x80, 0x00,
  0x18, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x0C, 0x00,
  0x07, 0x06, 0x00, 0x03, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60,
  0x00, 0xE0, 0x30, 0x00, 0x60, 0x1C, 0x00, 0x30, 0x06, 0x00, 0x38, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x07, 0x00,
  0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0xE0,
  0x00, 0xC0, 0x60, 0x00, 0x70, 0x30, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x18,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x86, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xB8, 0x00, 0x0F, 0x00, 0x00, 0xCC, 0x00, 0x07, 0x80, 0x00, 0xE6,
  0x00, 0x03, 0xC0, 0x00, 0x63, 0x00, 0x01, 0xE0, 0x00, 0x31, 0xC0, 0x01,
  0x98, 0x00, 0x18, 0x60, 0x00, 0xCC, 0x00, 0x1C, 0x30, 0x00, 0x66, 0x00,
  0x0C, 0x18, 0x00, 0x33, 0x00, 0x06, 0x0C, 0x00, 0x19, 0xC0, 0x03, 0x07,
  0x00, 0x18, 0x60, 0x03, 0x81, 0x80, 0x0C, 0x30, 0x01, 0xC0, 0xC0, 0x06,
  0x18, 0x00, 0xC0, 0x60, 0x03, 0x0C, 0x00, 0x60, 0x38, 0x03, 0x83, 0x00,
  0x70, 0x0C, 0x01, 0x81, 0x80, 0x38, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x60, 0x0C, 0x01, 0xC0, 0x30, 0x38, 0x06, 0x00, 0x60, 0x30,
  0x0C, 0x07, 0x00, 0x30, 0x18, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x03, 0x01,
  0x80, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x07, 0x07, 0x00, 0x60, 0xE0, 0x01,
  0x83, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x00, 0x60, 0xC0,
  0x0C, 0x18, 0x00, 0x38, 0x60, 0x07, 0x1C, 0x00, 0x0C, 0x60, 0x01, 0x8E,
  0x00, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x63, 0x00, 0x01,
  0x8C, 0x00, 0x31, 0x80, 0x00, 0xEE, 0x00, 0x0D, 0xC0, 0x00, 0x36, 0x00,
  0x06, 0xC0, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x01, 0xB0,
  0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x38, 0x60, 0x00, 0x60, 0xE0, 0x01, 0xC0, 0xC0, 0x03,
  0x01, 0xC0, 0x0E, 0x01, 0x80, 0x18, 0x03, 0x80, 0x70, 0x03, 0x00, 0xC0,
  0x06, 0x01, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x39, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1B, 0x80, 0x00, 0x33, 0x00, 0x00, 0xC6, 0x00, 0x01, 0x86,
  0x00, 0x07, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x60, 0x38,
  0x01, 0xC0, 0x30, 0x03, 0x00, 0x70, 0x0E, 0x00, 0x60, 0x18, 0x00, 0xC0,
  0x70, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x86, 0x00, 0x03, 0x0C,
  0x00, 0x07, 0x30, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0D, 0x80,
  0x00, 0x77, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x38, 0xE0, 0x00,
  0xC1, 0x80, 0x07, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x80,
  0xE0, 0x0C, 0x01, 0x80, 0x70, 0x06, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30,
  0x38, 0x00, 0xE0, 0xC0, 0x01, 0x87, 0x00, 0x06, 0x18, 0x00, 0x0C, 0x60,
  0x00, 0x33, 0x80, 0x00, 0xEC, 0x00, 0x01, 0xB0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xFF, 0xFF, 0xFC, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x63, 0x00, 0x00, 0xC3, 0x80, 0x00, 0xC1, 0x80, 0x01,
  0x81, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x00, 0xE0, 0x03, 0x00, 0x60, 0x06,
  0x00, 0x70, 0x0E, 0x00, 0x30, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x18,
  0x00, 0x1C, 0x38, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x06, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x03, 0xFC, 0x07, 0xFF,
  0xC1, 0xC0, 0x70, 0x40, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x03, 0xF0, 0x1F, 0xFC, 0x1F, 0x03, 0x1E, 0x00, 0xCE, 0x00,
  0x37, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x3D, 0xC0, 0x0B, 0x38,
  0x0E, 0xC7, 0x8F, 0x30, 0xFF, 0x0C, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0xFF, 0x03, 0x8F, 0xFE, 0x1C,
  0xC0, 0x78, 0xEC, 0x00, 0xC7, 0xC0, 0x07, 0x34, 0x00, 0x19, 0xE0, 0x00,
  0xEF, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x78, 0x00, 0x3B,
  0xC0, 0x01, 0x9B, 0x00, 0x1C, 0xCC, 0x00, 0xC6, 0x70, 0x1E, 0x31, 0xF7,
  0xE1, 0x87, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC3,
  0xC0, 0x43, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x08, 0x7F, 0x7C, 0x0F,
  0xFC, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x3F, 0xC3, 0x07, 0xFE, 0x30, 0xE0, 0x33, 0x1C, 0x01, 0xB3, 0x80, 0x0F,
  0x30, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00, 0x76,
  0x00, 0x07, 0x70, 0x00, 0x73, 0x00, 0x0F, 0x38, 0x01, 0x91, 0xC0, 0x39,
  0x0F, 0x9F, 0x10, 0x7F, 0xC1, 0x00, 0x60, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xC0, 0x38, 0x1C, 0x0E, 0x01, 0xC3, 0x80, 0x1C, 0x60, 0x01, 0x9C, 0x00,
  0x33, 0x00, 0x03, 0x60, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x10, 0xE0, 0x0C, 0x0F, 0x9F, 0x80, 0xFF, 0xE0, 0x01, 0x80,
  0x01, 0xFE, 0x07, 0xFC, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x07, 0xFE, 0x3F, 0xFC, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x03,
  0xFC, 0x10, 0x7F, 0xF1, 0x1E, 0x03, 0x31, 0xC0, 0x1B, 0x38, 0x00, 0xF3,
  0x00, 0x07, 0x70, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x36, 0x00, 0x07, 0x60,
  0x00, 0x77, 0x00, 0x07, 0x30, 0x00, 0xF3, 0x80, 0x1B, 0x1C, 0x03, 0x30,
  0xF9, 0xE3, 0x07, 0xFC, 0x30, 0x04, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE4, 0x00, 0x1C, 0x78, 0x07, 0x83, 0xFF,
  0xF0, 0x07, 0xF8, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC3,
  0xFC, 0x38, 0xFF, 0xC7, 0x30, 0x1C, 0xEC, 0x01, 0xDB, 0x00, 0x1B, 0x40,
  0x03, 0x78, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x30, 0xFF, 0xF0, 0x00, 0x00, 0x36, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x07, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x06, 0x06, 0x8E, 0xFC,
  0xF8, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xEE, 0x00, 0x33, 0x80,
  0x18, 0xE0, 0x0E, 0x38, 0x07, 0x0E, 0x01, 0x83, 0x80, 0xE0, 0xE0, 0x70,
  0x38, 0x18, 0x0E, 0x0C, 0x03, 0x87, 0x00, 0xE1, 0x80, 0x38, 0xC0, 0x0E,
  0x78, 0x03, 0xBE, 0x00, 0xCC, 0xC0, 0x36, 0x30, 0x0F, 0x06, 0x03, 0xC1,
  0x80, 0xE0, 0x30, 0x38, 0x0C, 0x0E, 0x01, 0x83, 0x80, 0x60, 0xE0, 0x0C,
  0x38, 0x03, 0x0E, 0x00, 0x63, 0x80, 0x18, 0xE0, 0x03, 0x38, 0x00, 0xCE,
  0x00, 0x1B, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC1, 0xF8, 0x07,
  0xF0, 0xC7, 0xFE, 0x0F, 0xFC, 0xCE, 0x07, 0x18, 0x1E, 0xC8, 0x03, 0x30,
  0x0E, 0xD8, 0x03, 0xA0, 0x07, 0xD0, 0x01, 0xE0, 0x07, 0xE0, 0x01, 0xC0,
  0x03, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xE0, 0x01, 0xC0,
  0x03, 0xE0, 0x01, 0x80, 0x03, 0xE0, 0x01, 0x80, 0x03, 0xE0, 0x01, 0x80,
  0x03, 0xE0, 0x01, 0x80, 0x03, 0xE0, 0x01, 0x80, 0x03, 0xE0, 0x01, 0x80,
  0x03, 0xE0, 0x01, 0x80, 0x03, 0xE0, 0x01, 0x80, 0x03, 0xE0, 0x01, 0x80,
  0x03, 0xE0, 0x01, 0x80, 0x03, 0xE0, 0x01, 0x80, 0x03, 0xE0, 0x01, 0x80,
  0x03, 0xE0, 0x01, 0x80, 0x03, 0xE0, 0x01, 0x80, 0x03, 0xE0, 0x01, 0x80,
  0x03, 0xE0, 0x01, 0x80, 0x03, 0xE0, 0x01, 0x80, 0x03, 0xE0, 0x01, 0x80,
  0x03, 0xE0, 0x01, 0x80, 0x03, 0xE0, 0x01, 0x80, 0x03, 0xE0, 0x01, 0x80,
  0x03, 0xC1, 0xFE, 0x18, 0x7F, 0xE3, 0x18, 0x0E, 0x66, 0x00, 0xED, 0x80,
  0x0D, 0xA0, 0x01, 0xBC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x18, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0x80, 0xE0, 0x30,
  0x03, 0x83, 0x80, 0x0E, 0x18, 0x00, 0x31, 0x80, 0x01, 0xCC, 0x00, 0x06,
  0x60, 0x00, 0x37, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00,
  0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x71, 0x80, 0x03, 0x0C,
  0x00, 0x38, 0x30, 0x01, 0x81, 0xC0, 0x1C, 0x07, 0xEF, 0xC0, 0x0F, 0xF8,
  0x00, 0x04, 0x00, 0xC1, 0xFE, 0x06, 0x1F, 0xFC, 0x31, 0x80, 0xF1, 0x98,
  0x01, 0x8D, 0x80, 0x0E, 0x6C, 0x00, 0x33, 0x40, 0x01, 0xDE, 0x00, 0x06,
  0xE0, 0x00, 0x37, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1B, 0x80, 0x00, 0xDC, 0x00, 0x06, 0xF0, 0x00, 0x76, 0x80, 0x03, 0x36,
  0x00, 0x39, 0xD8, 0x01, 0x8E, 0xE0, 0x3C, 0x73, 0xEF, 0xC3, 0x87, 0xF8,
  0x1C, 0x0C, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x10, 0x7F, 0xE1, 0x0E, 0x03, 0x31, 0xC0, 0x1B,
  0x38, 0x00, 0xF3, 0x00, 0x07, 0x70, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x36,
  0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x0F, 0x30, 0x00, 0xF3, 0x80, 0x1B,
  0x1C, 0x03, 0x30, 0xF9, 0xE3, 0x07, 0xFC, 0x30, 0x04, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0xC1, 0xFE, 0x1F, 0xF1, 0xC3,
  0x98, 0x0D, 0x80, 0x6C, 0x03, 0x40, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0xFC,
  0x0F, 0xFF, 0x8F, 0x00, 0xCE, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xD0, 0x00, 0xEC, 0x00, 0xE7,
  0xF7, 0xE0, 0xFF, 0xE0, 0x07, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xF8, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x1C, 0x00, 0x7B, 0x03, 0xF8, 0x03, 0x00, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xEC, 0x00, 0x2D,
  0x80, 0x0D, 0xB8, 0x01, 0x33, 0x80, 0xE6, 0x3E, 0xF8, 0xC3, 0xFE, 0x18,
  0x0E, 0x00, 0xC0, 0x00, 0x36, 0x00, 0x07, 0x60, 0x00, 0x66, 0x00, 0x06,
  0x70, 0x00, 0x63, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x38, 0x00,
  0xC1, 0x80, 0x18, 0x18, 0x01, 0x81, 0xC0, 0x18, 0x0C, 0x03, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xE0, 0x30, 0x06, 0x06, 0x00, 0x60, 0x60, 0x07,
  0x06, 0x00, 0x30, 0xE0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x8C, 0x00,
  0x19, 0x80, 0x01, 0x98, 0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x06,
  0x60, 0x03, 0xC0, 0x06, 0x60, 0x03, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x70, 0x06, 0x60, 0x0E, 0x30, 0x06, 0x60, 0x0C, 0x30, 0x06, 0x70, 0x0C,
  0x30, 0x0E, 0x30, 0x0C, 0x38, 0x0C, 0x30, 0x1C, 0x18, 0x0C, 0x30, 0x18,
  0x18, 0x0C, 0x38, 0x18, 0x18, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x0C, 0x18, 0x18, 0x30, 0x0C, 0x18, 0x1C, 0x30, 0x0C, 0x38, 0x0C, 0x30,
  0x0C, 0x30, 0x0C, 0x30, 0x06, 0x30, 0x0C, 0x60, 0x06, 0x30, 0x0C, 0x60,
  0x06, 0x70, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x07, 0x60, 0x06, 0xE0,
  0x03, 0x60, 0x06, 0xC0, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x01, 0x80,
  0x60, 0x00, 0x67, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x80, 0x1C, 0x18, 0x01,
  0x81, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x60, 0x06, 0x06, 0x00, 0x30,
  0xC0, 0x03, 0x1C, 0x00, 0x19, 0x80, 0x01, 0xB8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0x98, 0x00,
  0x39, 0x80, 0x03, 0x0C, 0x00, 0x70, 0xE0, 0x06, 0x06, 0x00, 0xC0, 0x70,
  0x0C, 0x03, 0x01, 0x80, 0x38, 0x38, 0x01, 0x83, 0x00, 0x1C, 0x70, 0x00,
  0xC6, 0x00, 0x0E, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x3B, 0x00, 0x01, 0x9C,
  0x00, 0x0C, 0x60, 0x00, 0x63, 0x00, 0x06, 0x18, 0x00, 0x30, 0x60, 0x01,
  0x83, 0x00, 0x1C, 0x18, 0x00, 0xC0, 0xE0, 0x06, 0x03, 0x00, 0x70, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x0E, 0x00, 0xC0, 0x60,
  0x03, 0x03, 0x00, 0x18, 0x38, 0x00, 0xC1, 0x80, 0x07, 0x0C, 0x00, 0x18,
  0x60, 0x00, 0xC7, 0x00, 0x06, 0x30, 0x00, 0x19, 0x80, 0x00, 0xDC, 0x00,
  0x06, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x21, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x01, 0xF8, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xFC,
  0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x07, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x1F, 0xC0, 0x05,
  0xFF, 0xC0, 0x1E, 0x07, 0x81, 0xF0, 0x07, 0xFE, 0x80, 0x07, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraLight58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 41, 12, 4, -41 },
  { 22, 11, 15, 19, 4, -41 },
  { 43, 26, 41, 29, 1, -41 },
  { 177, 21, 47, 26, 2, -44 },
  { 301, 32, 43, 38, 3, -42 },
  { 473, 26, 43, 29, 2, -42 },
  { 613, 2, 15, 10, 4, -41 },
  { 617, 10, 50, 15, 3, -41 },
  { 680, 11, 50, 15, 2, -41 },
  { 749, 18, 18, 24, 3, -44 },
  { 790, 22, 27, 26, 2, -34 },
  { 865, 6, 13, 11, 2, -6 },
  { 875, 13, 2, 16, 2, -17 },
  { 879, 4, 4, 12, 4, -4 },
  { 881, 18, 41, 19, 1, -41 },
  { 974, 20, 42, 26, 3, -42 },
  { 1079, 11, 41, 26, 5, -41 },
  { 1136, 20, 42, 26, 3, -42 },
  { 1241, 21, 43, 26, 2, -42 },
  { 1354, 25, 42, 26, 1, -42 },
  { 1486, 20, 42, 26, 3, -41 },
  { 1591, 20, 43, 26, 3, -42 },
  { 1699, 20, 41, 26, 3, -41 },
  { 1802, 22, 43, 26, 2, -42 },
  { 1921, 20, 43, 26, 3, -42 },
  { 2029, 4, 31, 12, 4, -31 },
  { 2045, 6, 38, 12, 2, -31 },
  { 2074, 22, 25, 26, 2, -33 },
  { 2143, 22, 15, 26, 2, -28 },
  { 2185, 22, 25, 26, 2, -33 },
  { 2254, 16, 42, 18, 1, -42 },
  { 2338, 34, 46, 40, 3, -41 },
  { 2534, 26, 41, 26, 0, -41 },
  { 2668, 21, 41, 29, 5, -41 },
  { 2776, 23, 43, 28, 3, -42 },
  { 2900, 23, 41, 32, 5, -41 },
  { 3018, 17, 41, 25, 5, -41 },
  { 3106, 17, 41, 23, 5, -41 },
  { 3194, 27, 43, 34, 3, -42 },
  { 3340, 23, 41, 33, 5, -41 },
  { 3458, 10, 41, 15, 2, -41 },
  { 3510, 10, 51, 12, -3, -41 },
  { 3574, 21, 41, 26, 5, -41 },
  { 3682, 17, 41, 23, 5, -41 },
  { 3770, 32, 41, 42, 5, -41 },
  { 3934, 23, 41, 33, 5, -41 },
  { 4052, 28, 43, 34, 3, -42 },
  { 4203, 19, 41, 27, 5, -41 },
  { 4301, 28, 52, 34, 3, -42 },
  { 4483, 21, 41, 27, 5, -41 },
  { 4591, 20, 43, 25, 3, -42 },
  { 4699, 23, 41, 23, 0, -41 },
  { 4817, 23, 42, 32, 5, -41 },
  { 4938, 25, 41, 25, 0, -41 },
  { 5067, 41, 41, 42, 1, -41 },
  { 5278, 23, 41, 23, 0, -41 },
  { 5396, 22, 41, 22, 0, -41 },
  { 5509, 20, 41, 23, 2, -41 },
  { 5612, 11, 50, 18, 5, -41 },
  { 5681, 18, 41, 19, 1, -41 },
  { 5774, 11, 50, 18, 2, -41 },
  { 5843, 24, 21, 26, 1, -41 },
  { 5906, 23, 2, 23, 0, 5 },
  { 5912, 10, 9, 14, 2, -44 },
  { 5924, 18, 32, 24, 2, -31 },
  { 5996, 21, 45, 28, 4, -44 },
  { 6115, 17, 32, 21, 3, -31 },
  { 6183, 20, 45, 28, 3, -44 },
  { 6296, 19, 32, 25, 3, -31 },
  { 6372, 15, 44, 14, 1, -44 },
  { 6455, 20, 45, 28, 3, -31 },
  { 6568, 19, 44, 27, 4, -44 },
  { 6673, 3, 42, 11, 4, -42 },
  { 6689, 8, 56, 11, -1, -42 },
  { 6745, 18, 44, 22, 4, -44 },
  { 6844, 3, 44, 11, 4, -44 },
  { 6861, 32, 31, 40, 4, -31 },
  { 6985, 19, 31, 27, 4, -31 },
  { 7059, 21, 32, 27, 3, -31 },
  { 7143, 21, 45, 28, 4, -31 },
  { 7262, 20, 45, 28, 3, -31 },
  { 7375, 13, 31, 18, 4, -31 },
  { 7426, 17, 32, 21, 2, -31 },
  { 7494, 13, 39, 15, 1, -38 },
  { 7558, 19, 32, 27, 4, -31 },
  { 7634, 20, 31, 20, 0, -31 },
  { 7712, 32, 31, 34, 1, -31 },
  { 7836, 20, 31, 22, 1, -31 },
  { 7914, 21, 45, 21, 0, -31 },
  { 8033, 15, 31, 19, 2, -31 },
  { 8092, 16, 50, 20, 2, -41 },
  { 8192, 2, 58, 25, 11, -44 },
  { 8207, 15, 50, 20, 3, -41 },
  { 8301, 22, 5, 26, 2, -23 },
};

const GFXfont NotoSans_Condensed_ExtraLight58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight58pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT58PT7B_H_
