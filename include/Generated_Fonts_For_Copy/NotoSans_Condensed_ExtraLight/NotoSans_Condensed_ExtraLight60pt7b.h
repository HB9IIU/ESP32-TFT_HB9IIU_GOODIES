#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT60PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight60pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x70, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x00, 0x30, 0x06,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x30,
  0x0C, 0x00, 0x06, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8,
  0x06, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x60, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x06,
  0x00, 0x06, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x06,
  0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x60,
  0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x06, 0x00,
  0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xE0,
  0x07, 0xFF, 0xE0, 0x79, 0x8F, 0x87, 0x0C, 0x0C, 0x70, 0x60, 0x07, 0x03,
  0x00, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30, 0x03,
  0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x38, 0x18,
  0x00, 0xE0, 0xC0, 0x03, 0x86, 0x00, 0x0F, 0x30, 0x00, 0x3F, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1B, 0xE0, 0x00, 0xC7,
  0x80, 0x06, 0x0E, 0x00, 0x30, 0x38, 0x01, 0x80, 0xC0, 0x0C, 0x07, 0x00,
  0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x1C, 0x01, 0x80, 0xC0, 0x0C, 0x0E, 0x80, 0x60, 0xE7, 0x03,
  0x1E, 0x3F, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0xC0,
  0x1E, 0xF0, 0x00, 0x60, 0x0C, 0x18, 0x00, 0x60, 0x0E, 0x06, 0x00, 0x30,
  0x06, 0x03, 0x00, 0x30, 0x03, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x06,
  0x00, 0x30, 0x06, 0x03, 0x00, 0x18, 0x03, 0x01, 0x80, 0x0C, 0x01, 0x81,
  0x80, 0x06, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0x60, 0xC0, 0x01, 0x80, 0x30,
  0x60, 0x00, 0xC0, 0x18, 0x30, 0x00, 0x60, 0x0C, 0x30, 0x7E, 0x30, 0x06,
  0x18, 0x77, 0x98, 0x03, 0x18, 0x60, 0xC6, 0x03, 0x8C, 0x70, 0x33, 0x01,
  0x86, 0x30, 0x19, 0xC0, 0xC6, 0x18, 0x0E, 0x60, 0xC3, 0x18, 0x03, 0x3F,
  0xE3, 0x0C, 0x01, 0x87, 0xE1, 0x86, 0x00, 0xC0, 0x00, 0xC3, 0x00, 0x60,
  0x00, 0xC1, 0x80, 0x30, 0x00, 0x60, 0xC0, 0x18, 0x00, 0x70, 0x60, 0x0C,
  0x00, 0x30, 0x30, 0x06, 0x00, 0x18, 0x18, 0x03, 0x00, 0x18, 0x0C, 0x01,
  0x80, 0x0C, 0x06, 0x00, 0xC0, 0x0E, 0x03, 0x00, 0x60, 0x06, 0x01, 0x80,
  0x30, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x1C, 0x01, 0x80, 0x18,
  0x0C, 0x01, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x03, 0x06, 0x00, 0x60, 0x00,
  0xE7, 0x00, 0x60, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x60, 0x1C, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00, 0x60, 0x06,
  0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x30, 0x03, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x18, 0x38, 0x00, 0x03, 0x86, 0x00, 0x00, 0x33, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x60, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x0C, 0x00, 0xC7, 0x01,
  0xC0, 0x18, 0xC0, 0x1C, 0x07, 0x38, 0x01, 0x80, 0xC6, 0x00, 0x18, 0x18,
  0xC0, 0x03, 0x83, 0x38, 0x00, 0x30, 0xE7, 0x00, 0x03, 0x18, 0xE0, 0x00,
  0x77, 0x1C, 0x00, 0x07, 0xC3, 0x80, 0x00, 0x78, 0x30, 0x00, 0x0E, 0x06,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x7C, 0x0C, 0x00, 0x1C, 0xC1, 0xC0, 0x07,
  0x1C, 0x1C, 0x01, 0xC1, 0x81, 0xFF, 0xF0, 0x18, 0x1F, 0xF8, 0x03, 0x80,
  0x70, 0x00, 0x00, 0xFF, 0xFD, 0xB6, 0xDB, 0x6D, 0xB6, 0x00, 0xE0, 0x38,
  0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xE0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0x70, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x0C,
  0x03, 0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x20,
  0x10, 0x0F, 0x02, 0x0E, 0xFC, 0x47, 0xE1, 0xFF, 0xC0, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x1B, 0x00, 0x06, 0x30, 0x01, 0x86, 0x00, 0x70, 0x60, 0x0C,
  0x06, 0x03, 0x00, 0xE0, 0xE0, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x71, 0xC6, 0x18, 0xE3, 0x8C, 0x31, 0xC6,
  0x18, 0x63, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0xF8, 0x03, 0xC0, 0xE0, 0x18, 0x03, 0x81, 0xC0, 0x0C, 0x1C,
  0x00, 0x70, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x70, 0x00, 0x73, 0x00, 0x01,
  0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1D, 0x80, 0x00, 0xEC, 0x00, 0x06, 0x60, 0x00,
  0x33, 0x00, 0x01, 0x9C, 0x00, 0x1C, 0x60, 0x00, 0xC3, 0x00, 0x06, 0x1C,
  0x00, 0x70, 0x70, 0x03, 0x01, 0x80, 0x38, 0x0F, 0x03, 0x80, 0x3F, 0xF8,
  0x00, 0x7F, 0x80, 0x00, 0x60, 0x1C, 0x07, 0x81, 0xF0, 0xF6, 0x38, 0xCE,
  0x1B, 0x83, 0xE0, 0x68, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x1E, 0x01, 0xE0, 0xC0,
  0x03, 0x84, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x01, 0xFF,
  0xF8, 0x1E, 0x01, 0xE1, 0xC0, 0x03, 0x88, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x7C,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x90, 0x00, 0x38, 0xE0, 0x03, 0x87, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x1D, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x38, 0x00,
  0x06, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x03, 0x83, 0x80,
  0x01, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0xE0, 0x38,
  0x00, 0x60, 0x1C, 0x00, 0x60, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x18, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0C, 0x00,
  0x38, 0x0E, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x03, 0x00,
  0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x07, 0x80, 0x1F, 0xFF, 0xC0, 0xFF, 0x7F, 0x02,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x90, 0x00, 0x38, 0xE0, 0x07, 0x87, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xF8, 0x08, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x0F, 0xF8, 0x38, 0xFF, 0xE1, 0xCC, 0x03, 0x8E, 0xC0, 0x0E, 0x6C, 0x00,
  0x3B, 0x40, 0x00, 0xDE, 0x00, 0x06, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x0E, 0xE0,
  0x00, 0x73, 0x00, 0x03, 0x1C, 0x00, 0x38, 0x60, 0x01, 0x83, 0x80, 0x1C,
  0x0E, 0x01, 0xC0, 0x3E, 0x7C, 0x00, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0x80, 0xF0,
  0x70, 0x01, 0xC3, 0x00, 0x06, 0x38, 0x00, 0x39, 0x80, 0x00, 0xCC, 0x00,
  0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x67,
  0x00, 0x03, 0x18, 0x00, 0x38, 0xE0, 0x01, 0x83, 0x00, 0x18, 0x0E, 0x01,
  0xC0, 0x38, 0x3C, 0x00, 0xE3, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xFE, 0x00, 0x1C, 0x3C, 0x01, 0xC0, 0x70, 0x1C, 0x01, 0xC1, 0xC0, 0x07,
  0x1C, 0x00, 0x1C, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x19, 0xC0, 0x01, 0xC7, 0x00,
  0x1C, 0x3C, 0x01, 0xC0, 0x7E, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x40, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0x01, 0xE0, 0x70, 0x03, 0x03, 0x00,
  0x0C, 0x38, 0x00, 0x71, 0x80, 0x01, 0x9C, 0x00, 0x0C, 0xC0, 0x00, 0x76,
  0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xF6, 0x00, 0x07, 0xB8, 0x00, 0x7C, 0xC0, 0x06,
  0xE7, 0x80, 0x77, 0x1F, 0xBF, 0x38, 0x3F, 0xE1, 0x80, 0x38, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x01,
  0xEF, 0xE0, 0x0F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x1C, 0xF3, 0xCF, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x1C, 0x61, 0x8E,
  0x38, 0xC3, 0x1C, 0x61, 0x86, 0x30, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xF8,
  0x60, 0x1C, 0x40, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x03, 0x00, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x30, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x3C, 0x00, 0xC3, 0x00, 0x1F, 0xF8,
  0x0E, 0x30, 0x03, 0x83, 0x80, 0x67, 0x00, 0x70, 0x18, 0x06, 0x60, 0x0E,
  0x01, 0x80, 0x66, 0x01, 0xC0, 0x18, 0x06, 0x60, 0x18, 0x01, 0x80, 0x66,
  0x01, 0x80, 0x38, 0x06, 0xE0, 0x38, 0x03, 0x80, 0x7C, 0x03, 0x00, 0x38,
  0x07, 0xC0, 0x30, 0x03, 0x80, 0x7C, 0x03, 0x00, 0x30, 0x07, 0xC0, 0x30,
  0x03, 0x00, 0x7C, 0x03, 0x00, 0x30, 0x06, 0xC0, 0x30, 0x03, 0x00, 0x6C,
  0x03, 0x00, 0x30, 0x06, 0xC0, 0x30, 0x03, 0x00, 0x6C, 0x03, 0x00, 0x70,
  0x06, 0xE0, 0x38, 0x07, 0x00, 0xE6, 0x01, 0x80, 0x58, 0x0C, 0x60, 0x18,
  0x0D, 0x81, 0xC6, 0x00, 0xC1, 0x8C, 0x38, 0x60, 0x0F, 0xF8, 0xFF, 0x07,
  0x00, 0x3F, 0x07, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x40, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x38,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x38, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x38,
  0x03, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0,
  0x07, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x38, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x0E, 0x1C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x60, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x73, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0C, 0x00,
  0xFC, 0x30, 0x00, 0x78, 0xC0, 0x00, 0x73, 0x00, 0x01, 0xCC, 0x00, 0x03,
  0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0,
  0x00, 0x06, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0xEC, 0x00, 0x03, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x73, 0x00, 0x03, 0x8C, 0x00, 0x1C, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0C, 0x00, 0x1E, 0x30, 0x00, 0x1C, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xB0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x06, 0xC0, 0x00, 0x3B, 0x00,
  0x00, 0xEC, 0x00, 0x07, 0x30, 0x00, 0x38, 0xC0, 0x07, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x01, 0xF0,
  0x07, 0x03, 0xC0, 0x01, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x03, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xC0, 0x1F,
  0x80, 0xC0, 0x03, 0xE0, 0xC0, 0x00, 0xF0, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0x38, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x0E, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0E, 0xC0, 0x00,
  0x1C, 0xC0, 0x00, 0x1C, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0xF0, 0xC0, 0x01, 0xE0, 0xC0, 0x0F, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0xF8,
  0x01, 0xF0, 0x1E, 0x00, 0x02, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x37, 0x00, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x33, 0x80,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x0E, 0x00, 0x00,
  0x30, 0x70, 0x00, 0x03, 0x07, 0x80, 0x00, 0x30, 0x3C, 0x00, 0x03, 0x01,
  0xF0, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x7F, 0xFF, 0xE0, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0E, 0x01, 0xCF, 0xFC, 0xFF, 0x83, 0xC0, 0xC0, 0x00, 0x3B, 0x00,
  0x00, 0xCC, 0x00, 0x07, 0x30, 0x00, 0x38, 0xC0, 0x01, 0xC3, 0x00, 0x07,
  0x0C, 0x00, 0x38, 0x30, 0x01, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x38, 0x0C,
  0x01, 0xC0, 0x30, 0x0E, 0x00, 0xC0, 0x38, 0x03, 0x01, 0xC0, 0x0C, 0x0E,
  0x00, 0x30, 0x30, 0x00, 0xC1, 0xC0, 0x03, 0x0E, 0x00, 0x0C, 0x30, 0x00,
  0x31, 0xE0, 0x00, 0xCF, 0x80, 0x03, 0x77, 0x00, 0x0D, 0x8C, 0x00, 0x3C,
  0x38, 0x00, 0xF0, 0x60, 0x03, 0x81, 0xC0, 0x0C, 0x03, 0x80, 0x30, 0x0E,
  0x00, 0xC0, 0x1C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xE0, 0x30, 0x01, 0x80,
  0xC0, 0x07, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x30, 0x00, 0x70, 0xC0,
  0x00, 0xC3, 0x00, 0x03, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x1C, 0xC0, 0x00,
  0x33, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFD, 0x80, 0x00, 0x00, 0xFE, 0xC0, 0x00, 0x00, 0x6F, 0x70, 0x00, 0x00,
  0x37, 0x98, 0x00, 0x00, 0x3B, 0xCC, 0x00, 0x00, 0x19, 0xE7, 0x00, 0x00,
  0x0C, 0xF1, 0x80, 0x00, 0x0E, 0x78, 0xC0, 0x00, 0x06, 0x3C, 0x70, 0x00,
  0x03, 0x1E, 0x18, 0x00, 0x03, 0x8F, 0x0C, 0x00, 0x01, 0x87, 0x87, 0x00,
  0x00, 0xC3, 0xC1, 0x80, 0x00, 0xE1, 0xE0, 0xC0, 0x00, 0x60, 0xF0, 0x70,
  0x00, 0x30, 0x78, 0x18, 0x00, 0x38, 0x3C, 0x0C, 0x00, 0x18, 0x1E, 0x07,
  0x00, 0x0C, 0x0F, 0x01, 0x80, 0x0E, 0x07, 0x80, 0xC0, 0x06, 0x03, 0xC0,
  0x70, 0x03, 0x01, 0xE0, 0x18, 0x03, 0x80, 0xF0, 0x0C, 0x01, 0x80, 0x78,
  0x07, 0x00, 0xC0, 0x3C, 0x01, 0x80, 0xE0, 0x1E, 0x00, 0xC0, 0x60, 0x0F,
  0x00, 0x70, 0x30, 0x07, 0x80, 0x18, 0x38, 0x03, 0xC0, 0x0C, 0x18, 0x01,
  0xE0, 0x07, 0x0C, 0x00, 0xF0, 0x01, 0x8E, 0x00, 0x78, 0x00, 0xC6, 0x00,
  0x3C, 0x00, 0x73, 0x00, 0x1E, 0x00, 0x1B, 0x80, 0x0F, 0x00, 0x0D, 0x80,
  0x07, 0x80, 0x06, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x60, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xD8, 0x00, 0x03,
  0xDC, 0x00, 0x03, 0xCC, 0x00, 0x03, 0xCE, 0x00, 0x03, 0xC6, 0x00, 0x03,
  0xC7, 0x00, 0x03, 0xC3, 0x00, 0x03, 0xC1, 0x80, 0x03, 0xC1, 0x80, 0x03,
  0xC1, 0xC0, 0x03, 0xC0, 0xC0, 0x03, 0xC0, 0x60, 0x03, 0xC0, 0x60, 0x03,
  0xC0, 0x30, 0x03, 0xC0, 0x30, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x18, 0x03,
  0xC0, 0x0C, 0x03, 0xC0, 0x0E, 0x03, 0xC0, 0x06, 0x03, 0xC0, 0x07, 0x03,
  0xC0, 0x03, 0x03, 0xC0, 0x03, 0x83, 0xC0, 0x01, 0x83, 0xC0, 0x01, 0xC3,
  0xC0, 0x00, 0xC3, 0xC0, 0x00, 0xE3, 0xC0, 0x00, 0x63, 0xC0, 0x00, 0x73,
  0xC0, 0x00, 0x33, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0x1B, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xF8,
  0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x07, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x03, 0x03, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x61,
  0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x07, 0x60, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x03,
  0xB0, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x06, 0x30,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x18, 0x30, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0xC0, 0x3F, 0x0C, 0x00, 0x3C, 0xC0, 0x01, 0xCC, 0x00, 0x0E, 0xC0, 0x00,
  0x6C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x01, 0xCC,
  0x00, 0x38, 0xC0, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xF0, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x38, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x03, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0xEC, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0xCE,
  0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x71, 0x80, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x0C, 0x03, 0xF0, 0x30, 0x00, 0xF0, 0xC0, 0x01, 0xC3, 0x00, 0x03,
  0x8C, 0x00, 0x06, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x73, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00,
  0x07, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x0E,
  0x30, 0x00, 0x70, 0xC0, 0x03, 0x83, 0x00, 0x7C, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x30, 0x03,
  0x00, 0xC0, 0x0E, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x70, 0x30, 0x01, 0xC0,
  0xC0, 0x03, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x70, 0xC0,
  0x00, 0xE3, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x30, 0x00, 0x1C, 0xC0, 0x00,
  0x3B, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xFF,
  0x87, 0x80, 0x1C, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0xC0, 0x07, 0xC7, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x70, 0x00,
  0x0C, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0xF0, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x06, 0x70, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x03,
  0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x60, 0x60, 0x00, 0x18, 0x1C, 0x00,
  0x06, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x30, 0x0E,
  0x00, 0x1C, 0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80, 0x1C, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x0E, 0x00,
  0xC0, 0x01, 0x80, 0x70, 0x00, 0x60, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x03,
  0x03, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x0E, 0x0C, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x61, 0x80, 0x00, 0x18, 0x60, 0x00, 0x07, 0x38,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x78, 0x00, 0x06,
  0x60, 0x00, 0x1E, 0x00, 0x01, 0x98, 0x00, 0x0D, 0x80, 0x00, 0xE7, 0x00,
  0x03, 0x60, 0x00, 0x31, 0xC0, 0x00, 0xDC, 0x00, 0x0C, 0x30, 0x00, 0x37,
  0x00, 0x03, 0x0C, 0x00, 0x0C, 0xC0, 0x01, 0xC3, 0x00, 0x07, 0x30, 0x00,
  0x70, 0xE0, 0x01, 0x8C, 0x00, 0x18, 0x18, 0x00, 0x63, 0x80, 0x06, 0x06,
  0x00, 0x18, 0x60, 0x03, 0x81, 0x80, 0x0E, 0x18, 0x00, 0xE0, 0x70, 0x03,
  0x06, 0x00, 0x30, 0x1C, 0x00, 0xC1, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x30,
  0x03, 0x00, 0xC0, 0x0C, 0x0C, 0x01, 0xC0, 0x30, 0x07, 0x03, 0x00, 0x60,
  0x0E, 0x01, 0x80, 0xC0, 0x18, 0x01, 0x80, 0x60, 0x38, 0x06, 0x00, 0x60,
  0x18, 0x06, 0x03, 0x80, 0x18, 0x0E, 0x01, 0x80, 0xE0, 0x07, 0x03, 0x00,
  0x60, 0x30, 0x00, 0xC0, 0xC0, 0x1C, 0x0C, 0x00, 0x30, 0x30, 0x03, 0x07,
  0x00, 0x0C, 0x0C, 0x00, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x30, 0x60, 0x00,
  0xE1, 0x80, 0x0C, 0x18, 0x00, 0x18, 0x60, 0x03, 0x8E, 0x00, 0x06, 0x18,
  0x00, 0x63, 0x80, 0x01, 0x8E, 0x00, 0x18, 0xC0, 0x00, 0x73, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0xC0, 0x01, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x37, 0x00,
  0x00, 0xCC, 0x00, 0x0D, 0x80, 0x00, 0x3F, 0x00, 0x03, 0x60, 0x00, 0x07,
  0x80, 0x00, 0xD8, 0x00, 0x01, 0xE0, 0x00, 0x36, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x06, 0x38, 0x00, 0x0E, 0x18, 0x00, 0x0C, 0x1C, 0x00,
  0x1C, 0x0C, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x06, 0x00, 0x30, 0x06, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x03, 0x00, 0xE0, 0x03, 0x80, 0xC0, 0x01, 0x80,
  0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xC1, 0x80, 0x00, 0xE3, 0x80, 0x00, 0x63,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x67, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xC3,
  0x80, 0x01, 0xC1, 0x80, 0x01, 0x81, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x00,
  0xC0, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x70, 0x0C, 0x00,
  0x30, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x30, 0x00,
  0x0C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x06, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x33, 0x80, 0x00, 0xE3, 0x00, 0x01,
  0xC7, 0x00, 0x03, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x1C, 0x00, 0x30,
  0x18, 0x00, 0xE0, 0x38, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x00,
  0xE0, 0x18, 0x00, 0xC0, 0x70, 0x01, 0x80, 0xC0, 0x01, 0x83, 0x80, 0x03,
  0x06, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x60, 0x00, 0x0D,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x30, 0x00,
  0x03, 0x98, 0x00, 0x01, 0x86, 0x00, 0x01, 0xC3, 0x00, 0x00, 0xC0, 0xC0,
  0x00, 0xE0, 0x60, 0x00, 0x60, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x30, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x18, 0x00, 0xE0, 0x1C, 0x00, 0x30, 0x0C, 0x00,
  0x1C, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x03, 0x87, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x1B, 0x80, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x03, 0xFE, 0x03, 0xFF, 0xE0, 0x70, 0x0E, 0x08, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x1F, 0xF8, 0x1F, 0xFB, 0x0F, 0x00, 0x63, 0x80, 0x0C, 0xE0, 0x01,
  0xB8, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1D, 0x80, 0x07, 0xB0, 0x00, 0xB7, 0x00, 0x36,
  0x70, 0x0C, 0xC7, 0xC7, 0x18, 0x7F, 0xC3, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x0F, 0xF0, 0x38, 0xFF, 0xE0, 0xE7, 0x01, 0xC3, 0xB0, 0x03, 0x8E,
  0x80, 0x07, 0x3E, 0x00, 0x0C, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00,
  0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x6F, 0x00, 0x03, 0xBC, 0x00, 0x0C,
  0xF0, 0x00, 0x33, 0xE0, 0x01, 0xCE, 0xC0, 0x0E, 0x39, 0x80, 0x70, 0xC3,
  0xFF, 0x83, 0x07, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0xF0, 0x70, 0x08, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x10, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x0F, 0xF0, 0x60, 0xFF, 0xE3, 0x0E, 0x03, 0x98, 0xE0, 0x06, 0xCE, 0x00,
  0x36, 0x60, 0x00, 0xF7, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0x80, 0x00, 0xEC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xB0, 0x00, 0x1D, 0x80, 0x00, 0xEE, 0x00, 0x07, 0x30, 0x00, 0x79, 0xC0,
  0x02, 0xC6, 0x00, 0x36, 0x3C, 0x03, 0x30, 0xFD, 0xF1, 0x81, 0xFF, 0x0C,
  0x01, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0E, 0x03, 0x81, 0xC0,
  0x1C, 0x38, 0x00, 0xC3, 0x00, 0x0E, 0x30, 0x00, 0x66, 0x00, 0x06, 0x60,
  0x00, 0x76, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x20, 0xE0, 0x06, 0x07, 0xE7, 0xE0, 0x3F, 0xF8, 0x00,
  0x38, 0x00, 0x00, 0x7D, 0x01, 0xFE, 0x03, 0xC2, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x3F, 0xF0, 0xFF, 0xF0, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0xFE,
  0x18, 0x3F, 0xF8, 0xC3, 0x80, 0xE6, 0x38, 0x01, 0xB3, 0x80, 0x05, 0x98,
  0x00, 0x3D, 0xC0, 0x00, 0xEC, 0x00, 0x07, 0x60, 0x00, 0x3B, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xEC, 0x00,
  0x07, 0x60, 0x00, 0x3B, 0x80, 0x01, 0xCC, 0x00, 0x1E, 0x70, 0x00, 0xB1,
  0x80, 0x0D, 0x8F, 0x01, 0xCC, 0x3F, 0x7C, 0x60, 0x7F, 0xC3, 0x00, 0x60,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x10, 0x00, 0x38, 0xE0, 0x07, 0x87, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0xFF, 0x06, 0x3F,
  0xF8, 0xCE, 0x07, 0x9B, 0x00, 0x73, 0x40, 0x07, 0x78, 0x00, 0x6E, 0x00,
  0x0D, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xC0, 0x4F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x02,
  0x03, 0x81, 0xE0, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38,
  0x18, 0x1C, 0xFE, 0x7E, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x3B, 0x00, 0x1C, 0xC0, 0x0E, 0x30, 0x03, 0x0C, 0x01, 0xC3,
  0x00, 0xE0, 0xC0, 0x30, 0x30, 0x18, 0x0C, 0x0E, 0x03, 0x03, 0x00, 0xC1,
  0x80, 0x30, 0xE0, 0x0C, 0x70, 0x03, 0x1C, 0x00, 0xCF, 0x80, 0x37, 0x60,
  0x0D, 0x9C, 0x03, 0xC3, 0x00, 0xE0, 0xE0, 0x38, 0x18, 0x0C, 0x07, 0x03,
  0x00, 0xC0, 0xC0, 0x38, 0x30, 0x06, 0x0C, 0x01, 0xC3, 0x00, 0x30, 0xC0,
  0x0E, 0x30, 0x01, 0x8C, 0x00, 0x73, 0x00, 0x0C, 0xC0, 0x03, 0xB0, 0x00,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x83, 0xF8, 0x07, 0xF0, 0x47, 0xFE, 0x07, 0xFE, 0x23, 0x03, 0x86,
  0x07, 0x93, 0x00, 0xE6, 0x01, 0xCB, 0x00, 0x36, 0x00, 0x77, 0x00, 0x1B,
  0x00, 0x1B, 0x80, 0x07, 0x00, 0x0D, 0x80, 0x03, 0x80, 0x06, 0xC0, 0x01,
  0x80, 0x03, 0x60, 0x00, 0xC0, 0x01, 0xB0, 0x00, 0x60, 0x00, 0xF8, 0x00,
  0x30, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x1F, 0x00,
  0x06, 0x00, 0x0F, 0x80, 0x03, 0x00, 0x07, 0xC0, 0x01, 0x80, 0x03, 0xE0,
  0x00, 0xC0, 0x01, 0xF0, 0x00, 0x60, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x7C,
  0x00, 0x18, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x06, 0x00, 0x0F,
  0x80, 0x03, 0x00, 0x07, 0xC0, 0x01, 0x80, 0x03, 0xE0, 0x00, 0xC0, 0x01,
  0xF0, 0x00, 0x60, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x18, 0x00,
  0x3E, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x06, 0x00, 0x0F, 0x80, 0x03, 0x00,
  0x07, 0x83, 0xFC, 0x10, 0xFF, 0xE2, 0x38, 0x1E, 0x4C, 0x00, 0xC9, 0x00,
  0x1D, 0xE0, 0x01, 0xB8, 0x00, 0x37, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0x38, 0x38, 0x00, 0x60, 0xC0, 0x01, 0xC7, 0x00, 0x03,
  0x18, 0x00, 0x0E, 0x60, 0x00, 0x19, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x6E, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60,
  0x00, 0x39, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x38, 0x00,
  0x81, 0xFE, 0x04, 0x3F, 0xF8, 0x23, 0x80, 0xE1, 0x38, 0x03, 0x89, 0x80,
  0x0E, 0x58, 0x00, 0x33, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1B, 0x00, 0x00,
  0xD8, 0x00, 0x06, 0xE0, 0x00, 0x77, 0x00, 0x03, 0x3C, 0x00, 0x19, 0xE0,
  0x01, 0xCD, 0x80, 0x1C, 0x66, 0x01, 0xC3, 0x1F, 0x7C, 0x18, 0x7F, 0xC0,
  0xC0, 0x20, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xFE, 0x18, 0x3F, 0xF8, 0xC3, 0xC0, 0xE6, 0x38, 0x01, 0xB3,
  0x80, 0x0D, 0x98, 0x00, 0x3D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x60, 0x00,
  0x3B, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xEC, 0x00, 0x07, 0x60, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x1E,
  0x70, 0x01, 0xB1, 0xC0, 0x0D, 0x8F, 0x01, 0xCC, 0x3F, 0x7C, 0x60, 0x7F,
  0xC3, 0x00, 0x60, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x83, 0xFC, 0x3F, 0xA3, 0x83, 0xB8, 0x0D, 0x80, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x07, 0xFE, 0x0F, 0xFF, 0xCF, 0x00,
  0xE6, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x78, 0x00, 0x37, 0x00, 0x3B, 0xFF, 0xF8,
  0x7F, 0xF0, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x07, 0xFF, 0xFF, 0xF8, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0xDC, 0x0F, 0xE0, 0x18, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xEC, 0x00, 0x1D,
  0x80, 0x02, 0xB8, 0x00, 0xD3, 0x00, 0x32, 0x70, 0x0C, 0x47, 0xFF, 0x08,
  0x7F, 0xC1, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x3B, 0x00, 0x01, 0x98, 0x00,
  0x0C, 0xC0, 0x00, 0x67, 0x00, 0x07, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x87,
  0x00, 0x1C, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x38, 0x03,
  0x80, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x00, 0xC0, 0x60, 0x06,
  0x03, 0x00, 0x30, 0x18, 0x01, 0xC1, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0x60,
  0x01, 0x87, 0x00, 0x0E, 0x30, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0E,
  0xE0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x76, 0x00, 0x36,
  0x00, 0x33, 0x00, 0x1B, 0x00, 0x19, 0x80, 0x0D, 0x80, 0x0C, 0xE0, 0x06,
  0x60, 0x0E, 0x30, 0x07, 0x30, 0x06, 0x18, 0x03, 0x18, 0x03, 0x0C, 0x01,
  0x8C, 0x01, 0x87, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0xE1, 0x80, 0xC0, 0xC0,
  0x60, 0xC0, 0x60, 0x60, 0x30, 0x60, 0x30, 0x38, 0x18, 0x18, 0x18, 0x0C,
  0x1C, 0x0C, 0x1C, 0x06, 0x0C, 0x06, 0x0C, 0x03, 0x06, 0x03, 0x06, 0x01,
  0xC3, 0x01, 0xC3, 0x00, 0x63, 0x80, 0x63, 0x80, 0x31, 0x80, 0x31, 0x80,
  0x18, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x0E, 0x60, 0x03, 0x70, 0x03, 0x30,
  0x01, 0xB0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x6C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x60, 0x00, 0x77, 0x00, 0x06, 0x30, 0x00,
  0xE3, 0x80, 0x0C, 0x18, 0x01, 0xC1, 0xC0, 0x18, 0x0C, 0x03, 0x80, 0x60,
  0x30, 0x06, 0x07, 0x00, 0x30, 0x60, 0x03, 0x8C, 0x00, 0x18, 0xC0, 0x01,
  0xD8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x01, 0xD8, 0x00, 0x19, 0xC0, 0x03, 0x8C, 0x00, 0x30, 0xE0,
  0x07, 0x06, 0x00, 0x60, 0x70, 0x0E, 0x03, 0x00, 0xC0, 0x38, 0x1C, 0x01,
  0x81, 0x80, 0x1C, 0x30, 0x00, 0xC7, 0x00, 0x0E, 0x60, 0x00, 0x7E, 0x00,
  0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xDC, 0x00, 0x0E, 0x60, 0x00, 0x63,
  0x00, 0x03, 0x1C, 0x00, 0x18, 0x60, 0x01, 0xC3, 0x00, 0x0C, 0x18, 0x00,
  0x60, 0xE0, 0x07, 0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0xE0, 0x0C, 0x03,
  0x00, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x03, 0x03, 0x80, 0x18, 0x18,
  0x00, 0xC0, 0xC0, 0x07, 0x06, 0x00, 0x18, 0x70, 0x00, 0xC3, 0x00, 0x06,
  0x18, 0x00, 0x19, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x3B, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00,
  0xFC, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x01, 0xF8, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0xF8, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x03, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x02, 0x7F, 0xE0, 0x05, 0xC1,
  0xE0, 0x1E, 0x00, 0xFD, 0xE8, 0x00, 0x7F, 0x80, 0x00, 0x18, 0x00,
};

const GFXglyph NotoSans_Condensed_ExtraLight60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 43, 13, 4, -43 },
  { 23, 11, 16, 19, 4, -43 },
  { 45, 27, 43, 30, 1, -43 },
  { 191, 21, 49, 27, 3, -46 },
  { 320, 33, 44, 39, 3, -43 },
  { 502, 27, 44, 30, 2, -43 },
  { 651, 3, 16, 10, 4, -43 },
  { 657, 11, 52, 16, 3, -43 },
  { 729, 11, 52, 16, 2, -43 },
  { 801, 19, 19, 25, 3, -46 },
  { 847, 23, 28, 27, 2, -35 },
  { 928, 6, 14, 11, 2, -6 },
  { 939, 13, 2, 17, 2, -17 },
  { 943, 4, 4, 12, 4, -4 },
  { 945, 18, 43, 20, 1, -43 },
  { 1042, 21, 43, 27, 3, -43 },
  { 1155, 11, 43, 27, 5, -43 },
  { 1215, 21, 43, 27, 3, -43 },
  { 1328, 21, 44, 27, 3, -43 },
  { 1444, 25, 43, 27, 1, -43 },
  { 1579, 21, 44, 27, 3, -43 },
  { 1695, 21, 44, 27, 3, -43 },
  { 1811, 21, 43, 27, 3, -43 },
  { 1924, 21, 44, 27, 3, -43 },
  { 2040, 21, 44, 27, 3, -43 },
  { 2156, 4, 32, 12, 4, -32 },
  { 2172, 6, 40, 12, 2, -32 },
  { 2202, 23, 26, 27, 2, -34 },
  { 2277, 23, 15, 27, 2, -29 },
  { 2321, 23, 26, 27, 2, -34 },
  { 2396, 16, 43, 19, 1, -43 },
  { 2482, 36, 49, 42, 3, -43 },
  { 2703, 27, 43, 27, 0, -43 },
  { 2849, 22, 43, 30, 5, -43 },
  { 2968, 24, 44, 29, 3, -43 },
  { 3100, 24, 43, 33, 5, -43 },
  { 3229, 18, 43, 26, 5, -43 },
  { 3326, 18, 43, 24, 5, -43 },
  { 3423, 28, 44, 35, 3, -43 },
  { 3577, 24, 43, 34, 5, -43 },
  { 3706, 9, 43, 15, 3, -43 },
  { 3755, 12, 54, 12, -4, -43 },
  { 3836, 22, 43, 27, 5, -43 },
  { 3955, 18, 43, 24, 5, -43 },
  { 4052, 33, 43, 43, 5, -43 },
  { 4230, 24, 43, 35, 5, -43 },
  { 4359, 29, 44, 35, 3, -43 },
  { 4519, 20, 43, 27, 5, -43 },
  { 4627, 29, 53, 35, 3, -43 },
  { 4820, 22, 43, 28, 5, -43 },
  { 4939, 21, 44, 26, 3, -43 },
  { 5055, 23, 43, 24, 0, -43 },
  { 5179, 24, 44, 34, 5, -43 },
  { 5311, 26, 43, 26, 0, -43 },
  { 5451, 42, 43, 44, 1, -43 },
  { 5677, 24, 43, 24, 0, -43 },
  { 5806, 23, 43, 23, 0, -43 },
  { 5930, 21, 43, 24, 2, -43 },
  { 6043, 12, 52, 19, 5, -43 },
  { 6121, 18, 43, 20, 1, -43 },
  { 6218, 12, 52, 19, 2, -43 },
  { 6296, 25, 23, 27, 1, -43 },
  { 6368, 24, 2, 24, 0, 5 },
  { 6374, 10, 10, 14, 2, -46 },
  { 6387, 19, 33, 25, 2, -32 },
  { 6466, 22, 47, 29, 4, -46 },
  { 6596, 18, 33, 22, 3, -32 },
  { 6671, 21, 47, 29, 3, -46 },
  { 6795, 20, 33, 26, 3, -32 },
  { 6878, 16, 46, 14, 1, -46 },
  { 6970, 21, 46, 29, 3, -32 },
  { 7091, 19, 46, 28, 5, -46 },
  { 7201, 4, 44, 12, 4, -44 },
  { 7223, 9, 58, 12, -1, -44 },
  { 7289, 18, 46, 23, 5, -46 },
  { 7393, 2, 46, 11, 5, -46 },
  { 7405, 33, 32, 42, 5, -32 },
  { 7537, 19, 32, 28, 5, -32 },
  { 7613, 22, 33, 28, 3, -32 },
  { 7704, 21, 46, 29, 5, -32 },
  { 7825, 21, 46, 29, 3, -32 },
  { 7946, 13, 32, 18, 5, -32 },
  { 7998, 17, 33, 22, 2, -32 },
  { 8069, 13, 40, 15, 1, -39 },
  { 8134, 19, 33, 28, 4, -32 },
  { 8213, 21, 32, 21, 0, -32 },
  { 8297, 33, 32, 35, 1, -32 },
  { 8429, 20, 32, 23, 1, -32 },
  { 8509, 21, 47, 22, 0, -32 },
  { 8633, 16, 32, 20, 2, -32 },
  { 8697, 15, 52, 21, 3, -43 },
  { 8795, 2, 61, 26, 12, -46 },
  { 8811, 15, 52, 21, 3, -43 },
  { 8909, 23, 6, 27, 2, -24 },
};

const GFXfont NotoSans_Condensed_ExtraLight60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight60pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT60PT7B_H_
