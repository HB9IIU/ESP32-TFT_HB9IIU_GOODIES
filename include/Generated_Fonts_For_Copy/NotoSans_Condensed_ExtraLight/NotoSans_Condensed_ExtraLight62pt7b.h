#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT62PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight62pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x04, 0xEF, 0xFE, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x06, 0xE0,
  0x6E, 0x06, 0xE0, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0x40, 0x64, 0x06, 0x00,
  0x18, 0x03, 0x00, 0x01, 0x80, 0x70, 0x00, 0x38, 0x06, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60,
  0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x03, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x01,
  0xC0, 0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x03,
  0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x01, 0x80, 0x30, 0x00,
  0x38, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60,
  0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0xC1, 0xE2, 0x0F, 0x0E, 0x08, 0x08, 0x70, 0x20, 0x03, 0x80, 0x80,
  0x0E, 0x02, 0x00, 0x30, 0x08, 0x00, 0xC0, 0x20, 0x03, 0x00, 0x80, 0x0C,
  0x02, 0x00, 0x30, 0x08, 0x00, 0xC0, 0x20, 0x03, 0x80, 0x80, 0x06, 0x02,
  0x00, 0x1C, 0x08, 0x00, 0x38, 0x20, 0x00, 0x78, 0x80, 0x00, 0xFA, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x02, 0xF8, 0x00,
  0x08, 0xF0, 0x00, 0x20, 0xE0, 0x00, 0x81, 0xC0, 0x02, 0x03, 0x80, 0x08,
  0x06, 0x00, 0x20, 0x1C, 0x00, 0x80, 0x70, 0x02, 0x00, 0xC0, 0x08, 0x03,
  0x00, 0x20, 0x0C, 0x00, 0x80, 0x70, 0x02, 0x01, 0x80, 0x08, 0x0E, 0x00,
  0x20, 0x32, 0x00, 0x81, 0xCF, 0x02, 0x1E, 0x3F, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x0C, 0x00, 0xE1, 0x80, 0x03, 0x00, 0x18, 0x18, 0x00, 0x60, 0x07,
  0x03, 0x80, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x18, 0x06, 0x00, 0x60,
  0x07, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x60, 0x03, 0x00, 0x30, 0x18, 0x00, 0x60, 0x06, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0xC0, 0x01, 0x80, 0x18, 0x18, 0x00, 0x30, 0x03, 0x03, 0x00, 0x06,
  0x00, 0x60, 0xC0, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0x18, 0x01, 0x86, 0x00,
  0x03, 0x00, 0x70, 0xC1, 0xF0, 0x60, 0x0E, 0x18, 0x7F, 0x8E, 0x01, 0x86,
  0x18, 0x30, 0xC0, 0x30, 0xC7, 0x03, 0x18, 0x06, 0x30, 0xC0, 0x63, 0x81,
  0x86, 0x18, 0x0E, 0x30, 0x30, 0xC6, 0x00, 0xC7, 0x1C, 0x30, 0xC0, 0x18,
  0x7F, 0x86, 0x18, 0x03, 0x03, 0xC1, 0xC3, 0x00, 0x60, 0x00, 0x30, 0x60,
  0x0C, 0x00, 0x06, 0x0C, 0x01, 0xC0, 0x01, 0x81, 0x80, 0x38, 0x00, 0x30,
  0x30, 0x07, 0x00, 0x0E, 0x06, 0x00, 0xE0, 0x01, 0x80, 0xC0, 0x1C, 0x00,
  0x30, 0x18, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x60, 0x01, 0x80, 0x60, 0x0C,
  0x00, 0x70, 0x0C, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x01, 0x80, 0x38,
  0x06, 0x00, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x30, 0x03, 0x80,
  0x06, 0x0E, 0x00, 0x60, 0x00, 0xF7, 0x80, 0x1C, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x60, 0x0C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x30, 0x18, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x18, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0D,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x71, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x06, 0x18,
  0x06, 0x00, 0xE3, 0x80, 0x70, 0x0E, 0x70, 0x03, 0x80, 0xC7, 0x00, 0x18,
  0x0C, 0x60, 0x01, 0xC0, 0xC6, 0x00, 0x0E, 0x1C, 0x60, 0x00, 0x61, 0x8E,
  0x00, 0x07, 0x18, 0xE0, 0x00, 0x3B, 0x06, 0x00, 0x01, 0xF0, 0x60, 0x00,
  0x0E, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1F, 0x07, 0x00, 0x01, 0xB0,
  0x38, 0x00, 0x3B, 0x83, 0x80, 0x0F, 0x1C, 0x1E, 0x01, 0xE0, 0xC0, 0xFF,
  0xF8, 0x0E, 0x03, 0xFF, 0x00, 0x70, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x92, 0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x03,
  0x80, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0xE0,
  0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x07,
  0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0xE0, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x30, 0x18, 0x0F, 0x83, 0x0F, 0x7E, 0x4F,
  0xC0, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x78, 0x00, 0x1B, 0x00, 0x06, 0x30,
  0x01, 0xC3, 0x00, 0x30, 0x70, 0x0C, 0x07, 0x03, 0x80, 0x60, 0x60, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x1C, 0x71, 0xC7, 0x1C, 0x63, 0x8E, 0x38, 0xC3, 0x1C, 0x61, 0x8C,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x27, 0xFF, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x78,
  0x78, 0x03, 0x80, 0x70, 0x0C, 0x00, 0xE0, 0x70, 0x01, 0x81, 0x80, 0x07,
  0x0E, 0x00, 0x0C, 0x30, 0x00, 0x31, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x98,
  0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0xB8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xD8, 0x00, 0x06, 0x60, 0x00, 0x19,
  0x80, 0x00, 0x67, 0x00, 0x01, 0x9C, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xC0,
  0x00, 0xC3, 0x80, 0x07, 0x06, 0x00, 0x18, 0x1C, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0x70, 0x3C, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x0F, 0x01, 0xF0, 0x3B, 0x0F, 0x31, 0xC3, 0x38, 0x37, 0x03,
  0xE0, 0x34, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x03,
  0xF0, 0xF8, 0x1E, 0x00, 0xF0, 0x60, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF8,
  0x00, 0x7F, 0xF8, 0x0F, 0xC3, 0xE1, 0xE0, 0x03, 0x8E, 0x00, 0x0E, 0x40,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x01, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x74, 0x00, 0x07,
  0x38, 0x00, 0xF1, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xB0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x07, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x03, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x0C, 0x03,
  0x00, 0x06, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x01,
  0xC0, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x1C, 0x00, 0x0C,
  0x06, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC1, 0x80, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x30, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x80, 0x01, 0xE3, 0xC0, 0x0F, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x00, 0xA0, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xC0,
  0x0F, 0xCF, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x0F, 0xF0, 0x18, 0xFF,
  0xF0, 0xE7, 0x01, 0xE3, 0xB8, 0x01, 0xCF, 0x80, 0x07, 0x3E, 0x00, 0x0E,
  0xF0, 0x00, 0x1B, 0xC0, 0x00, 0x6E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00,
  0x0D, 0x80, 0x00, 0x36, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1C,
  0xC0, 0x00, 0x63, 0x00, 0x01, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x30, 0x70,
  0x01, 0xC0, 0xF0, 0x1E, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0xF8, 0x7C, 0x07, 0x00,
  0x38, 0x38, 0x00, 0x70, 0xC0, 0x00, 0xC7, 0x00, 0x03, 0x9C, 0x00, 0x0E,
  0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60,
  0x00, 0x19, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0x70, 0x38, 0x00, 0xE1, 0xC0, 0x01, 0xFE, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xE3, 0xC0, 0x0F, 0x03, 0x80, 0x70,
  0x07, 0x83, 0x80, 0x0F, 0x0C, 0x00, 0x1C, 0x70, 0x00, 0x3B, 0x80, 0x00,
  0x6E, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xD8, 0x00, 0x0E, 0x70, 0x00, 0x38, 0xE0, 0x01, 0xC1, 0xE0, 0x1E,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0xF0, 0xF8, 0x07, 0x00, 0xF0, 0x38, 0x00, 0xC0, 0xC0,
  0x03, 0x87, 0x00, 0x06, 0x18, 0x00, 0x1C, 0xE0, 0x00, 0x33, 0x80, 0x00,
  0xCC, 0x00, 0x03, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3D, 0x80, 0x00, 0xF7, 0x00, 0x07,
  0xCC, 0x00, 0x36, 0x38, 0x01, 0xD8, 0x78, 0x1E, 0x60, 0xFF, 0xE1, 0x80,
  0xFF, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x2F, 0xFF, 0x70, 0x1C, 0x73, 0xC7,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC6, 0x38, 0xE3, 0x0C,
  0x31, 0xC6, 0x18, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x1F, 0xFC, 0x3F, 0x0F, 0x0C, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0x80, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x30, 0x00, 0x00, 0x00, 0xC3, 0x80, 0x03, 0xE0,
  0x07, 0x18, 0x00, 0x7F, 0xE0, 0x18, 0xC0, 0x0F, 0x07, 0x00, 0xCE, 0x00,
  0xE0, 0x18, 0x06, 0x70, 0x06, 0x01, 0xC0, 0x33, 0x00, 0x60, 0x0E, 0x01,
  0xD8, 0x03, 0x00, 0x70, 0x0E, 0xC0, 0x38, 0x03, 0x80, 0x36, 0x01, 0x80,
  0x1C, 0x01, 0xF0, 0x0C, 0x00, 0xC0, 0x0F, 0x80, 0x60, 0x06, 0x00, 0x7C,
  0x07, 0x00, 0x30, 0x03, 0xC0, 0x38, 0x01, 0x80, 0x1E, 0x01, 0xC0, 0x0C,
  0x00, 0xF0, 0x0E, 0x00, 0x60, 0x0F, 0x80, 0x70, 0x03, 0x00, 0x7E, 0x03,
  0x80, 0x18, 0x03, 0x70, 0x0C, 0x01, 0xC0, 0x1B, 0x80, 0x60, 0x0E, 0x00,
  0xCC, 0x03, 0x00, 0x50, 0x0E, 0x60, 0x1C, 0x06, 0xC0, 0x63, 0x00, 0x60,
  0x36, 0x07, 0x18, 0x03, 0x87, 0x18, 0x70, 0xE0, 0x0F, 0xF0, 0xFF, 0x03,
  0x00, 0x3F, 0x03, 0xF0, 0x18, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x01, 0x80, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x06, 0x00, 0x00,
  0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00,
  0x18, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x60, 0x00, 0x60, 0x0E, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x70, 0x0C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x03,
  0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x83, 0x80, 0x00, 0x1C, 0x38,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0x80, 0x0F, 0x87,
  0x00, 0x03, 0x8E, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x06, 0x70,
  0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00,
  0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x06, 0x70, 0x00,
  0x1C, 0xE0, 0x00, 0x31, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x87, 0x00, 0x7E,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x38, 0x00, 0x78, 0x70, 0x00, 0x38,
  0xE0, 0x00, 0x39, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0xF1, 0xC0, 0x0F, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x87, 0xE0, 0x3E, 0x00, 0x30, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x38, 0x01, 0xF8, 0x1C, 0x00, 0x1E, 0x0E, 0x00,
  0x07, 0x87, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x0E, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x06, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0x9C,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xE1,
  0xC0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0x70, 0x07, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xB8, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x01, 0xE0, 0x00,
  0xF0, 0x1C, 0x00, 0x01, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFB, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x00, 0xCE, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x01,
  0x86, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x03, 0x03,
  0x80, 0x00, 0x18, 0x0F, 0x00, 0x00, 0xC0, 0x3E, 0x00, 0x1E, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x70, 0xFF, 0xCF, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x06, 0x00, 0xE0, 0x0E, 0xC3, 0xCF, 0xF8, 0x7F, 0x00, 0xE0, 0x00, 0x1D,
  0xC0, 0x00, 0x73, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0x60, 0x70, 0x01, 0xC0, 0xE0, 0x07, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x1C, 0x06,
  0x00, 0x38, 0x1C, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80,
  0x03, 0x8E, 0x00, 0x07, 0x3C, 0x00, 0x0E, 0x7C, 0x00, 0x1D, 0xB8, 0x00,
  0x3F, 0x38, 0x00, 0x7C, 0x70, 0x00, 0xF0, 0x70, 0x01, 0xC0, 0x60, 0x03,
  0x80, 0xE0, 0x07, 0x00, 0xC0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x03, 0x80, 0xE0, 0x03, 0x01, 0xC0, 0x07, 0x03, 0x80,
  0x06, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x33, 0x80, 0x00,
  0x77, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xEC, 0x00, 0x00, 0x01,
  0xFD, 0x80, 0x00, 0x00, 0x7F, 0xB8, 0x00, 0x00, 0x0D, 0xF3, 0x00, 0x00,
  0x01, 0xBF, 0x60, 0x00, 0x00, 0x77, 0xEE, 0x00, 0x00, 0x0C, 0xFC, 0xC0,
  0x00, 0x01, 0x9F, 0x98, 0x00, 0x00, 0x73, 0xF3, 0x80, 0x00, 0x0C, 0x7E,
  0x30, 0x00, 0x01, 0x8F, 0xC6, 0x00, 0x00, 0x71, 0xF8, 0xE0, 0x00, 0x0C,
  0x3F, 0x0C, 0x00, 0x01, 0x87, 0xE1, 0x80, 0x00, 0x70, 0xFC, 0x38, 0x00,
  0x0C, 0x1F, 0x83, 0x00, 0x01, 0x83, 0xF0, 0x60, 0x00, 0x70, 0x7E, 0x0E,
  0x00, 0x0C, 0x0F, 0xC0, 0xC0, 0x01, 0x81, 0xF8, 0x18, 0x00, 0x70, 0x3F,
  0x03, 0x80, 0x0C, 0x07, 0xE0, 0x30, 0x01, 0x80, 0xFC, 0x06, 0x00, 0x70,
  0x1F, 0x80, 0xE0, 0x0C, 0x03, 0xF0, 0x0C, 0x01, 0x80, 0x7E, 0x01, 0x80,
  0x70, 0x0F, 0xC0, 0x38, 0x0C, 0x01, 0xF8, 0x03, 0x01, 0x80, 0x3F, 0x00,
  0x60, 0x70, 0x07, 0xE0, 0x0E, 0x0C, 0x00, 0xFC, 0x00, 0xC1, 0x80, 0x1F,
  0x80, 0x18, 0x70, 0x03, 0xF0, 0x03, 0x8C, 0x00, 0x7E, 0x00, 0x31, 0x80,
  0x0F, 0xC0, 0x06, 0x70, 0x01, 0xF8, 0x00, 0xEC, 0x00, 0x3F, 0x00, 0x0D,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x1F, 0x80,
  0x03, 0x80, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3D, 0x80, 0x00, 0x1E,
  0xE0, 0x00, 0x0F, 0xB0, 0x00, 0x07, 0xDC, 0x00, 0x03, 0xE6, 0x00, 0x01,
  0xF3, 0x80, 0x00, 0xF8, 0xC0, 0x00, 0x7C, 0x70, 0x00, 0x3E, 0x18, 0x00,
  0x1F, 0x0E, 0x00, 0x0F, 0x83, 0x00, 0x07, 0xC1, 0xC0, 0x03, 0xE0, 0x60,
  0x01, 0xF0, 0x38, 0x00, 0xF8, 0x0C, 0x00, 0x7C, 0x07, 0x00, 0x3E, 0x01,
  0x80, 0x1F, 0x00, 0xE0, 0x0F, 0x80, 0x30, 0x07, 0xC0, 0x1C, 0x03, 0xE0,
  0x06, 0x01, 0xF0, 0x03, 0x80, 0xF8, 0x00, 0xE0, 0x7C, 0x00, 0x70, 0x3E,
  0x00, 0x1C, 0x1F, 0x00, 0x06, 0x0F, 0x80, 0x03, 0x87, 0xC0, 0x00, 0xC3,
  0xE0, 0x00, 0x71, 0xF0, 0x00, 0x18, 0xF8, 0x00, 0x0E, 0x7C, 0x00, 0x03,
  0x3E, 0x00, 0x01, 0xDF, 0x00, 0x00, 0x6F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x30, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0x87,
  0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x06, 0x70, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01,
  0xC0, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x38, 0x03, 0xF1, 0xC0, 0x03, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0x80,
  0x01, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xCE,
  0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80, 0x1E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x1C, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x0E,
  0x30, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x00, 0x67, 0x00, 0x00, 0x01, 0xD8,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0D, 0x80, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0x80, 0x1F, 0x07, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x39, 0xC0,
  0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00,
  0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x31, 0xC0, 0x00,
  0xE3, 0x80, 0x01, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0xF0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x30, 0x03,
  0x80, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xC0, 0x38,
  0x01, 0xC0, 0x70, 0x01, 0x80, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x03, 0x80,
  0x07, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x33, 0x80, 0x00,
  0x77, 0x00, 0x00, 0x70, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xF1, 0xFE,
  0x3C, 0x00, 0x63, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x74, 0x00, 0x07, 0x38, 0x00, 0xF1, 0xFF, 0xFF, 0x07,
  0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x33, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03,
  0x30, 0x00, 0x00, 0x67, 0x00, 0x00, 0x1C, 0x60, 0x00, 0x03, 0x8C, 0x00,
  0x00, 0x61, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x83, 0x00, 0x00, 0x60,
  0x60, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x70, 0x18, 0x00,
  0x0C, 0x03, 0x00, 0x01, 0x80, 0x70, 0x00, 0x70, 0x06, 0x00, 0x0E, 0x00,
  0xC0, 0x01, 0x80, 0x1C, 0x00, 0x30, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xE0, 0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x01,
  0x80, 0x30, 0x00, 0x30, 0x06, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x60, 0x30,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x18, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x77, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x03, 0xB0,
  0x00, 0x0F, 0x00, 0x00, 0x76, 0x00, 0x01, 0xB0, 0x00, 0x0C, 0xC0, 0x00,
  0x36, 0x00, 0x01, 0x9C, 0x00, 0x06, 0xC0, 0x00, 0x71, 0x80, 0x00, 0xD8,
  0x00, 0x0E, 0x30, 0x00, 0x3B, 0x80, 0x01, 0x86, 0x00, 0x06, 0x30, 0x00,
  0x30, 0xE0, 0x00, 0xC6, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0xC0, 0x01, 0xC1,
  0x80, 0x07, 0x18, 0x00, 0x30, 0x30, 0x00, 0xE3, 0x80, 0x06, 0x07, 0x00,
  0x18, 0x30, 0x01, 0xC0, 0xE0, 0x03, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x60,
  0xC0, 0x06, 0x01, 0x80, 0x1C, 0x1C, 0x00, 0xC0, 0x30, 0x03, 0x01, 0x80,
  0x18, 0x07, 0x00, 0x60, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x06, 0x00, 0xE0,
  0x0C, 0x03, 0x80, 0xC0, 0x18, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0x38,
  0x0C, 0x01, 0x80, 0xE0, 0x07, 0x01, 0x80, 0x30, 0x1C, 0x00, 0x60, 0x30,
  0x06, 0x03, 0x00, 0x0C, 0x0E, 0x00, 0xE0, 0x60, 0x01, 0xC1, 0x80, 0x0C,
  0x1C, 0x00, 0x38, 0x30, 0x01, 0x83, 0x80, 0x03, 0x06, 0x00, 0x30, 0x60,
  0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0xE3, 0x80, 0x01,
  0xC6, 0x00, 0x0C, 0x70, 0x00, 0x18, 0xC0, 0x01, 0x8E, 0x00, 0x03, 0x18,
  0x00, 0x31, 0x80, 0x00, 0x67, 0x00, 0x07, 0x30, 0x00, 0x0E, 0xC0, 0x00,
  0x6E, 0x00, 0x01, 0xD8, 0x00, 0x0D, 0xC0, 0x00, 0x1B, 0x00, 0x01, 0xB0,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x00, 0x7C, 0x00, 0x06, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x18, 0x00, 0x06, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x0E, 0x00, 0x18, 0x06, 0x00,
  0x38, 0x07, 0x00, 0x30, 0x03, 0x00, 0x70, 0x03, 0x80, 0x60, 0x01, 0x80,
  0x60, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0xC0, 0x00, 0xC1, 0xC0, 0x00, 0xE1,
  0x80, 0x00, 0x63, 0x80, 0x00, 0x73, 0x00, 0x00, 0x37, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x37, 0x00, 0x00, 0x73, 0x00, 0x00, 0x63,
  0x80, 0x00, 0xE1, 0x80, 0x00, 0xC1, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0x80,
  0xC0, 0x03, 0x80, 0xE0, 0x03, 0x00, 0x60, 0x07, 0x00, 0x70, 0x06, 0x00,
  0x30, 0x0E, 0x00, 0x38, 0x0C, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x18, 0x00,
  0x1C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x70, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x18, 0x00,
  0x18, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0C, 0x00, 0x30, 0x0E, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x00,
  0xC0, 0x03, 0x81, 0xC0, 0x01, 0x81, 0x80, 0x01, 0xC1, 0x80, 0x01, 0xC3,
  0x80, 0x00, 0xC3, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0xFF,
  0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x70, 0x00,
  0x03, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x01, 0x83, 0x00, 0x01, 0x81, 0xC0,
  0x01, 0xC0, 0x60, 0x00, 0xC0, 0x38, 0x00, 0xE0, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x70, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x38, 0x00, 0x30, 0x18, 0x00,
  0x18, 0x1C, 0x00, 0x0E, 0x0C, 0x00, 0x03, 0x0E, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30,
  0x06, 0x00, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1E, 0x03, 0xC1, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x0F, 0xF0, 0x1F, 0xFF, 0x07, 0xE0, 0x71, 0xE0, 0x07,
  0x3C, 0x00, 0x73, 0x80, 0x07, 0x70, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00,
  0x76, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x60, 0x00, 0xF6, 0x00,
  0x0F, 0x70, 0x01, 0xF3, 0x00, 0x33, 0x38, 0x07, 0x31, 0xF3, 0xE3, 0x0F,
  0xF8, 0x30, 0x0E, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x1F, 0xE0, 0x31, 0xFF, 0xE0,
  0xCE, 0x03, 0xC3, 0x70, 0x03, 0x8D, 0x80, 0x06, 0x3C, 0x00, 0x1C, 0xF0,
  0x00, 0x33, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x06, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x80, 0x00,
  0x6E, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x33, 0xC0, 0x01, 0xCD,
  0x80, 0x06, 0x36, 0x00, 0x38, 0xCE, 0x03, 0xC3, 0x1F, 0xFE, 0x0C, 0x3F,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x78, 0x04, 0x38,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x04, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x1F, 0xE0, 0xC1, 0xFF, 0xE3, 0x0F, 0x01, 0xCC, 0x70, 0x03, 0x31, 0x80,
  0x06, 0xCE, 0x00, 0x0F, 0x30, 0x00, 0x3D, 0xC0, 0x00, 0x76, 0x00, 0x01,
  0xD8, 0x00, 0x07, 0x60, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1D, 0x80, 0x00, 0x76, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70,
  0x00, 0x3C, 0xC0, 0x00, 0xB3, 0x80, 0x06, 0xC7, 0x00, 0x33, 0x0E, 0x01,
  0xCC, 0x1F, 0xFE, 0x30, 0x3F, 0xE0, 0xC0, 0x0E, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xFC, 0x03, 0xC0, 0xF0, 0x38, 0x01, 0x81, 0x80, 0x0E, 0x1C, 0x00,
  0x30, 0xC0, 0x01, 0xCE, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x08, 0x3C, 0x01, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xC0,
  0x01, 0xE0, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x01, 0xFE, 0x0C, 0x1F, 0xFE, 0x30, 0xF0, 0x1C, 0xC7, 0x00, 0x3B,
  0x18, 0x00, 0x6C, 0xE0, 0x00, 0xF3, 0x00, 0x03, 0xDC, 0x00, 0x07, 0x60,
  0x00, 0x1D, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00,
  0x77, 0x00, 0x03, 0xCC, 0x00, 0x0B, 0x38, 0x00, 0x6C, 0x70, 0x03, 0x30,
  0xE0, 0x1C, 0xC1, 0xFF, 0xE3, 0x03, 0xFE, 0x0C, 0x01, 0xC0, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x60, 0x00, 0xE1, 0xF8, 0x1F, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x7F,
  0x86, 0x3F, 0xFC, 0xCE, 0x03, 0x9B, 0x80, 0x3B, 0x60, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x18, 0x6F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x60, 0x03, 0x03, 0xC1, 0xE0, 0xF0, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x4F, 0x3F, 0x1F, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x3B, 0x00, 0x0C,
  0xC0, 0x07, 0x30, 0x03, 0x8C, 0x00, 0xC3, 0x00, 0x70, 0xC0, 0x38, 0x30,
  0x0C, 0x0C, 0x06, 0x03, 0x03, 0x80, 0xC1, 0xC0, 0x30, 0x60, 0x0C, 0x38,
  0x03, 0x1C, 0x00, 0xC7, 0x80, 0x33, 0x60, 0x0D, 0xDC, 0x03, 0x63, 0x00,
  0xF0, 0xE0, 0x38, 0x18, 0x0E, 0x07, 0x03, 0x00, 0xC0, 0xC0, 0x38, 0x30,
  0x06, 0x0C, 0x01, 0xC3, 0x00, 0x30, 0xC0, 0x0E, 0x30, 0x01, 0x8C, 0x00,
  0x73, 0x00, 0x0C, 0xC0, 0x03, 0xB0, 0x00, 0x6C, 0x00, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC3, 0xFC,
  0x03, 0xFC, 0x31, 0xFF, 0x83, 0xFF, 0x8C, 0xC0, 0x71, 0xC0, 0xF3, 0x60,
  0x0C, 0x60, 0x0C, 0xD0, 0x03, 0xB0, 0x03, 0xBC, 0x00, 0x68, 0x00, 0x6E,
  0x00, 0x1E, 0x00, 0x1B, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x01, 0xC0, 0x01,
  0xF0, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x03, 0x00,
  0x07, 0xC0, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x0C,
  0x00, 0x1F, 0x00, 0x03, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x01, 0xF0, 0x00,
  0x30, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x07, 0xC0,
  0x00, 0xC0, 0x01, 0xF0, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x1F,
  0x00, 0x03, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x30, 0x00,
  0x7C, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x07, 0xC0, 0x00, 0xC0,
  0x01, 0xF0, 0x00, 0x30, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x03,
  0x00, 0x07, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0xC1, 0xFE, 0x18, 0xFF, 0xF3,
  0x38, 0x0F, 0x6E, 0x00, 0xED, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x60, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3C, 0x07, 0x80, 0xE0,
  0x03, 0x81, 0x80, 0x07, 0x07, 0x00, 0x07, 0x0C, 0x00, 0x06, 0x38, 0x00,
  0x0C, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x37, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xDC, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60,
  0x00, 0x1C, 0xE0, 0x00, 0x30, 0xC0, 0x00, 0x61, 0xC0, 0x01, 0xC1, 0x80,
  0x03, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x78, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0xC1, 0xFE, 0x03, 0x1F, 0xFE, 0x0C, 0xE0, 0x3C,
  0x33, 0x00, 0x38, 0xD8, 0x00, 0x63, 0x40, 0x01, 0xCF, 0x00, 0x03, 0x38,
  0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00,
  0x06, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0xEF, 0x00, 0x03, 0x3C, 0x00, 0x1C, 0xD8, 0x00, 0x63,
  0x70, 0x03, 0x8C, 0xE0, 0x3C, 0x31, 0xFF, 0xE0, 0xC3, 0xFF, 0x03, 0x00,
  0xC0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x01, 0xFE, 0x0C, 0x1F, 0xFE, 0x30, 0xF0, 0x1C,
  0xC7, 0x00, 0x33, 0x18, 0x00, 0x6C, 0xE0, 0x00, 0xB3, 0x00, 0x03, 0xDC,
  0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x60, 0x00,
  0x1D, 0xC0, 0x00, 0x77, 0x00, 0x03, 0xCC, 0x00, 0x0B, 0x38, 0x00, 0x6C,
  0x70, 0x03, 0x30, 0xE0, 0x18, 0xC1, 0xFF, 0xE3, 0x03, 0xFE, 0x0C, 0x01,
  0xC0, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0xC1, 0xFE, 0x3F, 0xF3, 0x83, 0x98, 0x0D, 0x80,
  0x68, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x07, 0xFF,
  0x03, 0xFF, 0xF1, 0xC0, 0x18, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0xA0, 0x00, 0xEE, 0x00, 0x73, 0xFF, 0xF8, 0x3F, 0xFC,
  0x00, 0xF8, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xC3, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0x00,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0x60, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x0F, 0x70, 0x01,
  0xB3, 0x80, 0x1B, 0x3C, 0x07, 0x31, 0xFF, 0xE3, 0x0F, 0xFC, 0x30, 0x0C,
  0x00, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x0E, 0xE0, 0x00, 0x77,
  0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x01, 0xC7, 0x00, 0x0C, 0x18, 0x00,
  0x60, 0xC0, 0x07, 0x06, 0x00, 0x38, 0x38, 0x01, 0x80, 0xC0, 0x0C, 0x06,
  0x00, 0xE0, 0x38, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x03, 0x80, 0x30, 0x1C,
  0x01, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x70, 0x01, 0xC3, 0x00, 0x06,
  0x18, 0x00, 0x30, 0xC0, 0x01, 0x8E, 0x00, 0x0E, 0x60, 0x00, 0x33, 0x00,
  0x01, 0xB8, 0x00, 0x0D, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x3E, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x60, 0x01, 0xB0,
  0x01, 0x98, 0x00, 0x6C, 0x00, 0x67, 0x00, 0x1B, 0x00, 0x19, 0xC0, 0x0C,
  0xC0, 0x0E, 0x30, 0x03, 0x38, 0x03, 0x8C, 0x00, 0xC6, 0x00, 0xC3, 0x80,
  0x31, 0x80, 0x30, 0xE0, 0x1C, 0x60, 0x0C, 0x18, 0x06, 0x1C, 0x07, 0x06,
  0x01, 0x83, 0x01, 0x81, 0x80, 0xE0, 0xC0, 0x60, 0x70, 0x38, 0x30, 0x18,
  0x0C, 0x0C, 0x0E, 0x0E, 0x03, 0x03, 0x01, 0x83, 0x00, 0xC1, 0xC0, 0x60,
  0xC0, 0x38, 0x70, 0x18, 0x30, 0x06, 0x18, 0x07, 0x0C, 0x01, 0x86, 0x00,
  0xC6, 0x00, 0x63, 0x80, 0x31, 0x80, 0x1C, 0xE0, 0x0C, 0x60, 0x03, 0x30,
  0x03, 0x98, 0x00, 0xCC, 0x00, 0xEE, 0x00, 0x33, 0x00, 0x1B, 0x00, 0x0D,
  0xC0, 0x06, 0xC0, 0x01, 0xE0, 0x01, 0xB0, 0x00, 0x78, 0x00, 0x6C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x3B, 0x80, 0x03, 0x8E, 0x00, 0x18, 0x70, 0x01, 0xC1,
  0xC0, 0x0C, 0x06, 0x00, 0xE0, 0x38, 0x06, 0x00, 0xC0, 0x70, 0x07, 0x03,
  0x00, 0x18, 0x38, 0x00, 0xE1, 0x80, 0x03, 0x1C, 0x00, 0x1C, 0xC0, 0x00,
  0x6E, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0,
  0x00, 0x36, 0x00, 0x03, 0xB8, 0x00, 0x18, 0xC0, 0x01, 0xC7, 0x00, 0x0C,
  0x18, 0x00, 0xE0, 0xE0, 0x06, 0x03, 0x00, 0x70, 0x0C, 0x03, 0x00, 0x70,
  0x38, 0x01, 0x81, 0x80, 0x0E, 0x1C, 0x00, 0x31, 0xC0, 0x01, 0xCE, 0x00,
  0x06, 0xE0, 0x00, 0x38, 0x60, 0x00, 0x0D, 0xC0, 0x00, 0x77, 0x00, 0x01,
  0x8C, 0x00, 0x06, 0x30, 0x00, 0x38, 0xE0, 0x00, 0xE1, 0x80, 0x03, 0x06,
  0x00, 0x0C, 0x1C, 0x00, 0x70, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00,
  0x38, 0x0E, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x70,
  0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x38, 0x00, 0xE0, 0xC0, 0x01,
  0x83, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x70, 0x00, 0x31, 0x80, 0x00, 0xC6,
  0x00, 0x03, 0x38, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x02, 0x1C, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0x00, 0x7F, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF0, 0x01, 0x78, 0xF8, 0x03, 0xE0,
  0x1F, 0x0F, 0x80, 0x07, 0xFC, 0x80, 0x01, 0xF8,
};

const GFXglyph NotoSans_Condensed_ExtraLight62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 44, 13, 5, -44 },
  { 23, 12, 16, 20, 4, -44 },
  { 47, 28, 44, 31, 1, -44 },
  { 201, 22, 51, 28, 3, -47 },
  { 342, 35, 46, 41, 3, -45 },
  { 544, 28, 46, 31, 2, -45 },
  { 705, 3, 16, 11, 4, -44 },
  { 711, 11, 54, 17, 3, -44 },
  { 786, 12, 54, 17, 2, -44 },
  { 867, 19, 19, 25, 3, -47 },
  { 913, 24, 28, 28, 2, -36 },
  { 997, 6, 15, 12, 2, -7 },
  { 1009, 14, 2, 17, 2, -18 },
  { 1013, 4, 5, 12, 4, -5 },
  { 1016, 19, 44, 21, 1, -44 },
  { 1121, 22, 46, 28, 3, -45 },
  { 1248, 12, 44, 28, 5, -44 },
  { 1314, 22, 45, 28, 3, -45 },
  { 1438, 21, 46, 28, 3, -45 },
  { 1559, 26, 45, 28, 1, -45 },
  { 1706, 22, 45, 28, 3, -44 },
  { 1830, 22, 46, 28, 3, -45 },
  { 1957, 22, 44, 28, 3, -44 },
  { 2078, 22, 46, 28, 3, -45 },
  { 2205, 22, 46, 28, 3, -45 },
  { 2332, 4, 33, 13, 4, -33 },
  { 2349, 6, 41, 12, 2, -33 },
  { 2380, 24, 26, 28, 2, -35 },
  { 2458, 24, 15, 28, 2, -29 },
  { 2503, 24, 26, 28, 2, -35 },
  { 2581, 17, 45, 20, 1, -45 },
  { 2677, 37, 50, 43, 3, -44 },
  { 2909, 28, 44, 28, 0, -44 },
  { 3063, 23, 44, 31, 5, -44 },
  { 3190, 25, 46, 30, 3, -45 },
  { 3334, 25, 44, 34, 5, -44 },
  { 3472, 19, 44, 27, 5, -44 },
  { 3577, 19, 44, 25, 5, -44 },
  { 3682, 29, 46, 36, 3, -45 },
  { 3849, 25, 44, 35, 5, -44 },
  { 3987, 10, 44, 16, 3, -44 },
  { 4042, 12, 55, 13, -4, -44 },
  { 4125, 23, 44, 28, 5, -44 },
  { 4252, 18, 44, 25, 5, -44 },
  { 4351, 35, 44, 45, 5, -44 },
  { 4544, 25, 44, 36, 5, -44 },
  { 4682, 30, 46, 37, 3, -45 },
  { 4855, 21, 44, 28, 5, -44 },
  { 4971, 30, 56, 37, 3, -45 },
  { 5181, 23, 44, 29, 5, -44 },
  { 5308, 21, 46, 27, 3, -45 },
  { 5429, 24, 44, 25, 0, -44 },
  { 5561, 25, 45, 35, 5, -44 },
  { 5702, 27, 44, 27, 0, -44 },
  { 5851, 43, 44, 45, 1, -44 },
  { 6088, 24, 44, 25, 0, -44 },
  { 6220, 24, 44, 24, 0, -44 },
  { 6352, 22, 44, 25, 2, -44 },
  { 6473, 12, 54, 19, 5, -44 },
  { 6554, 19, 44, 21, 1, -44 },
  { 6659, 12, 54, 19, 2, -44 },
  { 6740, 25, 23, 28, 2, -44 },
  { 6812, 25, 2, 25, 0, 6 },
  { 6819, 10, 9, 15, 2, -47 },
  { 6831, 20, 34, 26, 2, -33 },
  { 6916, 22, 48, 30, 5, -47 },
  { 7048, 18, 34, 23, 3, -33 },
  { 7125, 22, 48, 30, 3, -47 },
  { 7257, 21, 34, 27, 3, -33 },
  { 7347, 16, 47, 15, 1, -47 },
  { 7441, 22, 48, 30, 3, -33 },
  { 7573, 19, 47, 29, 5, -47 },
  { 7685, 4, 45, 12, 4, -45 },
  { 7708, 9, 60, 12, -1, -45 },
  { 7776, 18, 47, 24, 5, -47 },
  { 7882, 2, 47, 12, 5, -47 },
  { 7894, 34, 33, 43, 5, -33 },
  { 8035, 19, 33, 29, 5, -33 },
  { 8114, 23, 34, 29, 3, -33 },
  { 8212, 22, 48, 30, 5, -33 },
  { 8344, 22, 48, 30, 3, -33 },
  { 8476, 13, 33, 19, 5, -33 },
  { 8530, 18, 34, 22, 2, -33 },
  { 8607, 13, 42, 16, 1, -41 },
  { 8676, 20, 34, 29, 4, -33 },
  { 8761, 21, 33, 22, 0, -33 },
  { 8848, 34, 33, 36, 1, -33 },
  { 8989, 21, 33, 23, 1, -33 },
  { 9076, 22, 48, 22, 0, -33 },
  { 9208, 16, 33, 20, 2, -33 },
  { 9274, 16, 54, 22, 3, -44 },
  { 9382, 2, 62, 27, 12, -47 },
  { 9398, 16, 54, 22, 3, -44 },
  { 9506, 24, 6, 28, 2, -25 },
};

const GFXfont NotoSans_Condensed_ExtraLight62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight62pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT62PT7B_H_
