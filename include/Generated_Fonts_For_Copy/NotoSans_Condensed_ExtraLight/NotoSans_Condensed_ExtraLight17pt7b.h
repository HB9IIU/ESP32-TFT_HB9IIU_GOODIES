#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT17PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x90, 0xB6, 0xD0, 0x12, 0x12, 0x12, 0x7F, 0x24, 0x24, 0x24,
  0xFF, 0x24, 0x24, 0x24, 0x48, 0x21, 0xEA, 0x28, 0xA2, 0x86, 0x0E, 0x24,
  0x92, 0x6A, 0x70, 0x80, 0xE2, 0x49, 0x25, 0x12, 0x89, 0x54, 0xD6, 0xB2,
  0xA9, 0x14, 0x8A, 0x48, 0xA4, 0x70, 0x70, 0x91, 0x22, 0x45, 0x04, 0x34,
  0x49, 0x8B, 0x0A, 0x13, 0xD0, 0xF0, 0x29, 0x49, 0x24, 0x92, 0x44, 0x88,
  0x89, 0x22, 0x49, 0x25, 0x25, 0x20, 0x21, 0x3E, 0x45, 0x00, 0x20, 0x82,
  0x08, 0xFC, 0x82, 0x08, 0xF0, 0xE0, 0x80, 0x08, 0x42, 0x21, 0x08, 0x84,
  0x42, 0x11, 0x00, 0x7A, 0x28, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x9C,
  0x35, 0x91, 0x11, 0x11, 0x11, 0x11, 0xF8, 0x20, 0x41, 0x08, 0x21, 0x04,
  0x21, 0x08, 0x3F, 0xF8, 0x20, 0x41, 0x09, 0xC0, 0x81, 0x04, 0x10, 0xBE,
  0x04, 0x0C, 0x14, 0x14, 0x24, 0x24, 0x44, 0x44, 0xFF, 0x04, 0x04, 0x04,
  0xFA, 0x08, 0x20, 0x83, 0xE0, 0x41, 0x04, 0x10, 0xBC, 0x3D, 0x08, 0x20,
  0xB3, 0x28, 0x61, 0x86, 0x18, 0x5E, 0xFC, 0x10, 0x82, 0x08, 0x41, 0x08,
  0x20, 0x84, 0x10, 0x7A, 0x18, 0x61, 0x48, 0xC4, 0xA1, 0x86, 0x18, 0x5E,
  0x7A, 0x28, 0x61, 0x86, 0x15, 0xC9, 0x04, 0x20, 0xBC, 0x80, 0x80, 0x81,
  0xE0, 0x04, 0x66, 0x20, 0xC0, 0xC0, 0x81, 0xFC, 0x00, 0x3F, 0x81, 0x03,
  0x03, 0x08, 0xCC, 0x20, 0xF0, 0x42, 0x10, 0x88, 0x84, 0x20, 0x00, 0x40,
  0x1F, 0x18, 0x24, 0x0A, 0x39, 0x92, 0x64, 0x9A, 0x26, 0x89, 0x92, 0x67,
  0x68, 0x01, 0x00, 0x21, 0x07, 0x80, 0x10, 0x18, 0x18, 0x28, 0x24, 0x24,
  0x44, 0x7A, 0x42, 0x42, 0x82, 0x81, 0xFD, 0x0A, 0x0C, 0x28, 0x5F, 0x21,
  0x41, 0x83, 0x06, 0x17, 0xC0, 0x3E, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x01, 0x01, 0xF0, 0xF9, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x17, 0xC0, 0xFE, 0x08, 0x20, 0x83, 0xE8, 0x20, 0x82, 0x08, 0x3F,
  0xFE, 0x08, 0x20, 0x82, 0x0F, 0xA0, 0x82, 0x08, 0x20, 0x3F, 0x40, 0x80,
  0x80, 0x80, 0x80, 0x8F, 0x81, 0x81, 0x81, 0x41, 0x3F, 0x83, 0x06, 0x0C,
  0x18, 0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0xE9, 0x24, 0x92, 0x49,
  0x70, 0x24, 0x92, 0x49, 0x24, 0x92, 0x78, 0x85, 0x12, 0x24, 0x8A, 0x14,
  0x34, 0x48, 0x89, 0x12, 0x14, 0x30, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0xF0, 0xC0, 0x70, 0x3C, 0x0E, 0x85, 0xA1, 0x68, 0x59, 0x26, 0x49,
  0x92, 0x63, 0x18, 0xC6, 0x11, 0x83, 0x86, 0x8D, 0x19, 0x32, 0x62, 0xC5,
  0x87, 0x0E, 0x0C, 0x10, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x42, 0x3C, 0xFA, 0x18, 0x61, 0x86, 0x1F, 0xA0, 0x82, 0x08,
  0x20, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x42,
  0x3C, 0x04, 0x04, 0x02, 0xF9, 0x0A, 0x14, 0x28, 0x51, 0x3C, 0x48, 0x89,
  0x12, 0x14, 0x30, 0x7E, 0x08, 0x20, 0x81, 0x81, 0x81, 0x04, 0x10, 0xBE,
  0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0x09, 0xE0, 0x83, 0x05,
  0x0A, 0x14, 0x48, 0x89, 0x12, 0x28, 0x50, 0x40, 0x80, 0x82, 0x18, 0x61,
  0x46, 0x14, 0x62, 0x45, 0x24, 0x92, 0x29, 0x22, 0x92, 0x28, 0xC2, 0x8C,
  0x30, 0xC1, 0x08, 0xC6, 0x88, 0x91, 0x42, 0x82, 0x04, 0x14, 0x28, 0x89,
  0x14, 0x10, 0x87, 0x09, 0x12, 0x42, 0x85, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x80, 0xF8, 0x44, 0x21, 0x10, 0x88, 0x44, 0x21, 0xF0, 0xF8, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0xF0, 0x82, 0x10, 0x82, 0x10, 0x42, 0x10, 0x42,
  0x10, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x78, 0x18, 0x30, 0x91, 0x24, 0x38,
  0x40, 0xFE, 0x94, 0xF0, 0x42, 0x17, 0xC6, 0x31, 0xF8, 0x82, 0x08, 0x20,
  0xBB, 0x18, 0x61, 0x86, 0x18, 0x71, 0xB8, 0x7C, 0x21, 0x08, 0x42, 0x10,
  0x78, 0x04, 0x10, 0x41, 0x7E, 0x18, 0x61, 0x86, 0x18, 0x61, 0x7C, 0x7A,
  0x28, 0x61, 0xFA, 0x08, 0x20, 0x78, 0x3A, 0x10, 0x8F, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x00, 0x7E, 0x18, 0x61, 0x86, 0x18, 0x61, 0x7C, 0x10, 0x41,
  0xF8, 0x82, 0x08, 0x20, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x9F,
  0xF0, 0x41, 0x55, 0x55, 0x57, 0x84, 0x21, 0x08, 0xCA, 0x94, 0xE4, 0xA5,
  0x18, 0x80, 0xFF, 0xF8, 0xFB, 0xA3, 0x18, 0x86, 0x21, 0x88, 0x62, 0x18,
  0x86, 0x21, 0x88, 0x40, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x7A,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x78, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x71,
  0xBA, 0x08, 0x20, 0x80, 0x7E, 0x18, 0x61, 0x86, 0x18, 0x61, 0x7C, 0x10,
  0x41, 0x04, 0xBC, 0x88, 0x88, 0x88, 0x80, 0xF8, 0x88, 0x61, 0x11, 0xF0,
  0x44, 0xF4, 0x44, 0x44, 0x44, 0x30, 0x86, 0x18, 0x61, 0x86, 0x18, 0x63,
  0x74, 0x86, 0x14, 0x92, 0x49, 0x43, 0x0C, 0x20, 0x84, 0x63, 0x14, 0xC9,
  0x32, 0x52, 0x94, 0xA3, 0x30, 0x84, 0x21, 0x00, 0xC5, 0x22, 0x8C, 0x10,
  0xC2, 0x92, 0x84, 0x86, 0x14, 0x52, 0x48, 0xA3, 0x0C, 0x10, 0x82, 0x08,
  0xC0, 0xF1, 0x22, 0x44, 0x88, 0xF0, 0x34, 0x44, 0x44, 0x48, 0x44, 0x44,
  0x42, 0x10, 0xFF, 0xFF, 0x80, 0xC2, 0x22, 0x22, 0x21, 0x22, 0x22, 0x24,
  0x80, 0xE6, 0x60,
};

const GFXglyph NotoSans_Condensed_ExtraLight17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 12, 4, 1, -12 },
  { 3, 3, 4, 5, 1, -12 },
  { 5, 8, 12, 8, 0, -12 },
  { 17, 6, 14, 8, 1, -13 },
  { 28, 9, 12, 11, 1, -12 },
  { 42, 7, 12, 8, 1, -12 },
  { 53, 1, 4, 3, 1, -12 },
  { 54, 3, 15, 5, 1, -12 },
  { 60, 3, 15, 5, 1, -12 },
  { 66, 5, 5, 7, 1, -13 },
  { 70, 6, 8, 8, 1, -10 },
  { 76, 1, 4, 3, 1, -2 },
  { 77, 3, 1, 5, 1, -5 },
  { 78, 1, 1, 3, 1, -1 },
  { 79, 5, 12, 6, 0, -12 },
  { 87, 6, 12, 8, 1, -12 },
  { 96, 4, 12, 8, 1, -12 },
  { 102, 6, 12, 8, 1, -12 },
  { 111, 6, 12, 8, 1, -12 },
  { 120, 8, 12, 8, 0, -12 },
  { 132, 6, 12, 8, 1, -12 },
  { 141, 6, 12, 8, 1, -12 },
  { 150, 6, 12, 8, 1, -12 },
  { 159, 6, 12, 8, 1, -12 },
  { 168, 6, 12, 8, 1, -12 },
  { 177, 1, 9, 3, 1, -9 },
  { 179, 1, 11, 3, 1, -9 },
  { 181, 6, 8, 8, 1, -10 },
  { 187, 6, 4, 8, 1, -8 },
  { 190, 6, 8, 8, 1, -10 },
  { 196, 5, 12, 5, 0, -12 },
  { 204, 10, 14, 12, 1, -12 },
  { 222, 8, 12, 8, 0, -12 },
  { 234, 7, 12, 8, 1, -12 },
  { 245, 7, 12, 8, 1, -12 },
  { 256, 7, 12, 9, 1, -12 },
  { 267, 6, 12, 7, 1, -12 },
  { 276, 6, 12, 7, 1, -12 },
  { 285, 8, 12, 10, 1, -12 },
  { 297, 7, 12, 10, 1, -12 },
  { 308, 3, 12, 4, 1, -12 },
  { 313, 3, 15, 4, -1, -12 },
  { 319, 7, 12, 8, 1, -12 },
  { 330, 5, 12, 7, 1, -12 },
  { 338, 10, 12, 12, 1, -12 },
  { 353, 7, 12, 10, 1, -12 },
  { 364, 8, 12, 10, 1, -12 },
  { 376, 6, 12, 8, 1, -12 },
  { 385, 8, 15, 10, 1, -12 },
  { 400, 7, 12, 8, 1, -12 },
  { 411, 6, 12, 7, 1, -12 },
  { 420, 7, 12, 7, 0, -12 },
  { 431, 7, 12, 10, 1, -12 },
  { 442, 7, 12, 7, 0, -12 },
  { 453, 12, 12, 12, 0, -12 },
  { 471, 7, 12, 7, 0, -12 },
  { 482, 7, 12, 7, 0, -12 },
  { 493, 5, 12, 7, 1, -12 },
  { 501, 4, 15, 5, 1, -12 },
  { 509, 5, 12, 6, 0, -12 },
  { 517, 3, 15, 5, 1, -12 },
  { 523, 7, 6, 8, 0, -12 },
  { 529, 7, 1, 7, 0, 1 },
  { 530, 2, 3, 4, 1, -13 },
  { 531, 5, 9, 7, 1, -9 },
  { 537, 6, 13, 8, 1, -13 },
  { 547, 5, 9, 6, 1, -9 },
  { 553, 6, 13, 8, 1, -13 },
  { 563, 6, 9, 7, 1, -9 },
  { 570, 5, 13, 4, 0, -13 },
  { 579, 6, 13, 8, 1, -9 },
  { 589, 6, 13, 8, 1, -13 },
  { 599, 1, 12, 3, 1, -12 },
  { 601, 2, 16, 3, 0, -12 },
  { 605, 5, 13, 6, 1, -13 },
  { 614, 1, 13, 3, 1, -13 },
  { 616, 10, 9, 12, 1, -9 },
  { 628, 6, 9, 8, 1, -9 },
  { 635, 6, 9, 8, 1, -9 },
  { 642, 6, 13, 8, 1, -9 },
  { 652, 6, 13, 8, 1, -9 },
  { 662, 4, 9, 5, 1, -9 },
  { 667, 4, 9, 6, 1, -9 },
  { 672, 4, 11, 4, 0, -11 },
  { 678, 6, 9, 8, 1, -9 },
  { 685, 6, 9, 6, 0, -9 },
  { 692, 10, 9, 10, 0, -9 },
  { 704, 6, 9, 6, 0, -9 },
  { 711, 6, 13, 6, 0, -9 },
  { 721, 4, 9, 6, 1, -9 },
  { 726, 4, 15, 6, 1, -12 },
  { 734, 1, 17, 7, 3, -13 },
  { 737, 4, 15, 6, 1, -12 },
  { 745, 6, 2, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_ExtraLight17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight17pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT17PT7B_H_
