#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT41PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight41pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6C, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x80, 0x03, 0x7E,
  0xC3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x01, 0x02, 0x00,
  0x40, 0x80, 0x30, 0x20, 0x0C, 0x08, 0x03, 0x06, 0x00, 0x81, 0x80, 0x20,
  0x40, 0x08, 0x10, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x60, 0x40, 0x18, 0x30,
  0x04, 0x0C, 0x01, 0x03, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x08, 0x03,
  0x02, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0x08, 0x18, 0x02, 0x04, 0x00, 0x81,
  0x00, 0x20, 0x40, 0x18, 0x10, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x40, 0xC0,
  0x10, 0x20, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x78, 0x07, 0xFE, 0x73, 0x19,
  0x8C, 0x0C, 0x30, 0x20, 0xC0, 0x83, 0x02, 0x0C, 0x08, 0x30, 0x30, 0xC0,
  0x43, 0x01, 0x8C, 0x03, 0xB0, 0x03, 0xC0, 0x03, 0x80, 0x0F, 0x80, 0x33,
  0x80, 0xC6, 0x03, 0x0C, 0x0C, 0x10, 0x30, 0x40, 0xC1, 0x03, 0x04, 0x0C,
  0x30, 0x30, 0xE0, 0xC6, 0xFF, 0xF0, 0xFF, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x00, 0x00, 0x7C, 0x01, 0x81, 0x8C, 0x02, 0x02, 0x08, 0x0C,
  0x0C, 0x18, 0x10, 0x18, 0x30, 0x20, 0x30, 0x20, 0xC0, 0x40, 0x41, 0x00,
  0x80, 0x86, 0x01, 0x01, 0x08, 0x02, 0x02, 0x10, 0x04, 0x04, 0x60, 0x08,
  0x08, 0x8F, 0x18, 0x33, 0x33, 0x30, 0x64, 0x43, 0x20, 0x89, 0x82, 0x63,
  0x32, 0x04, 0x7C, 0x44, 0x0C, 0x71, 0x88, 0x18, 0x02, 0x10, 0x30, 0x04,
  0x20, 0x60, 0x18, 0x40, 0xC0, 0x20, 0x81, 0x80, 0xC1, 0x03, 0x01, 0x02,
  0x06, 0x02, 0x04, 0x08, 0x0C, 0x0C, 0x10, 0x10, 0x08, 0x60, 0x60, 0x18,
  0x80, 0x80, 0x1F, 0x00, 0x03, 0x00, 0x03, 0xF0, 0x01, 0x86, 0x00, 0x40,
  0x80, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x20,
  0x04, 0x08, 0x01, 0x86, 0x00, 0x23, 0x00, 0x0D, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x6C, 0x00, 0x31, 0x80, 0x18, 0x60, 0x24, 0x0C, 0x1B, 0x01,
  0x86, 0x80, 0x21, 0x20, 0x0C, 0x48, 0x01, 0xB2, 0x00, 0x28, 0x80, 0x0E,
  0x30, 0x03, 0x8C, 0x01, 0xB1, 0x80, 0xEC, 0x30, 0x61, 0x87, 0xF0, 0x30,
  0xEA, 0xAA, 0xA0, 0x06, 0x08, 0x30, 0xC1, 0x06, 0x0C, 0x10, 0x60, 0xC1,
  0x02, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0x40, 0xC1, 0x83, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x18, 0xC0, 0x81,
  0x81, 0x83, 0x03, 0x06, 0x04, 0x0C, 0x18, 0x10, 0x20, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x41, 0x83,
  0x04, 0x18, 0x20, 0xC3, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x0C,
  0x21, 0xBD, 0x78, 0x3E, 0x00, 0xE0, 0x0D, 0x00, 0x44, 0x04, 0x30, 0x60,
  0xC2, 0x02, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x01, 0xFF, 0xFC, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x2D, 0xB4, 0xB4, 0x80, 0xFF, 0xFF, 0xC0, 0xFC, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0x81, 0x83,
  0x0C, 0x04, 0x20, 0x19, 0x80, 0x26, 0x00, 0xD0, 0x03, 0x40, 0x0F, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x34, 0x00, 0xD0,
  0x03, 0x60, 0x09, 0x80, 0x23, 0x01, 0x8C, 0x0C, 0x1C, 0x60, 0x3F, 0x00,
  0x03, 0x07, 0x0D, 0x39, 0x61, 0xC1, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x07, 0x00, 0xFF, 0x8E, 0x07, 0x10, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x03, 0xFF, 0xF0, 0x07, 0x00,
  0xFF, 0x8E, 0x03, 0x20, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x30, 0x03, 0x81, 0xF8,
  0x07, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xA0, 0x06, 0xE0,
  0x71, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0A, 0x00, 0x0F, 0x00,
  0x05, 0x80, 0x06, 0xC0, 0x06, 0x60, 0x02, 0x30, 0x03, 0x18, 0x01, 0x0C,
  0x01, 0x86, 0x00, 0x83, 0x00, 0xC1, 0x80, 0x40, 0xC0, 0x60, 0x60, 0x60,
  0x30, 0x20, 0x18, 0x30, 0x0C, 0x10, 0x06, 0x18, 0x03, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x3F, 0xF8, 0x80, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x10, 0x80, 0x7F, 0xE1, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x68, 0x03, 0x38, 0x18, 0x7F, 0xC0, 0x00, 0xF0, 0x07, 0xF0,
  0x38, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x7E, 0x19, 0xCE, 0x34, 0x06,
  0x70, 0x06, 0xE0, 0x0D, 0x80, 0x0B, 0x00, 0x16, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xD0, 0x01, 0xA0, 0x02, 0x60, 0x04, 0xC0, 0x18, 0x80, 0x31, 0x80,
  0xC1, 0x83, 0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x03, 0x80, 0x3F, 0xC0,
  0xC0, 0xE3, 0x00, 0xC6, 0x00, 0xC8, 0x01, 0x90, 0x03, 0x20, 0x06, 0x40,
  0x0C, 0xC0, 0x19, 0x80, 0x61, 0x80, 0x81, 0x86, 0x01, 0xD8, 0x00, 0xE0,
  0x07, 0x60, 0x18, 0x70, 0x60, 0x31, 0x80, 0x26, 0x00, 0x6C, 0x00, 0x50,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0B, 0x00, 0x33, 0x00,
  0xC3, 0x83, 0x03, 0xFC, 0x00, 0x07, 0x00, 0x7F, 0x83, 0x07, 0x18, 0x04,
  0x40, 0x1B, 0x00, 0x2C, 0x00, 0xB0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x34, 0x00, 0xD8, 0x05, 0x30, 0x34, 0xFF,
  0x90, 0xF8, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x41, 0xC1, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x67, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x26, 0x66, 0x44, 0xC8, 0x80, 0x00, 0x06, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x02, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C,
  0x00, 0x70, 0x00, 0x80, 0x00, 0x0E, 0x1F, 0xF2, 0x07, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x00,
  0x7F, 0x80, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x08,
  0x00, 0x0C, 0x18, 0x00, 0x04, 0x30, 0x00, 0x06, 0x20, 0x00, 0x02, 0x60,
  0x1F, 0x83, 0x60, 0x71, 0x83, 0x40, 0x40, 0x81, 0x40, 0xC1, 0x81, 0xC0,
  0x81, 0x81, 0xC1, 0x81, 0x81, 0xC1, 0x81, 0x81, 0xC1, 0x01, 0x81, 0xC1,
  0x01, 0x81, 0xC1, 0x01, 0x81, 0xC1, 0x01, 0x81, 0xC1, 0x01, 0x83, 0xC1,
  0x83, 0x83, 0xC1, 0x82, 0x82, 0x40, 0xC6, 0xC6, 0x40, 0x7C, 0x7C, 0x60,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x40, 0x03, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0A, 0x00, 0x06, 0x80, 0x01,
  0x30, 0x00, 0x4C, 0x00, 0x31, 0x00, 0x0C, 0x40, 0x02, 0x18, 0x00, 0x86,
  0x00, 0x60, 0x80, 0x18, 0x30, 0x04, 0x0C, 0x03, 0x01, 0x00, 0xC0, 0x40,
  0x20, 0x18, 0x08, 0x06, 0x07, 0xFF, 0x81, 0x80, 0x30, 0x40, 0x0C, 0x30,
  0x03, 0x0C, 0x00, 0x43, 0x00, 0x18, 0x80, 0x06, 0x60, 0x00, 0x98, 0x00,
  0x34, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x40, 0xFF, 0xE1, 0x80, 0x73,
  0x00, 0x36, 0x00, 0x6C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0B, 0x00, 0x36, 0x00, 0xCC, 0x03, 0x1F, 0xF8, 0x30, 0x1E,
  0x60, 0x06, 0xC0, 0x05, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1B, 0x00, 0x76, 0x07,
  0xCF, 0xFE, 0x00, 0x00, 0x38, 0x01, 0xFF, 0xC1, 0xC0, 0x41, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x30, 0x0F, 0xF8, 0xFF, 0xE0, 0x60, 0x3C, 0x30,
  0x07, 0x18, 0x01, 0xCC, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x02,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x16, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x04, 0xC0, 0x06,
  0x60, 0x06, 0x30, 0x06, 0x18, 0x7E, 0x0F, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFB, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0xDF, 0xFE, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x3F, 0xF8, 0x1C, 0x03, 0x87, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0xC0,
  0x00, 0x58, 0x00, 0x09, 0x00, 0x01, 0x30, 0x00, 0x23, 0x00, 0x04, 0x60,
  0x00, 0x87, 0x00, 0x10, 0x78, 0x0E, 0x03, 0xFF, 0x80, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x18, 0xFE,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x8F,
  0xE0, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x83, 0x06, 0x0E, 0x37, 0xC0, 0xC0, 0x07, 0x80,
  0x1B, 0x00, 0x66, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x30, 0x30, 0x60, 0x40,
  0xC1, 0x81, 0x86, 0x03, 0x18, 0x06, 0x30, 0x0C, 0xC0, 0x1B, 0xC0, 0x35,
  0x80, 0x79, 0x80, 0xE3, 0x01, 0x83, 0x03, 0x02, 0x06, 0x06, 0x0C, 0x06,
  0x18, 0x0C, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x19, 0x80, 0x13, 0x00, 0x36,
  0x00, 0x2C, 0x00, 0x60, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xF0,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x2F, 0x80, 0x00, 0x5D,
  0x00, 0x01, 0xBB, 0x00, 0x02, 0x76, 0x00, 0x04, 0xE4, 0x00, 0x19, 0xCC,
  0x00, 0x23, 0x98, 0x00, 0x47, 0x10, 0x01, 0x8E, 0x30, 0x02, 0x1C, 0x60,
  0x04, 0x38, 0x40, 0x18, 0x70, 0xC0, 0x20, 0xE1, 0x80, 0x41, 0xC1, 0x01,
  0x83, 0x83, 0x02, 0x07, 0x06, 0x04, 0x0E, 0x04, 0x18, 0x1C, 0x0C, 0x20,
  0x38, 0x18, 0x40, 0x70, 0x11, 0x80, 0xE0, 0x32, 0x01, 0xC0, 0x64, 0x03,
  0x80, 0x58, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x20,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1D, 0x80, 0x0E, 0x40,
  0x07, 0x30, 0x03, 0x88, 0x01, 0xC6, 0x00, 0xE1, 0x00, 0x70, 0xC0, 0x38,
  0x20, 0x1C, 0x18, 0x0E, 0x04, 0x07, 0x03, 0x03, 0x80, 0x81, 0xC0, 0x60,
  0xE0, 0x10, 0x70, 0x0C, 0x38, 0x02, 0x1C, 0x01, 0x8E, 0x00, 0x47, 0x00,
  0x33, 0x80, 0x09, 0xC0, 0x06, 0xE0, 0x01, 0x70, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0x3F, 0xE0, 0x0E, 0x07, 0x01, 0x80, 0x18,
  0x10, 0x00, 0xC3, 0x00, 0x0C, 0x20, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00,
  0x24, 0x00, 0x02, 0x40, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x36, 0x00, 0x02, 0x60, 0x00, 0x66,
  0x00, 0x06, 0x30, 0x00, 0x43, 0x00, 0x0C, 0x18, 0x00, 0x80, 0xC0, 0x18,
  0x07, 0x07, 0x00, 0x3F, 0xC0, 0xFF, 0xC3, 0x03, 0xCC, 0x01, 0xB0, 0x06,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0B, 0x00, 0x6C, 0x07, 0x3F, 0xF8, 0xFF, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x3F,
  0xE0, 0x0E, 0x07, 0x01, 0x80, 0x18, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x20,
  0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00,
  0x36, 0x00, 0x02, 0x60, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0x43, 0x00,
  0x0C, 0x18, 0x00, 0x80, 0xC0, 0x18, 0x07, 0x07, 0x00, 0x3F, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0xFF, 0xC1, 0x81, 0xE3, 0x00, 0x66, 0x00,
  0x4C, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x02, 0xC0, 0x0D, 0x80, 0x1B,
  0x00, 0x36, 0x00, 0x4C, 0x01, 0x98, 0x06, 0x30, 0x78, 0x7F, 0xC0, 0xC1,
  0x81, 0x81, 0x83, 0x03, 0x06, 0x03, 0x0C, 0x06, 0x18, 0x06, 0x30, 0x0C,
  0x60, 0x0C, 0xC0, 0x19, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x3C, 0x00, 0x60,
  0x03, 0x80, 0x7F, 0xF3, 0x80, 0x98, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x0E, 0xC0, 0x73, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x06, 0x80, 0x02, 0x60, 0x03, 0x30, 0x01, 0x8C, 0x01,
  0x83, 0x83, 0x80, 0xFF, 0x80, 0xC0, 0x00, 0xF0, 0x00, 0x24, 0x00, 0x09,
  0x80, 0x06, 0x60, 0x01, 0x88, 0x00, 0x42, 0x00, 0x30, 0xC0, 0x0C, 0x30,
  0x03, 0x04, 0x00, 0x81, 0x80, 0x60, 0x60, 0x18, 0x08, 0x04, 0x02, 0x01,
  0x00, 0xC0, 0xC0, 0x30, 0x30, 0x04, 0x08, 0x01, 0x06, 0x00, 0x61, 0x80,
  0x18, 0x40, 0x02, 0x10, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x04, 0x80, 0x01,
  0x20, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0,
  0x03, 0x00, 0x0B, 0x00, 0x18, 0x00, 0xD8, 0x01, 0xC0, 0x06, 0xC0, 0x0E,
  0x00, 0x22, 0x00, 0x78, 0x01, 0x10, 0x02, 0xC0, 0x18, 0xC0, 0x12, 0x00,
  0xC6, 0x01, 0x90, 0x06, 0x10, 0x0C, 0xC0, 0x20, 0x80, 0x46, 0x03, 0x06,
  0x02, 0x10, 0x18, 0x30, 0x30, 0x80, 0xC1, 0x81, 0x84, 0x04, 0x04, 0x0C,
  0x30, 0x60, 0x20, 0x41, 0x83, 0x01, 0x82, 0x04, 0x18, 0x0C, 0x30, 0x20,
  0x80, 0x21, 0x81, 0x84, 0x01, 0x08, 0x0C, 0x60, 0x0C, 0x40, 0x23, 0x00,
  0x66, 0x01, 0x18, 0x03, 0x30, 0x08, 0x80, 0x09, 0x80, 0x6C, 0x00, 0x68,
  0x03, 0x60, 0x03, 0x40, 0x0B, 0x00, 0x1E, 0x00, 0x50, 0x00, 0x70, 0x02,
  0x80, 0x03, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x60, 0x03, 0x30,
  0x06, 0x30, 0x06, 0x18, 0x0C, 0x18, 0x0C, 0x08, 0x08, 0x0C, 0x18, 0x04,
  0x10, 0x06, 0x30, 0x02, 0x20, 0x03, 0x60, 0x03, 0x40, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0x40, 0x03, 0x60, 0x02, 0x60, 0x06, 0x20, 0x04,
  0x30, 0x0C, 0x10, 0x08, 0x18, 0x18, 0x08, 0x18, 0x0C, 0x30, 0x0C, 0x30,
  0x06, 0x60, 0x06, 0x60, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x06, 0x60,
  0x06, 0x20, 0x04, 0x30, 0x0C, 0x30, 0x0C, 0x10, 0x08, 0x18, 0x18, 0x08,
  0x10, 0x0C, 0x30, 0x0C, 0x30, 0x04, 0x20, 0x06, 0x60, 0x06, 0x40, 0x02,
  0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x7F, 0xFC, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0F, 0xFF, 0xE0,
  0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xC0,
  0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0xFF, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xD0,
  0x00, 0x6C, 0x00, 0x62, 0x00, 0x31, 0x80, 0x30, 0x40, 0x18, 0x30, 0x18,
  0x08, 0x0C, 0x06, 0x0C, 0x01, 0x06, 0x00, 0xC6, 0x00, 0x23, 0x00, 0x1B,
  0x00, 0x06, 0xFF, 0xFF, 0x80, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x1F, 0x87,
  0x8E, 0x40, 0x20, 0x03, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x03, 0x0F, 0xF3, 0x81, 0x60, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38,
  0x03, 0xC0, 0x3C, 0x05, 0x60, 0x93, 0xF1, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x8F, 0x83, 0x71, 0xC6, 0x80, 0xCE, 0x00, 0x9C, 0x01, 0xB0, 0x03, 0x60,
  0x02, 0xC0, 0x05, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x02, 0xC0, 0x05, 0x80, 0x1B, 0x00, 0x37, 0x00, 0x4F,
  0x01, 0x93, 0x0E, 0x23, 0xF8, 0x00, 0x07, 0xE0, 0xE3, 0x18, 0x03, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x1C, 0x10, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x1F, 0x8C, 0x71, 0x99,
  0x80, 0xB2, 0x00, 0xEC, 0x01, 0xD0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x06, 0x80, 0x0D, 0x00, 0x3B, 0x00, 0x73, 0x01, 0x67, 0x06, 0xC3,
  0xF1, 0x80, 0x07, 0xC0, 0x73, 0x83, 0x03, 0x08, 0x06, 0x60, 0x09, 0x00,
  0x24, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x01, 0x1C, 0x18, 0x3F, 0xC0, 0x03, 0xE0, 0xC0, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x07, 0xF3, 0xFE, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x0F, 0xC6, 0x38, 0xCC, 0xC0, 0x5B, 0x00, 0x76, 0x00, 0xE8, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x40, 0x0E, 0x80, 0x1D, 0x80, 0x39,
  0x80, 0xB3, 0x82, 0x61, 0xF8, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x88, 0x07, 0x1F, 0xFC, 0x0F, 0xC0,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x3E, 0x37, 0x3D, 0xA0, 0x6E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x20, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C,
  0x30, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x2F, 0xBC, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x03, 0xC0, 0x6C, 0x0C, 0xC0,
  0xCC, 0x18, 0xC3, 0x0C, 0x20, 0xC6, 0x0C, 0xC0, 0xCC, 0x0D, 0x60, 0xF6,
  0x0E, 0x30, 0xC3, 0x0C, 0x18, 0xC1, 0x8C, 0x0C, 0xC0, 0xCC, 0x06, 0xC0,
  0x6C, 0x03, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x8F, 0x81, 0xF1, 0x31, 0xCE, 0x72, 0xC1, 0x90, 0x35, 0x01, 0xC0, 0x6C,
  0x03, 0x80, 0x58, 0x06, 0x00, 0xF0, 0x04, 0x01, 0xE0, 0x08, 0x03, 0xC0,
  0x10, 0x07, 0x80, 0x20, 0x0F, 0x00, 0x40, 0x1E, 0x00, 0x80, 0x3C, 0x01,
  0x00, 0x78, 0x02, 0x00, 0xF0, 0x04, 0x01, 0xE0, 0x08, 0x03, 0xC0, 0x10,
  0x07, 0x80, 0x20, 0x0F, 0x00, 0x40, 0x1E, 0x00, 0x80, 0x3C, 0x01, 0x00,
  0x78, 0x02, 0x00, 0xC0, 0x87, 0xC4, 0xE7, 0xA4, 0x0D, 0x40, 0x3A, 0x01,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x04, 0x07, 0xC0, 0x38, 0xE0, 0xC0, 0x63, 0x00, 0x66,
  0x00, 0xC8, 0x00, 0xB0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x40, 0x04,
  0xC0, 0x19, 0x80, 0x31, 0x80, 0xC1, 0x83, 0x01, 0xFC, 0x00, 0x87, 0xC1,
  0x18, 0xE2, 0x40, 0x65, 0x00, 0x4A, 0x00, 0xD8, 0x01, 0xB0, 0x01, 0x60,
  0x02, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0x60, 0x02, 0xC0, 0x0D, 0xC0, 0x1B, 0x80, 0x27, 0x80, 0xCD,
  0x83, 0x19, 0xFC, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x0F, 0xC6,
  0x38, 0xCC, 0xC0, 0x59, 0x00, 0x76, 0x00, 0xE8, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0E, 0x80, 0x1D, 0x80, 0x39, 0x80, 0xB3,
  0x86, 0x61, 0xF8, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x87, 0xCF,
  0xE4, 0x14, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x1F,
  0xCE, 0x1F, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x20, 0x04,
  0x01, 0xC0, 0x3C, 0x1D, 0xFF, 0x00, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0xFF, 0xFE, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x07,
  0xE0, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0A, 0xC0, 0xD7, 0x0C, 0x9F,
  0xC4, 0xC0, 0x07, 0x00, 0x34, 0x00, 0xD8, 0x02, 0x60, 0x18, 0x80, 0x62,
  0x01, 0x0C, 0x04, 0x30, 0x30, 0x40, 0xC1, 0x82, 0x06, 0x18, 0x08, 0x60,
  0x21, 0x00, 0xC4, 0x03, 0x30, 0x04, 0xC0, 0x12, 0x00, 0x68, 0x00, 0xE0,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x18, 0x02, 0x80, 0x30, 0x05, 0x80, 0x60,
  0x1B, 0x01, 0xE0, 0x36, 0x03, 0x40, 0x44, 0x04, 0x80, 0x88, 0x09, 0x01,
  0x18, 0x33, 0x06, 0x30, 0x66, 0x0C, 0x20, 0x84, 0x10, 0x41, 0x08, 0x20,
  0xC6, 0x18, 0xC1, 0x8C, 0x31, 0x81, 0x10, 0x22, 0x02, 0x20, 0x44, 0x06,
  0xC0, 0xD8, 0x0D, 0x81, 0xB0, 0x0B, 0x01, 0x40, 0x14, 0x02, 0x80, 0x38,
  0x05, 0x00, 0x70, 0x0E, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x19, 0x00, 0x66,
  0x03, 0x0C, 0x0C, 0x30, 0x60, 0x61, 0x81, 0x8C, 0x03, 0x20, 0x05, 0x80,
  0x1C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x80, 0x36, 0x00, 0x8C, 0x06, 0x30,
  0x10, 0x60, 0xC1, 0x82, 0x03, 0x18, 0x04, 0x40, 0x1B, 0x00, 0x30, 0x40,
  0x06, 0x80, 0x09, 0x80, 0x33, 0x00, 0x62, 0x00, 0x86, 0x01, 0x0C, 0x06,
  0x08, 0x0C, 0x10, 0x10, 0x30, 0x60, 0x20, 0xC0, 0x41, 0x00, 0xC2, 0x01,
  0x8C, 0x01, 0x10, 0x02, 0x20, 0x06, 0xC0, 0x05, 0x80, 0x0A, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x3E, 0x00, 0x78, 0x00, 0x7F,
  0xEF, 0xFC, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0xFF, 0xC0, 0x03, 0xC1, 0xC0, 0x40, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x60, 0x38, 0x38, 0x07, 0x00, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01,
  0x80, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x0E, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x18, 0x03, 0x00, 0x30,
  0x38, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x06, 0x0F, 0x00, 0x7E, 0x03, 0x87,
  0x0E, 0x03, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraLight41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 29, 9, 3, -29 },
  { 12, 7, 10, 13, 3, -29 },
  { 21, 18, 29, 20, 1, -29 },
  { 87, 14, 33, 19, 2, -31 },
  { 145, 23, 30, 27, 2, -30 },
  { 232, 18, 30, 20, 2, -30 },
  { 300, 2, 10, 7, 3, -29 },
  { 303, 7, 35, 11, 2, -29 },
  { 334, 7, 35, 11, 2, -29 },
  { 365, 13, 13, 17, 2, -31 },
  { 387, 15, 19, 19, 2, -24 },
  { 423, 3, 9, 8, 2, -4 },
  { 427, 9, 2, 12, 1, -12 },
  { 430, 2, 3, 8, 3, -3 },
  { 431, 12, 29, 14, 1, -29 },
  { 475, 14, 30, 19, 2, -30 },
  { 528, 8, 29, 19, 3, -29 },
  { 557, 14, 30, 19, 2, -30 },
  { 610, 14, 30, 19, 2, -30 },
  { 663, 17, 29, 19, 1, -29 },
  { 725, 14, 29, 19, 2, -29 },
  { 776, 15, 30, 19, 2, -30 },
  { 833, 14, 29, 19, 2, -29 },
  { 884, 15, 30, 19, 2, -30 },
  { 941, 14, 30, 19, 2, -30 },
  { 994, 2, 22, 8, 3, -22 },
  { 1000, 4, 27, 8, 2, -22 },
  { 1014, 15, 17, 19, 2, -23 },
  { 1046, 15, 10, 19, 2, -19 },
  { 1065, 15, 17, 19, 2, -23 },
  { 1097, 11, 30, 13, 1, -30 },
  { 1139, 24, 33, 28, 2, -29 },
  { 1238, 18, 29, 18, 0, -29 },
  { 1304, 15, 29, 20, 3, -29 },
  { 1359, 17, 30, 20, 2, -30 },
  { 1423, 17, 29, 22, 3, -29 },
  { 1485, 13, 29, 18, 3, -29 },
  { 1533, 13, 29, 16, 3, -29 },
  { 1581, 19, 30, 24, 2, -30 },
  { 1653, 17, 29, 23, 3, -29 },
  { 1715, 7, 29, 10, 2, -29 },
  { 1741, 7, 36, 8, -2, -29 },
  { 1773, 15, 29, 18, 3, -29 },
  { 1828, 12, 29, 16, 3, -29 },
  { 1872, 23, 29, 30, 3, -29 },
  { 1956, 17, 29, 24, 3, -29 },
  { 2018, 20, 30, 24, 2, -30 },
  { 2093, 14, 29, 19, 3, -29 },
  { 2144, 20, 37, 24, 2, -30 },
  { 2237, 15, 29, 19, 3, -29 },
  { 2292, 14, 30, 18, 2, -30 },
  { 2345, 16, 29, 16, 0, -29 },
  { 2403, 17, 29, 23, 3, -29 },
  { 2465, 18, 29, 18, 0, -29 },
  { 2531, 29, 29, 30, 0, -29 },
  { 2637, 16, 29, 16, 0, -29 },
  { 2695, 16, 29, 16, 0, -29 },
  { 2753, 15, 29, 17, 1, -29 },
  { 2808, 8, 35, 13, 3, -29 },
  { 2843, 12, 29, 14, 1, -29 },
  { 2887, 8, 35, 13, 1, -29 },
  { 2922, 17, 15, 19, 1, -29 },
  { 2954, 17, 1, 16, 0, 4 },
  { 2957, 6, 6, 10, 2, -31 },
  { 2962, 12, 22, 17, 2, -22 },
  { 2995, 15, 31, 20, 3, -31 },
  { 3054, 12, 22, 15, 2, -22 },
  { 3087, 15, 31, 20, 2, -31 },
  { 3146, 14, 22, 18, 2, -22 },
  { 3185, 11, 31, 10, 0, -31 },
  { 3228, 15, 32, 20, 2, -22 },
  { 3288, 13, 31, 19, 3, -31 },
  { 3339, 2, 30, 8, 3, -30 },
  { 3347, 6, 40, 8, -1, -30 },
  { 3377, 12, 31, 16, 3, -31 },
  { 3424, 2, 31, 8, 3, -31 },
  { 3432, 23, 22, 29, 3, -22 },
  { 3496, 13, 22, 19, 3, -22 },
  { 3532, 15, 22, 19, 2, -22 },
  { 3574, 15, 32, 20, 3, -22 },
  { 3634, 15, 32, 20, 2, -22 },
  { 3694, 9, 22, 12, 3, -22 },
  { 3719, 11, 22, 15, 2, -22 },
  { 3750, 9, 27, 10, 1, -27 },
  { 3781, 13, 22, 19, 3, -22 },
  { 3817, 14, 22, 14, 0, -22 },
  { 3856, 23, 22, 24, 0, -22 },
  { 3920, 14, 22, 15, 1, -22 },
  { 3959, 15, 32, 15, 0, -22 },
  { 4019, 11, 22, 13, 1, -22 },
  { 4050, 10, 35, 14, 2, -29 },
  { 4094, 2, 41, 18, 8, -31 },
  { 4105, 10, 35, 14, 2, -29 },
  { 4149, 15, 3, 19, 2, -16 },
};

const GFXfont NotoSans_Condensed_ExtraLight41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight41pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT41PT7B_H_
