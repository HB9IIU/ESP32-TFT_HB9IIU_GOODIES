#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT6PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x57, 0xE0, 0x69, 0xC0, 0xEE, 0x57, 0xCB, 0xF0, 0x80,
  0xF8, 0xF8, 0x70, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x5A, 0xFF, 0xD5, 0xD7,
  0xD7, 0x5B, 0xA0, 0xF7, 0xFF, 0xD5, 0xFF, 0xF7, 0xA0, 0xB0, 0xEC, 0xFC,
  0xF8, 0xD8, 0xFF, 0xF8, 0x60, 0x5A, 0xD0, 0xFE, 0xF0, 0xF2, 0x70, 0xF6,
  0xF0, 0xFB, 0xFA, 0xF2, 0xF0, 0xBE, 0xD0, 0xF0, 0xF8, 0xF3, 0x50, 0xAB,
  0x9B, 0xFD, 0xBE, 0xD0, 0xF6, 0xF0, 0xF7, 0x40, 0xF6, 0xF2, 0xF7, 0x50,
  0xE7, 0xD5, 0xB6, 0xF0, 0xB7, 0x20, 0xDB, 0x55, 0xD7, 0xD5, 0xDB, 0xEA,
  0xC0, 0xA5, 0xF8, 0x54, 0xC0, 0x80, 0xFC, 0x9A, 0xDE, 0xEC, 0x5F, 0xC0,
  0xEC, 0x6A, 0x80, 0xFF, 0xAF, 0xC0, 0xF0, 0xF8, 0xAE, 0xC0, 0xF8, 0xFB,
  0xB0, 0xFC, 0xFC, 0xF7, 0xC0, 0xFD, 0xE8, 0xDC, 0xF0, 0xFC, 0xF8, 0xF6,
  0x80, 0xDC, 0xDA, 0xEC, 0xEA, 0x40, 0xFC, 0xD5, 0xC0, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraLight6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 2, 1, 2, 0, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 2, 5, 3, 0, -5 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 1, 1, 0, -4 },
  { 12, 1, 5, 2, 0, -4 },
  { 13, 1, 5, 2, 0, -4 },
  { 14, 2, 2, 2, 0, -5 },
  { 15, 3, 3, 3, 0, -4 },
  { 17, 1, 2, 1, 0, -1 },
  { 18, 2, 1, 2, 0, -2 },
  { 19, 1, 1, 1, 0, -1 },
  { 20, 2, 4, 2, 0, -4 },
  { 21, 2, 4, 3, 0, -4 },
  { 22, 2, 4, 3, 0, -4 },
  { 23, 2, 4, 3, 0, -4 },
  { 24, 2, 4, 3, 0, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 2, 4, 3, 0, -4 },
  { 28, 2, 4, 3, 0, -4 },
  { 29, 2, 4, 3, 0, -4 },
  { 30, 2, 4, 3, 0, -4 },
  { 31, 2, 4, 3, 0, -4 },
  { 32, 1, 3, 1, 0, -3 },
  { 33, 1, 4, 1, 0, -3 },
  { 34, 3, 2, 3, 0, -3 },
  { 35, 3, 2, 3, 0, -3 },
  { 36, 3, 2, 3, 0, -3 },
  { 37, 2, 4, 2, 0, -4 },
  { 38, 4, 5, 4, 0, -4 },
  { 41, 3, 4, 3, 0, -4 },
  { 43, 3, 4, 3, 0, -4 },
  { 45, 3, 4, 3, 0, -4 },
  { 47, 3, 4, 3, 0, -4 },
  { 49, 2, 4, 3, 0, -4 },
  { 50, 2, 4, 2, 0, -4 },
  { 51, 3, 4, 4, 0, -4 },
  { 53, 3, 4, 3, 0, -4 },
  { 55, 1, 4, 2, 0, -4 },
  { 56, 1, 5, 1, 0, -4 },
  { 57, 3, 4, 3, 0, -4 },
  { 59, 2, 4, 2, 0, -4 },
  { 60, 4, 4, 4, 0, -4 },
  { 62, 3, 4, 3, 0, -4 },
  { 64, 3, 4, 4, 0, -4 },
  { 66, 3, 4, 3, 0, -4 },
  { 68, 3, 5, 4, 0, -4 },
  { 70, 3, 4, 3, 0, -4 },
  { 72, 2, 4, 3, 0, -4 },
  { 73, 2, 4, 2, 0, -4 },
  { 74, 3, 4, 3, 0, -4 },
  { 76, 3, 4, 3, 0, -4 },
  { 78, 4, 4, 4, 0, -4 },
  { 80, 2, 4, 2, 0, -4 },
  { 81, 2, 4, 2, 0, -4 },
  { 82, 2, 4, 2, 0, -4 },
  { 83, 2, 5, 2, 0, -4 },
  { 85, 2, 4, 2, 0, -4 },
  { 86, 1, 5, 2, 0, -4 },
  { 87, 3, 2, 3, 0, -4 },
  { 88, 2, 1, 2, 0, 0 },
  { 89, 1, 1, 1, 0, -5 },
  { 90, 2, 3, 3, 0, -3 },
  { 91, 3, 5, 3, 0, -5 },
  { 93, 2, 3, 2, 0, -3 },
  { 94, 2, 5, 3, 0, -5 },
  { 96, 2, 3, 3, 0, -3 },
  { 97, 2, 5, 1, 0, -5 },
  { 99, 2, 4, 3, 0, -3 },
  { 100, 2, 5, 3, 0, -5 },
  { 102, 1, 4, 1, 0, -4 },
  { 103, 1, 5, 1, 0, -4 },
  { 104, 2, 5, 2, 0, -5 },
  { 106, 1, 5, 1, 0, -5 },
  { 107, 4, 3, 4, 0, -3 },
  { 109, 2, 3, 3, 0, -3 },
  { 110, 2, 3, 3, 0, -3 },
  { 111, 3, 4, 3, 0, -3 },
  { 113, 2, 4, 3, 0, -3 },
  { 114, 2, 3, 2, 0, -3 },
  { 115, 2, 3, 2, 0, -3 },
  { 116, 1, 4, 2, 0, -4 },
  { 117, 2, 3, 3, 0, -3 },
  { 118, 2, 3, 2, 0, -3 },
  { 119, 3, 3, 4, 0, -3 },
  { 121, 2, 3, 2, 0, -3 },
  { 122, 2, 4, 2, 0, -3 },
  { 123, 2, 3, 2, 0, -3 },
  { 124, 2, 5, 2, 0, -4 },
  { 126, 1, 6, 3, 1, -5 },
  { 127, 2, 5, 2, 0, -4 },
  { 129, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_ExtraLight6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight6pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT6PT7B_H_
