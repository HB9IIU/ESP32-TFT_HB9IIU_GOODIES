#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT9PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xC0, 0x5F, 0x5F, 0x66, 0x6C, 0xC6, 0x55, 0xE4, 0x45, 0xAD,
  0x77, 0x9D, 0x60, 0x46, 0x64, 0xB9, 0xF0, 0xC0, 0x6A, 0xA4, 0xD5, 0x5C,
  0x5D, 0x80, 0x2F, 0x22, 0xC0, 0xC0, 0x80, 0x29, 0x29, 0x00, 0x69, 0x99,
  0x99, 0x60, 0xFC, 0x61, 0x12, 0x24, 0xF0, 0x69, 0x16, 0x11, 0xE0, 0x26,
  0x6A, 0x72, 0xE8, 0x61, 0x1E, 0x24, 0x86, 0x99, 0x70, 0xF2, 0x22, 0x44,
  0x69, 0x96, 0x99, 0xF0, 0x69, 0x99, 0x71, 0x60, 0x88, 0x8C, 0x3C, 0x61,
  0xFF, 0xC3, 0x68, 0xC4, 0xA4, 0x10, 0x7A, 0x5B, 0x6D, 0xBD, 0x03, 0x00,
  0x26, 0x66, 0x99, 0xF7, 0x5B, 0xC0, 0x34, 0x88, 0x88, 0x70, 0xF6, 0xDB,
  0xC0, 0xEE, 0xB0, 0xEE, 0xA0, 0x3A, 0x21, 0x28, 0xC5, 0xE0, 0xB7, 0xDB,
  0x40, 0xD5, 0x70, 0x55, 0x57, 0xBA, 0x6D, 0x40, 0xAA, 0xB0, 0x8C, 0x67,
  0xBE, 0xD4, 0xB7, 0xFB, 0x40, 0x32, 0x63, 0x18, 0xC5, 0xC0, 0xF6, 0xE9,
  0x00, 0x32, 0x63, 0x18, 0xC5, 0xC2, 0x10, 0xF6, 0xEB, 0x40, 0x68, 0x86,
  0x11, 0xE0, 0xF4, 0x44, 0x44, 0xB6, 0xDB, 0xC0, 0x99, 0xA6, 0x64, 0x96,
  0xDB, 0x5B, 0x49, 0x20, 0xA6, 0x44, 0xA9, 0xB5, 0x24, 0x80, 0xE5, 0x25,
  0xC0, 0xEA, 0xAC, 0x89, 0x22, 0x40, 0xD5, 0x5C, 0x66, 0x90, 0xF0, 0x90,
  0x65, 0xDE, 0x93, 0x5B, 0x78, 0x72, 0x46, 0x11, 0x79, 0x99, 0x70, 0x77,
  0xC6, 0x6E, 0xA8, 0x79, 0x99, 0x71, 0x70, 0x93, 0x5B, 0x68, 0xBE, 0xBF,
  0x80, 0xAE, 0xBC, 0xFE, 0xF5, 0x6B, 0x5A, 0x80, 0xD6, 0xDA, 0x69, 0x99,
  0x70, 0xD6, 0xDF, 0x20, 0x79, 0x99, 0x71, 0x10, 0xEA, 0x80, 0x71, 0x1E,
  0xBA, 0xB0, 0xB6, 0xDE, 0xB6, 0xA4, 0xAD, 0x6A, 0xA5, 0x00, 0xA9, 0x2A,
  0xB6, 0xA4, 0xB0, 0xE9, 0x2E, 0x69, 0x44, 0x98, 0xFF, 0x80, 0xC9, 0x14,
  0xB0, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraLight9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 1, 2, 3, 1, -6 },
  { 3, 4, 6, 4, 0, -6 },
  { 6, 4, 8, 4, 0, -7 },
  { 10, 5, 7, 6, 0, -7 },
  { 15, 4, 7, 4, 0, -7 },
  { 19, 1, 2, 2, 0, -6 },
  { 20, 2, 7, 2, 0, -6 },
  { 22, 2, 7, 2, 0, -6 },
  { 24, 3, 3, 4, 0, -7 },
  { 26, 4, 4, 4, 0, -5 },
  { 28, 1, 2, 2, 0, -1 },
  { 29, 2, 1, 3, 0, -3 },
  { 30, 1, 1, 2, 0, -1 },
  { 31, 3, 6, 3, 0, -6 },
  { 34, 4, 7, 4, 0, -7 },
  { 38, 1, 6, 4, 1, -6 },
  { 39, 4, 7, 4, 0, -7 },
  { 43, 4, 7, 4, 0, -7 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 7, 4, 0, -7 },
  { 57, 4, 6, 4, 0, -6 },
  { 60, 4, 7, 4, 0, -7 },
  { 64, 4, 7, 4, 0, -7 },
  { 68, 1, 5, 2, 0, -5 },
  { 69, 1, 6, 2, 0, -5 },
  { 70, 4, 4, 4, 0, -5 },
  { 72, 4, 2, 4, 0, -4 },
  { 73, 4, 4, 4, 0, -5 },
  { 75, 3, 7, 3, 0, -7 },
  { 78, 6, 7, 6, 0, -6 },
  { 84, 4, 6, 4, 0, -6 },
  { 87, 3, 6, 4, 1, -6 },
  { 90, 4, 7, 4, 0, -7 },
  { 94, 3, 6, 5, 1, -6 },
  { 97, 2, 6, 4, 1, -6 },
  { 99, 2, 6, 4, 1, -6 },
  { 101, 5, 7, 5, 0, -7 },
  { 106, 3, 6, 5, 1, -6 },
  { 109, 2, 6, 2, 0, -6 },
  { 111, 2, 8, 2, -1, -6 },
  { 113, 3, 6, 4, 1, -6 },
  { 116, 2, 6, 4, 1, -6 },
  { 118, 5, 6, 6, 1, -6 },
  { 122, 3, 6, 5, 1, -6 },
  { 125, 5, 7, 5, 0, -7 },
  { 130, 3, 6, 4, 1, -6 },
  { 133, 5, 9, 5, 0, -7 },
  { 139, 3, 6, 4, 1, -6 },
  { 142, 4, 7, 4, 0, -7 },
  { 146, 4, 6, 4, 0, -6 },
  { 149, 3, 6, 5, 1, -6 },
  { 152, 4, 6, 4, 0, -6 },
  { 155, 6, 6, 7, 0, -6 },
  { 160, 4, 6, 4, 0, -6 },
  { 163, 3, 6, 3, 0, -6 },
  { 166, 3, 6, 4, 0, -6 },
  { 169, 2, 7, 3, 1, -6 },
  { 171, 3, 6, 3, 0, -6 },
  { 174, 2, 7, 3, 0, -6 },
  { 176, 4, 3, 4, 0, -6 },
  { 178, 4, 1, 4, 0, 0 },
  { 179, 2, 2, 2, 0, -7 },
  { 180, 3, 5, 4, 0, -5 },
  { 182, 3, 7, 4, 1, -7 },
  { 185, 3, 5, 3, 0, -5 },
  { 187, 4, 7, 4, 0, -7 },
  { 191, 3, 5, 4, 0, -5 },
  { 193, 2, 7, 2, 0, -7 },
  { 195, 4, 7, 4, 0, -5 },
  { 199, 3, 7, 4, 1, -7 },
  { 202, 1, 7, 2, 0, -7 },
  { 203, 1, 9, 2, 0, -7 },
  { 205, 2, 7, 3, 1, -7 },
  { 207, 1, 7, 2, 0, -7 },
  { 208, 5, 5, 6, 1, -5 },
  { 212, 3, 5, 4, 1, -5 },
  { 214, 4, 5, 4, 0, -5 },
  { 217, 3, 7, 4, 1, -5 },
  { 220, 4, 7, 4, 0, -5 },
  { 224, 2, 5, 3, 1, -5 },
  { 226, 3, 5, 3, 0, -5 },
  { 228, 2, 6, 2, 0, -6 },
  { 230, 3, 5, 4, 1, -5 },
  { 232, 3, 5, 3, 0, -5 },
  { 234, 5, 5, 5, 0, -5 },
  { 238, 3, 5, 3, 0, -5 },
  { 240, 3, 7, 3, 0, -5 },
  { 243, 3, 5, 3, 0, -5 },
  { 245, 3, 7, 3, 0, -6 },
  { 248, 1, 9, 4, 1, -7 },
  { 250, 3, 7, 3, 0, -6 },
  { 253, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_Condensed_ExtraLight9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight9pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT9PT7B_H_
