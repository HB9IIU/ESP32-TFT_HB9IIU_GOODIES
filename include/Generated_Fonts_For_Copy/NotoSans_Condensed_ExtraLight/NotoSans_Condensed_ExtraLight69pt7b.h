#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT69PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight69pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x63, 0x18, 0xC6,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x7B, 0xFE, 0xF0, 0xE0, 0x7E, 0x07, 0xE0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x38, 0x01, 0x80, 0x00, 0x38, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00, 0x70, 0x03, 0x00, 0x00,
  0x60, 0x07, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xE0, 0x06, 0x00, 0x00,
  0xE0, 0x06, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00,
  0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x0C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01,
  0x80, 0x1C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x80, 0x18, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x03, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x3E, 0x63,
  0xF8, 0x3C, 0x30, 0x18, 0x38, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x1C, 0x06,
  0x00, 0x1C, 0x03, 0x00, 0x0E, 0x01, 0x80, 0x07, 0x00, 0xC0, 0x03, 0x00,
  0x60, 0x01, 0x80, 0x30, 0x00, 0xE0, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x38,
  0x06, 0x00, 0x0C, 0x03, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0xC0, 0x00,
  0xF0, 0x60, 0x00, 0x3E, 0x30, 0x00, 0x07, 0x98, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xCF,
  0x80, 0x00, 0x63, 0xE0, 0x00, 0x30, 0x78, 0x00, 0x18, 0x1E, 0x00, 0x0C,
  0x07, 0x80, 0x06, 0x01, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x38, 0x00,
  0xC0, 0x1C, 0x00, 0x60, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x18, 0x03, 0x80,
  0x0C, 0x01, 0x80, 0x06, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x01, 0x80, 0xE4,
  0x00, 0xC0, 0xF3, 0x80, 0x60, 0xF1, 0xFC, 0x33, 0xF0, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0,
  0x00, 0x02, 0x00, 0x1F, 0xE0, 0x00, 0x18, 0x00, 0x70, 0xE0, 0x00, 0x70,
  0x01, 0xC0, 0xE0, 0x00, 0xC0, 0x03, 0x80, 0xC0, 0x01, 0x80, 0x06, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x38,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x01, 0x80,
  0x1C, 0x03, 0x80, 0x07, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x00, 0x70, 0x1C,
  0x00, 0x1C, 0x00, 0xE0, 0x30, 0x00, 0x38, 0x01, 0xC0, 0x60, 0x00, 0x70,
  0x03, 0x81, 0xC0, 0x00, 0xE0, 0x07, 0x03, 0x00, 0x01, 0xC0, 0x0E, 0x0E,
  0x00, 0x03, 0x80, 0x1C, 0x18, 0x00, 0x07, 0x00, 0x38, 0x30, 0x00, 0x06,
  0x00, 0x70, 0xE0, 0xFC, 0x0C, 0x00, 0xC1, 0x83, 0xFC, 0x18, 0x01, 0x87,
  0x0E, 0x1C, 0x30, 0x03, 0x0E, 0x38, 0x1C, 0x70, 0x0E, 0x18, 0x60, 0x18,
  0x60, 0x18, 0x70, 0xC0, 0x38, 0xE0, 0x30, 0xC3, 0x80, 0x70, 0xC0, 0xE3,
  0x86, 0x00, 0x61, 0xE7, 0x87, 0x0C, 0x00, 0xC1, 0xFE, 0x0C, 0x18, 0x01,
  0x80, 0xF0, 0x38, 0x30, 0x03, 0x80, 0x00, 0x60, 0xE0, 0x07, 0x00, 0x01,
  0xC1, 0xC0, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x1C, 0x00, 0x06, 0x07, 0x00,
  0x38, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x00, 0x30, 0x1C, 0x00, 0xE0, 0x00,
  0xE0, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x03, 0x00, 0x60,
  0x07, 0x00, 0x0E, 0x00, 0xC0, 0x0E, 0x00, 0x18, 0x01, 0x80, 0x18, 0x00,
  0x70, 0x03, 0x00, 0x30, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x01, 0xC0, 0x07, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x00, 0x1C, 0x0E, 0x00,
  0x18, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x00, 0x1F, 0xF0, 0x00, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x60, 0x01, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x0E,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x03, 0x00, 0x30, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0C, 0x1C, 0x00,
  0x00, 0x1C, 0x70, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x00, 0x70, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x01, 0x87,
  0x00, 0xE0, 0x07, 0x1C, 0x00, 0xE0, 0x0E, 0x38, 0x00, 0xE0, 0x1C, 0x60,
  0x01, 0xC0, 0x31, 0xC0, 0x01, 0xC0, 0x63, 0x80, 0x01, 0xC1, 0xC7, 0x00,
  0x01, 0x83, 0x8C, 0x00, 0x03, 0x86, 0x18, 0x00, 0x03, 0x9C, 0x30, 0x00,
  0x03, 0xB0, 0x60, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x1E, 0x03, 0x00, 0x00, 0x7E, 0x07, 0x00, 0x01,
  0xEE, 0x07, 0x00, 0x07, 0x8C, 0x0F, 0x00, 0x1E, 0x1C, 0x0F, 0x00, 0xF8,
  0x1C, 0x0F, 0xFF, 0xC0, 0x1C, 0x07, 0xFE, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x00, 0xFF, 0xFD, 0xB6, 0xDB, 0x6D, 0xB6, 0xD8, 0x00, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0xE0, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x1C,
  0x0C, 0x07, 0xFC, 0x30, 0xFC, 0x7E, 0xDF, 0xC0, 0x3F, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xB0, 0x00, 0x1C, 0x60, 0x00, 0x61, 0xC0,
  0x03, 0x03, 0x00, 0x1C, 0x06, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x38, 0x0C,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x1C, 0x71,
  0xC7, 0x38, 0xE3, 0x8E, 0x31, 0xC7, 0x18, 0x63, 0x8C, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFD,
  0xF8, 0x00, 0xF0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x70,
  0x00, 0x70, 0x38, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0x86, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39,
  0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x30, 0x00, 0x01,
  0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3B, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0x38,
  0x00, 0x01, 0x9C, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x0C, 0x38, 0x00, 0x0E,
  0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x01,
  0xC0, 0x70, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x07, 0x81, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x38, 0x03, 0xC0,
  0x7E, 0x07, 0xF0, 0x7B, 0x87, 0x9C, 0x70, 0xE7, 0x07, 0xF0, 0x3F, 0x01,
  0xD0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xEF,
  0xE0, 0x7C, 0x00, 0xF0, 0x30, 0x00, 0x78, 0x20, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xEF, 0xE0, 0x7C, 0x00, 0xF0, 0xF0, 0x00,
  0x38, 0x40, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x78, 0xF8, 0x01, 0xF0, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x01, 0xF4, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x19, 0xC0,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x06, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38,
  0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x18, 0x0E, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x00, 0xE0, 0x00,
  0x70, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0xE0, 0x06, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x07,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x18, 0x00,
  0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x20, 0x00, 0x6F, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x78, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0xC0, 0x00, 0xF0, 0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8,
  0x01, 0xE0, 0x04, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0xFF, 0x80, 0xE3, 0xFF, 0xE0, 0xC7, 0x81, 0xF0,
  0xCE, 0x00, 0x78, 0xCC, 0x00, 0x3C, 0xD8, 0x00, 0x1C, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0x60, 0x00, 0x07, 0x70, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x38, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x38,
  0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFD, 0xFC, 0x01, 0xE0, 0x0F, 0x01, 0xE0,
  0x01, 0xC0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0C, 0x30,
  0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x0F, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0xE0,
  0x1E, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x1E, 0x70, 0x00, 0x07, 0x30, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x70, 0x70, 0x00,
  0x70, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xEF, 0xE0, 0x0F,
  0x00, 0xF0, 0x1C, 0x00, 0x78, 0x38, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70,
  0x00, 0x0F, 0x70, 0x00, 0x0B, 0x38, 0x00, 0x1B, 0x3C, 0x00, 0x33, 0x1E,
  0x00, 0x73, 0x0F, 0x83, 0xE3, 0x07, 0xFF, 0x87, 0x01, 0xFE, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x20,
  0x0F, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x6F,
  0xFF, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x18, 0xF3, 0xCF, 0x3C, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x1C, 0x73, 0x8E, 0x38, 0xE3, 0x1C,
  0x71, 0x86, 0x38, 0xC3, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x07, 0xFF, 0xC3, 0xFD, 0xFC, 0x38, 0x03, 0xC4, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x0C, 0x00, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x18, 0x00,
  0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x3F, 0xE0,
  0x06, 0x30, 0x00, 0xFF, 0xF0, 0x06, 0x70, 0x01, 0xE0, 0x30, 0x07, 0x70,
  0x03, 0x80, 0x30, 0x07, 0x60, 0x07, 0x00, 0x70, 0x07, 0xE0, 0x06, 0x00,
  0x70, 0x03, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0xC0, 0x0C, 0x00, 0x70, 0x03, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x18, 0x00, 0x70,
  0x03, 0xC0, 0x18, 0x00, 0x70, 0x03, 0xC0, 0x18, 0x00, 0x60, 0x03, 0xC0,
  0x18, 0x00, 0x60, 0x03, 0xC0, 0x18, 0x00, 0x60, 0x03, 0xC0, 0x18, 0x00,
  0x60, 0x07, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0xC0, 0x1C, 0x00, 0xE0, 0x06,
  0xC0, 0x1C, 0x00, 0xE0, 0x06, 0xC0, 0x0C, 0x01, 0xB0, 0x0E, 0xE0, 0x0E,
  0x01, 0xB0, 0x0C, 0xE0, 0x0E, 0x03, 0x38, 0x1C, 0x60, 0x07, 0x87, 0x1C,
  0x38, 0x60, 0x03, 0xFE, 0x1F, 0xF0, 0x70, 0x01, 0xFC, 0x0F, 0xE0, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03, 0x98, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x38, 0x60, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x07, 0x03, 0x00, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0xE0, 0x18, 0x00, 0x01, 0x80, 0x38, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30,
  0x01, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00,
  0x60, 0x06, 0x00, 0x00, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x1C, 0x0C, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x03, 0x98, 0x00, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x30, 0x00, 0xFE, 0x18, 0x00, 0x0F, 0x8C, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x39, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x60,
  0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x0E,
  0x60, 0x00, 0x07, 0x30, 0x00, 0x07, 0x18, 0x00, 0x07, 0x8C, 0x00, 0x07,
  0x86, 0x00, 0x0F, 0x83, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xC0, 0x07,
  0xF0, 0x60, 0x00, 0x3C, 0x30, 0x00, 0x07, 0x18, 0x00, 0x01, 0xCC, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x03, 0xD8, 0x00, 0x01,
  0xCC, 0x00, 0x01, 0xC6, 0x00, 0x03, 0xC3, 0x00, 0x3F, 0xC1, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0x7F, 0x80, 0x7C, 0x00, 0x70, 0x1E, 0x00, 0x02, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x08, 0x07, 0xE0, 0x0F, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xC0, 0x07, 0xF0, 0x0C, 0x00, 0x0F, 0x80,
  0xC0, 0x00, 0x3C, 0x0C, 0x00, 0x01, 0xE0, 0xC0, 0x00, 0x0F, 0x0C, 0x00,
  0x00, 0x70, 0xC0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x01,
  0xCC, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x0E, 0xC0,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x1C, 0xC0,
  0x00, 0x01, 0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x8C, 0x00, 0x00,
  0x70, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x7C, 0x0C,
  0x00, 0x1F, 0x00, 0xC0, 0x3F, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x06, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x07, 0x30, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x07, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0,
  0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x87, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x30, 0xF9, 0xFF, 0x8F, 0xF0, 0x00,
  0xC0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x30, 0x00, 0x07, 0x18, 0x00, 0x07,
  0x8C, 0x00, 0x03, 0x86, 0x00, 0x03, 0x83, 0x00, 0x03, 0x81, 0x80, 0x01,
  0xC0, 0xC0, 0x01, 0xC0, 0x60, 0x01, 0xC0, 0x30, 0x01, 0xE0, 0x18, 0x00,
  0xE0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0xF0, 0x03, 0x00, 0x70, 0x01, 0x80,
  0x70, 0x00, 0xC0, 0x70, 0x00, 0x60, 0x78, 0x00, 0x30, 0x38, 0x00, 0x18,
  0x38, 0x00, 0x0C, 0x3C, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x1F, 0x00, 0x01,
  0x9F, 0xC0, 0x00, 0xCC, 0xE0, 0x00, 0x6E, 0x38, 0x00, 0x3E, 0x1C, 0x00,
  0x1E, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x06, 0x00, 0xE0, 0x03, 0x00, 0x70,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x03, 0x80, 0x30, 0x00,
  0xE0, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x03, 0x00,
  0x03, 0x81, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x30,
  0x00, 0x0E, 0x18, 0x00, 0x03, 0x8C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x73,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xD8, 0x00, 0x00, 0x00,
  0xFF, 0x70, 0x00, 0x00, 0x03, 0xFD, 0xC0, 0x00, 0x00, 0x0D, 0xF3, 0x00,
  0x00, 0x00, 0x77, 0xCE, 0x00, 0x00, 0x01, 0xDF, 0x38, 0x00, 0x00, 0x06,
  0x7C, 0x60, 0x00, 0x00, 0x39, 0xF1, 0xC0, 0x00, 0x00, 0xE7, 0xC7, 0x00,
  0x00, 0x03, 0x1F, 0x0C, 0x00, 0x00, 0x1C, 0x7C, 0x38, 0x00, 0x00, 0x71,
  0xF0, 0xE0, 0x00, 0x01, 0x87, 0xC1, 0x80, 0x00, 0x0E, 0x1F, 0x07, 0x00,
  0x00, 0x38, 0x7C, 0x1C, 0x00, 0x00, 0xC1, 0xF0, 0x30, 0x00, 0x07, 0x07,
  0xC0, 0xE0, 0x00, 0x1C, 0x1F, 0x03, 0x80, 0x00, 0x60, 0x7C, 0x06, 0x00,
  0x03, 0x81, 0xF0, 0x1C, 0x00, 0x0E, 0x07, 0xC0, 0x70, 0x00, 0x30, 0x1F,
  0x00, 0xC0, 0x01, 0xC0, 0x7C, 0x03, 0x80, 0x07, 0x01, 0xF0, 0x0E, 0x00,
  0x18, 0x07, 0xC0, 0x18, 0x00, 0xE0, 0x1F, 0x00, 0x70, 0x03, 0x80, 0x7C,
  0x01, 0xC0, 0x0C, 0x01, 0xF0, 0x03, 0x00, 0x70, 0x07, 0xC0, 0x0E, 0x01,
  0xC0, 0x1F, 0x00, 0x38, 0x06, 0x00, 0x7C, 0x00, 0x60, 0x38, 0x01, 0xF0,
  0x01, 0xC0, 0xE0, 0x07, 0xC0, 0x07, 0x03, 0x00, 0x1F, 0x00, 0x0C, 0x0C,
  0x00, 0x7C, 0x00, 0x38, 0x70, 0x01, 0xF0, 0x00, 0xE1, 0x80, 0x07, 0xC0,
  0x01, 0x86, 0x00, 0x1F, 0x00, 0x07, 0x38, 0x00, 0x7C, 0x00, 0x1C, 0xC0,
  0x01, 0xF0, 0x00, 0x33, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7D,
  0xC0, 0x00, 0x07, 0xDC, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x07, 0xCE, 0x00,
  0x00, 0x7C, 0x70, 0x00, 0x07, 0xC3, 0x00, 0x00, 0x7C, 0x38, 0x00, 0x07,
  0xC1, 0x80, 0x00, 0x7C, 0x1C, 0x00, 0x07, 0xC0, 0xC0, 0x00, 0x7C, 0x0E,
  0x00, 0x07, 0xC0, 0x60, 0x00, 0x7C, 0x07, 0x00, 0x07, 0xC0, 0x30, 0x00,
  0x7C, 0x03, 0x80, 0x07, 0xC0, 0x18, 0x00, 0x7C, 0x01, 0xC0, 0x07, 0xC0,
  0x0C, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0xC0, 0x06, 0x00, 0x7C, 0x00, 0x70,
  0x07, 0xC0, 0x03, 0x00, 0x7C, 0x00, 0x38, 0x07, 0xC0, 0x01, 0x80, 0x7C,
  0x00, 0x1C, 0x07, 0xC0, 0x00, 0xC0, 0x7C, 0x00, 0x0E, 0x07, 0xC0, 0x00,
  0x60, 0x7C, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x30, 0x7C, 0x00, 0x03, 0x87,
  0xC0, 0x00, 0x1C, 0x7C, 0x00, 0x01, 0xC7, 0xC0, 0x00, 0x0E, 0x7C, 0x00,
  0x00, 0xE7, 0xC0, 0x00, 0x07, 0x7C, 0x00, 0x00, 0x77, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x1C, 0x0C,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0x87, 0x00, 0x00, 0x01, 0xC7,
  0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x1C,
  0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0x70, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0x00,
  0x3F, 0x86, 0x00, 0x0F, 0x8C, 0x00, 0x07, 0x98, 0x00, 0x07, 0x30, 0x00,
  0x07, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x76,
  0x00, 0x00, 0xEC, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x30, 0x00, 0x0E, 0x60,
  0x00, 0x38, 0xC0, 0x01, 0xE1, 0x80, 0x1F, 0x83, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x03, 0x87,
  0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x63, 0x80, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x03,
  0x70, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x1C, 0x38,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0x7E, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x30, 0x03, 0xF8, 0x18, 0x00, 0x3E, 0x0C, 0x00, 0x07, 0x86, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0x71, 0x80, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x60, 0x00,
  0x07, 0x30, 0x00, 0x03, 0x98, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xE6, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x39, 0x80, 0x00, 0x1C, 0xC0, 0x00, 0x0E, 0x60,
  0x00, 0x06, 0x30, 0x00, 0x07, 0x18, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x86,
  0x00, 0x01, 0xC3, 0x00, 0x01, 0xC1, 0x80, 0x03, 0xC0, 0xC0, 0x0F, 0xC0,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x18, 0x03, 0x80, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x1C, 0x01, 0x80, 0x0E, 0x00, 0xC0, 0x03,
  0x80, 0x60, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x18, 0x00, 0x38, 0x0C, 0x00,
  0x0E, 0x06, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC1, 0x80, 0x00, 0xE0, 0xC0,
  0x00, 0x38, 0x60, 0x00, 0x1C, 0x30, 0x00, 0x07, 0x18, 0x00, 0x03, 0x8C,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x73, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0E,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x0F, 0x80, 0x0E, 0x1E, 0x00, 0x02, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x80, 0x00,
  0x78, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x03,
  0x80, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x1F, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x38, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x70, 0x60, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x06, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x06, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x03, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x01, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x30, 0x03, 0x80, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x00, 0x70, 0x18, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x03, 0x03, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x38, 0x70,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0x86, 0x00, 0x00, 0x07, 0x18, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x70, 0x00,
  0x07, 0xE0, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x38, 0x00,
  0x06, 0x60, 0x00, 0x0C, 0x38, 0x00, 0x06, 0x60, 0x00, 0x1C, 0x38, 0x00,
  0x0E, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x18, 0x00,
  0x0C, 0x30, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x30, 0x00, 0x38, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x0C, 0x00,
  0x1C, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x18, 0x18, 0x00, 0x70, 0x0E, 0x00,
  0x18, 0x18, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x06, 0x00,
  0x38, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x03, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x03, 0x80,
  0x60, 0x06, 0x01, 0xC0, 0x03, 0x80, 0x60, 0x06, 0x01, 0xC0, 0x03, 0x80,
  0xE0, 0x07, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x07, 0x01, 0x80, 0x01, 0xC0,
  0xC0, 0x03, 0x03, 0x80, 0x01, 0xC0, 0xC0, 0x03, 0x03, 0x80, 0x01, 0xC1,
  0xC0, 0x03, 0x83, 0x80, 0x00, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x00, 0xC1,
  0xC0, 0x01, 0x83, 0x00, 0x00, 0xE1, 0x80, 0x01, 0x87, 0x00, 0x00, 0xE1,
  0x80, 0x01, 0x87, 0x00, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x00, 0x63,
  0x80, 0x01, 0xC6, 0x00, 0x00, 0x73, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x73,
  0x00, 0x00, 0xCE, 0x00, 0x00, 0x73, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x37,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x37, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x38, 0x70,
  0x00, 0x06, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x0C, 0x00, 0x0E,
  0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x0C, 0x03, 0x80,
  0x01, 0xC0, 0x60, 0x00, 0x18, 0x1C, 0x00, 0x03, 0x83, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x07, 0x18, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x03, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x03, 0x00, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x06, 0x01, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x38,
  0x70, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x06, 0xF0, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07,
  0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x06, 0x06, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0,
  0x38, 0x00, 0x30, 0x03, 0x00, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x30, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0x80, 0x01, 0x80, 0x70, 0x00,
  0x38, 0x0E, 0x00, 0x07, 0x01, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0C,
  0x00, 0x00, 0xC3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8C, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x07, 0x60, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0,
  0x30, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x18, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x0C, 0x00, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0xE0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xC0,
  0xF0, 0x30, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x1F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFC, 0x0E, 0x3E, 0x00, 0x73, 0xC0, 0x03,
  0xBC, 0x00, 0x1D, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1B, 0x70, 0x00, 0xDB, 0x80, 0x0C, 0xCE, 0x01,
  0xC6, 0x3F, 0xFC, 0x30, 0xFF, 0xC1, 0x80, 0xF0, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0xFF, 0x00, 0xE1,
  0xFF, 0xE0, 0x71, 0xE0, 0xF8, 0x39, 0xC0, 0x1E, 0x1D, 0xC0, 0x07, 0x8E,
  0xC0, 0x01, 0xC7, 0xC0, 0x00, 0x73, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0x0E,
  0xF0, 0x00, 0x07, 0x78, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0D, 0xC0,
  0x00, 0x06, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0xCF, 0x00, 0x00, 0xE7, 0xC0, 0x00, 0x73, 0xE0, 0x00, 0x71,
  0xD8, 0x00, 0x38, 0xEE, 0x00, 0x38, 0x63, 0xC0, 0x78, 0x30, 0xFF, 0xF8,
  0x18, 0x1F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0xC0, 0xFC, 0x1C, 0x0F, 0x00, 0x20, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x04, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0xFE,
  0x07, 0x01, 0xFF, 0xC3, 0x83, 0xE0, 0xF9, 0xC3, 0xC0, 0x0C, 0xE1, 0xC0,
  0x03, 0x71, 0xC0, 0x00, 0xF8, 0xE0, 0x00, 0x7C, 0xE0, 0x00, 0x1E, 0x70,
  0x00, 0x0F, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x76, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1D, 0x80, 0x00,
  0x0E, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x7C, 0x70,
  0x00, 0x36, 0x38, 0x00, 0x33, 0x0E, 0x00, 0x39, 0x87, 0xC0, 0x38, 0xC0,
  0xFF, 0xF8, 0x60, 0x3F, 0xF0, 0x30, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0xC1, 0xE0, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x38,
  0x1C, 0x00, 0x18, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x38, 0x00, 0x0E,
  0x30, 0x00, 0x0E, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06,
  0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x04, 0x07, 0xC0, 0x1C, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x1F, 0xFC, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x7F, 0x81, 0x80, 0xFF, 0xF0, 0xC1, 0xF0, 0x7C,
  0x61, 0xE0, 0x07, 0x30, 0xE0, 0x01, 0xB8, 0xE0, 0x00, 0x7C, 0x70, 0x00,
  0x3E, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x79, 0xC0, 0x00,
  0x3C, 0xE0, 0x00, 0x3E, 0x38, 0x00, 0x1F, 0x1C, 0x00, 0x1B, 0x87, 0x00,
  0x19, 0xC1, 0xE0, 0x3C, 0xE0, 0x7F, 0xFC, 0x70, 0x1F, 0xF8, 0x38, 0x01,
  0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x10, 0x00, 0x1E, 0x0F, 0x00, 0x3E, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x1F, 0xE0,
  0xE1, 0xFF, 0xC3, 0x8F, 0x8F, 0x8E, 0x70, 0x07, 0x3B, 0x80, 0x0E, 0xEC,
  0x00, 0x3B, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xEF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C,
  0xFE, 0x3F, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x0E, 0xE0, 0x00,
  0xE7, 0x00, 0x06, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0x70,
  0x03, 0x83, 0x80, 0x38, 0x1C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0,
  0x38, 0x1C, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x8F,
  0x00, 0x1C, 0x7C, 0x00, 0xE7, 0xE0, 0x07, 0x73, 0x80, 0x3B, 0x1C, 0x01,
  0xF0, 0x70, 0x0F, 0x83, 0x80, 0x78, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x01,
  0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x07, 0x0E,
  0x00, 0x38, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x1C, 0xE0, 0x00,
  0xE7, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0xFE, 0x00, 0x7F, 0x83, 0x0F, 0xFE,
  0x03, 0xFF, 0x8C, 0x78, 0x7C, 0x1E, 0x1F, 0x33, 0x80, 0x78, 0xE0, 0x1C,
  0xCC, 0x00, 0xE6, 0x00, 0x3B, 0x60, 0x01, 0x98, 0x00, 0xED, 0x80, 0x07,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0x38, 0x00, 0x1F,
  0x80, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x0E,
  0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0x00, 0x01, 0xF8, 0x00, 0x0C, 0x00, 0x07, 0xE0, 0x00, 0x30,
  0x00, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0x00, 0x01, 0xF8,
  0x00, 0x0C, 0x00, 0x07, 0xE0, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x00, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0x00, 0x01, 0xF8, 0x00, 0x0C, 0x00, 0x07, 0xE0,
  0x00, 0x30, 0x00, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0x00,
  0x01, 0xF8, 0x00, 0x0C, 0x00, 0x07, 0xE0, 0x00, 0x30, 0x00, 0x1F, 0x80,
  0x00, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0x00, 0x01, 0xF8, 0x00, 0x0C, 0x00,
  0x07, 0xE0, 0x00, 0x30, 0x00, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0x00, 0x01, 0xF8, 0x00, 0x0C, 0x00, 0x07, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0xC0, 0x7F, 0x83, 0x07, 0xFF, 0x8C, 0x3C, 0x1F, 0x31, 0xC0, 0x1C,
  0xCE, 0x00, 0x3B, 0x30, 0x00, 0xED, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x07,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x60, 0xE0, 0x00, 0x1C, 0x30, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x60, 0x00,
  0x03, 0x98, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0xE0,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x06,
  0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x66, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x06, 0x60, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x0E, 0x30, 0x00, 0x03, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x03, 0xC0, 0x07, 0x00, 0x78, 0x07,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xC0,
  0x7F, 0x80, 0x60, 0xFF, 0xF0, 0x30, 0xF8, 0x7C, 0x18, 0xE0, 0x0F, 0x0C,
  0xE0, 0x03, 0xC6, 0x60, 0x00, 0xE3, 0x60, 0x00, 0x39, 0xB0, 0x00, 0x1C,
  0xF0, 0x00, 0x07, 0x78, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x06, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x67, 0x80, 0x00, 0x73, 0xE0, 0x00, 0x39,
  0xF0, 0x00, 0x38, 0xEC, 0x00, 0x1C, 0x73, 0x00, 0x1C, 0x39, 0xE0, 0x3C,
  0x1C, 0x7F, 0xFC, 0x0E, 0x0F, 0xFC, 0x07, 0x00, 0xF0, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x81,
  0x80, 0xFF, 0xE0, 0xC1, 0xF8, 0x78, 0x61, 0xE0, 0x0E, 0x30, 0xE0, 0x01,
  0xB8, 0xE0, 0x00, 0xFC, 0x70, 0x00, 0x3E, 0x70, 0x00, 0x0F, 0x38, 0x00,
  0x07, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07,
  0x60, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x3E, 0x38, 0x00,
  0x1F, 0x1C, 0x00, 0x1B, 0x87, 0x00, 0x19, 0xC1, 0xE0, 0x38, 0xE0, 0x7F,
  0xFC, 0x70, 0x1F, 0xF8, 0x38, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0xC0, 0xFF, 0x83, 0xFF, 0x0F,
  0xFE, 0x38, 0x0C, 0xE0, 0x1D, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xF8, 0x7C, 0x0F,
  0x9C, 0x00, 0x27, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xD0,
  0x00, 0x3B, 0xC0, 0x1E, 0x7F, 0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xC0, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x1F,
  0xE0, 0x0F, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xF6, 0x00, 0x02, 0xDC, 0x00, 0x1B, 0x70, 0x00, 0xCC, 0xE0, 0x07,
  0x33, 0xC0, 0x38, 0xC7, 0xFF, 0xC3, 0x0F, 0xFC, 0x0C, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x06, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38,
  0x0C, 0x00, 0x30, 0x0E, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0x81, 0x80,
  0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0x60, 0x00,
  0x7C, 0x00, 0x1D, 0xC0, 0x01, 0xB0, 0x00, 0x67, 0x00, 0x06, 0xC0, 0x01,
  0x9C, 0x00, 0x3B, 0x80, 0x0E, 0x30, 0x00, 0xCE, 0x00, 0x38, 0xE0, 0x03,
  0x18, 0x00, 0xC3, 0x80, 0x0C, 0x60, 0x03, 0x0E, 0x00, 0x71, 0x80, 0x1C,
  0x18, 0x01, 0xC7, 0x00, 0x70, 0x60, 0x06, 0x0C, 0x01, 0x81, 0xC0, 0x38,
  0x30, 0x06, 0x07, 0x00, 0xE0, 0xC0, 0x38, 0x0C, 0x03, 0x83, 0x80, 0xE0,
  0x30, 0x0C, 0x0E, 0x03, 0x00, 0xE0, 0x70, 0x18, 0x0C, 0x03, 0x81, 0xC0,
  0x60, 0x30, 0x06, 0x07, 0x01, 0xC1, 0xC0, 0x18, 0x18, 0x07, 0x07, 0x00,
  0x70, 0xE0, 0x0C, 0x18, 0x01, 0xC3, 0x80, 0x30, 0x60, 0x03, 0x0E, 0x00,
  0xE3, 0x80, 0x0C, 0x30, 0x03, 0x8E, 0x00, 0x38, 0xC0, 0x06, 0x30, 0x00,
  0xE7, 0x00, 0x18, 0xC0, 0x01, 0x9C, 0x00, 0x77, 0x00, 0x06, 0x60, 0x01,
  0xDC, 0x00, 0x19, 0x80, 0x03, 0x60, 0x00, 0x7E, 0x00, 0x0D, 0x80, 0x00,
  0xF8, 0x00, 0x36, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x18, 0x00, 0x18, 0x1C,
  0x00, 0x38, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC3, 0x80, 0x01,
  0xC3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x66, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xC3, 0x00, 0x01,
  0xC3, 0x80, 0x03, 0x81, 0x80, 0x03, 0x81, 0xC0, 0x07, 0x00, 0xC0, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0xE0,
  0x00, 0x0F, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0x9C, 0x00, 0x01, 0xC6,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x07,
  0x01, 0xC0, 0x03, 0x00, 0xE0, 0x03, 0x80, 0x30, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0xE0,
  0x18, 0x00, 0x70, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x03, 0x00, 0x01, 0x83, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x70, 0xC0, 0x00,
  0x18, 0xE0, 0x00, 0x0C, 0x70, 0x00, 0x07, 0x30, 0x00, 0x03, 0x98, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xC0, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x17, 0xFF, 0x80,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x0F, 0xFF, 0xA0, 0x00, 0xFF, 0xC8, 0x00,
  0x07, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraLight69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 49, 15, 5, -49 },
  { 32, 12, 18, 22, 5, -49 },
  { 59, 32, 49, 34, 1, -49 },
  { 255, 25, 56, 31, 3, -52 },
  { 430, 39, 51, 45, 3, -50 },
  { 679, 31, 51, 34, 3, -50 },
  { 877, 3, 18, 12, 5, -49 },
  { 884, 13, 60, 18, 3, -49 },
  { 982, 12, 60, 18, 3, -49 },
  { 1072, 22, 21, 28, 3, -52 },
  { 1130, 26, 32, 31, 3, -40 },
  { 1234, 6, 16, 13, 3, -7 },
  { 1246, 15, 3, 19, 2, -20 },
  { 1252, 4, 5, 14, 5, -5 },
  { 1255, 21, 49, 23, 1, -49 },
  { 1384, 25, 51, 31, 3, -50 },
  { 1544, 13, 49, 31, 6, -49 },
  { 1624, 24, 50, 31, 3, -50 },
  { 1774, 24, 51, 31, 3, -50 },
  { 1927, 29, 50, 31, 1, -50 },
  { 2109, 24, 50, 31, 4, -49 },
  { 2259, 24, 51, 31, 4, -50 },
  { 2412, 25, 49, 31, 3, -49 },
  { 2566, 25, 51, 31, 3, -50 },
  { 2726, 24, 51, 31, 3, -50 },
  { 2879, 4, 37, 14, 5, -37 },
  { 2898, 6, 46, 14, 3, -37 },
  { 2933, 26, 29, 31, 3, -39 },
  { 3028, 26, 17, 31, 3, -33 },
  { 3084, 26, 29, 31, 3, -39 },
  { 3179, 19, 50, 22, 1, -50 },
  { 3298, 40, 55, 48, 4, -49 },
  { 3573, 31, 49, 31, 0, -49 },
  { 3763, 25, 49, 34, 6, -49 },
  { 3917, 27, 51, 33, 4, -50 },
  { 4090, 28, 49, 38, 6, -49 },
  { 4262, 20, 49, 30, 6, -49 },
  { 4385, 21, 49, 28, 6, -49 },
  { 4514, 32, 51, 40, 4, -50 },
  { 4718, 27, 49, 39, 6, -49 },
  { 4884, 11, 49, 17, 3, -49 },
  { 4952, 13, 61, 14, -4, -49 },
  { 5052, 25, 49, 31, 6, -49 },
  { 5206, 20, 49, 27, 6, -49 },
  { 5329, 38, 49, 50, 6, -49 },
  { 5562, 28, 49, 40, 6, -49 },
  { 5734, 33, 51, 41, 4, -50 },
  { 5945, 23, 49, 32, 6, -49 },
  { 6086, 33, 62, 41, 4, -50 },
  { 6342, 25, 49, 32, 6, -49 },
  { 6496, 24, 51, 30, 3, -50 },
  { 6649, 27, 49, 27, 0, -49 },
  { 6815, 28, 50, 39, 5, -49 },
  { 6990, 30, 49, 30, 0, -49 },
  { 7174, 48, 49, 50, 1, -49 },
  { 7468, 27, 49, 28, 0, -49 },
  { 7634, 27, 49, 27, 0, -49 },
  { 7800, 24, 49, 28, 2, -49 },
  { 7947, 13, 60, 21, 6, -49 },
  { 8045, 21, 49, 23, 1, -49 },
  { 8174, 14, 60, 21, 2, -49 },
  { 8279, 28, 26, 31, 2, -49 },
  { 8370, 28, 2, 28, 0, 6 },
  { 8377, 11, 11, 17, 3, -53 },
  { 8393, 21, 38, 29, 3, -37 },
  { 8493, 25, 53, 33, 5, -52 },
  { 8659, 21, 38, 25, 3, -37 },
  { 8759, 25, 53, 33, 3, -52 },
  { 8925, 24, 38, 30, 3, -37 },
  { 9039, 18, 53, 17, 1, -53 },
  { 9159, 25, 54, 33, 3, -37 },
  { 9328, 22, 52, 32, 5, -52 },
  { 9471, 4, 50, 13, 5, -50 },
  { 9496, 10, 67, 13, -1, -50 },
  { 9580, 21, 52, 26, 5, -52 },
  { 9717, 3, 52, 13, 5, -52 },
  { 9737, 38, 37, 48, 5, -37 },
  { 9913, 22, 37, 32, 5, -37 },
  { 10015, 26, 38, 32, 3, -37 },
  { 10139, 25, 53, 33, 5, -37 },
  { 10305, 25, 53, 33, 3, -37 },
  { 10471, 15, 37, 21, 5, -37 },
  { 10541, 19, 38, 25, 3, -37 },
  { 10632, 15, 46, 17, 1, -45 },
  { 10719, 22, 38, 32, 5, -37 },
  { 10824, 24, 37, 24, 0, -37 },
  { 10935, 38, 37, 40, 1, -37 },
  { 11111, 24, 37, 26, 1, -37 },
  { 11222, 25, 54, 25, 0, -37 },
  { 11391, 18, 37, 22, 2, -37 },
  { 11475, 18, 60, 24, 3, -49 },
  { 11610, 2, 70, 30, 14, -53 },
  { 11628, 18, 60, 24, 3, -49 },
  { 11763, 26, 7, 31, 3, -28 },
};

const GFXfont NotoSans_Condensed_ExtraLight69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight69pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT69PT7B_H_
