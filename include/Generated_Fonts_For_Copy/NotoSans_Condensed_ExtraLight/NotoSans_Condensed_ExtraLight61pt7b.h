#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT61PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight61pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF6, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0x00, 0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60,
  0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x06, 0x01, 0x80,
  0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x30,
  0x00, 0x1C, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x03, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x18, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0x01, 0x80, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xBF, 0xC3, 0xC6, 0x06, 0x1C, 0x18, 0x08,
  0x60, 0x60, 0x03, 0x81, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0x60, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x60,
  0x03, 0x81, 0x80, 0x06, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x3C, 0x60, 0x00,
  0x7D, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xFC, 0x00, 0x06, 0x7C, 0x00, 0x18, 0x78, 0x00, 0x60, 0x70, 0x01, 0x80,
  0xC0, 0x06, 0x03, 0x80, 0x18, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60,
  0x06, 0x01, 0xC0, 0x18, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x06,
  0x03, 0x80, 0x18, 0x1C, 0x80, 0x60, 0xE3, 0xC1, 0x87, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x60,
  0x07, 0xF8, 0x00, 0x30, 0x03, 0x86, 0x00, 0x0C, 0x00, 0xC0, 0xC0, 0x06,
  0x00, 0x60, 0x30, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x06, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x30, 0x06,
  0x01, 0x80, 0x0C, 0x01, 0xC0, 0x60, 0x03, 0x00, 0x70, 0x30, 0x00, 0xC0,
  0x1C, 0x0C, 0x00, 0x30, 0x07, 0x06, 0x00, 0x0C, 0x01, 0xC1, 0x80, 0x03,
  0x00, 0x70, 0x60, 0x00, 0xC0, 0x1C, 0x30, 0x00, 0x30, 0x06, 0x0C, 0x1E,
  0x0C, 0x01, 0x86, 0x0F, 0xE3, 0x00, 0x61, 0x86, 0x1C, 0x60, 0x18, 0x63,
  0x03, 0x18, 0x06, 0x30, 0xC0, 0xE6, 0x03, 0x0C, 0x60, 0x18, 0xC0, 0xC6,
  0x18, 0x06, 0x38, 0x61, 0x86, 0x01, 0x87, 0xF8, 0x61, 0x80, 0x70, 0xF8,
  0x30, 0xE0, 0x0C, 0x00, 0x0C, 0x30, 0x03, 0x00, 0x07, 0x0C, 0x00, 0xC0,
  0x01, 0x83, 0x00, 0x30, 0x00, 0x60, 0xC0, 0x0C, 0x00, 0x30, 0x30, 0x03,
  0x00, 0x0C, 0x0C, 0x00, 0xC0, 0x07, 0x03, 0x00, 0x30, 0x01, 0x80, 0xC0,
  0x0C, 0x00, 0x60, 0x18, 0x03, 0x00, 0x30, 0x06, 0x01, 0xC0, 0x0C, 0x01,
  0x80, 0x60, 0x07, 0x00, 0x60, 0x18, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60,
  0x03, 0x03, 0x00, 0x30, 0x00, 0xE0, 0xC0, 0x0C, 0x00, 0x1C, 0xE0, 0x07,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x18, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00,
  0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xE0,
  0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x07, 0x01, 0x80,
  0x00, 0x30, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01,
  0x80, 0xE0, 0x0C, 0x38, 0x06, 0x00, 0xC3, 0x00, 0x30, 0x0C, 0x70, 0x03,
  0x80, 0xC6, 0x00, 0x1C, 0x1C, 0x60, 0x00, 0xC1, 0x86, 0x00, 0x0E, 0x18,
  0xE0, 0x00, 0x73, 0x8E, 0x00, 0x03, 0x30, 0xE0, 0x00, 0x3F, 0x06, 0x00,
  0x01, 0xE0, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x3F,
  0x03, 0x00, 0x07, 0x38, 0x38, 0x00, 0xE1, 0x81, 0xE0, 0x1C, 0x1C, 0x0F,
  0xFF, 0x80, 0xE0, 0x7F, 0xE0, 0x07, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFB, 0x6D, 0xB6, 0x00, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0E,
  0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30,
  0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0xE0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x01, 0xC0,
  0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x30, 0x10, 0x1F, 0xC2, 0x1F, 0x3F, 0x5F, 0x80, 0x7F, 0x00, 0x03, 0x80,
  0x00, 0xD8, 0x00, 0x39, 0x80, 0x06, 0x30, 0x01, 0x83, 0x00, 0x70, 0x30,
  0x1C, 0x07, 0x07, 0x00, 0x70, 0x20, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x71, 0xC7, 0x18,
  0x63, 0x8E, 0x30, 0xC7, 0x18, 0x61, 0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF7, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x70, 0x78, 0x03, 0x80, 0x70, 0x1C,
  0x00, 0xC0, 0x60, 0x03, 0x83, 0x80, 0x06, 0x0C, 0x00, 0x1C, 0x30, 0x00,
  0x31, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x0E, 0x60, 0x00, 0x19,
  0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0x80,
  0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6E,
  0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x66, 0x00,
  0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x39, 0x80, 0x00, 0xE7, 0x00, 0x03,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x70, 0xE0, 0x01, 0x81, 0x80, 0x06, 0x07,
  0x00, 0x38, 0x0E, 0x01, 0xC0, 0x3C, 0x0E, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0x30, 0x0F, 0x01, 0xF0, 0x3F, 0x07, 0x70, 0xE7, 0x1C, 0x77,
  0x87, 0xF0, 0x74, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x03, 0xFC, 0x00, 0xFF, 0xF8,
  0x0F, 0x01, 0xE0, 0xE0, 0x03, 0x84, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0x01, 0xE1, 0xE0,
  0x03, 0x8C, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x80, 0x01, 0xE7, 0x00, 0x1E, 0x3F, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x02, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x33,
  0x00, 0x00, 0x1C, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x38, 0x30, 0x00, 0x0C, 0x0C, 0x00,
  0x07, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x30, 0x0C,
  0x00, 0x1C, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x30, 0x07,
  0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0xE0, 0x00, 0xC0, 0x30, 0x00, 0x30,
  0x18, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x7F, 0xC0, 0x1F, 0xFF, 0xE0, 0x78, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x80, 0x01, 0xC3, 0x80, 0x1E, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x1F,
  0x02, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x81, 0xF0, 0x06, 0x1F, 0xF8, 0x39, 0xF1, 0xF0,
  0xEE, 0x00, 0xE3, 0xB0, 0x01, 0xCF, 0x80, 0x03, 0x3C, 0x00, 0x0E, 0xF0,
  0x00, 0x3B, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x1D,
  0x80, 0x00, 0x76, 0x00, 0x01, 0x9C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0,
  0x00, 0xE3, 0x80, 0x03, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x38, 0x07,
  0x80, 0x7E, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xF0,
  0x3C, 0x07, 0x00, 0x38, 0x38, 0x00, 0x70, 0xC0, 0x01, 0xC7, 0x00, 0x03,
  0x18, 0x00, 0x0E, 0x60, 0x00, 0x39, 0x80, 0x00, 0xE6, 0x00, 0x03, 0x98,
  0x00, 0x0E, 0x60, 0x00, 0x39, 0xC0, 0x00, 0xC3, 0x00, 0x07, 0x0E, 0x00,
  0x18, 0x1C, 0x00, 0xC0, 0x38, 0x0F, 0x00, 0x78, 0x70, 0x00, 0xF7, 0x80,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x3D, 0xE0, 0x01, 0xC1, 0xE0, 0x1E,
  0x01, 0xC0, 0xE0, 0x03, 0x83, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x60, 0x00,
  0x3B, 0x80, 0x00, 0x6C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x66, 0x00, 0x03, 0x9C, 0x00, 0x0C, 0x38, 0x00, 0x70, 0x70, 0x07,
  0x80, 0xFD, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xF8, 0x07, 0x81, 0xE0, 0x38, 0x03, 0x83, 0x80, 0x0C, 0x38, 0x00,
  0x71, 0x80, 0x01, 0x8C, 0x00, 0x0E, 0xE0, 0x00, 0x36, 0x00, 0x01, 0xB0,
  0x00, 0x0D, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x76, 0x00, 0x03, 0xB0, 0x00, 0x3D, 0xC0, 0x03, 0x67, 0x00, 0x33,
  0x1C, 0x03, 0x98, 0x7F, 0xF8, 0xC1, 0xFF, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x0F,
  0x7F, 0x00, 0x7F, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x2F, 0xFF, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x2F, 0xFF,
  0x70, 0x08, 0x73, 0xCF, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x1C, 0x71,
  0x86, 0x38, 0xE3, 0x0C, 0x71, 0x86, 0x18, 0xC0, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x3F, 0xFC, 0x3C, 0x0F, 0x08, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00,
  0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0xE3, 0x80, 0x0F, 0xF8, 0x06, 0x30,
  0x03, 0xFF, 0x80, 0x63, 0x00, 0x78, 0x18, 0x07, 0x70, 0x06, 0x01, 0x80,
  0x36, 0x00, 0xC0, 0x18, 0x03, 0x60, 0x0C, 0x01, 0x80, 0x36, 0x01, 0x80,
  0x18, 0x03, 0x60, 0x18, 0x01, 0x80, 0x3E, 0x01, 0x80, 0x18, 0x03, 0xE0,
  0x38, 0x01, 0x80, 0x3C, 0x03, 0x00, 0x18, 0x03, 0xC0, 0x30, 0x01, 0x80,
  0x3C, 0x03, 0x00, 0x18, 0x03, 0xC0, 0x30, 0x03, 0x80, 0x3C, 0x03, 0x00,
  0x38, 0x03, 0xC0, 0x30, 0x03, 0x80, 0x3C, 0x03, 0x00, 0x38, 0x07, 0xE0,
  0x38, 0x03, 0x80, 0x66, 0x01, 0x80, 0x78, 0x06, 0x60, 0x18, 0x07, 0x80,
  0xE6, 0x01, 0xC0, 0xCC, 0x0C, 0x60, 0x0E, 0x1C, 0xC1, 0xC6, 0x00, 0x7F,
  0x87, 0xF8, 0x70, 0x03, 0xF0, 0x3F, 0x03, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x98, 0x00, 0x00, 0x31, 0xC0,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00,
  0x60, 0xE0, 0x00, 0x06, 0x06, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x18, 0x03, 0x80, 0x01, 0x80, 0x18, 0x00, 0x38, 0x01, 0x80, 0x03, 0x00,
  0x18, 0x00, 0x30, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x00, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0E, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x60, 0x0C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x03,
  0x01, 0x80, 0x00, 0x38, 0x18, 0x00, 0x03, 0x83, 0x80, 0x00, 0x18, 0x38,
  0x00, 0x01, 0x83, 0x00, 0x00, 0x1C, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x0C, 0x60, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x38,
  0x00, 0x78, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xCE, 0x00, 0x03, 0xB8, 0x00,
  0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x06,
  0xE0, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x0E, 0xE0,
  0x00, 0x33, 0x80, 0x01, 0xCE, 0x00, 0x0E, 0x38, 0x00, 0xF0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0E, 0x00, 0x7C, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0x73,
  0x80, 0x00, 0xEE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x6E,
  0x00, 0x03, 0xB8, 0x00, 0x1C, 0xE0, 0x00, 0xF3, 0x80, 0x1F, 0x8F, 0xFF,
  0xF8, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x3E,
  0x03, 0xC0, 0x3C, 0x00, 0x20, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x01, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x18,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1C, 0x00,
  0x7C, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x38, 0xE0, 0x00, 0x0C, 0x70, 0x00, 0x07, 0x38, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0D,
  0xC0, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x0D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0x38,
  0x00, 0x03, 0x9C, 0x00, 0x01, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xC3,
  0x80, 0x00, 0xE1, 0xC0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0x70, 0x07, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x01, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00,
  0x00, 0x0D, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x19, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x06, 0x38, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x03, 0x03, 0xC0, 0x00, 0x18, 0x07, 0x80, 0x03, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x0F, 0xFF, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0xE7, 0xCF,
  0xF8, 0x7E, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xEE, 0x00, 0x03, 0x38,
  0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x18, 0x38, 0x00,
  0xE0, 0xE0, 0x07, 0x03, 0x80, 0x18, 0x0E, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x38, 0x03, 0x80, 0xE0, 0x0E, 0x07, 0x00, 0x38, 0x38, 0x00, 0xE0,
  0xC0, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x39, 0xE0, 0x00, 0xE7, 0x80,
  0x03, 0xBF, 0x00, 0x0F, 0xDC, 0x00, 0x3E, 0x38, 0x00, 0xF0, 0x60, 0x03,
  0x81, 0xC0, 0x0E, 0x03, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0xE0, 0x38, 0x01, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x0C,
  0x0E, 0x00, 0x38, 0x38, 0x00, 0x60, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x8E,
  0x00, 0x06, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x33, 0x80, 0x00, 0xEE, 0x00,
  0x01, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xD8, 0x00, 0x00, 0x06, 0xF6, 0x00, 0x00, 0x01, 0xBD, 0xC0, 0x00, 0x00,
  0xEF, 0x30, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x00, 0x0C, 0xF3, 0x80, 0x00,
  0x07, 0x3C, 0x60, 0x00, 0x01, 0x8F, 0x18, 0x00, 0x00, 0x63, 0xC7, 0x00,
  0x00, 0x38, 0xF0, 0xC0, 0x00, 0x0C, 0x3C, 0x30, 0x00, 0x03, 0x0F, 0x0E,
  0x00, 0x01, 0xC3, 0xC1, 0x80, 0x00, 0x60, 0xF0, 0x60, 0x00, 0x18, 0x3C,
  0x1C, 0x00, 0x0E, 0x0F, 0x03, 0x00, 0x03, 0x03, 0xC0, 0xC0, 0x00, 0xC0,
  0xF0, 0x38, 0x00, 0x70, 0x3C, 0x06, 0x00, 0x18, 0x0F, 0x01, 0x80, 0x06,
  0x03, 0xC0, 0x70, 0x03, 0x80, 0xF0, 0x0C, 0x00, 0xC0, 0x3C, 0x03, 0x00,
  0x30, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x18, 0x06, 0x00, 0xF0, 0x06,
  0x01, 0x80, 0x3C, 0x01, 0xC0, 0xE0, 0x0F, 0x00, 0x30, 0x30, 0x03, 0xC0,
  0x0C, 0x0C, 0x00, 0xF0, 0x03, 0x87, 0x00, 0x3C, 0x00, 0x61, 0x80, 0x0F,
  0x00, 0x18, 0x60, 0x03, 0xC0, 0x07, 0x38, 0x00, 0xF0, 0x00, 0xCC, 0x00,
  0x3C, 0x00, 0x33, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1E, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x07,
  0x98, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xE3, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x78, 0x60, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x0C, 0x00, 0x0F, 0x07, 0x00,
  0x07, 0x81, 0x80, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0x30, 0x00, 0xF0, 0x1C,
  0x00, 0x78, 0x06, 0x00, 0x3C, 0x03, 0x80, 0x1E, 0x00, 0xC0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x18, 0x03, 0xC0, 0x06, 0x01, 0xE0, 0x03, 0x80, 0xF0,
  0x00, 0xC0, 0x78, 0x00, 0x70, 0x3C, 0x00, 0x18, 0x1E, 0x00, 0x0E, 0x0F,
  0x00, 0x03, 0x07, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0x61, 0xE0, 0x00, 0x38,
  0xF0, 0x00, 0x0C, 0x78, 0x00, 0x07, 0x3C, 0x00, 0x01, 0x9E, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x37, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0C, 0x07, 0x00,
  0x00, 0x38, 0x18, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0xC3, 0x00, 0x00,
  0x03, 0x0C, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x00, 0x66, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x38,
  0xC0, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x1C,
  0x00, 0x00, 0x60, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xC0, 0x0F, 0x8E, 0x00, 0x1C, 0x70, 0x00,
  0x73, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xB8,
  0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0xF0, 0x00, 0x1B, 0x80, 0x00,
  0xDC, 0x00, 0x06, 0xE0, 0x00, 0x37, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0,
  0x00, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80, 0x1E, 0x1C, 0x1F, 0xE0,
  0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x60, 0xE0, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x0C, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE6, 0x00, 0x00,
  0x01, 0x98, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x00, 0x76, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x67, 0x00, 0x00,
  0x01, 0x9C, 0x00, 0x00, 0x0E, 0x30, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x07, 0x06, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x38, 0x01, 0xF0, 0xE0, 0x01, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x38,
  0x00, 0x1C, 0xE0, 0x00, 0x33, 0x80, 0x00, 0xCE, 0x00, 0x03, 0x38, 0x00,
  0x0C, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xCE, 0x00, 0x03, 0x38, 0x00, 0x0C,
  0xE0, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0,
  0x01, 0xC3, 0x80, 0x1E, 0x0E, 0x07, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x03,
  0x80, 0x38, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80,
  0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0x80, 0x03,
  0x8E, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x83, 0xC0,
  0x3C, 0x38, 0x00, 0x23, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x80, 0x01, 0xE7, 0x00, 0x1E, 0x3F, 0xFF, 0xE0, 0xFF, 0xFC,
  0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x06, 0x70, 0x00,
  0x0E, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1F, 0x00, 0x78, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x61, 0x80, 0x00, 0x1C, 0x38, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x80, 0x60, 0x00,
  0x70, 0x0E, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0x80, 0x18, 0x00, 0x70, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x0E,
  0x00, 0x1C, 0x01, 0x80, 0x01, 0x80, 0x30, 0x00, 0x30, 0x0E, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x38, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0C,
  0x38, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x38, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x1B, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x66, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x98, 0x00, 0x07, 0xC0,
  0x00, 0x63, 0x80, 0x01, 0xD8, 0x00, 0x0C, 0x30, 0x00, 0x33, 0x00, 0x03,
  0x86, 0x00, 0x06, 0x60, 0x00, 0x70, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0x1C,
  0x00, 0x19, 0xC0, 0x01, 0x81, 0x80, 0x07, 0x18, 0x00, 0x70, 0x30, 0x00,
  0xC3, 0x00, 0x0E, 0x06, 0x00, 0x18, 0x60, 0x01, 0x80, 0xE0, 0x03, 0x0E,
  0x00, 0x30, 0x1C, 0x00, 0xE0, 0xC0, 0x0E, 0x01, 0x80, 0x18, 0x18, 0x01,
  0xC0, 0x30, 0x03, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x60, 0x06, 0x00,
  0xE0, 0x0C, 0x0E, 0x00, 0xC0, 0x0C, 0x03, 0x80, 0xC0, 0x38, 0x01, 0x80,
  0x60, 0x18, 0x07, 0x00, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x07, 0x01, 0x80,
  0x70, 0x18, 0x00, 0xE0, 0x70, 0x06, 0x07, 0x00, 0x0C, 0x0C, 0x00, 0xC0,
  0xE0, 0x01, 0x81, 0x80, 0x18, 0x18, 0x00, 0x38, 0x30, 0x03, 0x83, 0x00,
  0x07, 0x06, 0x00, 0x30, 0xE0, 0x00, 0x61, 0xC0, 0x06, 0x1C, 0x00, 0x0C,
  0x30, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x18, 0x60, 0x00, 0x38, 0xC0,
  0x03, 0x8C, 0x00, 0x03, 0x38, 0x00, 0x33, 0x80, 0x00, 0x66, 0x00, 0x06,
  0x60, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x01, 0xD8, 0x00, 0x19, 0x80,
  0x00, 0x3B, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x07,
  0x38, 0x00, 0x06, 0x18, 0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x1C,
  0x0C, 0x00, 0x18, 0x0E, 0x00, 0x38, 0x06, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x03, 0x00, 0x60, 0x03, 0x80, 0xE0, 0x01, 0x80, 0xE0, 0x01, 0xC0, 0xC0,
  0x00, 0xC1, 0xC0, 0x00, 0xC1, 0x80, 0x00, 0x63, 0x80, 0x00, 0x63, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x36, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x63, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xC1, 0x80,
  0x01, 0xC1, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x00, 0xE0,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x70, 0x0E, 0x00, 0x30, 0x0C, 0x00, 0x38,
  0x1C, 0x00, 0x18, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x0C,
  0x30, 0x00, 0x0E, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x06, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x0C, 0x00, 0x70, 0x0E, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x07, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x01, 0xC0, 0x03, 0x81, 0x80,
  0x01, 0x83, 0x80, 0x01, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0xE6, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x76, 0x00, 0x00, 0x67, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0xC3, 0x80, 0x01, 0xC1, 0x80, 0x01, 0x81, 0x80, 0x03, 0x80, 0xC0, 0x03,
  0x00, 0xC0, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x30, 0x0C,
  0x00, 0x30, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x30,
  0x00, 0x0C, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x1C, 0x03,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x00, 0xFC,
  0x00, 0xFF, 0xE0, 0x7E, 0x1E, 0x0C, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xF8, 0x07, 0xFF,
  0x07, 0xF0, 0x61, 0xE0, 0x0C, 0x70, 0x01, 0x9C, 0x00, 0x37, 0x00, 0x06,
  0xC0, 0x00, 0xD8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1D,
  0x80, 0x03, 0xB0, 0x00, 0xF6, 0x00, 0x16, 0xE0, 0x06, 0xCE, 0x01, 0x98,
  0xF9, 0xE3, 0x0F, 0xF8, 0x60, 0x18, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x7E, 0x03, 0x0F, 0xFC, 0x18, 0xF0,
  0xF0, 0xCC, 0x01, 0xC6, 0xC0, 0x07, 0x3C, 0x00, 0x19, 0xE0, 0x00, 0xEE,
  0x00, 0x03, 0x70, 0x00, 0x1B, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1B, 0x80,
  0x00, 0xDC, 0x00, 0x0E, 0xF0, 0x00, 0x67, 0x80, 0x07, 0x36, 0x00, 0x71,
  0x98, 0x07, 0x8C, 0x7F, 0xF8, 0x41, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0xF0, 0x7E, 0x1C, 0x3C, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x04, 0x1F, 0xFF, 0x01,
  0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x03, 0xE0, 0x70, 0x3F, 0xF1, 0xC3, 0xE1, 0xE7,
  0x0E, 0x01, 0xDC, 0x70, 0x03, 0x73, 0x80, 0x07, 0xCC, 0x00, 0x0B, 0x70,
  0x00, 0x3D, 0x80, 0x00, 0x76, 0x00, 0x01, 0xD8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1D, 0x80, 0x00,
  0x76, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x30, 0x00, 0x2C, 0xE0, 0x01, 0xB1,
  0xC0, 0x0C, 0xC7, 0x80, 0x63, 0x0F, 0xFF, 0x0C, 0x0F, 0xF8, 0x30, 0x07,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xE1, 0xE0, 0x1C, 0x03,
  0x81, 0xC0, 0x0C, 0x1C, 0x00, 0x70, 0xC0, 0x01, 0x8E, 0x00, 0x0E, 0x60,
  0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x03,
  0x70, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x08, 0x3C, 0x01, 0x80,
  0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x01, 0xFF,
  0x03, 0xE6, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x30,
  0xF8, 0x78, 0xC7, 0x80, 0x33, 0x1C, 0x00, 0x6C, 0xE0, 0x01, 0xF3, 0x00,
  0x03, 0xDC, 0x00, 0x0F, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x76, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0x60, 0x00, 0x1D, 0x80, 0x00, 0xF7, 0x00, 0x03, 0xCC, 0x00, 0x1F, 0x38,
  0x00, 0x7C, 0x70, 0x03, 0x71, 0xE0, 0x19, 0xC3, 0xF7, 0xC7, 0x03, 0xFE,
  0x1C, 0x01, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x10, 0x00, 0x38, 0x70, 0x01, 0xE1, 0xFC, 0x7F,
  0x01, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x81, 0xF0, 0x30, 0xFF, 0xC6, 0x7C, 0x7C, 0xCC, 0x03, 0x9B, 0x00,
  0x3B, 0xC0, 0x03, 0x78, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xC0, 0xEF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x07, 0x03, 0xC1, 0xE0, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0xDE, 0x7E, 0x1C,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x3B, 0x00,
  0x1C, 0xC0, 0x0E, 0x30, 0x03, 0x0C, 0x01, 0xC3, 0x00, 0xE0, 0xC0, 0x30,
  0x30, 0x18, 0x0C, 0x0E, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x30, 0xE0, 0x0C,
  0x70, 0x03, 0x1E, 0x00, 0xCD, 0x80, 0x37, 0x70, 0x0D, 0x8C, 0x03, 0xC3,
  0x80, 0xE0, 0x60, 0x38, 0x1C, 0x0C, 0x03, 0x03, 0x00, 0xE0, 0xC0, 0x18,
  0x30, 0x07, 0x0C, 0x00, 0xC3, 0x00, 0x38, 0xC0, 0x06, 0x30, 0x01, 0xCC,
  0x00, 0x33, 0x00, 0x0E, 0xC0, 0x01, 0xB0, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x43, 0xFE, 0x03, 0xFE, 0x23, 0xC7, 0x87, 0x87, 0x9B, 0x80, 0xE3,
  0x00, 0xED, 0x00, 0x33, 0x00, 0x77, 0x80, 0x1F, 0x00, 0x1B, 0x80, 0x07,
  0x80, 0x0F, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x00, 0xFC, 0x10, 0x7F, 0xE2, 0x3C, 0x3E, 0x66, 0x01, 0xED,
  0x80, 0x1D, 0xE0, 0x01, 0xB8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x7C, 0x00,
  0x0F, 0xFE, 0x00, 0xF8, 0x7C, 0x07, 0x80, 0x38, 0x1C, 0x00, 0x70, 0xE0,
  0x01, 0xC3, 0x00, 0x03, 0x9C, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00,
  0x6E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xD8, 0x00, 0x07, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x67, 0x00, 0x03, 0x8C,
  0x00, 0x0C, 0x38, 0x00, 0x70, 0x70, 0x03, 0x80, 0xE0, 0x1E, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x04, 0x1F, 0xF8,
  0x21, 0xE1, 0xE1, 0x98, 0x03, 0x8D, 0x80, 0x0E, 0x68, 0x00, 0x33, 0xC0,
  0x01, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x37, 0x00, 0x01, 0xB8, 0x00, 0x1D, 0xE0, 0x00, 0xCD, 0x80, 0x0E, 0x6C,
  0x00, 0xE3, 0x38, 0x0F, 0x18, 0xFB, 0xF0, 0xC3, 0xFE, 0x06, 0x01, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xFC, 0x30, 0xF8, 0x78, 0xC3, 0x80, 0x73, 0x1C, 0x00,
  0xCC, 0xE0, 0x01, 0xF3, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x60, 0x00, 0x3D,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0xF7, 0x00,
  0x03, 0xCC, 0x00, 0x1F, 0x38, 0x00, 0x5C, 0x70, 0x03, 0x71, 0xE0, 0x19,
  0xC3, 0xF7, 0xC7, 0x03, 0xFE, 0x1C, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x01, 0xF6, 0x1F,
  0xF1, 0xFF, 0x98, 0x0D, 0x80, 0x68, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xE1, 0xE0, 0xF8, 0xE0, 0x02,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0xA0, 0x00, 0xEE, 0x00,
  0x73, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xC3, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x1F, 0xE0,
  0x7F, 0x00, 0x60, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x0F, 0x60, 0x00, 0xB7, 0x00,
  0x1B, 0x38, 0x03, 0x33, 0xC0, 0x73, 0x1F, 0xFE, 0x30, 0xFF, 0x83, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x1B, 0x00, 0x01, 0xD8, 0x00, 0x0C, 0xE0, 0x00,
  0x63, 0x00, 0x07, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x87, 0x00, 0x0C, 0x18,
  0x00, 0xE0, 0xC0, 0x06, 0x07, 0x00, 0x30, 0x18, 0x03, 0x80, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x70, 0x06, 0x03, 0x00, 0x38,
  0x18, 0x01, 0xC1, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0xC3, 0x00,
  0x06, 0x38, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x0E, 0x60, 0x00, 0x36,
  0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x6E, 0x00,
  0x1E, 0x00, 0x19, 0x80, 0x07, 0x80, 0x06, 0x60, 0x01, 0xE0, 0x01, 0x98,
  0x00, 0xCC, 0x00, 0xE7, 0x00, 0x33, 0x00, 0x30, 0xC0, 0x0C, 0xC0, 0x0C,
  0x30, 0x03, 0x30, 0x03, 0x0C, 0x01, 0xCE, 0x01, 0xC3, 0x80, 0x61, 0x80,
  0x60, 0x60, 0x18, 0x60, 0x18, 0x18, 0x06, 0x18, 0x06, 0x06, 0x03, 0x87,
  0x03, 0x81, 0xC0, 0xC0, 0xC0, 0xC0, 0x70, 0x30, 0x30, 0x30, 0x0C, 0x0C,
  0x0C, 0x0C, 0x03, 0x07, 0x03, 0x83, 0x00, 0xC1, 0x80, 0x61, 0xC0, 0x38,
  0x60, 0x18, 0x60, 0x06, 0x18, 0x06, 0x18, 0x01, 0x8E, 0x01, 0xC6, 0x00,
  0x63, 0x00, 0x33, 0x80, 0x1C, 0xC0, 0x0C, 0xC0, 0x03, 0x30, 0x03, 0x30,
  0x00, 0xDC, 0x00, 0xCC, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x70, 0x00, 0x71, 0x80, 0x03, 0x0E,
  0x00, 0x38, 0x30, 0x01, 0x81, 0xC0, 0x1C, 0x06, 0x00, 0xC0, 0x38, 0x0E,
  0x00, 0xC0, 0x60, 0x07, 0x07, 0x00, 0x18, 0x30, 0x00, 0xE3, 0x80, 0x03,
  0x18, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x06, 0xC0, 0x00, 0x76, 0x00, 0x03, 0x18, 0x00, 0x38,
  0xE0, 0x01, 0x83, 0x00, 0x1C, 0x1C, 0x00, 0xC0, 0x60, 0x0E, 0x03, 0x80,
  0x60, 0x0C, 0x07, 0x00, 0x70, 0x30, 0x01, 0x83, 0x80, 0x0E, 0x38, 0x00,
  0x31, 0x80, 0x01, 0xDC, 0x00, 0x07, 0x60, 0x00, 0x1D, 0xC0, 0x00, 0x63,
  0x00, 0x01, 0x8C, 0x00, 0x0E, 0x38, 0x00, 0x30, 0xE0, 0x00, 0xC1, 0x80,
  0x07, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x0E,
  0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x60, 0x18, 0x01,
  0xC0, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x0E, 0x00, 0x38, 0x30, 0x00, 0x60,
  0xC0, 0x01, 0x87, 0x00, 0x06, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x31, 0x80,
  0x00, 0xCE, 0x00, 0x03, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0xCF, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x7C,
  0x03, 0xF8, 0x0F, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x03, 0xE0,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0xF8, 0x00, 0xFE, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xC0, 0x00, 0x1F, 0xE0, 0x01, 0x7F, 0xF8, 0x03,
  0xE0, 0x3C, 0x0F, 0xC0, 0x0F, 0xFC, 0x80, 0x03, 0xF8,
};

const GFXglyph NotoSans_Condensed_ExtraLight61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 44, 13, 5, -44 },
  { 18, 11, 16, 19, 4, -44 },
  { 40, 28, 44, 30, 1, -44 },
  { 194, 22, 50, 28, 3, -46 },
  { 332, 34, 45, 40, 3, -44 },
  { 524, 28, 45, 30, 2, -44 },
  { 682, 3, 16, 11, 4, -44 },
  { 688, 11, 54, 16, 3, -44 },
  { 763, 11, 54, 16, 2, -44 },
  { 838, 19, 19, 25, 3, -46 },
  { 884, 23, 29, 28, 2, -36 },
  { 968, 6, 15, 12, 2, -7 },
  { 980, 13, 3, 17, 2, -18 },
  { 985, 4, 4, 12, 4, -4 },
  { 987, 19, 44, 20, 1, -44 },
  { 1092, 22, 44, 28, 3, -44 },
  { 1213, 12, 44, 28, 5, -44 },
  { 1279, 21, 44, 28, 3, -44 },
  { 1395, 21, 45, 28, 3, -44 },
  { 1514, 26, 44, 28, 1, -44 },
  { 1657, 22, 45, 28, 3, -44 },
  { 1781, 22, 45, 28, 3, -44 },
  { 1905, 21, 44, 28, 3, -44 },
  { 2021, 22, 45, 28, 3, -44 },
  { 2145, 21, 45, 28, 3, -44 },
  { 2264, 4, 33, 12, 4, -33 },
  { 2281, 6, 41, 12, 2, -33 },
  { 2312, 23, 26, 28, 2, -35 },
  { 2387, 23, 15, 28, 2, -29 },
  { 2431, 23, 26, 28, 2, -35 },
  { 2506, 17, 44, 19, 1, -44 },
  { 2600, 36, 50, 42, 3, -44 },
  { 2825, 28, 44, 28, 0, -44 },
  { 2979, 22, 44, 30, 5, -44 },
  { 3100, 25, 45, 29, 3, -44 },
  { 3241, 25, 44, 33, 5, -44 },
  { 3379, 18, 44, 27, 5, -44 },
  { 3478, 18, 44, 24, 5, -44 },
  { 3577, 29, 45, 36, 3, -44 },
  { 3741, 24, 44, 34, 5, -44 },
  { 3873, 10, 44, 15, 3, -44 },
  { 3928, 12, 55, 13, -4, -44 },
  { 4011, 22, 44, 27, 5, -44 },
  { 4132, 18, 44, 24, 5, -44 },
  { 4231, 34, 44, 44, 5, -44 },
  { 4418, 25, 44, 35, 5, -44 },
  { 4556, 30, 45, 36, 3, -44 },
  { 4725, 21, 44, 28, 5, -44 },
  { 4841, 30, 54, 36, 3, -44 },
  { 5044, 22, 44, 28, 5, -44 },
  { 5165, 21, 45, 27, 3, -44 },
  { 5284, 24, 44, 24, 0, -44 },
  { 5416, 24, 45, 34, 5, -44 },
  { 5551, 27, 44, 27, 0, -44 },
  { 5700, 43, 44, 44, 1, -44 },
  { 5937, 24, 44, 24, 0, -44 },
  { 6069, 24, 44, 24, 0, -44 },
  { 6201, 21, 44, 25, 2, -44 },
  { 6317, 12, 54, 19, 5, -44 },
  { 6398, 18, 44, 20, 1, -44 },
  { 6497, 12, 54, 19, 2, -44 },
  { 6578, 24, 23, 28, 2, -44 },
  { 6647, 25, 3, 24, 0, 5 },
  { 6657, 10, 10, 15, 2, -47 },
  { 6670, 19, 34, 26, 2, -33 },
  { 6751, 21, 47, 29, 5, -46 },
  { 6875, 18, 34, 22, 3, -33 },
  { 6952, 22, 47, 29, 3, -46 },
  { 7082, 21, 34, 27, 3, -33 },
  { 7172, 16, 47, 15, 1, -47 },
  { 7266, 22, 48, 29, 3, -33 },
  { 7398, 19, 46, 28, 5, -46 },
  { 7508, 4, 44, 12, 4, -44 },
  { 7530, 9, 59, 12, -1, -44 },
  { 7597, 18, 46, 23, 5, -46 },
  { 7701, 2, 46, 11, 5, -46 },
  { 7713, 33, 33, 43, 5, -33 },
  { 7850, 19, 33, 28, 5, -33 },
  { 7929, 22, 34, 28, 3, -33 },
  { 8023, 21, 47, 29, 5, -33 },
  { 8147, 22, 47, 29, 3, -33 },
  { 8277, 13, 33, 19, 5, -33 },
  { 8331, 18, 34, 22, 2, -33 },
  { 8408, 13, 41, 15, 1, -40 },
  { 8475, 20, 33, 28, 4, -32 },
  { 8558, 21, 32, 21, 0, -32 },
  { 8642, 34, 32, 36, 1, -32 },
  { 8778, 21, 32, 23, 1, -32 },
  { 8862, 22, 47, 22, 0, -32 },
  { 8992, 16, 32, 20, 2, -32 },
  { 9056, 15, 54, 21, 3, -44 },
  { 9158, 2, 61, 26, 12, -46 },
  { 9174, 16, 54, 21, 3, -44 },
  { 9282, 24, 5, 28, 2, -24 },
};

const GFXfont NotoSans_Condensed_ExtraLight61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight61pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT61PT7B_H_
