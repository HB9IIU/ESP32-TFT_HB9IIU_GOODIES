#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT27PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight27pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xA0, 0x3C, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x08,
  0x40, 0x84, 0x08, 0x80, 0x88, 0x10, 0x8F, 0xFF, 0x10, 0x81, 0x08, 0x10,
  0x81, 0x08, 0x11, 0x02, 0x10, 0xFF, 0xE2, 0x10, 0x21, 0x02, 0x10, 0x21,
  0x02, 0x20, 0x22, 0x00, 0x08, 0x02, 0x01, 0xF1, 0xA2, 0x48, 0x22, 0x08,
  0x82, 0x20, 0xC8, 0x1A, 0x03, 0x80, 0x38, 0x0B, 0x02, 0x20, 0x84, 0x21,
  0x08, 0x42, 0x38, 0x8B, 0xFC, 0x08, 0x02, 0x00, 0x80, 0x10, 0x00, 0xD0,
  0x21, 0x10, 0x82, 0x21, 0x08, 0x42, 0x10, 0x88, 0x21, 0x10, 0x42, 0x40,
  0x84, 0x9C, 0x89, 0x4D, 0x14, 0x8B, 0x4A, 0x11, 0x24, 0x20, 0x48, 0x40,
  0x90, 0x82, 0x21, 0x04, 0x42, 0x10, 0x44, 0x20, 0x88, 0x40, 0xE0, 0x0C,
  0x01, 0x20, 0x21, 0x02, 0x10, 0x21, 0x02, 0x10, 0x21, 0x03, 0x20, 0x14,
  0x00, 0x80, 0x3C, 0x06, 0x41, 0x42, 0x28, 0x32, 0x81, 0x28, 0x0E, 0x80,
  0x4C, 0x0C, 0x41, 0x23, 0xE1, 0xFE, 0x08, 0x88, 0x46, 0x21, 0x08, 0xC4,
  0x21, 0x08, 0x43, 0x08, 0x42, 0x18, 0x42, 0x08, 0x20, 0xC2, 0x08, 0x41,
  0x08, 0x43, 0x08, 0x42, 0x10, 0x84, 0x23, 0x10, 0x84, 0x42, 0x23, 0x00,
  0x08, 0x04, 0x02, 0x11, 0x17, 0xF0, 0x40, 0x50, 0x44, 0x61, 0x00, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x0F, 0xFC, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x00, 0x69, 0x25, 0x00, 0xFC, 0xB0, 0x03, 0x02, 0x02,
  0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x40,
  0x40, 0xC0, 0x80, 0x80, 0x04, 0x06, 0xC2, 0x11, 0x02, 0x40, 0x90, 0x24,
  0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x14, 0x0D, 0x02,
  0x40, 0x98, 0x22, 0x10, 0x78, 0x09, 0xDB, 0x90, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x08, 0x1D, 0xC4, 0x10, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x18, 0x04, 0x03, 0xFF, 0x08, 0x1D, 0xC8, 0x18, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x01, 0x03, 0x83, 0xE0, 0x06, 0x00, 0x80, 0x30,
  0x04, 0x01, 0x00, 0x80, 0x28, 0x1B, 0xF8, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x28, 0x04, 0x80, 0x48, 0x08, 0x80, 0x88, 0x10, 0x81, 0x08, 0x20, 0x86,
  0x08, 0x40, 0x8F, 0xFF, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x7F, 0x90, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x20, 0x77, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x02, 0x00, 0xA0, 0x47, 0xE0,
  0x02, 0x03, 0x61, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x4E, 0x3C,
  0x6A, 0x0B, 0x01, 0xC0, 0x70, 0x14, 0x05, 0x01, 0x40, 0x50, 0x22, 0x08,
  0x7C, 0xFF, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x03,
  0x00, 0x0C, 0x0C, 0xC4, 0x09, 0x02, 0x40, 0xD0, 0x24, 0x09, 0x82, 0x33,
  0x03, 0x01, 0xE0, 0x84, 0x40, 0xB0, 0x18, 0x06, 0x01, 0x80, 0x50, 0x36,
  0x08, 0xFC, 0x0C, 0x0C, 0xC4, 0x11, 0x02, 0x80, 0xA0, 0x28, 0x06, 0x01,
  0x80, 0xD0, 0x34, 0x14, 0xCD, 0x18, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80,
  0x40, 0x21, 0xF0, 0xE0, 0x00, 0x00, 0xB0, 0x68, 0x00, 0x00, 0x00, 0x34,
  0x92, 0x80, 0x00, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x10, 0x18, 0x18, 0x18,
  0x18, 0x08, 0x00, 0x31, 0xB8, 0x10, 0x10, 0x20, 0x40, 0x82, 0x04, 0x10,
  0x41, 0x02, 0x04, 0x08, 0x00, 0x00, 0x00, 0x83, 0x00, 0x07, 0xF0, 0x08,
  0x0C, 0x10, 0x04, 0x20, 0x02, 0x20, 0x03, 0x41, 0xE1, 0x43, 0x11, 0x42,
  0x21, 0x44, 0x21, 0x84, 0x21, 0x84, 0x21, 0x84, 0x21, 0x84, 0x21, 0x44,
  0x21, 0x46, 0x52, 0x43, 0x9E, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x0E, 0x70, 0x00, 0x80, 0x06, 0x00, 0x60, 0x05, 0x00, 0x90, 0x09,
  0x00, 0x90, 0x08, 0x81, 0x08, 0x10, 0x81, 0x0C, 0x20, 0x43, 0xFC, 0x20,
  0x42, 0x02, 0x40, 0x24, 0x02, 0x40, 0x2C, 0x01, 0x80, 0x10, 0xFF, 0x20,
  0x28, 0x0A, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x06, 0xFF, 0x20, 0xC8, 0x0A,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x6F, 0xF0, 0x03, 0x07,
  0x32, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x7F, 0xFF,
  0x10, 0x32, 0x03, 0x40, 0x28, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x14, 0x02, 0x80, 0x90, 0x33,
  0xF8, 0x00, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x01, 0x01, 0xEF, 0x30, 0x16, 0x00, 0x40, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x81, 0xF8, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x40, 0x16, 0x01, 0x30, 0x10, 0xFF, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF, 0xF0, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x3E, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x7C, 0x80, 0xE0, 0x68, 0x12, 0x08, 0x84, 0x23, 0x08,
  0x82, 0x40, 0xB0, 0x2A, 0x0C, 0x82, 0x10, 0x84, 0x20, 0x88, 0x32, 0x04,
  0x81, 0xA0, 0x28, 0x04, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xC0,
  0x07, 0x80, 0x0E, 0x80, 0x1D, 0x00, 0x5A, 0x00, 0xB2, 0x01, 0x64, 0x04,
  0xC8, 0x09, 0x88, 0x13, 0x10, 0x46, 0x20, 0x8C, 0x21, 0x18, 0x44, 0x30,
  0x88, 0x60, 0x90, 0xC1, 0x41, 0x82, 0x83, 0x03, 0x06, 0x04, 0x08, 0xC0,
  0x38, 0x06, 0x80, 0xD0, 0x19, 0x03, 0x20, 0x62, 0x0C, 0x41, 0x84, 0x30,
  0x86, 0x08, 0xC1, 0x18, 0x13, 0x02, 0x60, 0x2C, 0x05, 0x80, 0x70, 0x0E,
  0x00, 0x80, 0x06, 0x01, 0x98, 0x20, 0x44, 0x02, 0xC0, 0x38, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x40, 0x24, 0x02, 0x20, 0x41, 0xF8, 0xFE, 0x40, 0xA0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC1, 0xBF, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x00, 0x06, 0x01, 0x98, 0x20, 0x44, 0x02,
  0xC0, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x40, 0x24, 0x02, 0x20, 0x41, 0xF8,
  0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x60, 0xFE, 0x20, 0x48, 0x0A,
  0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x81, 0x3F, 0x88, 0x42, 0x10, 0x82,
  0x20, 0x88, 0x12, 0x04, 0x80, 0xA0, 0x28, 0x04, 0x06, 0x0E, 0xE4, 0x01,
  0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00,
  0x80, 0x20, 0x04, 0x01, 0x00, 0x80, 0x28, 0x1B, 0xF8, 0xFF, 0xE0, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x40, 0x4C,
  0x18, 0xFE, 0x00, 0x80, 0x1C, 0x02, 0x40, 0x24, 0x02, 0x40, 0x62, 0x04,
  0x20, 0x42, 0x04, 0x20, 0x81, 0x08, 0x10, 0x81, 0x08, 0x09, 0x00, 0x90,
  0x09, 0x00, 0xA0, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x40, 0x28, 0x0C,
  0x05, 0x01, 0x80, 0xA0, 0x50, 0x24, 0x0A, 0x04, 0x41, 0x20, 0x88, 0x24,
  0x11, 0x04, 0x86, 0x21, 0x10, 0x82, 0x22, 0x10, 0x44, 0x22, 0x08, 0x84,
  0xC1, 0x20, 0x90, 0x34, 0x12, 0x02, 0x81, 0x40, 0x50, 0x28, 0x0A, 0x06,
  0x01, 0x80, 0xC0, 0x10, 0x18, 0x00, 0x40, 0x44, 0x18, 0x82, 0x18, 0x41,
  0x10, 0x22, 0x02, 0x80, 0x50, 0x04, 0x00, 0x80, 0x28, 0x05, 0x01, 0x10,
  0x22, 0x08, 0x21, 0x04, 0x40, 0xC8, 0x0B, 0x01, 0x80, 0x80, 0x50, 0x14,
  0x08, 0x82, 0x21, 0x88, 0x41, 0x10, 0x48, 0x1A, 0x02, 0x80, 0xC0, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0xFF, 0x80, 0xC0,
  0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x03, 0x01,
  0x01, 0x80, 0x80, 0x40, 0x40, 0x3F, 0xE0, 0xFE, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F,
  0xC0, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x10,
  0x08, 0x08, 0x04, 0x04, 0x04, 0x02, 0x02, 0x03, 0xF8, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xE0, 0x0C,
  0x01, 0x40, 0x48, 0x09, 0x82, 0x10, 0x42, 0x10, 0x22, 0x04, 0x80, 0x50,
  0x0C, 0xFF, 0xE0, 0x84, 0x21, 0x10, 0x08, 0x76, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x1F, 0x61, 0xC1, 0x81, 0x81, 0x81, 0x43, 0x7D, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x82, 0xDC, 0xC1, 0xB0, 0x28, 0x0A, 0x02,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x80, 0xA0, 0x2C, 0x0A, 0x84, 0xBE, 0x00,
  0x06, 0x19, 0x20, 0x40, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40,
  0x40, 0x20, 0x1F, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0xC4,
  0xED, 0x60, 0xD0, 0x34, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0,
  0x50, 0x14, 0x0C, 0x85, 0x3E, 0x40, 0x0C, 0x1D, 0x88, 0x48, 0x14, 0x0E,
  0x06, 0x03, 0xFF, 0x80, 0x40, 0x10, 0x08, 0x04, 0x01, 0x04, 0x7E, 0x0E,
  0x34, 0x41, 0x82, 0x04, 0x08, 0x7E, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0x0C, 0x0C, 0xD6, 0x0D, 0x03, 0x40,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x05, 0x03, 0x40, 0xC8, 0x53,
  0xE4, 0x01, 0x00, 0x40, 0x10, 0x08, 0x02, 0x77, 0x02, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x11, 0x6E, 0xC1, 0x60, 0xA0, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0xC3, 0xFF,
  0xF0, 0x24, 0x00, 0x09, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x3E, 0x00,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x81, 0x82, 0x84, 0x84, 0x88, 0x90,
  0x90, 0xB0, 0xC8, 0x88, 0x84, 0x84, 0x82, 0x82, 0x81, 0xFF, 0xFF, 0xF8,
  0x08, 0x11, 0x6C, 0xDB, 0x0A, 0x16, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60,
  0x40, 0xC0, 0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10,
  0x30, 0x20, 0x60, 0x40, 0x80, 0x08, 0x59, 0xB0, 0x58, 0x38, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x04, 0x0E,
  0xC6, 0x09, 0x03, 0x40, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x05,
  0x01, 0x40, 0x88, 0x21, 0xF0, 0x04, 0x2D, 0xCC, 0x1B, 0x02, 0x80, 0xA0,
  0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0A, 0x02, 0xC0, 0xA8, 0x49, 0xE2,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x0C, 0x0E, 0xD6, 0x0D,
  0x03, 0x40, 0x70, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x05, 0x03, 0x40,
  0xC8, 0x53, 0xE4, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x0A,
  0xFC, 0x30, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x00, 0x18,
  0x67, 0xC0, 0x80, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x02, 0x01, 0x01, 0x01,
  0x82, 0xFC, 0x20, 0x82, 0x08, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x70, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x81, 0xC0, 0xE0, 0x70, 0x34, 0x2B, 0xE4, 0x80, 0xA0, 0x50, 0x28,
  0x24, 0x11, 0x08, 0x88, 0x44, 0x12, 0x09, 0x05, 0x02, 0x80, 0xC0, 0x40,
  0x81, 0x82, 0x83, 0x05, 0x06, 0x0A, 0x14, 0x14, 0x24, 0x44, 0x48, 0x88,
  0x91, 0x12, 0x22, 0x24, 0x28, 0x28, 0x50, 0x50, 0xA0, 0xA1, 0x41, 0x81,
  0x01, 0x02, 0x00, 0x81, 0x21, 0x10, 0x84, 0x82, 0x40, 0xC0, 0x60, 0x30,
  0x34, 0x12, 0x10, 0x88, 0x48, 0x14, 0x0C, 0xC0, 0xD0, 0x24, 0x09, 0x06,
  0x21, 0x08, 0x42, 0x10, 0x48, 0x12, 0x04, 0x81, 0x40, 0x30, 0x0C, 0x03,
  0x00, 0x80, 0x20, 0x08, 0x04, 0x01, 0x02, 0x80, 0x40, 0x00, 0xFE, 0x08,
  0x10, 0x60, 0x83, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x1F, 0xC0, 0x0E,
  0x30, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x86, 0x02, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x30, 0x83,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x38, 0x00, 0x70, 0x63, 0x18,
  0x38,
};

const GFXglyph NotoSans_Condensed_ExtraLight27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 19, 6, 2, -19 },
  { 6, 5, 7, 9, 2, -19 },
  { 11, 12, 19, 13, 1, -19 },
  { 40, 10, 23, 12, 1, -21 },
  { 69, 15, 20, 18, 1, -20 },
  { 107, 12, 20, 13, 1, -20 },
  { 137, 1, 7, 5, 2, -19 },
  { 138, 5, 23, 7, 1, -19 },
  { 153, 5, 23, 7, 1, -19 },
  { 168, 9, 9, 11, 1, -21 },
  { 179, 10, 13, 12, 1, -16 },
  { 196, 3, 6, 5, 1, -3 },
  { 199, 6, 1, 8, 1, -8 },
  { 200, 2, 2, 5, 2, -2 },
  { 201, 8, 19, 9, 1, -19 },
  { 220, 10, 20, 12, 1, -20 },
  { 245, 5, 19, 12, 2, -19 },
  { 257, 10, 20, 12, 1, -20 },
  { 282, 10, 20, 12, 1, -20 },
  { 307, 12, 19, 12, 0, -19 },
  { 336, 10, 19, 12, 1, -19 },
  { 360, 10, 20, 12, 1, -20 },
  { 385, 10, 19, 12, 1, -19 },
  { 409, 10, 20, 12, 1, -20 },
  { 434, 10, 20, 12, 1, -20 },
  { 459, 2, 14, 5, 2, -14 },
  { 463, 3, 17, 5, 1, -14 },
  { 470, 10, 11, 12, 1, -15 },
  { 484, 10, 7, 12, 1, -13 },
  { 493, 10, 11, 12, 1, -15 },
  { 507, 7, 20, 9, 1, -20 },
  { 525, 16, 22, 19, 1, -19 },
  { 569, 12, 19, 12, 0, -19 },
  { 598, 10, 19, 13, 2, -19 },
  { 622, 10, 20, 13, 2, -20 },
  { 647, 11, 19, 15, 2, -19 },
  { 674, 8, 19, 12, 2, -19 },
  { 693, 8, 19, 11, 2, -19 },
  { 712, 12, 20, 16, 2, -20 },
  { 742, 11, 19, 15, 2, -19 },
  { 769, 5, 19, 7, 1, -19 },
  { 781, 5, 24, 6, -2, -19 },
  { 796, 10, 19, 12, 2, -19 },
  { 820, 8, 19, 11, 2, -19 },
  { 839, 15, 19, 19, 2, -19 },
  { 875, 11, 19, 16, 2, -19 },
  { 902, 12, 20, 16, 2, -20 },
  { 932, 9, 19, 12, 2, -19 },
  { 954, 12, 25, 16, 2, -20 },
  { 992, 10, 19, 13, 2, -19 },
  { 1016, 10, 20, 12, 1, -20 },
  { 1041, 11, 19, 11, 0, -19 },
  { 1068, 11, 19, 15, 2, -19 },
  { 1095, 12, 19, 12, 0, -19 },
  { 1124, 19, 19, 20, 0, -19 },
  { 1170, 11, 19, 11, 0, -19 },
  { 1197, 10, 19, 10, 0, -19 },
  { 1221, 9, 19, 11, 1, -19 },
  { 1243, 6, 23, 8, 2, -19 },
  { 1261, 8, 19, 9, 1, -19 },
  { 1280, 5, 23, 8, 1, -19 },
  { 1295, 11, 10, 12, 1, -19 },
  { 1309, 11, 1, 11, 0, 2 },
  { 1311, 4, 5, 6, 1, -21 },
  { 1314, 8, 15, 11, 1, -15 },
  { 1329, 10, 21, 13, 2, -21 },
  { 1356, 8, 15, 10, 1, -15 },
  { 1371, 10, 21, 13, 1, -21 },
  { 1398, 9, 15, 12, 1, -15 },
  { 1415, 7, 21, 6, 0, -21 },
  { 1434, 10, 22, 13, 1, -15 },
  { 1462, 9, 21, 13, 2, -21 },
  { 1486, 1, 20, 5, 2, -20 },
  { 1489, 3, 27, 5, 0, -20 },
  { 1500, 8, 21, 10, 2, -21 },
  { 1521, 1, 21, 5, 2, -21 },
  { 1524, 15, 15, 19, 2, -15 },
  { 1553, 9, 15, 13, 2, -15 },
  { 1570, 10, 15, 12, 1, -15 },
  { 1589, 10, 21, 13, 2, -15 },
  { 1616, 10, 21, 13, 1, -15 },
  { 1643, 6, 15, 8, 2, -15 },
  { 1655, 8, 15, 10, 1, -15 },
  { 1670, 6, 18, 7, 0, -18 },
  { 1684, 9, 14, 13, 2, -14 },
  { 1700, 9, 14, 9, 0, -14 },
  { 1716, 15, 14, 16, 0, -14 },
  { 1743, 9, 14, 10, 1, -14 },
  { 1759, 10, 21, 10, 0, -14 },
  { 1786, 7, 14, 9, 1, -14 },
  { 1799, 7, 23, 9, 1, -19 },
  { 1820, 1, 28, 12, 5, -21 },
  { 1824, 7, 23, 9, 1, -19 },
  { 1845, 10, 3, 12, 1, -11 },
};

const GFXfont NotoSans_Condensed_ExtraLight27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight27pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT27PT7B_H_
