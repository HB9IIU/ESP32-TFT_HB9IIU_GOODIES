#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT63PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight63pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x4E, 0xFF, 0xE0,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x36, 0x03, 0x40, 0x34, 0x03,
  0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x30, 0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0,
  0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x00, 0x60,
  0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x38, 0x03, 0x00, 0x01, 0x80, 0x38,
  0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60,
  0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x03, 0x00, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x1C, 0x01, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30,
  0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C,
  0x00, 0x07, 0x00, 0x60, 0x00, 0x30, 0x07, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF,
  0x81, 0xF3, 0x1F, 0x8F, 0x0C, 0x0C, 0x70, 0x30, 0x01, 0x80, 0xC0, 0x0E,
  0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03,
  0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0E, 0x03, 0x00,
  0x1C, 0x0C, 0x00, 0x78, 0x30, 0x00, 0xF0, 0xC0, 0x01, 0xF3, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0D,
  0xF0, 0x00, 0x31, 0xE0, 0x00, 0xC1, 0xC0, 0x03, 0x03, 0x80, 0x0C, 0x06,
  0x00, 0x30, 0x1C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00,
  0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x07, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0xE8, 0x03, 0x07, 0x3C, 0x0C, 0x78, 0xFF, 0xFF, 0xC0,
  0x7F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x0E, 0x00, 0x73, 0x80, 0x01, 0x80, 0x1C, 0x18, 0x00, 0x70,
  0x03, 0x03, 0x80, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x18, 0x06, 0x00,
  0x60, 0x03, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0x18, 0x01,
  0x80, 0x60, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x06, 0x03, 0x00, 0x0C,
  0x00, 0xC0, 0x60, 0x01, 0x80, 0x18, 0x1C, 0x00, 0x30, 0x03, 0x03, 0x00,
  0x06, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0x18, 0x01, 0x83,
  0x00, 0x03, 0x00, 0x30, 0xE0, 0x60, 0x60, 0x06, 0x18, 0x3F, 0x8E, 0x00,
  0xC3, 0x0E, 0x78, 0xC0, 0x38, 0xC3, 0x03, 0x18, 0x06, 0x18, 0x60, 0x73,
  0x00, 0xC7, 0x18, 0x06, 0x30, 0x38, 0xC3, 0x00, 0xC7, 0x06, 0x18, 0x60,
  0x1C, 0x7B, 0x87, 0x1C, 0x01, 0x87, 0xE0, 0xC3, 0x00, 0x30, 0x30, 0x38,
  0x60, 0x06, 0x00, 0x06, 0x0C, 0x00, 0xC0, 0x00, 0xC1, 0x80, 0x18, 0x00,
  0x38, 0x30, 0x03, 0x00, 0x06, 0x06, 0x00, 0x60, 0x01, 0xC0, 0xC0, 0x0C,
  0x00, 0x30, 0x18, 0x01, 0x80, 0x06, 0x03, 0x00, 0x30, 0x01, 0xC0, 0x60,
  0x06, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x0E, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x07, 0x00, 0x30, 0x03, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x18, 0x01,
  0x80, 0x06, 0x07, 0x00, 0x30, 0x00, 0xE0, 0xC0, 0x0C, 0x00, 0x0F, 0x70,
  0x01, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x70, 0x38, 0x00, 0x0E,
  0x01, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x0C, 0x00, 0xC0, 0x01, 0xC0, 0x0C,
  0x00, 0x1C, 0x00, 0xC0, 0x01, 0xC0, 0x0C, 0x00, 0x1C, 0x00, 0xC0, 0x01,
  0xC0, 0x0C, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0xC0, 0x1C, 0x00, 0x0E, 0x01,
  0x80, 0x00, 0x60, 0x38, 0x00, 0x06, 0x03, 0x00, 0x00, 0x30, 0x70, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0xC1, 0x80, 0x00, 0x38, 0x1C, 0x00, 0xC7, 0x00, 0xE0, 0x0C, 0x70,
  0x06, 0x00, 0xCE, 0x00, 0x70, 0x1C, 0xE0, 0x03, 0x81, 0xCC, 0x00, 0x1C,
  0x18, 0xC0, 0x00, 0xC1, 0x8C, 0x00, 0x0E, 0x38, 0xC0, 0x00, 0x73, 0x0C,
  0x00, 0x03, 0x70, 0xC0, 0x00, 0x3E, 0x0C, 0x00, 0x01, 0xE0, 0xC0, 0x00,
  0x1C, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3F, 0x07, 0x00, 0x07, 0x38,
  0x38, 0x00, 0xE1, 0x83, 0xC0, 0x3C, 0x1C, 0x1F, 0xFF, 0x80, 0xE0, 0x7F,
  0xE0, 0x07, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xB6, 0xDB,
  0x00, 0x70, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00,
  0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x80, 0x60, 0x1E, 0x06, 0x0E, 0xFC, 0x63, 0xF1, 0xFF, 0xF0, 0x01,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x19, 0x80, 0x03, 0x0C, 0x00,
  0x70, 0xE0, 0x0E, 0x06, 0x00, 0xC0, 0x30, 0x18, 0x03, 0x80, 0x80, 0x10,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x0C, 0x71, 0xC7, 0x1C, 0x61, 0x8E, 0x38, 0xC3, 0x1C,
  0x61, 0x8E, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x27, 0xFF, 0x70, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0xE0, 0x70,
  0x01, 0x81, 0x80, 0x07, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xC0, 0x00,
  0xE7, 0x00, 0x01, 0x9C, 0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x76,
  0x00, 0x01, 0xD8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xD8, 0x00,
  0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x76, 0x00, 0x01, 0x9C, 0x00, 0x06,
  0x70, 0x00, 0x18, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x1C,
  0x00, 0x70, 0x70, 0x01, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0xF0, 0x03, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x30, 0x0F, 0x01, 0xF0,
  0x3B, 0x07, 0x30, 0xE3, 0x1C, 0x37, 0x83, 0xF0, 0x34, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x00, 0x60, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF8, 0x1F,
  0x00, 0xF0, 0x70, 0x00, 0xE0, 0x80, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x1E, 0x00, 0xF0, 0xE0, 0x00, 0xE3,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC8, 0x00, 0x0E, 0x38, 0x00, 0xF0, 0xFF,
  0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x03, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x06, 0x38, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x0E, 0x1C,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0C, 0x0E, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x18, 0x07, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x06, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0x80, 0x07, 0x00,
  0x60, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x70, 0x18, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x3F, 0xC0, 0x1F, 0xFF, 0xE0, 0x7E,
  0x07, 0xC0, 0x80, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x72, 0x00, 0x07, 0x8F,
  0x00, 0x3C, 0x3F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0x80, 0x20, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x7C, 0x01, 0x87, 0xFE, 0x03, 0x1F, 0xFF, 0x0E, 0x70, 0x0F, 0x1D,
  0x80, 0x0E, 0x3E, 0x00, 0x0E, 0x7C, 0x00, 0x0C, 0xF0, 0x00, 0x1D, 0xE0,
  0x00, 0x3B, 0x80, 0x00, 0x37, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xDC, 0x00,
  0x01, 0x98, 0x00, 0x03, 0x30, 0x00, 0x07, 0x60, 0x00, 0x0C, 0xC0, 0x00,
  0x19, 0x80, 0x00, 0x33, 0x80, 0x00, 0x67, 0x00, 0x01, 0xC6, 0x00, 0x03,
  0x8E, 0x00, 0x06, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0xE0,
  0x3C, 0x03, 0x80, 0x3F, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0xF0, 0x0F, 0x01, 0xC0, 0x07, 0x07, 0x00, 0x06, 0x0C, 0x00, 0x0E,
  0x38, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x39, 0x80, 0x00, 0x73,
  0x00, 0x00, 0xE6, 0x00, 0x01, 0x8E, 0x00, 0x03, 0x0C, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x18, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x3C,
  0x1C, 0x00, 0x3C, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0x87, 0x80, 0x1C, 0x03, 0x80, 0x70, 0x03, 0x81, 0xC0, 0x03,
  0x87, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x38, 0x00, 0x07, 0x70, 0x00, 0x06,
  0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x1C, 0xE0, 0x00, 0x70, 0xE0, 0x01, 0xC0, 0xF0, 0x07, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xF8, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0xE0, 0xE0, 0x03,
  0x87, 0x00, 0x07, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x80, 0x00, 0xEE,
  0x00, 0x01, 0xB8, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0xF7, 0x00, 0x02, 0xDC,
  0x00, 0x1B, 0x38, 0x00, 0xDC, 0x70, 0x07, 0x70, 0xF8, 0xF9, 0xC1, 0xFF,
  0x87, 0x01, 0xF8, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x27, 0xFF, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x7F, 0xF7, 0x08,
  0x38, 0x78, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x61,
  0xC3, 0x87, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x06, 0x1C, 0x30, 0x61, 0x80,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0xFC, 0x3F, 0xFF,
  0x0C, 0x01, 0xC4, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x06, 0x00,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x06,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x00, 0x30, 0xE0, 0x01,
  0xFF, 0x00, 0xC3, 0x00, 0x1F, 0xFC, 0x03, 0x8C, 0x00, 0xE0, 0x30, 0x06,
  0x70, 0x07, 0x00, 0xC0, 0x19, 0xC0, 0x18, 0x03, 0x00, 0x66, 0x00, 0xE0,
  0x0C, 0x01, 0x98, 0x03, 0x00, 0x30, 0x06, 0x60, 0x1C, 0x00, 0xC0, 0x19,
  0x80, 0x60, 0x03, 0x00, 0x6E, 0x01, 0x80, 0x0C, 0x01, 0xF8, 0x06, 0x00,
  0x30, 0x07, 0xE0, 0x18, 0x00, 0xC0, 0x1B, 0x80, 0x60, 0x07, 0x00, 0x6E,
  0x01, 0x80, 0x1C, 0x01, 0xB8, 0x06, 0x00, 0x70, 0x06, 0xE0, 0x18, 0x01,
  0xC0, 0x1B, 0x80, 0x60, 0x07, 0x00, 0x6E, 0x01, 0x80, 0x1C, 0x01, 0x98,
  0x06, 0x00, 0xF0, 0x0C, 0x60, 0x1C, 0x03, 0xC0, 0x31, 0x80, 0x30, 0x0B,
  0x01, 0xC6, 0x00, 0xE0, 0x66, 0x06, 0x18, 0x01, 0xC3, 0x1C, 0x78, 0x70,
  0x03, 0xF8, 0x3F, 0xC0, 0xC0, 0x07, 0xC0, 0x7C, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x19, 0xC0, 0x00,
  0x01, 0x8C, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x70, 0x60, 0x00, 0x06, 0x07, 0x00,
  0x00, 0x60, 0x30, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0C,
  0x03, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x1C, 0x01, 0x80, 0x01, 0x80, 0x1C,
  0x00, 0x18, 0x01, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x30, 0x00, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x38, 0x0C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x18, 0x1C, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x06, 0x60, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x30, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0x80, 0x1F, 0x87, 0x00, 0x07,
  0x8E, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x38, 0x00, 0x07, 0x70, 0x00, 0x0E,
  0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x37, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0xDC, 0x00, 0x01, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0,
  0x00, 0x19, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xC7, 0x00, 0x0F, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x38, 0x07, 0xF0, 0x70, 0x00, 0x78, 0xE0, 0x00,
  0x39, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x39, 0xC0,
  0x01, 0xE3, 0x80, 0x0F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3C, 0x00, 0xE0,
  0x3C, 0x00, 0x10, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x60, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x0E, 0x00, 0xFE, 0x03,
  0x80, 0x07, 0xC0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x06, 0x38, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0E, 0xE0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0,
  0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x78, 0x38, 0x00, 0x7C, 0x0E, 0x00, 0xFC, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x60,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x73, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x0E, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x18, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0xFF, 0xC0,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE8, 0x1C, 0xFF, 0x8F, 0xF0,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x8E,
  0x00, 0x06, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x70, 0x01, 0xC0, 0xE0,
  0x03, 0x81, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01,
  0xC0, 0x1C, 0x07, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xE0,
  0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x78, 0x00,
  0x1C, 0xF8, 0x00, 0x3B, 0x38, 0x00, 0x7E, 0x70, 0x00, 0xF8, 0x70, 0x01,
  0xE0, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xC0, 0x0E, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0,
  0x07, 0x03, 0x80, 0x06, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0C, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x39, 0xC0, 0x00,
  0x73, 0x80, 0x00, 0x77, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x37, 0xF8, 0x00, 0x00, 0x06, 0xFB,
  0x00, 0x00, 0x01, 0xDF, 0x60, 0x00, 0x00, 0x33, 0xEE, 0x00, 0x00, 0x06,
  0x7C, 0xC0, 0x00, 0x01, 0xCF, 0x98, 0x00, 0x00, 0x31, 0xF3, 0x80, 0x00,
  0x06, 0x3E, 0x30, 0x00, 0x01, 0xC7, 0xC6, 0x00, 0x00, 0x30, 0xF8, 0xE0,
  0x00, 0x06, 0x1F, 0x0C, 0x00, 0x01, 0xC3, 0xE1, 0x80, 0x00, 0x30, 0x7C,
  0x38, 0x00, 0x06, 0x0F, 0x83, 0x00, 0x01, 0xC1, 0xF0, 0x60, 0x00, 0x30,
  0x3E, 0x0E, 0x00, 0x06, 0x07, 0xC0, 0xC0, 0x01, 0xC0, 0xF8, 0x18, 0x00,
  0x30, 0x1F, 0x03, 0x80, 0x06, 0x03, 0xE0, 0x30, 0x01, 0xC0, 0x7C, 0x06,
  0x00, 0x30, 0x0F, 0x80, 0xE0, 0x06, 0x01, 0xF0, 0x0C, 0x01, 0xC0, 0x3E,
  0x01, 0x80, 0x30, 0x07, 0xC0, 0x38, 0x06, 0x00, 0xF8, 0x03, 0x01, 0xC0,
  0x1F, 0x00, 0x60, 0x30, 0x03, 0xE0, 0x0E, 0x06, 0x00, 0x7C, 0x00, 0xC1,
  0xC0, 0x0F, 0x80, 0x18, 0x30, 0x01, 0xF0, 0x03, 0x86, 0x00, 0x3E, 0x00,
  0x31, 0xC0, 0x07, 0xC0, 0x06, 0x30, 0x00, 0xF8, 0x00, 0xE6, 0x00, 0x1F,
  0x00, 0x0D, 0xC0, 0x03, 0xE0, 0x01, 0xB0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0E,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0xC0, 0x00,
  0x0F, 0xB8, 0x00, 0x03, 0xE6, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x3E, 0x30,
  0x00, 0x0F, 0x8E, 0x00, 0x03, 0xE1, 0x80, 0x00, 0xF8, 0x70, 0x00, 0x3E,
  0x0C, 0x00, 0x0F, 0x83, 0x80, 0x03, 0xE0, 0x60, 0x00, 0xF8, 0x1C, 0x00,
  0x3E, 0x03, 0x00, 0x0F, 0x80, 0xE0, 0x03, 0xE0, 0x18, 0x00, 0xF8, 0x07,
  0x00, 0x3E, 0x00, 0xC0, 0x0F, 0x80, 0x38, 0x03, 0xE0, 0x06, 0x00, 0xF8,
  0x01, 0xC0, 0x3E, 0x00, 0x30, 0x0F, 0x80, 0x0E, 0x03, 0xE0, 0x01, 0xC0,
  0xF8, 0x00, 0x70, 0x3E, 0x00, 0x0E, 0x0F, 0x80, 0x03, 0x83, 0xE0, 0x00,
  0x70, 0xF8, 0x00, 0x1C, 0x3E, 0x00, 0x03, 0x8F, 0x80, 0x00, 0xE3, 0xE0,
  0x00, 0x1C, 0xF8, 0x00, 0x07, 0x3E, 0x00, 0x00, 0xEF, 0x80, 0x00, 0x1B,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x01, 0x87, 0x00, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x0C, 0x60, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x01, 0xB8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x70,
  0xC0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x30, 0x1C,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x07, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x38, 0x07, 0xE1, 0xC0, 0x07,
  0xCE, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0x80, 0x00, 0xDC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x73,
  0x80, 0x0F, 0x1C, 0x01, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xF0, 0x07, 0xC0, 0x07, 0x00, 0x07, 0x80, 0x38, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0, 0xC0,
  0x00, 0x01, 0x87, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x33, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x06, 0xE0, 0x00, 0x00, 0x39, 0x80, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x01, 0x83,
  0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x03, 0x80, 0x7F, 0x07, 0x00, 0x0F, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0x39, 0xC0, 0x00, 0x33, 0x80, 0x00, 0x67, 0x00, 0x00, 0xCE, 0x00, 0x01,
  0x9C, 0x00, 0x03, 0x38, 0x00, 0x06, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0x73, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x1C,
  0x00, 0x38, 0x38, 0x03, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xC0,
  0x30, 0x03, 0x80, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x00,
  0xC0, 0x38, 0x01, 0xC0, 0x70, 0x01, 0x80, 0xE0, 0x03, 0x81, 0xC0, 0x03,
  0x03, 0x80, 0x07, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0C,
  0x38, 0x00, 0x1C, 0x70, 0x00, 0x18, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x33,
  0x80, 0x00, 0x77, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x87, 0xC0, 0x0E, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC8, 0x00, 0x0E, 0x38, 0x00, 0xF0, 0xFF, 0xFF,
  0x81, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x76, 0x00, 0x00, 0x3B,
  0x00, 0x00, 0x19, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x0E, 0x38, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x01, 0xC3, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x18, 0x18, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x30, 0x1C, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x60,
  0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0xE0, 0x06, 0x00, 0x0C, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x03, 0x80, 0x18,
  0x00, 0x38, 0x01, 0x80, 0x01, 0x80, 0x38, 0x00, 0x18, 0x03, 0x80, 0x01,
  0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0xE0, 0x60, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00,
  0x07, 0x0C, 0x00, 0x00, 0x70, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x31,
  0x80, 0x00, 0x03, 0x98, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x76, 0x00,
  0x00, 0xF0, 0x00, 0x06, 0x60, 0x00, 0x0F, 0x00, 0x00, 0x66, 0x00, 0x01,
  0xF0, 0x00, 0x0E, 0x70, 0x00, 0x1B, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xB8,
  0x00, 0x0C, 0x30, 0x00, 0x19, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x98, 0x00,
  0x1C, 0x38, 0x00, 0x39, 0x80, 0x01, 0xC3, 0x80, 0x03, 0x1C, 0x00, 0x18,
  0x18, 0x00, 0x31, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x0C, 0x00, 0x38, 0x1C,
  0x00, 0x70, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x0C, 0x00, 0x38, 0x0C, 0x00,
  0x60, 0xE0, 0x03, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60,
  0x60, 0x07, 0x00, 0xE0, 0x0E, 0x06, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x70,
  0x06, 0x00, 0x60, 0x0C, 0x07, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x30, 0x0E,
  0x00, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x00,
  0x30, 0x18, 0x03, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x18, 0x1C, 0x00, 0x38,
  0x18, 0x01, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x18, 0x18, 0x00, 0x18, 0x30,
  0x01, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x30, 0x00,
  0xC3, 0x80, 0x01, 0xC7, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0xC3,
  0x00, 0x00, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x67, 0x00,
  0x00, 0xE6, 0x00, 0x06, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x66, 0x00, 0x00,
  0x6C, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x36, 0x00, 0x00, 0x6C,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x01, 0x83,
  0x80, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0xE0, 0x18, 0x00, 0x60,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x30, 0x01, 0xC0, 0x38, 0x00, 0x60, 0x1C,
  0x00, 0x38, 0x0C, 0x00, 0x1C, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x73, 0x80, 0x00, 0x19, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x1C, 0xE0, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x18, 0x00, 0x06, 0x0E, 0x00,
  0x07, 0x03, 0x00, 0x03, 0x01, 0xC0, 0x03, 0x80, 0x60, 0x01, 0x80, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x00,
  0xC0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x18, 0x38, 0x00, 0x0E, 0x1C, 0x00,
  0x03, 0x0C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x03, 0x60, 0x00, 0x07, 0x70, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x30,
  0x00, 0x0E, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x18, 0x1C,
  0x00, 0x38, 0x0C, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x06, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x07, 0x00, 0x60, 0x03, 0x00, 0xE0, 0x03, 0x80, 0xC0, 0x01,
  0x81, 0xC0, 0x01, 0x81, 0x80, 0x01, 0xC1, 0x80, 0x00, 0xC3, 0x80, 0x00,
  0xE3, 0x00, 0x00, 0x67, 0x00, 0x00, 0x66, 0x00, 0x00, 0x76, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0xFF,
  0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x07,
  0x70, 0x00, 0x03, 0x18, 0x00, 0x03, 0x8E, 0x00, 0x01, 0x83, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xE0, 0x38, 0x00, 0x60, 0x0C, 0x00,
  0x70, 0x07, 0x00, 0x30, 0x01, 0x80, 0x38, 0x00, 0xE0, 0x18, 0x00, 0x30,
  0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x86, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x73, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0D, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x01, 0xFC, 0x01,
  0xFF, 0xE0, 0xFC, 0x3E, 0x08, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x03, 0xFF, 0x03,
  0xFF, 0xE1, 0xF0, 0x0C, 0xF0, 0x01, 0xB8, 0x00, 0x36, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x17, 0xC0, 0x06, 0xD8, 0x00, 0xDB, 0x80,
  0x73, 0x3F, 0x7C, 0x63, 0xFF, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x0F, 0xE0, 0x30, 0xFF, 0xE0, 0xC7, 0x87, 0xC3, 0x38, 0x03, 0x8D, 0x80,
  0x07, 0x36, 0x00, 0x1C, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xEE, 0x00, 0x01,
  0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0,
  0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x07, 0x36, 0x00, 0x1C, 0xDC, 0x00,
  0xE3, 0x38, 0x07, 0x0C, 0x7F, 0xF8, 0x30, 0xFF, 0xC0, 0x00, 0x38, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x1F, 0x87, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x02, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x0F, 0xC0, 0xC0, 0xFF, 0xC3, 0x07, 0x83, 0xCC, 0x38,
  0x03, 0x31, 0xC0, 0x06, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x3C, 0xC0, 0x00,
  0x77, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8,
  0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x73, 0x80, 0x03, 0xCE, 0x00,
  0x0B, 0x1C, 0x00, 0x6C, 0x38, 0x07, 0x30, 0x7F, 0xF8, 0xC0, 0xFF, 0xC1,
  0x00, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xE1, 0xE0, 0x1C,
  0x03, 0x81, 0xC0, 0x0E, 0x0C, 0x00, 0x30, 0xE0, 0x01, 0xC6, 0x00, 0x06,
  0x70, 0x00, 0x3B, 0x00, 0x01, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x41, 0xE0, 0x06, 0x07, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0x00, 0x00,
  0x7F, 0x01, 0xFF, 0x03, 0xC1, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFE, 0x30, 0x7C, 0x3C, 0xC3, 0x80, 0x3B, 0x1C, 0x00,
  0x6C, 0xE0, 0x00, 0xF3, 0x80, 0x01, 0xCC, 0x00, 0x07, 0x70, 0x00, 0x1D,
  0x80, 0x00, 0x76, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x77, 0x00,
  0x01, 0xDC, 0x00, 0x0F, 0x38, 0x00, 0x3C, 0xE0, 0x01, 0xB1, 0xC0, 0x0E,
  0xC3, 0x80, 0x73, 0x07, 0xFF, 0x8C, 0x0F, 0xFC, 0x30, 0x03, 0x80, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x71, 0x80, 0x03, 0xC7, 0xC0, 0x3E, 0x0F, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0xFC, 0x0C, 0x3F, 0xF0, 0xC7, 0x87, 0x8C, 0xE0, 0x1C, 0xD8,
  0x00, 0xED, 0x80, 0x0E, 0xF0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x6F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x03, 0x03, 0xC1, 0xE0, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0xA3, 0x9F, 0xCF, 0x80, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x16, 0x00, 0x1C,
  0xC0, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x38, 0x60, 0x06, 0x0C, 0x01, 0xC1,
  0x80, 0x70, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0xE0, 0x18, 0x38, 0x03,
  0x06, 0x00, 0x61, 0xC0, 0x0C, 0x78, 0x01, 0x8F, 0x00, 0x33, 0x70, 0x06,
  0xE6, 0x00, 0xD8, 0xE0, 0x1E, 0x0C, 0x03, 0x81, 0xC0, 0x60, 0x18, 0x0C,
  0x03, 0x81, 0x80, 0x30, 0x30, 0x07, 0x06, 0x00, 0x60, 0xC0, 0x0E, 0x18,
  0x00, 0xC3, 0x00, 0x1C, 0x60, 0x01, 0x8C, 0x00, 0x39, 0x80, 0x03, 0x30,
  0x00, 0x76, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x01, 0xF8, 0x30, 0xFF, 0x81, 0xFF,
  0x8C, 0xF0, 0xF0, 0xF0, 0xF3, 0x30, 0x0E, 0x70, 0x0E, 0xD8, 0x03, 0x98,
  0x03, 0xBC, 0x00, 0x6C, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x03,
  0x80, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03,
  0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30,
  0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x0F, 0x00,
  0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x3C,
  0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0x30, 0x00, 0x30, 0x00, 0xFC, 0x0C, 0x3F, 0xF0, 0xC7, 0x87,
  0x8C, 0xE0, 0x1C, 0xD8, 0x00, 0xED, 0x80, 0x0E, 0xF0, 0x00, 0x6E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x1E, 0x0F, 0x80, 0x70, 0x07, 0x01, 0xC0, 0x07, 0x07, 0x00, 0x07, 0x0C,
  0x00, 0x06, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x19, 0x80,
  0x00, 0x37, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xB0, 0x00, 0x07, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0x71,
  0x80, 0x00, 0xE3, 0x80, 0x03, 0x83, 0x00, 0x07, 0x07, 0x00, 0x1C, 0x07,
  0x80, 0x70, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFE, 0x03, 0x0F, 0xFE, 0x0C, 0x78, 0x7C, 0x33, 0x80, 0x78, 0xDC, 0x00,
  0x73, 0x60, 0x01, 0xCF, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xE0, 0x00, 0x1B,
  0x80, 0x00, 0x6E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00,
  0x03, 0xBC, 0x00, 0x0E, 0xD0, 0x00, 0x73, 0x60, 0x01, 0xCC, 0xC0, 0x0E,
  0x33, 0x80, 0x70, 0xC7, 0xFF, 0x83, 0x07, 0xFC, 0x0C, 0x03, 0x80, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x30, 0x78, 0x7C, 0xC3, 0x80,
  0x33, 0x1C, 0x00, 0x6C, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0xCC, 0x00, 0x07,
  0x70, 0x00, 0x1D, 0x80, 0x00, 0x76, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x60, 0x00, 0x1D, 0x80,
  0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x0F, 0x38, 0x00, 0x3C, 0xE0, 0x01,
  0xB1, 0xC0, 0x0E, 0xC3, 0x80, 0x73, 0x07, 0xFF, 0x8C, 0x0F, 0xF8, 0x30,
  0x03, 0x80, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xFE, 0x1F, 0xF1, 0xFF, 0x9C, 0x0C,
  0xC0, 0x6C, 0x03, 0x40, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x00, 0x01, 0xFE, 0x03, 0xFF, 0xE1, 0xF0, 0x7C, 0xE0, 0x02, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x3B, 0x80,
  0x1E, 0xFF, 0xFF, 0x0F, 0xFF, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0x80, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xBE, 0x00, 0x1B, 0xE0, 0x01, 0xB7, 0x00,
  0x33, 0x78, 0x0E, 0x33, 0xFF, 0xC3, 0x0F, 0xF8, 0x30, 0x18, 0x00, 0xE0,
  0x00, 0x1D, 0x80, 0x00, 0x66, 0x00, 0x01, 0x9C, 0x00, 0x0E, 0x30, 0x00,
  0x30, 0xC0, 0x00, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x60,
  0x60, 0x01, 0x81, 0xC0, 0x0E, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30,
  0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x60, 0x06, 0x01, 0x80, 0x1C, 0x0E,
  0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0E, 0x1C, 0x00,
  0x18, 0x60, 0x00, 0x61, 0x80, 0x01, 0xCE, 0x00, 0x03, 0x30, 0x00, 0x0C,
  0xC0, 0x00, 0x33, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xFC, 0x00,
  0x1C, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x03, 0x30, 0x00, 0xF8, 0x00, 0x66,
  0x00, 0x1B, 0x00, 0x0C, 0xC0, 0x03, 0x60, 0x03, 0x9C, 0x00, 0x6E, 0x00,
  0x61, 0x80, 0x1C, 0xC0, 0x0C, 0x30, 0x03, 0x18, 0x01, 0x86, 0x00, 0x63,
  0x00, 0x70, 0xE0, 0x0C, 0x70, 0x0E, 0x0C, 0x03, 0x86, 0x01, 0x81, 0x80,
  0x60, 0xC0, 0x30, 0x30, 0x0C, 0x18, 0x06, 0x07, 0x01, 0x83, 0x81, 0xC0,
  0x60, 0x70, 0x70, 0x30, 0x0C, 0x0C, 0x06, 0x06, 0x01, 0x81, 0x80, 0xC0,
  0xC0, 0x38, 0x30, 0x1C, 0x38, 0x07, 0x0E, 0x03, 0x86, 0x00, 0x61, 0x80,
  0x30, 0xC0, 0x0C, 0x30, 0x06, 0x18, 0x01, 0xC6, 0x00, 0xC7, 0x00, 0x39,
  0xC0, 0x1C, 0xC0, 0x03, 0x30, 0x01, 0x98, 0x00, 0x66, 0x00, 0x33, 0x00,
  0x0C, 0xC0, 0x06, 0x60, 0x01, 0xD8, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x39, 0x80, 0x03,
  0x8E, 0x00, 0x18, 0x30, 0x01, 0xC1, 0xC0, 0x0C, 0x06, 0x00, 0xE0, 0x38,
  0x06, 0x00, 0xC0, 0x70, 0x07, 0x03, 0x00, 0x1C, 0x38, 0x00, 0x61, 0x80,
  0x03, 0x9C, 0x00, 0x0C, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x37, 0x00, 0x03, 0x98, 0x00,
  0x18, 0xE0, 0x01, 0xC3, 0x00, 0x0C, 0x1C, 0x00, 0xE0, 0x60, 0x06, 0x03,
  0x80, 0x70, 0x0C, 0x03, 0x00, 0x70, 0x38, 0x01, 0x81, 0x80, 0x0E, 0x1C,
  0x00, 0x38, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x70, 0x00,
  0x0D, 0xC0, 0x00, 0x73, 0x00, 0x01, 0xCC, 0x00, 0x06, 0x38, 0x00, 0x18,
  0x60, 0x00, 0xE1, 0x80, 0x03, 0x07, 0x00, 0x0C, 0x1C, 0x00, 0x70, 0x30,
  0x01, 0xC0, 0xC0, 0x06, 0x03, 0x80, 0x18, 0x06, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x70, 0x0C, 0x01, 0xC0, 0x70, 0x03, 0x01, 0xC0, 0x0C, 0x06, 0x00,
  0x38, 0x18, 0x00, 0x60, 0xE0, 0x01, 0x83, 0x00, 0x07, 0x0C, 0x00, 0x0C,
  0x70, 0x00, 0x31, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x98, 0x00, 0x06, 0xE0,
  0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x02, 0x1C, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00,
  0x7F, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0x1F, 0xC0, 0x01, 0x3F, 0xF0, 0x01, 0x70, 0x7C, 0x03, 0xC0, 0x0F,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraLight63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 45, 13, 5, -45 },
  { 24, 12, 16, 20, 4, -45 },
  { 48, 29, 45, 31, 1, -45 },
  { 212, 22, 52, 28, 3, -48 },
  { 355, 35, 47, 41, 3, -46 },
  { 561, 28, 47, 31, 3, -46 },
  { 726, 3, 16, 11, 4, -45 },
  { 732, 12, 55, 17, 3, -45 },
  { 815, 12, 55, 17, 2, -45 },
  { 898, 20, 20, 26, 3, -48 },
  { 948, 24, 29, 29, 2, -37 },
  { 1035, 6, 15, 12, 2, -7 },
  { 1047, 14, 2, 18, 2, -18 },
  { 1051, 4, 5, 13, 4, -5 },
  { 1054, 19, 45, 21, 1, -45 },
  { 1161, 22, 47, 28, 3, -46 },
  { 1291, 12, 45, 28, 5, -45 },
  { 1359, 22, 46, 28, 3, -46 },
  { 1486, 22, 47, 28, 3, -46 },
  { 1616, 27, 45, 28, 1, -45 },
  { 1768, 22, 46, 28, 3, -45 },
  { 1895, 23, 46, 28, 3, -45 },
  { 2028, 22, 45, 28, 3, -45 },
  { 2152, 23, 47, 28, 3, -46 },
  { 2288, 22, 47, 28, 3, -46 },
  { 2418, 4, 34, 13, 4, -34 },
  { 2435, 7, 42, 13, 2, -34 },
  { 2472, 24, 27, 29, 2, -36 },
  { 2553, 24, 16, 29, 2, -30 },
  { 2601, 24, 27, 29, 2, -36 },
  { 2682, 17, 46, 20, 1, -46 },
  { 2780, 38, 51, 44, 3, -45 },
  { 3023, 28, 45, 28, 0, -45 },
  { 3181, 23, 45, 31, 5, -45 },
  { 3311, 25, 47, 30, 4, -46 },
  { 3458, 26, 45, 34, 5, -45 },
  { 3605, 19, 45, 27, 5, -45 },
  { 3712, 19, 45, 25, 5, -45 },
  { 3819, 29, 47, 37, 4, -46 },
  { 3990, 25, 45, 35, 5, -45 },
  { 4131, 10, 45, 16, 3, -45 },
  { 4188, 12, 56, 13, -4, -45 },
  { 4272, 23, 45, 28, 5, -45 },
  { 4402, 19, 45, 25, 5, -45 },
  { 4509, 35, 45, 45, 5, -45 },
  { 4706, 26, 45, 36, 5, -45 },
  { 4853, 30, 47, 37, 4, -46 },
  { 5030, 21, 45, 29, 5, -45 },
  { 5149, 30, 57, 37, 4, -46 },
  { 5363, 23, 45, 29, 5, -45 },
  { 5493, 22, 47, 28, 3, -46 },
  { 5623, 25, 45, 25, 0, -45 },
  { 5764, 25, 46, 35, 5, -45 },
  { 5908, 28, 45, 28, 0, -45 },
  { 6066, 44, 45, 46, 1, -45 },
  { 6314, 25, 45, 25, 0, -45 },
  { 6455, 24, 45, 24, 0, -45 },
  { 6590, 22, 45, 26, 2, -45 },
  { 6714, 13, 55, 20, 5, -45 },
  { 6804, 19, 45, 21, 1, -45 },
  { 6911, 12, 55, 20, 2, -45 },
  { 6994, 25, 24, 29, 2, -45 },
  { 7069, 25, 2, 25, 0, 6 },
  { 7076, 10, 10, 15, 3, -48 },
  { 7089, 19, 35, 26, 3, -34 },
  { 7173, 22, 49, 30, 5, -48 },
  { 7308, 19, 35, 23, 3, -34 },
  { 7392, 22, 49, 30, 3, -48 },
  { 7527, 21, 35, 27, 3, -34 },
  { 7619, 16, 48, 15, 1, -48 },
  { 7715, 22, 49, 30, 3, -34 },
  { 7850, 20, 48, 29, 5, -48 },
  { 7970, 4, 46, 12, 4, -46 },
  { 7993, 9, 61, 12, -1, -46 },
  { 8062, 19, 48, 24, 5, -48 },
  { 8176, 2, 48, 12, 5, -48 },
  { 8188, 34, 34, 44, 5, -34 },
  { 8333, 20, 34, 29, 5, -34 },
  { 8418, 23, 35, 29, 3, -34 },
  { 8519, 22, 49, 30, 5, -34 },
  { 8654, 22, 49, 30, 3, -34 },
  { 8789, 13, 34, 19, 5, -34 },
  { 8845, 18, 35, 23, 2, -34 },
  { 8924, 14, 42, 16, 1, -41 },
  { 8998, 20, 34, 29, 5, -33 },
  { 9083, 22, 33, 22, 0, -33 },
  { 9174, 35, 33, 37, 1, -33 },
  { 9319, 21, 33, 24, 1, -33 },
  { 9406, 22, 48, 23, 0, -33 },
  { 9538, 17, 33, 20, 2, -33 },
  { 9609, 16, 55, 22, 3, -45 },
  { 9719, 3, 63, 27, 12, -48 },
  { 9743, 16, 55, 22, 3, -45 },
  { 9853, 24, 6, 29, 2, -25 },
};

const GFXfont NotoSans_Condensed_ExtraLight63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight63pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT63PT7B_H_
