#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT32PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight32pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x40, 0x3C, 0xC6, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x04, 0x10, 0x10, 0x40, 0x42, 0x01, 0x08, 0x04, 0x20, 0x20, 0x80,
  0x82, 0x1F, 0xFF, 0x08, 0x20, 0x21, 0x80, 0x84, 0x02, 0x10, 0x10, 0x40,
  0x41, 0x01, 0x04, 0x3F, 0xFE, 0x10, 0xC0, 0x42, 0x01, 0x08, 0x0C, 0x20,
  0x20, 0x80, 0x82, 0x02, 0x08, 0x00, 0x04, 0x00, 0x40, 0x1F, 0xC6, 0x42,
  0x44, 0x0C, 0x40, 0xC4, 0x0C, 0x40, 0x44, 0x04, 0x40, 0x24, 0x01, 0xC0,
  0x07, 0x00, 0x58, 0x04, 0x60, 0x42, 0x04, 0x30, 0x41, 0x04, 0x10, 0x43,
  0x04, 0x2C, 0x44, 0x7F, 0x80, 0x40, 0x04, 0x00, 0x40, 0x78, 0x0C, 0x26,
  0x04, 0x21, 0x02, 0x10, 0x82, 0x08, 0x61, 0x04, 0x11, 0x02, 0x08, 0x81,
  0x04, 0x40, 0x82, 0x40, 0x43, 0x27, 0x21, 0x26, 0x50, 0x92, 0x14, 0xC9,
  0x0B, 0xC9, 0x04, 0x04, 0x82, 0x04, 0x41, 0x02, 0x20, 0x81, 0x10, 0x41,
  0x08, 0x20, 0x86, 0x10, 0x81, 0x08, 0x40, 0x88, 0x60, 0x3C, 0x0F, 0x00,
  0x21, 0x00, 0xC2, 0x01, 0x06, 0x02, 0x04, 0x04, 0x18, 0x0C, 0x20, 0x08,
  0x40, 0x19, 0x00, 0x16, 0x00, 0x38, 0x00, 0xF0, 0x03, 0x20, 0x0C, 0x20,
  0x90, 0x63, 0x60, 0x44, 0xC0, 0x49, 0x80, 0xF3, 0x00, 0xC2, 0x01, 0x84,
  0x07, 0x8C, 0x19, 0x87, 0xE1, 0x80, 0xEA, 0xAA, 0x08, 0x8C, 0x46, 0x21,
  0x18, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0C, 0x21, 0x0C, 0x21,
  0x84, 0x10, 0xC1, 0x02, 0x0C, 0x10, 0x40, 0x82, 0x08, 0x30, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0xC2, 0x08, 0x21, 0x84, 0x30, 0x86, 0x30, 0x08,
  0x02, 0x00, 0x82, 0x23, 0x7F, 0x02, 0x01, 0x40, 0x88, 0x63, 0x10, 0x40,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x25,
  0xA4, 0xA0, 0xFE, 0xF0, 0x00, 0x80, 0x40, 0x40, 0x20, 0x30, 0x10, 0x08,
  0x0C, 0x04, 0x02, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x60, 0x20, 0x10,
  0x18, 0x08, 0x04, 0x04, 0x02, 0x00, 0x1F, 0x06, 0x31, 0x82, 0x20, 0x2C,
  0x05, 0x00, 0xA0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0B, 0x01, 0x20, 0x26, 0x08, 0x43,
  0x07, 0xC0, 0x0C, 0x73, 0x51, 0x84, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x40, 0x1F, 0x86, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x18,
  0x03, 0x00, 0x20, 0x04, 0x00, 0xFF, 0xF0, 0x3F, 0x8E, 0x0C, 0x40, 0x60,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x03, 0x01,
  0xF0, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x6C, 0x0C, 0x7F, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x50, 0x02,
  0x80, 0x24, 0x01, 0x20, 0x11, 0x01, 0x88, 0x08, 0x40, 0xC2, 0x04, 0x10,
  0x40, 0x82, 0x04, 0x20, 0x21, 0x01, 0x10, 0x08, 0xFF, 0xF8, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x7F, 0xC8, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x13, 0xC3, 0xDE, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20,
  0x0D, 0x03, 0x3F, 0xC0, 0x0F, 0xC3, 0x00, 0xC0, 0x30, 0x04, 0x00, 0x80,
  0x30, 0x04, 0x00, 0x80, 0x13, 0xE2, 0xC2, 0x60, 0x2C, 0x05, 0x00, 0xE0,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xA0, 0x24, 0x04, 0x41, 0x07, 0xC0,
  0xFF, 0xF0, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x00, 0x1F,
  0x83, 0x0C, 0x20, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x22, 0x02, 0x30,
  0x41, 0x88, 0x0F, 0x00, 0xF0, 0x10, 0xC2, 0x06, 0x40, 0x24, 0x03, 0xC0,
  0x1C, 0x01, 0xC0, 0x14, 0x03, 0x60, 0x23, 0x06, 0x1F, 0x80, 0x1F, 0x03,
  0x0C, 0x60, 0x44, 0x06, 0x40, 0x2C, 0x02, 0xC0, 0x2C, 0x03, 0xC0, 0x34,
  0x03, 0x40, 0x36, 0x07, 0x20, 0xF1, 0xF3, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x18, 0x7E, 0x00, 0xF4, 0x00, 0x00,
  0x03, 0xC0, 0x6C, 0x80, 0x00, 0x00, 0x00, 0x09, 0x69, 0x28, 0x00, 0x10,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x10, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00,
  0xC0, 0x00, 0x7C, 0x82, 0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x06,
  0x04, 0x08, 0x18, 0x10, 0x30, 0x20, 0x20, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x30, 0x01, 0xF0, 0x00, 0xC1, 0x80, 0x60, 0x08, 0x08, 0x00, 0x82, 0x00,
  0x08, 0xC0, 0x01, 0x10, 0x00, 0x12, 0x0F, 0xC2, 0x83, 0x08, 0x50, 0x41,
  0x0A, 0x18, 0x21, 0xC2, 0x04, 0x38, 0x41, 0x87, 0x08, 0x30, 0xE1, 0x06,
  0x14, 0x20, 0xC2, 0x84, 0x18, 0x50, 0x45, 0x1A, 0x0F, 0xBE, 0x60, 0x00,
  0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x08,
  0x00, 0x7E, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x28, 0x00, 0xA0, 0x04, 0x80,
  0x13, 0x00, 0x44, 0x03, 0x10, 0x08, 0x40, 0x21, 0x80, 0x82, 0x06, 0x08,
  0x10, 0x20, 0x7F, 0xC3, 0x01, 0x08, 0x04, 0x20, 0x18, 0x80, 0x26, 0x00,
  0x90, 0x02, 0x40, 0x0F, 0x00, 0x18, 0x00, 0x40, 0xFF, 0x10, 0x32, 0x01,
  0x40, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x50, 0x1B, 0xFC, 0x7F,
  0xC8, 0x0D, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x05, 0x03, 0xBF, 0xC0, 0x07, 0xF8, 0xE0, 0x8C, 0x00, 0x40, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x08, 0x1F, 0xC0, 0xFE, 0x04, 0x1C, 0x20, 0x31, 0x00,
  0xC8, 0x02, 0x40, 0x1A, 0x00, 0x50, 0x02, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x50, 0x02, 0x80, 0x14, 0x01, 0xA0,
  0x09, 0x00, 0xC8, 0x0C, 0x40, 0xC3, 0xF8, 0x00, 0xFF, 0xC0, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x3F, 0xFF, 0xF8, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFE, 0xFF, 0xC0,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x1F, 0xFF,
  0xFC, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00,
  0x03, 0xF8, 0x18, 0x18, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x0F,
  0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x06, 0x80, 0x0D, 0x00, 0x19,
  0x00, 0x33, 0x00, 0x63, 0x80, 0xC1, 0xFF, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0xFC, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF,
  0xC0, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0xFE, 0x70, 0x80,
  0x70, 0x0A, 0x02, 0x40, 0xC8, 0x31, 0x04, 0x21, 0x84, 0x60, 0x88, 0x12,
  0x02, 0xC0, 0x5C, 0x0C, 0x81, 0x08, 0x21, 0x84, 0x10, 0x83, 0x10, 0x22,
  0x06, 0x40, 0x48, 0x05, 0x00, 0xA0, 0x08, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFE, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x7A, 0x00, 0x2D, 0x00, 0x16, 0xC0, 0x1B,
  0x20, 0x09, 0x90, 0x04, 0xCC, 0x06, 0x62, 0x02, 0x31, 0x01, 0x18, 0xC1,
  0x8C, 0x20, 0x86, 0x10, 0x43, 0x0C, 0x61, 0x82, 0x20, 0xC1, 0x10, 0x60,
  0xD8, 0x30, 0x28, 0x18, 0x14, 0x0C, 0x0E, 0x06, 0x02, 0x02, 0x80, 0x0E,
  0x00, 0x70, 0x03, 0xC0, 0x1A, 0x00, 0xC8, 0x06, 0x40, 0x31, 0x01, 0x88,
  0x0C, 0x20, 0x61, 0x03, 0x04, 0x18, 0x20, 0xC0, 0x86, 0x04, 0x30, 0x11,
  0x80, 0x8C, 0x02, 0x60, 0x13, 0x00, 0x58, 0x02, 0xC0, 0x0E, 0x00, 0x60,
  0x0F, 0xE0, 0x30, 0x60, 0xC0, 0x63, 0x00, 0x64, 0x00, 0x48, 0x00, 0xB0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x06, 0x80, 0x09, 0x00, 0x13,
  0x00, 0x63, 0x01, 0x83, 0x06, 0x03, 0xF8, 0x00, 0xFE, 0x21, 0xE8, 0x0A,
  0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x06, 0xFF,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x00, 0x0F, 0xE0, 0x30, 0x60, 0xC0, 0x63, 0x00, 0x64, 0x00, 0x48, 0x00,
  0xB0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x06, 0x80, 0x09, 0x00,
  0x13, 0x00, 0x63, 0x01, 0x83, 0x06, 0x03, 0xF8, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0xFE, 0x10, 0x72, 0x02, 0x40, 0x28,
  0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50, 0x1A, 0x02, 0x41, 0x8F, 0xC1,
  0x0C, 0x20, 0x84, 0x18, 0x81, 0x10, 0x32, 0x02, 0x40, 0x68, 0x05, 0x00,
  0xE0, 0x08, 0x0F, 0xC3, 0x02, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x68, 0x0C, 0x7F,
  0x80, 0xFF, 0xF0, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x16, 0x01, 0x18, 0x18,
  0x7F, 0x00, 0x80, 0x07, 0x00, 0x34, 0x00, 0x90, 0x02, 0x40, 0x09, 0x80,
  0x62, 0x01, 0x08, 0x04, 0x30, 0x30, 0x40, 0x81, 0x02, 0x04, 0x08, 0x18,
  0x60, 0x21, 0x00, 0x84, 0x02, 0x10, 0x0C, 0xC0, 0x12, 0x00, 0x48, 0x01,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x10, 0x02, 0x80, 0x20,
  0x0D, 0x00, 0xE0, 0x12, 0x01, 0x40, 0x26, 0x02, 0x80, 0x44, 0x05, 0x01,
  0x88, 0x0B, 0x02, 0x10, 0x32, 0x04, 0x30, 0x44, 0x08, 0x20, 0x88, 0x30,
  0x41, 0x18, 0x60, 0x86, 0x10, 0x81, 0x08, 0x21, 0x03, 0x10, 0x46, 0x02,
  0x20, 0x8C, 0x04, 0x41, 0x90, 0x09, 0x81, 0x20, 0x1A, 0x02, 0x40, 0x14,
  0x05, 0x80, 0x28, 0x0A, 0x00, 0x50, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0x80,
  0x30, 0x00, 0x40, 0x11, 0x01, 0x88, 0x08, 0x60, 0x41, 0x04, 0x0C, 0x20,
  0x22, 0x01, 0x90, 0x05, 0x80, 0x28, 0x00, 0xC0, 0x04, 0x00, 0x50, 0x02,
  0x80, 0x32, 0x01, 0x10, 0x18, 0xC0, 0x82, 0x0C, 0x18, 0x40, 0x46, 0x02,
  0x20, 0x0B, 0x00, 0x60, 0x80, 0x14, 0x01, 0x40, 0x26, 0x02, 0x20, 0x62,
  0x04, 0x10, 0x41, 0x08, 0x18, 0x80, 0x98, 0x09, 0x00, 0x50, 0x06, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0xFF, 0xE0, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x40, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x80, 0x3F, 0xF8, 0xFE,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x80, 0x40, 0x30, 0x08,
  0x04, 0x01, 0x00, 0x80, 0x60, 0x10, 0x08, 0x06, 0x01, 0x00, 0x80, 0x20,
  0x10, 0x08, 0x02, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x0C, 0x02, 0xFC, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x7F, 0x02, 0x00, 0x38, 0x01, 0x40,
  0x13, 0x00, 0x88, 0x08, 0x60, 0x41, 0x04, 0x08, 0x20, 0x22, 0x01, 0x10,
  0x05, 0x00, 0x30, 0xFF, 0xF8, 0xC1, 0x0C, 0x30, 0x80, 0x3F, 0x08, 0x20,
  0x0C, 0x01, 0x00, 0x40, 0x10, 0x04, 0x0F, 0x1C, 0x58, 0x14, 0x07, 0x01,
  0xC0, 0x70, 0x34, 0x0D, 0x85, 0x3E, 0x40, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xF8, 0xD0, 0xCE, 0x06, 0xC0, 0x2C,
  0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x02, 0xC0, 0x2E, 0x06, 0xB0, 0xC9, 0xF8, 0x1F, 0x98, 0x18, 0x18, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x06, 0x01, 0x00,
  0xC0, 0x1F, 0x80, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0xF9, 0x60, 0xA8, 0x0F, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x80, 0xD8, 0x29, 0xF9,
  0x1F, 0x18, 0x64, 0x0B, 0x01, 0x80, 0x60, 0x18, 0x07, 0xFF, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x30, 0x04, 0x00, 0x81, 0x1F, 0x80, 0x0F, 0x8C,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x41, 0xFC, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x3F, 0x2C, 0x15, 0x01, 0xE0, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xD0, 0x2B, 0x05, 0x3F,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xA0, 0x37, 0xBC, 0x1E, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x7C, 0xD0,
  0xDC, 0x0B, 0x01, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xF0, 0x05, 0x55,
  0x55, 0x55, 0x54, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x59, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x03, 0xC1, 0xB0, 0xCC,
  0x23, 0x10, 0xCC, 0x32, 0x0D, 0x83, 0xB0, 0xE4, 0x31, 0x8C, 0x23, 0x0C,
  0xC1, 0x30, 0x6C, 0x0B, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0x1F, 0x2C, 0x6C, 0x2A, 0x0A, 0x0F, 0x03, 0x01, 0xC0, 0x40, 0x70, 0x10,
  0x1C, 0x04, 0x07, 0x01, 0x01, 0xC0, 0x40, 0x70, 0x10, 0x1C, 0x04, 0x07,
  0x01, 0x01, 0xC0, 0x40, 0x70, 0x10, 0x1C, 0x04, 0x07, 0x01, 0x01, 0xC0,
  0x40, 0x40, 0x8F, 0x92, 0x1A, 0x81, 0x60, 0x2C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x60, 0x1F, 0x0C, 0x11, 0x01, 0x60, 0x28, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0xD0, 0x13, 0x04,
  0x3F, 0x00, 0x8F, 0x89, 0x0C, 0xA0, 0x6C, 0x02, 0xC0, 0x2C, 0x03, 0xC0,
  0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x2C, 0x02, 0xE0,
  0x6D, 0x0C, 0xCF, 0x8C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x1F, 0x2C, 0x35, 0x02, 0xE0, 0x38, 0x07, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x80, 0xD0, 0x2B, 0x0D,
  0x3F, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x8F,
  0x22, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC0, 0x3F, 0xB0, 0x50, 0x18, 0x0C, 0x02, 0x01, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x60, 0x10, 0x08, 0x04, 0x03, 0x03, 0x7F, 0x00, 0x20, 0x82,
  0x18, 0xFD, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x82,
  0x08, 0x3C, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xD0, 0x33, 0x09,
  0x3E, 0x20, 0x80, 0x38, 0x0D, 0x01, 0x20, 0x26, 0x04, 0x41, 0x88, 0x21,
  0x04, 0x31, 0x82, 0x20, 0x44, 0x0C, 0x80, 0xB0, 0x14, 0x02, 0x80, 0x70,
  0x04, 0x00, 0xC0, 0x40, 0x50, 0x30, 0x14, 0x0A, 0x05, 0x02, 0x83, 0x60,
  0xA0, 0x88, 0x68, 0x22, 0x11, 0x08, 0x84, 0x46, 0x31, 0x11, 0x04, 0xC4,
  0x41, 0x21, 0x90, 0x48, 0x2C, 0x1A, 0x0A, 0x03, 0x82, 0x80, 0xC0, 0xE0,
  0x30, 0x18, 0x0C, 0x04, 0x00, 0x80, 0x50, 0x26, 0x08, 0x84, 0x33, 0x04,
  0x81, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0x20, 0x48, 0x21, 0x18, 0x64, 0x0B,
  0x03, 0x80, 0x40, 0xC0, 0x28, 0x05, 0x01, 0xB0, 0x22, 0x04, 0x40, 0x8C,
  0x30, 0x84, 0x10, 0x82, 0x30, 0x64, 0x04, 0x80, 0x90, 0x16, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x06, 0x05, 0x80,
  0xE0, 0x00, 0x7F, 0x01, 0x03, 0x02, 0x06, 0x04, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x20, 0x60, 0x40, 0xC0, 0xFF, 0x01, 0x83, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x83, 0x83, 0x80,
  0x20, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x03, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x80, 0x40, 0x38, 0x0E,
  0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x06, 0x1C, 0x00, 0x38, 0x1E, 0x61, 0x81, 0xE0,
};

const GFXglyph NotoSans_Condensed_ExtraLight32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 23, 7, 2, -23 },
  { 7, 6, 8, 10, 2, -23 },
  { 13, 14, 23, 16, 1, -23 },
  { 54, 12, 26, 14, 1, -24 },
  { 93, 17, 23, 21, 2, -23 },
  { 142, 15, 23, 16, 1, -23 },
  { 186, 2, 8, 6, 2, -23 },
  { 188, 5, 28, 9, 2, -23 },
  { 206, 6, 28, 9, 1, -23 },
  { 227, 10, 10, 13, 2, -24 },
  { 240, 12, 15, 15, 1, -19 },
  { 263, 3, 7, 6, 1, -3 },
  { 266, 7, 1, 9, 1, -9 },
  { 267, 2, 2, 6, 2, -2 },
  { 268, 9, 23, 11, 1, -23 },
  { 294, 11, 23, 14, 2, -23 },
  { 326, 6, 23, 14, 3, -23 },
  { 344, 12, 23, 14, 1, -23 },
  { 379, 12, 23, 14, 1, -23 },
  { 414, 13, 23, 14, 1, -23 },
  { 452, 11, 23, 14, 2, -23 },
  { 484, 11, 23, 14, 2, -23 },
  { 516, 12, 23, 14, 1, -23 },
  { 551, 12, 23, 14, 1, -23 },
  { 586, 12, 23, 14, 1, -23 },
  { 621, 2, 17, 6, 2, -17 },
  { 626, 3, 21, 6, 1, -17 },
  { 634, 12, 13, 15, 1, -18 },
  { 654, 12, 8, 15, 1, -15 },
  { 666, 12, 13, 15, 1, -18 },
  { 686, 8, 23, 10, 1, -23 },
  { 709, 19, 26, 22, 2, -23 },
  { 771, 14, 23, 14, 0, -23 },
  { 812, 11, 23, 16, 3, -23 },
  { 844, 13, 23, 15, 2, -23 },
  { 882, 13, 23, 18, 3, -23 },
  { 920, 9, 23, 14, 3, -23 },
  { 946, 9, 23, 13, 3, -23 },
  { 972, 15, 23, 19, 2, -23 },
  { 1016, 12, 23, 18, 3, -23 },
  { 1051, 6, 23, 8, 1, -23 },
  { 1069, 6, 29, 7, -2, -23 },
  { 1091, 11, 23, 14, 3, -23 },
  { 1123, 9, 23, 13, 3, -23 },
  { 1149, 17, 23, 23, 3, -23 },
  { 1198, 13, 23, 18, 3, -23 },
  { 1236, 15, 23, 19, 2, -23 },
  { 1280, 10, 23, 15, 3, -23 },
  { 1309, 15, 28, 19, 2, -23 },
  { 1362, 11, 23, 15, 3, -23 },
  { 1394, 12, 23, 14, 1, -23 },
  { 1429, 12, 23, 13, 0, -23 },
  { 1464, 13, 23, 18, 2, -23 },
  { 1502, 14, 23, 14, 0, -23 },
  { 1543, 23, 23, 23, 0, -23 },
  { 1610, 13, 23, 13, 0, -23 },
  { 1648, 12, 23, 12, 0, -23 },
  { 1683, 11, 23, 13, 1, -23 },
  { 1715, 6, 28, 10, 3, -23 },
  { 1736, 9, 23, 11, 1, -23 },
  { 1762, 6, 28, 10, 1, -23 },
  { 1783, 13, 12, 15, 1, -23 },
  { 1803, 13, 1, 13, 0, 3 },
  { 1805, 5, 5, 8, 1, -24 },
  { 1809, 10, 17, 13, 1, -17 },
  { 1831, 12, 24, 15, 2, -24 },
  { 1867, 9, 17, 12, 2, -17 },
  { 1887, 11, 24, 15, 2, -24 },
  { 1920, 10, 17, 14, 2, -17 },
  { 1942, 9, 24, 8, 0, -24 },
  { 1969, 11, 25, 15, 2, -17 },
  { 2004, 11, 24, 15, 2, -24 },
  { 2037, 2, 23, 6, 2, -23 },
  { 2043, 5, 31, 6, -1, -23 },
  { 2063, 10, 24, 12, 2, -24 },
  { 2093, 2, 24, 6, 2, -24 },
  { 2099, 18, 17, 22, 2, -17 },
  { 2138, 11, 17, 15, 2, -17 },
  { 2162, 11, 17, 15, 2, -17 },
  { 2186, 12, 24, 15, 2, -17 },
  { 2222, 11, 24, 15, 2, -17 },
  { 2255, 7, 17, 10, 2, -17 },
  { 2270, 9, 17, 12, 1, -17 },
  { 2290, 6, 21, 8, 1, -21 },
  { 2306, 11, 17, 15, 2, -17 },
  { 2330, 11, 17, 11, 0, -17 },
  { 2354, 18, 17, 19, 0, -17 },
  { 2393, 10, 17, 12, 1, -17 },
  { 2415, 11, 25, 12, 0, -17 },
  { 2450, 8, 17, 10, 1, -17 },
  { 2467, 9, 28, 11, 1, -23 },
  { 2499, 1, 32, 14, 6, -24 },
  { 2503, 9, 28, 11, 1, -23 },
  { 2535, 12, 3, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_ExtraLight32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight32pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT32PT7B_H_
