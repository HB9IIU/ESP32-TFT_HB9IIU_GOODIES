#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT45PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight45pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00, 0x01,
  0xFF, 0xC3, 0xC3, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0x00, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x10, 0x01, 0x01,
  0x00, 0x10, 0x10, 0x01, 0x01, 0x00, 0x10, 0x30, 0x03, 0x03, 0x07, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF0, 0x20, 0x20, 0x02, 0x02, 0x00, 0x20, 0x20, 0x02,
  0x02, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x04, 0x00,
  0x40, 0x40, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0C, 0x0C, 0x00, 0xC0, 0xC0,
  0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x08, 0x08, 0x00, 0x80, 0x80, 0x08, 0x08,
  0x00, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x0F, 0xF8, 0x39, 0x1E, 0x71, 0x02, 0x61, 0x00, 0xC1, 0x00,
  0xC1, 0x00, 0xC1, 0x00, 0xC1, 0x00, 0xC1, 0x00, 0xC1, 0x00, 0x61, 0x00,
  0x71, 0x00, 0x39, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x01, 0x38,
  0x01, 0x0C, 0x01, 0x06, 0x01, 0x03, 0x01, 0x03, 0x01, 0x03, 0x01, 0x03,
  0x01, 0x03, 0x01, 0x03, 0x01, 0x02, 0x01, 0x06, 0xC1, 0x1C, 0xFF, 0xF8,
  0x1F, 0xC0, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x0C, 0x00,
  0x00, 0x1F, 0x80, 0x18, 0x0C, 0x60, 0x08, 0x0C, 0x10, 0x0C, 0x04, 0x0C,
  0x04, 0x02, 0x06, 0x06, 0x03, 0x03, 0x03, 0x01, 0x80, 0x81, 0x00, 0xC0,
  0x41, 0x80, 0x60, 0x20, 0x80, 0x30, 0x10, 0xC0, 0x18, 0x08, 0x60, 0x0C,
  0x04, 0x20, 0x06, 0x02, 0x30, 0xE3, 0x03, 0x11, 0xF8, 0x81, 0x98, 0x86,
  0x40, 0xCC, 0xC1, 0x30, 0x44, 0x40, 0xCC, 0x66, 0x20, 0x67, 0xE2, 0x30,
  0x30, 0x43, 0x18, 0x08, 0x01, 0x8C, 0x04, 0x00, 0x86, 0x02, 0x00, 0xC3,
  0x01, 0x00, 0x41, 0x80, 0x80, 0x60, 0xC0, 0x40, 0x30, 0x60, 0x60, 0x10,
  0x30, 0x30, 0x18, 0x08, 0x18, 0x0C, 0x04, 0x0C, 0x04, 0x03, 0x0C, 0x06,
  0x00, 0xC6, 0x02, 0x00, 0x3E, 0x00, 0x01, 0x00, 0x00, 0x7E, 0x00, 0x0C,
  0x30, 0x01, 0x81, 0x00, 0x10, 0x18, 0x01, 0x01, 0x80, 0x10, 0x18, 0x01,
  0x01, 0x80, 0x10, 0x18, 0x01, 0x01, 0x80, 0x18, 0x10, 0x00, 0x83, 0x00,
  0x0C, 0x60, 0x00, 0x46, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x01, 0x98, 0x00, 0x30, 0xC0, 0x06, 0x04, 0x06, 0x60, 0x60, 0x6C, 0x03,
  0x04, 0xC0, 0x18, 0x4C, 0x01, 0x8C, 0xC0, 0x0C, 0xCC, 0x00, 0x78, 0xC0,
  0x07, 0x8C, 0x00, 0x30, 0xC0, 0x07, 0x86, 0x00, 0xE8, 0x60, 0x1C, 0xC3,
  0x87, 0x86, 0x1F, 0xE0, 0x30, 0xFF, 0xFF, 0xFC, 0x03, 0x06, 0x04, 0x0C,
  0x08, 0x18, 0x10, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60,
  0x60, 0x20, 0x30, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x06, 0x06, 0x03, 0xC0,
  0x60, 0x60, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06,
  0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x02, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x60,
  0x60, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x81, 0x07, 0xC4,
  0x71, 0xFF, 0x00, 0xC0, 0x03, 0x80, 0x13, 0x00, 0xC4, 0x06, 0x18, 0x30,
  0x30, 0x40, 0x40, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x33, 0x36, 0x66, 0x64, 0xCC, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x07, 0xF0, 0x0C, 0x38, 0x18, 0x0C, 0x30,
  0x0C, 0x30, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x02, 0x60, 0x03, 0x40,
  0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40,
  0x03, 0x40, 0x03, 0x60, 0x03, 0x60, 0x02, 0x60, 0x06, 0x20, 0x06, 0x30,
  0x04, 0x30, 0x0C, 0x18, 0x18, 0x0E, 0x78, 0x07, 0xF0, 0x03, 0x07, 0x0D,
  0x19, 0x71, 0xE1, 0x81, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x00, 0x1F, 0xF0, 0x78, 0x38, 0x60,
  0x1C, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0x00, 0x1F, 0xF0, 0x70, 0x38, 0xC0, 0x0C, 0x80, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0E, 0x80,
  0x1C, 0xF0, 0x78, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x50,
  0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0xC8, 0x00, 0x11, 0x00, 0x06, 0x20,
  0x00, 0x84, 0x00, 0x30, 0x80, 0x0C, 0x10, 0x01, 0x82, 0x00, 0x60, 0x40,
  0x0C, 0x08, 0x03, 0x01, 0x00, 0x40, 0x20, 0x18, 0x04, 0x02, 0x00, 0x80,
  0xC0, 0x10, 0x30, 0x02, 0x06, 0x00, 0x41, 0x80, 0x08, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x3F, 0xFC, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F,
  0xF0, 0x78, 0x78, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x80, 0x1C, 0xF0, 0x78, 0x3F,
  0xE0, 0x01, 0xFE, 0x07, 0x82, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x41, 0xE0, 0x47, 0xF8, 0xCC, 0x0C, 0xD0, 0x06, 0xE0, 0x06, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x03, 0x40,
  0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x30, 0x02, 0x30, 0x06, 0x18,
  0x0C, 0x0C, 0x1C, 0x07, 0xF0, 0x01, 0xC0, 0xFF, 0xFF, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x0F, 0xF0, 0x1C, 0x1C, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x02, 0x60, 0x03, 0x60, 0x03, 0x60, 0x02, 0x60, 0x06, 0x30, 0x06, 0x30,
  0x0C, 0x1C, 0x18, 0x0E, 0x70, 0x03, 0xC0, 0x03, 0xC0, 0x0E, 0x70, 0x18,
  0x18, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x06, 0x30,
  0x0E, 0x3C, 0x1C, 0x0F, 0xF0, 0x01, 0x00, 0x0F, 0xF0, 0x18, 0x38, 0x30,
  0x18, 0x60, 0x0C, 0x60, 0x04, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x02, 0xC0,
  0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40,
  0x07, 0x60, 0x07, 0x60, 0x0B, 0x38, 0x3B, 0x1F, 0xE3, 0x07, 0x83, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x70, 0x40, 0xE0, 0x7F, 0x80, 0xFF,
  0xA0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x37, 0x72, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x33, 0x66, 0x66, 0x4C, 0xC8, 0x00,
  0x00, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x10, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x00, 0x06, 0x07, 0xF8, 0xE0, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x1C, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x1F, 0x00, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x03, 0x00, 0x60, 0x00, 0x30, 0x18, 0x00, 0x02, 0x06,
  0x00, 0x00, 0x60, 0x80, 0x00, 0x04, 0x30, 0x00, 0x00, 0xC6, 0x01, 0xF8,
  0x19, 0x80, 0x73, 0x81, 0x30, 0x18, 0x30, 0x36, 0x06, 0x06, 0x06, 0x80,
  0x80, 0xC0, 0xD0, 0x30, 0x18, 0x1A, 0x06, 0x03, 0x03, 0xC0, 0x80, 0x60,
  0x78, 0x10, 0x0C, 0x0F, 0x02, 0x01, 0x81, 0xE0, 0x40, 0x20, 0x3C, 0x08,
  0x04, 0x07, 0x81, 0x01, 0x80, 0x90, 0x30, 0x38, 0x12, 0x06, 0x05, 0x06,
  0x40, 0x61, 0xA1, 0x8C, 0x0F, 0xE7, 0xF1, 0x80, 0x78, 0x78, 0x10, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x02, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0D, 0x00, 0x00, 0x98, 0x00, 0x09, 0x80, 0x01, 0x98, 0x00, 0x18,
  0x80, 0x01, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x04, 0x00, 0x30, 0x60, 0x02,
  0x06, 0x00, 0x60, 0x60, 0x06, 0x02, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x18, 0x01, 0x81, 0x80, 0x08,
  0x18, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x04, 0x20, 0x00,
  0x66, 0x00, 0x06, 0x60, 0x00, 0x26, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xFF, 0xE0, 0xC1, 0xF8, 0xC0, 0x1C, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x0C, 0xC0, 0x18, 0xFF, 0xF0, 0xFF, 0xF0, 0xC0, 0x1C, 0xC0,
  0x0E, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x1C, 0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0xFF, 0xC1, 0xC0, 0x61,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x07, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x30, 0xFE, 0x0C, 0x01, 0xC3, 0x00,
  0x38, 0xC0, 0x07, 0x30, 0x00, 0xCC, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01,
  0xB0, 0x00, 0x2C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x06, 0xC0, 0x01,
  0xB0, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x0E, 0x30, 0x0E, 0x0F,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xFF, 0xFE,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x1F, 0xFC, 0x07, 0x80, 0xF0, 0xE0, 0x01, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x40, 0x00, 0x16, 0x00, 0x01, 0x60, 0x00, 0x13, 0x00, 0x01, 0x38, 0x00,
  0x11, 0xC0, 0x01, 0x0E, 0x00, 0x10, 0x7C, 0x0F, 0x01, 0xFF, 0xE0, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xFE, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x7F, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x20, 0x30, 0x1B, 0xF9, 0xF8, 0xC0, 0x07, 0xC0, 0x06,
  0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC1, 0x80, 0xC3, 0x00, 0xC7, 0x00, 0xC6, 0x00, 0xCC, 0x00,
  0xDC, 0x00, 0xD6, 0x00, 0xF6, 0x00, 0xE3, 0x00, 0xC1, 0x80, 0xC1, 0x80,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x10,
  0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF6, 0x00, 0x00, 0xFB, 0x00, 0x00, 0x5D, 0x80, 0x00, 0x6E, 0x60,
  0x00, 0x37, 0x30, 0x00, 0x13, 0x98, 0x00, 0x19, 0xC6, 0x00, 0x0C, 0xE3,
  0x00, 0x04, 0x71, 0x80, 0x06, 0x38, 0x60, 0x03, 0x1C, 0x30, 0x01, 0x0E,
  0x18, 0x01, 0x87, 0x06, 0x00, 0xC3, 0x83, 0x00, 0x41, 0xC1, 0x80, 0x60,
  0xE0, 0x60, 0x30, 0x70, 0x30, 0x10, 0x38, 0x18, 0x18, 0x1C, 0x06, 0x0C,
  0x0E, 0x03, 0x04, 0x07, 0x01, 0x86, 0x03, 0x80, 0x63, 0x01, 0xC0, 0x31,
  0x00, 0xE0, 0x19, 0x80, 0x70, 0x06, 0xC0, 0x38, 0x03, 0x40, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0E, 0xC0, 0x03, 0xB0, 0x00, 0xE6, 0x00, 0x39, 0x80, 0x0E,
  0x30, 0x03, 0x8C, 0x00, 0xE1, 0x80, 0x38, 0x60, 0x0E, 0x0C, 0x03, 0x83,
  0x00, 0xE0, 0x60, 0x38, 0x18, 0x0E, 0x03, 0x03, 0x80, 0xC0, 0xE0, 0x18,
  0x38, 0x06, 0x0E, 0x00, 0xC3, 0x80, 0x30, 0xE0, 0x06, 0x38, 0x01, 0x8E,
  0x00, 0x33, 0x80, 0x0C, 0xE0, 0x01, 0xB8, 0x00, 0x6E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x30, 0x00, 0x1F,
  0xF0, 0x03, 0x81, 0xC0, 0x38, 0x03, 0x03, 0x80, 0x0C, 0x18, 0x00, 0x31,
  0x80, 0x01, 0x8C, 0x00, 0x06, 0x40, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00,
  0x05, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x02, 0xC0,
  0x00, 0x32, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0xC3, 0x00, 0x06,
  0x0C, 0x00, 0x60, 0x70, 0x06, 0x01, 0xE1, 0xE0, 0x03, 0xFE, 0x00, 0xFF,
  0xC1, 0x87, 0xE3, 0x00, 0xE6, 0x00, 0xEC, 0x00, 0xD8, 0x00, 0xB0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x58,
  0x01, 0xB0, 0x03, 0x60, 0x0C, 0xC0, 0xF1, 0xFF, 0xC3, 0xF0, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00,
  0x20, 0x00, 0x1F, 0xF0, 0x03, 0xC1, 0xE0, 0x38, 0x03, 0x83, 0x80, 0x0C,
  0x18, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x06, 0x40, 0x00, 0x36, 0x00,
  0x01, 0xB0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x02, 0xC0, 0x00, 0x32, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00,
  0xC3, 0x00, 0x06, 0x0C, 0x00, 0x60, 0x70, 0x06, 0x01, 0xE1, 0xE0, 0x03,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0xFF,
  0xC0, 0xC3, 0xF0, 0xC0, 0x38, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x04, 0xC0,
  0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x70, 0xFF, 0xE0, 0xFF, 0x80, 0xC1,
  0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x30, 0xC0,
  0x30, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x03, 0x00, 0xC0, 0x0F, 0xFC, 0x1C, 0x0E, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0E, 0x80, 0x1C, 0xF0, 0x78, 0x7F, 0xE0, 0xFF, 0xFF, 0xC0,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x2C, 0x00, 0x1B, 0x00, 0x06,
  0x60, 0x03, 0x0C, 0x01, 0xC1, 0xC1, 0xE0, 0x3F, 0xE0, 0xC0, 0x00, 0x3C,
  0x00, 0x06, 0x40, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x42, 0x00, 0x0C,
  0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0x81, 0x00, 0x18, 0x18, 0x01,
  0x81, 0x80, 0x10, 0x18, 0x03, 0x00, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x20, 0x04, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x40, 0x02,
  0x0C, 0x00, 0x30, 0xC0, 0x03, 0x08, 0x00, 0x31, 0x80, 0x01, 0x18, 0x00,
  0x19, 0x80, 0x01, 0x90, 0x00, 0x0B, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x80, 0x03, 0x00, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x24, 0x00, 0x68, 0x00,
  0xCC, 0x00, 0xD0, 0x01, 0x98, 0x01, 0xB0, 0x03, 0x30, 0x02, 0x60, 0x04,
  0x20, 0x04, 0xC0, 0x18, 0x60, 0x18, 0x80, 0x30, 0xC0, 0x31, 0x80, 0x61,
  0x80, 0x63, 0x00, 0xC3, 0x00, 0x86, 0x03, 0x02, 0x03, 0x04, 0x06, 0x06,
  0x06, 0x08, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x10, 0x30, 0x20, 0x10,
  0x20, 0x60, 0xC0, 0x30, 0xC0, 0x41, 0x80, 0x61, 0x80, 0xC3, 0x00, 0xC3,
  0x01, 0x84, 0x00, 0x84, 0x03, 0x18, 0x01, 0x18, 0x02, 0x30, 0x03, 0x30,
  0x04, 0x60, 0x06, 0x60, 0x0C, 0x80, 0x0C, 0x80, 0x1B, 0x00, 0x09, 0x00,
  0x36, 0x00, 0x1E, 0x00, 0x2C, 0x00, 0x3C, 0x00, 0x58, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x60, 0x01, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x01, 0x8C,
  0x00, 0x63, 0x00, 0x30, 0x60, 0x0C, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x40, 0x18, 0x30, 0x06, 0x08, 0x00, 0x86, 0x00, 0x31, 0x80, 0x04, 0xC0,
  0x01, 0xB0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x68, 0x00, 0x13, 0x00, 0x0C, 0xC0, 0x03, 0x18, 0x01, 0x86, 0x00, 0x60,
  0x80, 0x30, 0x30, 0x0C, 0x04, 0x06, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x0C,
  0x30, 0x03, 0x18, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x03, 0xC0, 0x01, 0xA0,
  0x00, 0xD8, 0x00, 0x4C, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30, 0x40, 0x18,
  0x30, 0x08, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x06, 0x00, 0x83, 0x00, 0x61,
  0x00, 0x31, 0x80, 0x0C, 0xC0, 0x06, 0xC0, 0x01, 0x60, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x7F, 0xFF, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x03, 0xFE, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0xFF, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x07, 0xFE, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x1A, 0x00,
  0x06, 0xC0, 0x03, 0x10, 0x00, 0xC6, 0x00, 0x60, 0x80, 0x18, 0x30, 0x0C,
  0x04, 0x03, 0x01, 0x81, 0x80, 0x20, 0x60, 0x0C, 0x30, 0x03, 0x0C, 0x00,
  0x66, 0x00, 0x19, 0x80, 0x03, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x1F, 0xE0, 0xF1, 0xC2,
  0x01, 0x80, 0x06, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x0F, 0xC3, 0xFF, 0x38, 0x0D, 0xC0, 0x36, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1D, 0x80, 0xB7, 0x0C,
  0xCF, 0xE3, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC7, 0xF0,
  0xCE, 0x38, 0xD8, 0x0C, 0xD0, 0x06, 0xE0, 0x06, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x06, 0xF0, 0x06, 0xD8, 0x0C, 0xCC, 0x38, 0xC7, 0xF0, 0x03, 0xF8,
  0x78, 0xC6, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x78, 0x20,
  0xFF, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x07, 0xE1, 0x1E,
  0x39, 0x18, 0x0D, 0x30, 0x05, 0x60, 0x07, 0x60, 0x03, 0x60, 0x03, 0x40,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x03, 0x60,
  0x07, 0x30, 0x05, 0x30, 0x0D, 0x1C, 0x39, 0x0F, 0xF1, 0x07, 0xE0, 0x1C,
  0xF0, 0x60, 0x61, 0x80, 0x62, 0x00, 0x4C, 0x00, 0xD8, 0x01, 0xA0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x47, 0x83, 0x83, 0xFE, 0x03, 0xF0, 0x71, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x7F, 0xCF, 0xFC,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x07, 0xF1, 0x1E,
  0x39, 0x18, 0x0D, 0x30, 0x05, 0x60, 0x07, 0x60, 0x03, 0x60, 0x03, 0x40,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x03, 0x60,
  0x05, 0x30, 0x07, 0x30, 0x0B, 0x1C, 0x3B, 0x0F, 0xE3, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x60, 0x1C, 0x7F, 0xF8, 0x0F, 0xC0, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x1F, 0xC6, 0x73, 0xCD, 0x81, 0xDA, 0x01, 0xB8, 0x01, 0x70,
  0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0C, 0x5F,
  0xA0, 0x00, 0x09, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x40,
  0x04, 0x1C, 0x38, 0x20, 0x00, 0x00, 0x00, 0x00, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x1B, 0xE7, 0x80, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x01, 0xB0, 0x0C,
  0xC0, 0x33, 0x01, 0x8C, 0x0C, 0x30, 0x20, 0xC1, 0x83, 0x0C, 0x0C, 0x60,
  0x31, 0x80, 0xCE, 0x03, 0x6C, 0x0D, 0x30, 0x3C, 0x60, 0xE1, 0x83, 0x03,
  0x0C, 0x0C, 0x30, 0x18, 0xC0, 0x63, 0x00, 0xCC, 0x03, 0x30, 0x06, 0xC0,
  0x1B, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC7, 0xE0, 0xFC, 0x66, 0x38, 0xE7, 0x34, 0x06, 0xC0, 0xDE, 0x03, 0x40,
  0x3E, 0x00, 0xC0, 0x1F, 0x00, 0x60, 0x0F, 0x00, 0x30, 0x07, 0x80, 0x18,
  0x03, 0xC0, 0x0C, 0x01, 0xE0, 0x06, 0x00, 0xF0, 0x03, 0x00, 0x78, 0x01,
  0x80, 0x3C, 0x00, 0xC0, 0x1E, 0x00, 0x60, 0x0F, 0x00, 0x30, 0x07, 0x80,
  0x18, 0x03, 0xC0, 0x0C, 0x01, 0xE0, 0x06, 0x00, 0xF0, 0x03, 0x00, 0x78,
  0x01, 0x80, 0x3C, 0x00, 0xC0, 0x1E, 0x00, 0x60, 0x0F, 0x00, 0x30, 0x07,
  0x80, 0x18, 0x03, 0xC7, 0xF1, 0x9C, 0xF3, 0x60, 0x36, 0x80, 0x6E, 0x00,
  0x5C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x07, 0xF0, 0x0F, 0x1C, 0x06, 0x03, 0x06, 0x00, 0xC6, 0x00, 0x23, 0x00,
  0x19, 0x80, 0x0C, 0x80, 0x06, 0xC0, 0x01, 0x60, 0x00, 0xB0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x05, 0x80, 0x02, 0x40, 0x01,
  0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x43, 0x00, 0x60, 0xC0, 0x60, 0x70,
  0x70, 0x0F, 0xE0, 0xC7, 0xF0, 0xCE, 0x38, 0xD8, 0x0C, 0xD0, 0x06, 0xE0,
  0x06, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x06, 0xD0, 0x06, 0xD8, 0x0C, 0xCC,
  0x38, 0xC7, 0xF0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x07, 0xE1, 0x0E, 0x39, 0x18, 0x09, 0x30, 0x05, 0x60, 0x07, 0x60,
  0x03, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40,
  0x03, 0x60, 0x03, 0x60, 0x05, 0x30, 0x07, 0x38, 0x0B, 0x1C, 0x3B, 0x0F,
  0xE3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0xC7,
  0xF3, 0xFD, 0x83, 0x40, 0xF0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x1F, 0xE1, 0xC7, 0x98, 0x05, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x03, 0x40, 0x1B, 0x83, 0x8F, 0xF8, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x83, 0xFF, 0xFF, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x04, 0x03, 0x01, 0x88, 0x7C, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3A, 0x00, 0x76, 0x01, 0xEC, 0x06, 0xCE,
  0x19, 0x8F, 0xE3, 0xC0, 0x03, 0x40, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x04, 0x20, 0x0C, 0x30, 0x0C, 0x30, 0x08, 0x30, 0x18, 0x10, 0x18, 0x18,
  0x18, 0x18, 0x10, 0x08, 0x30, 0x0C, 0x30, 0x0C, 0x20, 0x0C, 0x20, 0x04,
  0x60, 0x06, 0x60, 0x06, 0x40, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x01, 0x80, 0xC0, 0x0C, 0x00, 0xD8, 0x03, 0x80, 0x26, 0x00, 0xE0,
  0x09, 0x80, 0x28, 0x06, 0x20, 0x1A, 0x01, 0x88, 0x06, 0xC0, 0x63, 0x01,
  0x30, 0x10, 0xC0, 0x4C, 0x0C, 0x10, 0x31, 0x03, 0x04, 0x0C, 0x40, 0xC1,
  0x82, 0x18, 0x20, 0x60, 0x86, 0x18, 0x18, 0x60, 0x86, 0x02, 0x18, 0x21,
  0x80, 0xC4, 0x0C, 0x40, 0x31, 0x03, 0x10, 0x0C, 0xC0, 0x4C, 0x01, 0x30,
  0x13, 0x00, 0x68, 0x06, 0x80, 0x1A, 0x01, 0xA0, 0x07, 0x80, 0x38, 0x00,
  0xE0, 0x0E, 0x00, 0x30, 0x03, 0x80, 0x0C, 0x00, 0xC0, 0xC0, 0x06, 0xC0,
  0x19, 0x80, 0x21, 0x80, 0xC1, 0x01, 0x03, 0x06, 0x02, 0x18, 0x06, 0x30,
  0x04, 0xC0, 0x0D, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xD0, 0x01,
  0xB0, 0x06, 0x20, 0x0C, 0x60, 0x30, 0x60, 0x60, 0xC1, 0x80, 0xC3, 0x01,
  0x8C, 0x01, 0x98, 0x03, 0x60, 0x03, 0x40, 0x03, 0x60, 0x03, 0x60, 0x02,
  0x20, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x10, 0x0C, 0x18, 0x0C,
  0x18, 0x08, 0x08, 0x18, 0x0C, 0x18, 0x0C, 0x10, 0x0C, 0x30, 0x04, 0x30,
  0x06, 0x30, 0x06, 0x20, 0x02, 0x60, 0x03, 0x60, 0x03, 0x40, 0x01, 0x40,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xF0, 0x3C, 0x07, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x38, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x60, 0x07, 0x00,
  0x3E, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x03, 0x80,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x01, 0xC0, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0C, 0x03, 0x80, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xC0,
  0x60, 0x78, 0xD0, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Condensed_ExtraLight45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 32, 10, 3, -32 },
  { 13, 8, 11, 14, 3, -32 },
  { 24, 20, 32, 22, 1, -32 },
  { 104, 16, 37, 20, 2, -34 },
  { 178, 25, 33, 29, 2, -33 },
  { 282, 20, 33, 22, 2, -33 },
  { 365, 2, 11, 8, 3, -32 },
  { 368, 8, 39, 12, 2, -32 },
  { 407, 8, 39, 12, 2, -32 },
  { 446, 14, 14, 19, 2, -34 },
  { 471, 17, 21, 20, 2, -26 },
  { 516, 4, 11, 9, 2, -5 },
  { 522, 10, 2, 13, 1, -13 },
  { 525, 3, 3, 9, 3, -3 },
  { 527, 13, 32, 15, 1, -32 },
  { 579, 16, 33, 20, 2, -33 },
  { 645, 8, 32, 20, 4, -32 },
  { 677, 16, 33, 20, 2, -33 },
  { 743, 16, 33, 20, 2, -33 },
  { 809, 19, 32, 20, 1, -32 },
  { 885, 16, 32, 20, 2, -32 },
  { 949, 16, 33, 20, 2, -32 },
  { 1015, 16, 32, 20, 2, -32 },
  { 1079, 16, 33, 20, 2, -33 },
  { 1145, 16, 33, 20, 2, -33 },
  { 1211, 3, 24, 9, 3, -24 },
  { 1220, 4, 30, 9, 2, -24 },
  { 1235, 17, 20, 20, 2, -26 },
  { 1278, 17, 11, 20, 2, -21 },
  { 1302, 17, 20, 20, 2, -26 },
  { 1345, 12, 33, 14, 1, -33 },
  { 1395, 27, 36, 31, 2, -32 },
  { 1517, 20, 32, 20, 0, -32 },
  { 1597, 16, 32, 22, 4, -32 },
  { 1661, 17, 33, 22, 3, -33 },
  { 1732, 18, 32, 25, 4, -32 },
  { 1804, 13, 32, 20, 4, -32 },
  { 1856, 13, 32, 18, 4, -32 },
  { 1908, 20, 33, 26, 3, -33 },
  { 1991, 17, 32, 25, 4, -32 },
  { 2059, 7, 32, 11, 2, -32 },
  { 2087, 9, 40, 9, -3, -32 },
  { 2132, 16, 32, 20, 4, -32 },
  { 2196, 13, 32, 18, 4, -32 },
  { 2248, 25, 32, 32, 4, -32 },
  { 2348, 18, 32, 26, 4, -32 },
  { 2420, 21, 33, 27, 3, -33 },
  { 2507, 15, 32, 21, 4, -32 },
  { 2567, 21, 41, 27, 3, -33 },
  { 2675, 16, 32, 21, 4, -32 },
  { 2739, 16, 33, 20, 2, -33 },
  { 2805, 18, 32, 18, 0, -32 },
  { 2877, 18, 32, 25, 4, -32 },
  { 2949, 20, 32, 20, 0, -32 },
  { 3029, 31, 32, 33, 1, -32 },
  { 3153, 18, 32, 18, 0, -32 },
  { 3225, 17, 32, 17, 0, -32 },
  { 3293, 16, 32, 18, 1, -32 },
  { 3357, 9, 39, 14, 4, -32 },
  { 3401, 13, 32, 15, 1, -32 },
  { 3453, 9, 39, 14, 1, -32 },
  { 3497, 18, 17, 20, 1, -32 },
  { 3536, 18, 2, 18, 0, 4 },
  { 3541, 7, 7, 11, 2, -34 },
  { 3548, 14, 24, 19, 2, -24 },
  { 3590, 16, 34, 22, 3, -34 },
  { 3658, 13, 24, 16, 2, -24 },
  { 3697, 16, 34, 22, 2, -34 },
  { 3765, 15, 24, 20, 2, -24 },
  { 3810, 12, 34, 11, 0, -34 },
  { 3861, 16, 35, 22, 2, -24 },
  { 3931, 15, 34, 21, 3, -34 },
  { 3995, 3, 33, 9, 3, -33 },
  { 4008, 7, 44, 9, -1, -33 },
  { 4047, 14, 34, 17, 3, -34 },
  { 4107, 2, 34, 8, 3, -34 },
  { 4116, 25, 24, 31, 3, -24 },
  { 4191, 15, 24, 21, 3, -24 },
  { 4236, 17, 24, 21, 2, -24 },
  { 4287, 16, 35, 22, 3, -24 },
  { 4357, 16, 35, 22, 2, -24 },
  { 4427, 10, 24, 14, 3, -24 },
  { 4457, 13, 24, 16, 2, -24 },
  { 4496, 9, 30, 11, 1, -30 },
  { 4530, 15, 24, 21, 3, -24 },
  { 4575, 16, 24, 16, 0, -24 },
  { 4623, 26, 24, 26, 0, -24 },
  { 4701, 15, 24, 17, 1, -24 },
  { 4746, 16, 35, 16, 0, -24 },
  { 4816, 12, 24, 15, 1, -24 },
  { 4852, 12, 39, 16, 2, -32 },
  { 4911, 1, 45, 19, 9, -34 },
  { 4917, 12, 39, 16, 2, -32 },
  { 4976, 17, 4, 20, 2, -18 },
};

const GFXfont NotoSans_Condensed_ExtraLight45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight45pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT45PT7B_H_
