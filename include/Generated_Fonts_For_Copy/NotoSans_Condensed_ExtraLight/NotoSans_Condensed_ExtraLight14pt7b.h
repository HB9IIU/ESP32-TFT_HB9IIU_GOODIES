#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT14PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x40, 0xB6, 0xD0, 0x24, 0x48, 0x93, 0xD2, 0x85, 0x3F, 0x24,
  0x48, 0x90, 0x23, 0xA9, 0x4A, 0x20, 0xC5, 0x29, 0x7C, 0x40, 0xE5, 0x52,
  0xA5, 0x4B, 0x7F, 0x4A, 0x95, 0x2A, 0x8C, 0x62, 0x49, 0x18, 0x42, 0x89,
  0x66, 0x8B, 0xD0, 0xF0, 0x6A, 0xAA, 0xA9, 0xA5, 0x55, 0x5A, 0x44, 0xF6,
  0x90, 0x21, 0x09, 0xF2, 0x10, 0xF0, 0xF0, 0x80, 0x11, 0x12, 0x22, 0x44,
  0x48, 0x74, 0xA3, 0x18, 0xC6, 0x31, 0x93, 0x80, 0x3C, 0x92, 0x49, 0x24,
  0xF0, 0x84, 0x21, 0x10, 0x88, 0x87, 0xC0, 0xF0, 0x82, 0x26, 0x08, 0x21,
  0x0F, 0x80, 0x08, 0x61, 0x8A, 0x49, 0x28, 0xBF, 0x08, 0x20, 0xF4, 0x21,
  0x0F, 0x04, 0x21, 0x0F, 0x80, 0x7C, 0x21, 0x0F, 0x46, 0x31, 0x8B, 0x80,
  0xF8, 0x84, 0x22, 0x10, 0x88, 0x42, 0x00, 0xF4, 0x63, 0x26, 0x4A, 0x31,
  0x8F, 0x80, 0xF4, 0xA3, 0x18, 0xFC, 0x22, 0x17, 0x00, 0x82, 0x87, 0x80,
  0x1B, 0x21, 0x82, 0x0C, 0xF8, 0x01, 0xF0, 0x83, 0x06, 0x26, 0x40, 0xF1,
  0x11, 0x22, 0x44, 0x04, 0x3C, 0x42, 0x81, 0x9D, 0xA5, 0xA5, 0xA5, 0xAD,
  0x92, 0x80, 0x7C, 0x10, 0xC3, 0x0A, 0x49, 0x27, 0x61, 0x86, 0x10, 0xF4,
  0x63, 0x1F, 0x46, 0x31, 0x8F, 0x80, 0x7C, 0x21, 0x08, 0x42, 0x10, 0x83,
  0xC0, 0xF2, 0x28, 0x61, 0x86, 0x18, 0x61, 0x8B, 0xC0, 0xF8, 0x88, 0xF8,
  0x88, 0x8F, 0xF8, 0x88, 0x8F, 0x88, 0x88, 0x3D, 0x08, 0x20, 0x82, 0x38,
  0x61, 0x85, 0xF0, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x86, 0x10, 0xEA,
  0xAA, 0xB0, 0x24, 0x92, 0x49, 0x24, 0xF0, 0x8C, 0xA5, 0x4C, 0x52, 0x92,
  0x8C, 0x40, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x81, 0x81, 0xC3, 0xC3, 0xA5,
  0xA5, 0xA5, 0x99, 0x99, 0x89, 0x87, 0x1C, 0x69, 0xA6, 0x59, 0x63, 0x86,
  0x10, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE0, 0xF4, 0x63, 0x18,
  0xFA, 0x10, 0x84, 0x00, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE0,
  0x83, 0xF4, 0x63, 0x19, 0xF2, 0x52, 0x8C, 0x40, 0xF4, 0x21, 0x04, 0x18,
  0x21, 0x0F, 0x80, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x00, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x85, 0xE0, 0x86, 0x18, 0x52, 0x49, 0x22, 0x8C,
  0x30, 0x40, 0x84, 0x63, 0x14, 0xC5, 0x32, 0x4A, 0x94, 0xA5, 0x28, 0xCC,
  0x23, 0x08, 0x40, 0x89, 0x25, 0x0C, 0x20, 0x83, 0x12, 0x4A, 0x30, 0x8C,
  0x52, 0xA3, 0x10, 0x84, 0x21, 0x00, 0x78, 0x44, 0x21, 0x10, 0x88, 0x47,
  0xC0, 0xF2, 0x49, 0x24, 0x92, 0x70, 0x84, 0x44, 0x22, 0x21, 0x11, 0xE4,
  0x92, 0x49, 0x24, 0xF0, 0x10, 0xC2, 0x92, 0xC4, 0xFC, 0xA4, 0x69, 0x13,
  0xD9, 0x9F, 0x84, 0x21, 0x6C, 0xC6, 0x31, 0x8C, 0x7C, 0x78, 0x88, 0x88,
  0x87, 0x08, 0x42, 0xD9, 0xC6, 0x31, 0x8C, 0x7E, 0x69, 0x99, 0xE8, 0x87,
  0x34, 0x4E, 0x44, 0x44, 0x44, 0x40, 0x64, 0xE3, 0x18, 0xC6, 0x3F, 0x08,
  0x7C, 0x84, 0x21, 0x4D, 0x46, 0x31, 0x8C, 0x62, 0x9F, 0xC0, 0x41, 0x55,
  0x55, 0xC0, 0x88, 0x88, 0x9A, 0xCA, 0xA9, 0x90, 0xFF, 0xE0, 0x66, 0x99,
  0x91, 0x91, 0x91, 0x91, 0x91, 0x91, 0x26, 0xA3, 0x18, 0xC6, 0x31, 0x64,
  0xA3, 0x18, 0xC6, 0x2E, 0x36, 0x63, 0x18, 0xC6, 0x3E, 0x84, 0x20, 0x64,
  0xE3, 0x18, 0xC6, 0x3F, 0x08, 0x42, 0x3A, 0x49, 0x24, 0x68, 0x88, 0x61,
  0x1E, 0x5D, 0x24, 0x92, 0x60, 0x99, 0x99, 0x99, 0xF0, 0x8C, 0x54, 0xA5,
  0x30, 0x80, 0x89, 0x99, 0x59, 0x56, 0x66, 0x26, 0x24, 0xCA, 0x88, 0x45,
  0x2A, 0x20, 0x8A, 0x54, 0xA5, 0x10, 0x84, 0x26, 0x00, 0x71, 0x22, 0x44,
  0xF0, 0x29, 0x24, 0xA2, 0x49, 0x30, 0xFF, 0xFC, 0x89, 0x24, 0x9A, 0x49,
  0x60, 0xCD, 0x80,
};

const GFXglyph NotoSans_Condensed_ExtraLight14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 10, 3, 1, -10 },
  { 3, 3, 4, 4, 1, -10 },
  { 5, 7, 10, 7, 0, -10 },
  { 14, 5, 12, 6, 1, -11 },
  { 22, 7, 10, 9, 1, -10 },
  { 31, 6, 10, 7, 1, -10 },
  { 39, 1, 4, 2, 1, -10 },
  { 40, 2, 12, 4, 1, -10 },
  { 43, 2, 12, 4, 1, -10 },
  { 46, 4, 5, 6, 1, -11 },
  { 49, 5, 6, 6, 1, -8 },
  { 53, 1, 4, 3, 1, -2 },
  { 54, 4, 1, 4, 0, -4 },
  { 55, 1, 1, 3, 1, -1 },
  { 56, 4, 10, 5, 0, -10 },
  { 61, 5, 10, 6, 1, -10 },
  { 68, 3, 10, 6, 1, -10 },
  { 72, 5, 10, 6, 1, -10 },
  { 79, 5, 10, 6, 1, -10 },
  { 86, 6, 10, 6, 0, -10 },
  { 94, 5, 10, 6, 1, -10 },
  { 101, 5, 10, 6, 1, -10 },
  { 108, 5, 10, 6, 1, -10 },
  { 115, 5, 10, 6, 1, -10 },
  { 122, 5, 10, 6, 1, -10 },
  { 129, 1, 7, 3, 1, -7 },
  { 130, 1, 9, 3, 1, -7 },
  { 132, 5, 6, 6, 1, -8 },
  { 136, 5, 4, 6, 1, -7 },
  { 139, 5, 6, 6, 1, -8 },
  { 143, 4, 10, 4, 0, -10 },
  { 148, 8, 11, 10, 1, -10 },
  { 159, 6, 10, 6, 0, -10 },
  { 167, 5, 10, 7, 1, -10 },
  { 174, 5, 10, 7, 1, -10 },
  { 181, 6, 10, 8, 1, -10 },
  { 189, 4, 10, 6, 1, -10 },
  { 194, 4, 10, 6, 1, -10 },
  { 199, 6, 10, 8, 1, -10 },
  { 207, 6, 10, 8, 1, -10 },
  { 215, 2, 10, 4, 1, -10 },
  { 218, 3, 12, 3, -1, -10 },
  { 223, 5, 10, 6, 1, -10 },
  { 230, 4, 10, 6, 1, -10 },
  { 235, 8, 10, 10, 1, -10 },
  { 245, 6, 10, 8, 1, -10 },
  { 253, 6, 10, 8, 1, -10 },
  { 261, 5, 10, 6, 1, -10 },
  { 268, 6, 12, 8, 1, -10 },
  { 277, 5, 10, 7, 1, -10 },
  { 284, 5, 10, 6, 1, -10 },
  { 291, 5, 10, 6, 0, -10 },
  { 298, 6, 10, 8, 1, -10 },
  { 306, 6, 10, 6, 0, -10 },
  { 314, 10, 10, 10, 0, -10 },
  { 327, 6, 10, 6, 0, -10 },
  { 335, 5, 10, 5, 0, -10 },
  { 342, 5, 10, 6, 0, -10 },
  { 349, 3, 12, 4, 1, -10 },
  { 354, 4, 10, 5, 0, -10 },
  { 359, 3, 12, 4, 0, -10 },
  { 364, 6, 5, 6, 0, -10 },
  { 368, 6, 1, 6, 0, 1 },
  { 369, 2, 3, 3, 1, -11 },
  { 370, 4, 8, 6, 1, -8 },
  { 374, 5, 11, 7, 1, -11 },
  { 381, 4, 8, 5, 1, -8 },
  { 385, 5, 11, 7, 1, -11 },
  { 392, 4, 8, 6, 1, -8 },
  { 396, 4, 11, 3, 0, -11 },
  { 402, 5, 11, 7, 1, -8 },
  { 409, 5, 11, 7, 1, -11 },
  { 416, 1, 10, 3, 1, -10 },
  { 418, 2, 13, 3, 0, -10 },
  { 422, 4, 11, 5, 1, -11 },
  { 428, 1, 11, 3, 1, -11 },
  { 430, 8, 8, 10, 1, -8 },
  { 438, 5, 8, 7, 1, -8 },
  { 443, 5, 8, 6, 1, -8 },
  { 448, 5, 11, 7, 1, -8 },
  { 455, 5, 11, 7, 1, -8 },
  { 462, 3, 8, 4, 1, -8 },
  { 465, 4, 8, 5, 1, -8 },
  { 469, 3, 9, 4, 0, -9 },
  { 473, 4, 7, 7, 1, -7 },
  { 477, 5, 7, 5, 0, -7 },
  { 482, 8, 7, 8, 0, -7 },
  { 489, 5, 7, 5, 0, -7 },
  { 494, 5, 10, 5, 0, -7 },
  { 501, 4, 7, 5, 0, -7 },
  { 505, 3, 12, 5, 1, -10 },
  { 510, 1, 14, 6, 3, -11 },
  { 512, 3, 12, 5, 1, -10 },
  { 517, 5, 2, 6, 1, -6 },
};

const GFXfont NotoSans_Condensed_ExtraLight14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight14pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT14PT7B_H_
