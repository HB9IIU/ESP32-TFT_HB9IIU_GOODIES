#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT21PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE6, 0x99, 0x99, 0x90, 0x09, 0x02, 0x40, 0x90, 0x44, 0x7F,
  0xC4, 0x41, 0x10, 0x44, 0x12, 0x37, 0xE2, 0x20, 0x88, 0x22, 0x08, 0x82,
  0x20, 0x10, 0x79, 0x4C, 0x89, 0x12, 0x24, 0x38, 0x18, 0x28, 0x48, 0x91,
  0x22, 0x75, 0x1C, 0x10, 0x70, 0x89, 0x08, 0x89, 0x08, 0x90, 0x89, 0x08,
  0xA0, 0x8A, 0xE9, 0x52, 0x75, 0x10, 0x51, 0x09, 0x10, 0x91, 0x11, 0x11,
  0x12, 0x30, 0xE0, 0x38, 0x22, 0x11, 0x08, 0x84, 0x41, 0x40, 0xC0, 0x60,
  0x48, 0xC4, 0x61, 0x50, 0x68, 0x24, 0x19, 0xF2, 0xF8, 0x12, 0x44, 0x48,
  0x88, 0x88, 0x88, 0x88, 0x44, 0x23, 0x84, 0x42, 0x22, 0x21, 0x11, 0x11,
  0x22, 0x24, 0x48, 0x10, 0x23, 0x59, 0xC2, 0x89, 0x11, 0x00, 0x10, 0x10,
  0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x5A, 0x80, 0xF0, 0x70, 0x02,
  0x08, 0x10, 0x20, 0x81, 0x04, 0x08, 0x10, 0x40, 0x81, 0x04, 0x08, 0x30,
  0x00, 0x3C, 0x89, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x14,
  0x28, 0x8F, 0x00, 0x35, 0x91, 0x11, 0x11, 0x11, 0x11, 0x11, 0x10, 0x7D,
  0x08, 0x08, 0x10, 0x20, 0x41, 0x02, 0x08, 0x10, 0x41, 0x04, 0x08, 0x3F,
  0x80, 0x7D, 0x04, 0x08, 0x10, 0x20, 0x43, 0x1C, 0x06, 0x04, 0x08, 0x10,
  0x20, 0x7F, 0x00, 0x02, 0x03, 0x01, 0x81, 0x40, 0xA0, 0x90, 0x48, 0x44,
  0x42, 0x21, 0x3F, 0xE0, 0x40, 0x20, 0x10, 0x08, 0x7E, 0x81, 0x02, 0x08,
  0x10, 0x3F, 0x01, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7F, 0x00, 0x1E, 0x20,
  0x40, 0x40, 0x80, 0x80, 0xBC, 0xC2, 0x82, 0x81, 0x81, 0x81, 0x42, 0x42,
  0x3C, 0xFE, 0x04, 0x08, 0x10, 0x40, 0x82, 0x04, 0x08, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x00, 0x3C, 0x42, 0x82, 0x82, 0x82, 0x44, 0x28, 0x38, 0x44,
  0x82, 0x81, 0x81, 0x82, 0x82, 0x7C, 0x7C, 0x8A, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x7E, 0x04, 0x08, 0x10, 0x40, 0x9E, 0x00, 0xC0, 0x00, 0x1C, 0x40,
  0x00, 0x16, 0xA0, 0x01, 0x06, 0x18, 0x60, 0x80, 0x60, 0x18, 0x06, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x18, 0x06, 0x03, 0x04, 0x18,
  0x60, 0x80, 0xF8, 0x10, 0x41, 0x04, 0x10, 0x84, 0x20, 0x82, 0x00, 0x00,
  0x82, 0x00, 0x0F, 0x80, 0x82, 0x08, 0x08, 0x80, 0x24, 0x79, 0x44, 0x4A,
  0x22, 0x31, 0x11, 0x90, 0x8C, 0x84, 0x62, 0x65, 0x13, 0x28, 0x66, 0x20,
  0x01, 0x00, 0x04, 0x00, 0x1F, 0x80, 0x08, 0x06, 0x05, 0x02, 0x81, 0x20,
  0x90, 0x88, 0x44, 0x21, 0x2F, 0x90, 0x48, 0x14, 0x0C, 0x06, 0x02, 0xFD,
  0x06, 0x0C, 0x18, 0x30, 0x61, 0x7E, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F,
  0x00, 0x1F, 0x90, 0x10, 0x08, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x08, 0x04, 0x01, 0x00, 0x7C, 0xF8, 0x86, 0x82, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x86, 0xF8, 0xFE, 0x08, 0x20,
  0x82, 0x08, 0x3F, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0xFE, 0x08, 0x20,
  0x82, 0x08, 0x3F, 0x82, 0x08, 0x20, 0x82, 0x08, 0x00, 0x1F, 0xC8, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x0E, 0x80, 0x60, 0x18, 0x05, 0x01,
  0x40, 0x48, 0x11, 0xFC, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xE9, 0x24, 0x92, 0x49, 0x24,
  0xB8, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x12, 0xC0, 0x83,
  0x0A, 0x24, 0x49, 0x14, 0x28, 0x70, 0x91, 0x22, 0x24, 0x48, 0x50, 0x60,
  0x80, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F,
  0xC0, 0x80, 0x30, 0x07, 0x01, 0xE0, 0x3A, 0x07, 0x41, 0x68, 0x2C, 0x85,
  0x91, 0x32, 0x26, 0x24, 0xC5, 0x18, 0xA3, 0x08, 0x61, 0x08, 0x81, 0x81,
  0xC1, 0xA1, 0xA1, 0x91, 0x91, 0x89, 0x89, 0x85, 0x85, 0x83, 0x83, 0x81,
  0x81, 0x1F, 0x08, 0x24, 0x09, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x05, 0x01, 0x40, 0x88, 0x21, 0xF0, 0xF9, 0x0A, 0x0C, 0x18,
  0x30, 0x61, 0x46, 0xF1, 0x02, 0x04, 0x08, 0x10, 0x20, 0x00, 0x1F, 0x08,
  0x24, 0x09, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x05,
  0x01, 0x40, 0x88, 0x21, 0xF0, 0x08, 0x01, 0x00, 0x40, 0x08, 0xF9, 0x0A,
  0x0C, 0x18, 0x30, 0x61, 0x74, 0x91, 0x12, 0x24, 0x28, 0x50, 0x60, 0x80,
  0x3E, 0x82, 0x04, 0x08, 0x18, 0x18, 0x0C, 0x04, 0x04, 0x08, 0x10, 0x20,
  0x7F, 0x00, 0xFF, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x7C, 0x80, 0xC0, 0x50, 0x28,
  0x24, 0x12, 0x08, 0x88, 0x44, 0x22, 0x11, 0x05, 0x02, 0x81, 0x40, 0x40,
  0x20, 0x81, 0x02, 0x82, 0x05, 0x06, 0x0A, 0x14, 0x24, 0x28, 0x48, 0x50,
  0x88, 0x91, 0x12, 0x24, 0x24, 0x48, 0x48, 0x90, 0x51, 0x20, 0xA1, 0x81,
  0x83, 0x03, 0x06, 0x02, 0x0C, 0x00, 0x41, 0x42, 0x22, 0x22, 0x14, 0x14,
  0x08, 0x08, 0x18, 0x14, 0x24, 0x22, 0x42, 0x41, 0x81, 0x81, 0x41, 0x42,
  0x42, 0x24, 0x24, 0x24, 0x18, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0xFE, 0x08, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x10,
  0x3F, 0x80, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x80,
  0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80,
  0x80, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x10, 0x18,
  0x28, 0x24, 0x44, 0x42, 0x82, 0x81, 0xFF, 0x88, 0x80, 0x7C, 0x10, 0x41,
  0x0D, 0xD8, 0x61, 0x86, 0x17, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x1F, 0xA1,
  0x41, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x7C, 0x3D, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x81, 0x03, 0xC0, 0x02, 0x04, 0x08, 0x10, 0x27, 0xD0, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x50, 0x9F, 0x3C, 0x86, 0x0C, 0x18, 0x3F,
  0xA0, 0x40, 0x80, 0x80, 0xF8, 0x1C, 0x82, 0x08, 0x23, 0xE2, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x3E, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x82, 0x84, 0xF8, 0x10, 0x20, 0x60, 0xBE, 0x82, 0x08, 0x20, 0x83, 0xE8,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0xC0, 0x55, 0x55, 0x54, 0x60,
  0x02, 0x49, 0x24, 0x92, 0x49, 0x25, 0x60, 0x82, 0x08, 0x20, 0x86, 0x29,
  0x24, 0xA3, 0x8E, 0x24, 0x92, 0x28, 0xA1, 0xFF, 0xFF, 0xFB, 0xD0, 0x86,
  0x10, 0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x21, 0x84, 0x30, 0x86, 0x10,
  0x80, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x40, 0x3C, 0x42,
  0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x42, 0x3C, 0xFD, 0x0A, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x0B, 0xE4, 0x08, 0x10, 0x20, 0x40, 0x3E,
  0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x84, 0xF8, 0x10, 0x20, 0x40,
  0x81, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x80, 0x7E, 0x08, 0x20, 0x40, 0xC0,
  0x81, 0x04, 0x1F, 0x80, 0x21, 0x11, 0xF4, 0x21, 0x08, 0x42, 0x10, 0x82,
  0x1C, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x3F, 0x40, 0x83, 0x05,
  0x0A, 0x24, 0x44, 0x8A, 0x14, 0x28, 0x30, 0x40, 0x82, 0x14, 0x61, 0x46,
  0x14, 0x52, 0x45, 0x24, 0x92, 0x29, 0x22, 0x8C, 0x28, 0xC1, 0x0C, 0x10,
  0xC0, 0x42, 0x84, 0x91, 0x41, 0x83, 0x06, 0x12, 0x24, 0x87, 0x08, 0x83,
  0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x28, 0x18, 0x18, 0x10, 0x10, 0x10,
  0x10, 0x20, 0xC0, 0xF8, 0x44, 0x22, 0x11, 0x08, 0x84, 0x3E, 0x19, 0x08,
  0x42, 0x10, 0x84, 0x46, 0x08, 0x42, 0x10, 0x84, 0x20, 0xC0, 0xFF, 0xFF,
  0xF8, 0xC1, 0x08, 0x42, 0x10, 0x84, 0x10, 0xC8, 0x42, 0x10, 0x84, 0x27,
  0x00, 0xF9, 0x06,
};

const GFXglyph NotoSans_Condensed_ExtraLight21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 15, 4, 2, -15 },
  { 3, 4, 5, 7, 1, -15 },
  { 6, 10, 15, 10, 0, -15 },
  { 25, 7, 17, 9, 1, -16 },
  { 40, 12, 15, 14, 1, -15 },
  { 63, 9, 15, 10, 1, -15 },
  { 80, 1, 5, 4, 1, -15 },
  { 81, 4, 18, 6, 1, -15 },
  { 90, 4, 18, 6, 1, -15 },
  { 99, 7, 7, 9, 1, -16 },
  { 106, 8, 9, 10, 1, -12 },
  { 115, 2, 5, 4, 1, -2 },
  { 117, 4, 1, 6, 1, -6 },
  { 118, 2, 2, 4, 1, -2 },
  { 119, 7, 15, 7, 0, -15 },
  { 133, 7, 15, 9, 1, -15 },
  { 147, 4, 15, 9, 2, -15 },
  { 155, 7, 15, 9, 1, -15 },
  { 169, 7, 15, 9, 1, -15 },
  { 183, 9, 15, 9, 0, -15 },
  { 200, 7, 15, 9, 1, -15 },
  { 214, 8, 15, 9, 1, -15 },
  { 229, 7, 15, 9, 1, -15 },
  { 243, 8, 15, 9, 1, -15 },
  { 258, 7, 15, 9, 1, -15 },
  { 272, 2, 11, 4, 1, -11 },
  { 275, 2, 14, 4, 1, -11 },
  { 279, 8, 9, 10, 1, -12 },
  { 288, 8, 5, 10, 1, -10 },
  { 293, 8, 9, 10, 1, -12 },
  { 302, 6, 15, 7, 0, -15 },
  { 314, 13, 17, 15, 1, -15 },
  { 342, 9, 15, 9, 0, -15 },
  { 359, 7, 15, 10, 2, -15 },
  { 373, 9, 15, 10, 1, -15 },
  { 390, 8, 15, 11, 2, -15 },
  { 405, 6, 15, 9, 2, -15 },
  { 417, 6, 15, 8, 2, -15 },
  { 429, 10, 15, 12, 1, -15 },
  { 448, 8, 15, 12, 2, -15 },
  { 463, 3, 15, 5, 1, -15 },
  { 469, 4, 19, 4, -1, -15 },
  { 479, 7, 15, 9, 2, -15 },
  { 493, 6, 15, 8, 2, -15 },
  { 505, 11, 15, 15, 2, -15 },
  { 526, 8, 15, 12, 2, -15 },
  { 541, 10, 15, 12, 1, -15 },
  { 560, 7, 15, 10, 2, -15 },
  { 574, 10, 19, 12, 1, -15 },
  { 598, 7, 15, 10, 2, -15 },
  { 612, 7, 15, 9, 1, -15 },
  { 626, 8, 15, 8, 0, -15 },
  { 641, 8, 15, 12, 2, -15 },
  { 656, 9, 15, 9, 0, -15 },
  { 673, 15, 15, 15, 0, -15 },
  { 702, 8, 15, 8, 0, -15 },
  { 717, 8, 15, 8, 0, -15 },
  { 732, 7, 15, 9, 1, -15 },
  { 746, 4, 18, 7, 2, -15 },
  { 755, 7, 15, 7, 0, -15 },
  { 769, 4, 18, 7, 1, -15 },
  { 778, 8, 8, 10, 1, -15 },
  { 786, 8, 1, 8, 0, 2 },
  { 787, 3, 3, 5, 1, -16 },
  { 789, 6, 11, 9, 1, -11 },
  { 798, 7, 16, 10, 2, -16 },
  { 812, 6, 11, 8, 1, -11 },
  { 821, 7, 16, 10, 1, -16 },
  { 835, 7, 11, 9, 1, -11 },
  { 845, 6, 16, 5, 0, -16 },
  { 857, 7, 16, 10, 1, -11 },
  { 871, 6, 16, 10, 2, -16 },
  { 883, 2, 15, 4, 1, -15 },
  { 887, 3, 20, 4, 0, -15 },
  { 895, 6, 16, 8, 2, -16 },
  { 907, 1, 16, 4, 1, -16 },
  { 909, 11, 11, 15, 2, -11 },
  { 925, 6, 11, 10, 2, -11 },
  { 934, 8, 11, 10, 1, -11 },
  { 945, 7, 16, 10, 2, -11 },
  { 959, 7, 16, 10, 1, -11 },
  { 973, 4, 11, 6, 2, -11 },
  { 979, 6, 11, 8, 1, -11 },
  { 988, 5, 14, 5, 0, -14 },
  { 997, 6, 11, 10, 2, -11 },
  { 1006, 7, 11, 7, 0, -11 },
  { 1016, 12, 11, 12, 0, -11 },
  { 1033, 7, 11, 8, 0, -11 },
  { 1043, 8, 16, 8, 0, -11 },
  { 1059, 5, 11, 7, 1, -11 },
  { 1066, 5, 18, 7, 1, -15 },
  { 1078, 1, 21, 9, 4, -16 },
  { 1081, 5, 18, 7, 1, -15 },
  { 1093, 8, 2, 10, 1, -8 },
};

const GFXfont NotoSans_Condensed_ExtraLight21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight21pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT21PT7B_H_
