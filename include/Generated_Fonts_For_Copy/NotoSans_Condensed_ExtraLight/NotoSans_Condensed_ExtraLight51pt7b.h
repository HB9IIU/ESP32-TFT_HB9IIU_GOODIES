#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT51PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF6, 0xDB, 0x6D, 0xB6, 0xD9, 0x24, 0x92, 0x49, 0x00,
  0x00, 0x5F, 0xF0, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0x40, 0xD0, 0x34, 0x0D,
  0x03, 0x40, 0xD0, 0x34, 0x0D, 0x03, 0x40, 0xC0, 0x00, 0x40, 0x20, 0x00,
  0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18,
  0x0C, 0x00, 0x20, 0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0xC0, 0x03, 0x01,
  0x81, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0x40, 0x20, 0x00, 0x80, 0x40, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00,
  0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x40, 0x20, 0x00,
  0x80, 0x40, 0x7F, 0xFF, 0xFE, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x18, 0x00, 0x40, 0x20, 0x00, 0x80, 0x40, 0x03, 0x01,
  0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18,
  0x00, 0x40, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xF8, 0x00, 0xFF, 0xF0, 0x39, 0x8F, 0x0E, 0x30, 0x23, 0x06, 0x00, 0x60,
  0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x81,
  0x80, 0x38, 0x30, 0x03, 0x06, 0x00, 0x70, 0xC0, 0x07, 0x18, 0x00, 0x7B,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x37, 0x80, 0x06,
  0x38, 0x00, 0xC1, 0x80, 0x18, 0x38, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C,
  0x04, 0x01, 0x80, 0xC0, 0x30, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18,
  0x32, 0x03, 0x0E, 0x7C, 0x67, 0x87, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x02, 0x00,
  0xFC, 0x00, 0x20, 0x0C, 0x30, 0x03, 0x00, 0x60, 0xC0, 0x18, 0x06, 0x06,
  0x01, 0x80, 0x30, 0x10, 0x0C, 0x01, 0x80, 0xC0, 0x40, 0x08, 0x06, 0x06,
  0x00, 0x40, 0x30, 0x30, 0x06, 0x01, 0x83, 0x00, 0x30, 0x0C, 0x18, 0x01,
  0x80, 0x60, 0x80, 0x0C, 0x03, 0x0C, 0x00, 0x60, 0x18, 0x60, 0x01, 0x00,
  0xC6, 0x00, 0x08, 0x06, 0x30, 0xF8, 0x60, 0x31, 0x0C, 0xE3, 0x01, 0x18,
  0xC1, 0x18, 0x18, 0xCC, 0x0C, 0x60, 0xCC, 0x60, 0x63, 0x0C, 0x63, 0x01,
  0x0F, 0xC2, 0x10, 0x0C, 0x3C, 0x30, 0x80, 0x60, 0x01, 0x84, 0x03, 0x00,
  0x18, 0x60, 0x18, 0x00, 0xC3, 0x00, 0xC0, 0x04, 0x18, 0x06, 0x00, 0x60,
  0x40, 0x30, 0x03, 0x02, 0x01, 0x80, 0x30, 0x10, 0x0C, 0x01, 0x80, 0x80,
  0x60, 0x0C, 0x06, 0x02, 0x00, 0xC0, 0x30, 0x30, 0x06, 0x01, 0x81, 0x80,
  0x20, 0x06, 0x08, 0x03, 0x00, 0x19, 0xC0, 0x18, 0x00, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x60, 0x60, 0x01, 0x80,
  0x60, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x06,
  0x00, 0x30, 0x0C, 0x00, 0x20, 0x18, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0,
  0x00, 0xC3, 0x00, 0x01, 0x8E, 0x00, 0x01, 0xB8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x67, 0x00, 0x01, 0x86, 0x00, 0x06,
  0x06, 0x01, 0x98, 0x06, 0x02, 0x30, 0x0C, 0x0C, 0xE0, 0x0C, 0x19, 0x80,
  0x0C, 0x33, 0x00, 0x18, 0x46, 0x00, 0x19, 0x8C, 0x00, 0x1B, 0x18, 0x00,
  0x3C, 0x30, 0x00, 0x38, 0x70, 0x00, 0x70, 0x60, 0x01, 0xB0, 0xE0, 0x06,
  0x60, 0xE0, 0x18, 0x60, 0xF1, 0xE0, 0x60, 0xFF, 0x80, 0xE0, 0x30, 0x00,
  0x00, 0xFF, 0xF4, 0x92, 0x49, 0x24, 0x01, 0xC0, 0xC0, 0x30, 0x18, 0x0E,
  0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x40, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18,
  0x07, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x30, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C,
  0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18,
  0x18, 0x18, 0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x40, 0x81, 0x70, 0x87, 0xBE, 0xBE, 0x07, 0xE0, 0x01, 0xC0, 0x03,
  0x60, 0x02, 0x20, 0x06, 0x30, 0x0C, 0x18, 0x18, 0x0C, 0x18, 0x0C, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x39, 0xCC, 0x63, 0x19,
  0x8C, 0x66, 0x31, 0x80, 0xFF, 0xFF, 0xFC, 0xDF, 0xF0, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xFE, 0x01, 0xC1, 0xC0,
  0x60, 0x38, 0x30, 0x06, 0x1C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60,
  0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00,
  0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x0F,
  0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0,
  0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0x98, 0x00,
  0xC6, 0x00, 0x31, 0x80, 0x0C, 0x30, 0x06, 0x0E, 0x01, 0x81, 0xC0, 0xC0,
  0x3D, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x6C, 0x33, 0x18, 0xDC,
  0x3E, 0x0D, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x03, 0xF0, 0x07, 0xFF, 0x07, 0x80, 0xE1, 0x80, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xF0, 0x07, 0xFF, 0x07, 0x80, 0xE3, 0x80, 0x1C, 0x40,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xEC, 0x00, 0x73, 0xE0, 0xF8, 0x3F,
  0xF8, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0A, 0x00, 0x00, 0xD0, 0x00, 0x0C, 0x80, 0x00, 0x6C, 0x00, 0x06,
  0x60, 0x00, 0x33, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x01, 0x86, 0x00,
  0x0C, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x03,
  0x00, 0x30, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x18,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xFF, 0x08, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x04, 0x7E, 0x03, 0xFF, 0xE0, 0x60, 0x1E, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x20, 0x07, 0x0F, 0x07,
  0x81, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x78, 0x10, 0x38, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x1F, 0xE0, 0xCF, 0x1E, 0x36, 0x01, 0x8F, 0x00, 0x33, 0x80, 0x0E,
  0xE0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xB0, 0x00, 0x66, 0x00,
  0x19, 0x80, 0x06, 0x70, 0x03, 0x0C, 0x00, 0xC1, 0x80, 0x60, 0x78, 0x70,
  0x07, 0xF8, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x70, 0x1C, 0x0C, 0x01, 0xC3,
  0x00, 0x18, 0x60, 0x03, 0x18, 0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCC,
  0x00, 0x19, 0x80, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x30, 0x06, 0x03,
  0x01, 0xC0, 0x30, 0x60, 0x03, 0xB8, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x03,
  0x8E, 0x00, 0xC0, 0xE0, 0x30, 0x06, 0x0C, 0x00, 0x63, 0x00, 0x0E, 0x60,
  0x00, 0xDC, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3B, 0x00, 0x06, 0x60, 0x00, 0xC6, 0x00, 0x30, 0xE0,
  0x0E, 0x0F, 0x07, 0x80, 0x7F, 0xC0, 0x01, 0x80, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xC0, 0xE0, 0xE0, 0x18, 0x30, 0x03, 0x18, 0x00, 0x66, 0x00,
  0x19, 0x80, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0D, 0x80, 0x03, 0x60, 0x01, 0xD8,
  0x00, 0x77, 0x00, 0x1C, 0xC0, 0x0B, 0x18, 0x0E, 0xC3, 0xFF, 0x30, 0x7F,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0xC3, 0xC0, 0x3F, 0xE0, 0x00, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0xFF, 0x80, 0x39, 0xCE,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE7, 0x31, 0x8C, 0xE6, 0x31, 0x98, 0xC4, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F,
  0x81, 0xFF, 0x8E, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x03, 0x81, 0x80, 0x00, 0x06, 0x06, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x7F, 0x01, 0x98, 0x07, 0xDE,
  0x06, 0x60, 0x38, 0x18, 0x1B, 0x00, 0xC0, 0x60, 0x2C, 0x06, 0x01, 0x80,
  0xF0, 0x18, 0x06, 0x03, 0xC0, 0x40, 0x10, 0x0F, 0x03, 0x00, 0x40, 0x3C,
  0x0C, 0x01, 0x00, 0xF0, 0x30, 0x0C, 0x03, 0x80, 0xC0, 0x30, 0x0E, 0x03,
  0x00, 0xC0, 0x38, 0x0C, 0x03, 0x00, 0xF0, 0x30, 0x0C, 0x02, 0xC0, 0xC0,
  0x30, 0x1B, 0x03, 0x01, 0xC0, 0x6C, 0x06, 0x05, 0x81, 0x30, 0x18, 0x36,
  0x0C, 0xC0, 0x39, 0x8E, 0xE1, 0x80, 0x7C, 0x1F, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x10, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xB0, 0x00, 0x03,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0x80, 0x00, 0x31, 0x80, 0x00, 0x63,
  0x00, 0x00, 0xC6, 0x00, 0x01, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x30, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0,
  0x03, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00,
  0xC0, 0x06, 0x01, 0xFF, 0xFC, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC1, 0x80, 0x00, 0xC3, 0x00,
  0x01, 0x86, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x0C, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x30, 0xFF, 0xFC,
  0x18, 0x0F, 0xC3, 0x00, 0x1C, 0x60, 0x00, 0xCC, 0x00, 0x1D, 0x80, 0x01,
  0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03,
  0x60, 0x00, 0x6C, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0xC6, 0x00, 0x70,
  0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0x00, 0x1C, 0x60, 0x00, 0xCC, 0x00, 0x1D,
  0x80, 0x01, 0xB0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xB0, 0x00, 0x36,
  0x00, 0x0E, 0xC0, 0x03, 0x98, 0x00, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x03, 0xC0, 0x70, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x10, 0x3E, 0x1F, 0x00, 0xFF, 0xE0, 0x00, 0x40, 0xFF,
  0xF8, 0x06, 0x07, 0xF0, 0x30, 0x01, 0xC1, 0x80, 0x07, 0x0C, 0x00, 0x1C,
  0x60, 0x00, 0x73, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x36, 0x00,
  0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00,
  0xEC, 0x00, 0x06, 0x60, 0x00, 0x73, 0x00, 0x03, 0x18, 0x00, 0x30, 0xC0,
  0x03, 0x86, 0x00, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xE0, 0x1E, 0x07, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x70, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x38, 0x00, 0x03, 0x18, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x0E, 0x00, 0x03, 0x07, 0x80, 0x07, 0x01, 0xF0, 0x7F, 0x00, 0x7F,
  0xF8, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x8C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x07, 0x1F, 0xF0, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xDF, 0xEF, 0xC0, 0xC0, 0x01, 0xD8, 0x00, 0x33, 0x00,
  0x0C, 0x60, 0x03, 0x8C, 0x00, 0x61, 0x80, 0x18, 0x30, 0x06, 0x06, 0x01,
  0xC0, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x03, 0x80, 0x60, 0x60, 0x0C, 0x18,
  0x01, 0x87, 0x00, 0x31, 0xC0, 0x06, 0x30, 0x00, 0xCF, 0x00, 0x1B, 0x60,
  0x03, 0x66, 0x00, 0x78, 0xE0, 0x0E, 0x0C, 0x01, 0x81, 0xC0, 0x30, 0x18,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x06,
  0x0C, 0x00, 0xE1, 0x80, 0x0C, 0x30, 0x01, 0xC6, 0x00, 0x18, 0xC0, 0x01,
  0x98, 0x00, 0x33, 0x00, 0x03, 0x60, 0x00, 0x70, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7D, 0x00, 0x00, 0x0D, 0xD8, 0x00, 0x00, 0xDD, 0x80, 0x00,
  0x0D, 0xC8, 0x00, 0x01, 0x9C, 0xC0, 0x00, 0x19, 0xCC, 0x00, 0x01, 0x9C,
  0x40, 0x00, 0x31, 0xC6, 0x00, 0x03, 0x1C, 0x60, 0x00, 0x31, 0xC6, 0x00,
  0x06, 0x1C, 0x30, 0x00, 0x61, 0xC3, 0x00, 0x06, 0x1C, 0x30, 0x00, 0xC1,
  0xC1, 0x80, 0x0C, 0x1C, 0x18, 0x00, 0xC1, 0xC1, 0x80, 0x18, 0x1C, 0x0C,
  0x01, 0x81, 0xC0, 0xC0, 0x18, 0x1C, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x30,
  0x1C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x60, 0x1C, 0x03, 0x06, 0x01, 0xC0,
  0x30, 0x60, 0x1C, 0x03, 0x0C, 0x01, 0xC0, 0x18, 0xC0, 0x1C, 0x01, 0x8C,
  0x01, 0xC0, 0x19, 0x80, 0x1C, 0x00, 0xD8, 0x01, 0xC0, 0x0D, 0x80, 0x1C,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3D, 0x80, 0x01, 0xEE,
  0x00, 0x0F, 0x30, 0x00, 0x79, 0xC0, 0x03, 0xC6, 0x00, 0x1E, 0x38, 0x00,
  0xF0, 0xC0, 0x07, 0x83, 0x00, 0x3C, 0x18, 0x01, 0xE0, 0x60, 0x0F, 0x03,
  0x00, 0x78, 0x0C, 0x03, 0xC0, 0x60, 0x1E, 0x01, 0x80, 0xF0, 0x0C, 0x07,
  0x80, 0x30, 0x3C, 0x01, 0x81, 0xE0, 0x06, 0x0F, 0x00, 0x30, 0x78, 0x00,
  0xC3, 0xC0, 0x06, 0x1E, 0x00, 0x18, 0xF0, 0x00, 0xC7, 0x80, 0x03, 0x3C,
  0x00, 0x19, 0xE0, 0x00, 0x6F, 0x00, 0x03, 0x78, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x30, 0x00, 0x7E, 0x00,
  0x01, 0xFF, 0xC0, 0x07, 0x80, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38,
  0x18, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x30, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x0C, 0x00, 0x38, 0x0F, 0x00, 0x70, 0x03, 0xC7, 0xE0, 0x01, 0xFF, 0x80,
  0x00, 0x08, 0x00, 0xFF, 0xF0, 0x60, 0xFE, 0x30, 0x03, 0x98, 0x00, 0xEC,
  0x00, 0x36, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x06, 0xC0, 0x07, 0x60, 0x07, 0x30, 0x0F, 0x1F, 0xFE, 0x0F, 0xF8, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0x80, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x18,
  0x00, 0x1C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x38, 0x07, 0x00, 0x70, 0x03, 0xC7, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0x0B, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x38, 0xFF, 0xF0, 0x18, 0x1F, 0x83, 0x00, 0x38, 0x60, 0x03, 0x8C,
  0x00, 0x39, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x98,
  0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x30,
  0x00, 0xC6, 0x00, 0x18, 0xC0, 0x0E, 0x18, 0x03, 0x83, 0xFF, 0xE0, 0x7F,
  0xF0, 0x0C, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x06, 0x01, 0xC0, 0xC0,
  0x18, 0x18, 0x03, 0x83, 0x00, 0x30, 0x60, 0x07, 0x0C, 0x00, 0x61, 0x80,
  0x0E, 0x30, 0x00, 0xC6, 0x00, 0x1C, 0xC0, 0x01, 0x98, 0x00, 0x3B, 0x00,
  0x03, 0x60, 0x00, 0x70, 0x01, 0xFC, 0x01, 0xFF, 0xF1, 0xE0, 0x38, 0xE0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE8, 0x00, 0x73, 0xF8,
  0xF8, 0x7F, 0xF8, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x05, 0x80,
  0x00, 0x6C, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xCE, 0x00, 0x0C,
  0x30, 0x00, 0xE0, 0xE0, 0x0E, 0x03, 0xC3, 0xE0, 0x0F, 0xFC, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00,
  0x06, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x0C,
  0x30, 0x00, 0x30, 0x60, 0x00, 0xC1, 0x80, 0x06, 0x06, 0x00, 0x18, 0x0C,
  0x00, 0x60, 0x30, 0x01, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80, 0x60, 0x03, 0x01, 0x80,
  0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x40, 0xC0, 0x01, 0x82, 0x00, 0x06,
  0x18, 0x00, 0x18, 0x60, 0x00, 0x31, 0x80, 0x00, 0xCC, 0x00, 0x03, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x0E,
  0x00, 0x06, 0xC0, 0x00, 0xE0, 0x00, 0x66, 0x00, 0x0A, 0x00, 0x06, 0x60,
  0x01, 0xB0, 0x00, 0xC6, 0x00, 0x1B, 0x00, 0x0C, 0x60, 0x01, 0xB0, 0x00,
  0xC6, 0x00, 0x1B, 0x00, 0x0C, 0x30, 0x01, 0x10, 0x01, 0x83, 0x00, 0x31,
  0x80, 0x18, 0x30, 0x03, 0x18, 0x01, 0x83, 0x00, 0x31, 0x80, 0x18, 0x18,
  0x03, 0x18, 0x03, 0x81, 0x80, 0x60, 0xC0, 0x30, 0x18, 0x06, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0xC0, 0x30, 0x18, 0x06, 0x0C, 0x03, 0x00, 0xC0, 0x40,
  0x40, 0x60, 0x0C, 0x0C, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x60, 0x60, 0x0C,
  0x0C, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x60, 0xC0, 0x06, 0x18, 0x03, 0x0C,
  0x00, 0x61, 0x80, 0x30, 0xC0, 0x06, 0x18, 0x03, 0x0C, 0x00, 0x31, 0x80,
  0x31, 0x80, 0x03, 0x10, 0x01, 0x18, 0x00, 0x33, 0x00, 0x19, 0x80, 0x03,
  0x30, 0x01, 0x98, 0x00, 0x33, 0x00, 0x19, 0x80, 0x01, 0xB0, 0x01, 0xB0,
  0x00, 0x1A, 0x00, 0x0B, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x70,
  0x00, 0x73, 0x00, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x0C, 0x01, 0x80,
  0xC0, 0x18, 0x06, 0x03, 0x80, 0x60, 0x30, 0x07, 0x03, 0x00, 0x30, 0x60,
  0x03, 0x06, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x0D, 0x80, 0x00, 0xD8,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0D,
  0x80, 0x00, 0xD8, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x03,
  0x06, 0x00, 0x60, 0x60, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x81,
  0x80, 0x18, 0x18, 0x00, 0xC3, 0x80, 0x0C, 0x30, 0x00, 0xC7, 0x00, 0x06,
  0x60, 0x00, 0x6E, 0x00, 0x03, 0xC0, 0x00, 0x76, 0x00, 0x06, 0x60, 0x00,
  0xE3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x18, 0x18, 0x01, 0x81, 0x80,
  0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0x60, 0x60, 0x06,
  0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x01, 0x98, 0x00,
  0x19, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0xFF, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0x98,
  0x00, 0x0C, 0xC0, 0x00, 0xC2, 0x00, 0x06, 0x18, 0x00, 0x60, 0xC0, 0x03,
  0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0x60, 0x18, 0x03, 0x01, 0xC0, 0x0C,
  0x0C, 0x00, 0x60, 0xE0, 0x01, 0x86, 0x00, 0x0C, 0x70, 0x00, 0x33, 0x00,
  0x01, 0xB8, 0x00, 0x06, 0xFF, 0xFF, 0xF8, 0xE0, 0x60, 0x30, 0x38, 0x1C,
  0x0C, 0x06, 0x03, 0x0F, 0xF8, 0x3E, 0x3C, 0x10, 0x0E, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x0F, 0x03, 0xFF, 0x0F, 0x03, 0x38, 0x03, 0x70, 0x03, 0x60,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x60, 0x0B, 0x60, 0x1B, 0x38, 0x73, 0x1F, 0xE3, 0x03, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC7, 0xF8, 0x33, 0x87, 0x8D, 0x80, 0x63, 0xC0, 0x0C, 0xE0,
  0x03, 0xB8, 0x00, 0x6E, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x06, 0xC0,
  0x01, 0xB8, 0x00, 0x6E, 0x00, 0x33, 0xC0, 0x0C, 0xD8, 0x06, 0x23, 0x87,
  0x08, 0x7F, 0x80, 0x03, 0x00, 0x07, 0xFE, 0x1E, 0x18, 0x70, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x3E, 0x38, 0x1F, 0xF0, 0x02, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x3F, 0x86, 0x1E, 0x3C, 0xC7, 0x01, 0x98, 0xC0, 0x1B,
  0x30, 0x01, 0xE6, 0x00, 0x1D, 0x80, 0x03, 0xB0, 0x00, 0x76, 0x00, 0x0E,
  0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x3B,
  0x00, 0x07, 0x60, 0x00, 0xE6, 0x00, 0x1C, 0xC0, 0x07, 0x9C, 0x01, 0xB1,
  0xC0, 0x26, 0x1E, 0x1C, 0xC1, 0xFE, 0x18, 0x06, 0x00, 0x07, 0xF0, 0x0F,
  0x1E, 0x0E, 0x03, 0x06, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x1B, 0x00, 0x0D,
  0x80, 0x06, 0xC0, 0x01, 0x60, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x01, 0x0F, 0x0F, 0x81, 0xFF, 0x00, 0x18, 0x00, 0x01, 0xF8, 0x3F,
  0xC1, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x0F, 0xFC, 0x7F, 0xE0, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x00, 0x07, 0xFC, 0x61, 0xE3, 0xCC, 0x70, 0x0D, 0x8C, 0x00, 0xB3, 0x00,
  0x1E, 0x60, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x07, 0x60, 0x00, 0xEC, 0x00,
  0x0D, 0x80, 0x01, 0xB0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1A, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x1D, 0x80, 0x03, 0xB0, 0x00,
  0x76, 0x00, 0x0E, 0x60, 0x01, 0xCC, 0x00, 0x59, 0xC0, 0x1B, 0x1C, 0x06,
  0x61, 0xE3, 0x8C, 0x1F, 0xE1, 0x80, 0x20, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0xC2, 0x00, 0x70, 0x7E, 0xFC, 0x03, 0xFE, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC7, 0xF8,
  0xCF, 0x3C, 0xD8, 0x0E, 0xF0, 0x06, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x6F, 0x76, 0x00, 0x00, 0x00, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x06,
  0x0F, 0x0E, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0xFC, 0xF8,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0xD8, 0x03, 0x30, 0x0E, 0x60, 0x18, 0xC0, 0x61, 0x81, 0x83, 0x03, 0x06,
  0x0C, 0x0C, 0x30, 0x18, 0x60, 0x31, 0x80, 0x67, 0x00, 0xDB, 0x01, 0xB6,
  0x03, 0xC6, 0x07, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x18, 0x60, 0x30,
  0xC0, 0x31, 0x80, 0x63, 0x00, 0x66, 0x00, 0xCC, 0x00, 0xD8, 0x01, 0xB0,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x87, 0xF0, 0x3F, 0x88, 0xE3, 0x8E, 0x3C, 0x98, 0x1C, 0xC0, 0xEF, 0x00,
  0xD8, 0x06, 0xE0, 0x0D, 0x00, 0x6E, 0x00, 0x70, 0x03, 0xC0, 0x06, 0x00,
  0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0,
  0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60,
  0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C,
  0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06,
  0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03,
  0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x30, 0x87,
  0xF8, 0x8E, 0x3C, 0x98, 0x0E, 0xB0, 0x06, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x03, 0xFC, 0x01, 0xE3, 0xC0, 0x70, 0x0C,
  0x0C, 0x00, 0xC3, 0x00, 0x1C, 0x60, 0x01, 0x98, 0x00, 0x33, 0x00, 0x02,
  0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xA0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xD0, 0x00, 0x1A, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D,
  0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x60,
  0xC0, 0x0C, 0x1C, 0x03, 0x01, 0xE1, 0xC0, 0x0F, 0xF0, 0x00, 0x30, 0x00,
  0x87, 0xF8, 0x23, 0x87, 0x89, 0x80, 0x62, 0x40, 0x0C, 0xF0, 0x03, 0xB8,
  0x00, 0x6E, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x06, 0xE0, 0x01, 0xB8,
  0x00, 0x6E, 0x00, 0x33, 0x40, 0x0C, 0xD8, 0x06, 0x33, 0x87, 0x0C, 0x7F,
  0x83, 0x01, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0xF8, 0x61, 0xE3, 0xCC, 0x70, 0x19, 0x8C,
  0x01, 0xB3, 0x00, 0x16, 0x60, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x07, 0x60,
  0x00, 0xEC, 0x00, 0x1D, 0x80, 0x01, 0xB0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x1D, 0x80,
  0x03, 0xB0, 0x00, 0x76, 0x00, 0x0E, 0xE0, 0x03, 0xCC, 0x00, 0x59, 0xC0,
  0x1B, 0x1C, 0x06, 0x61, 0xE3, 0x8C, 0x1F, 0xE1, 0x80, 0x20, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x87, 0xF1, 0xFF, 0x60, 0x68, 0x0F, 0x01, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x00, 0x1F, 0xF8, 0xF0, 0xF7, 0x00, 0x58, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x1B, 0xC3,
  0xE7, 0xFE, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x07, 0xFF, 0xFF, 0xE3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0,
  0x0E, 0x20, 0xFC, 0x04, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xE0, 0x0B, 0x70, 0x1B, 0x3C, 0xF3, 0x1F, 0xE3, 0x02,
  0x00, 0xC0, 0x00, 0xD8, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03,
  0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x18, 0x06, 0x06, 0x01, 0x81,
  0x80, 0x60, 0x60, 0x30, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x10,
  0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61, 0x00, 0x0C, 0xC0, 0x03, 0x30,
  0x00, 0xCC, 0x00, 0x16, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x06, 0x60, 0x0F, 0x00, 0x66, 0x00, 0x90, 0x06, 0x60,
  0x19, 0x80, 0x66, 0x01, 0x98, 0x04, 0x30, 0x19, 0x80, 0xC3, 0x01, 0x88,
  0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x03, 0x0C, 0x08, 0x10, 0x30, 0xC1, 0x81,
  0x83, 0x04, 0x18, 0x18, 0x60, 0x61, 0x81, 0x86, 0x06, 0x18, 0x08, 0x60,
  0x63, 0x00, 0xC6, 0x02, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x30,
  0x04, 0xC0, 0x32, 0x00, 0x6C, 0x03, 0x60, 0x06, 0x80, 0x16, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0xE0, 0x03, 0xB0, 0x01, 0x8C, 0x01, 0x86, 0x00, 0xC1, 0x80, 0xC0,
  0xC0, 0x60, 0x30, 0x60, 0x18, 0x30, 0x06, 0x30, 0x03, 0x98, 0x00, 0xD8,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x06, 0xC0, 0x03,
  0x30, 0x03, 0x18, 0x01, 0x86, 0x01, 0x83, 0x01, 0xC0, 0xC0, 0xC0, 0x60,
  0xC0, 0x18, 0x60, 0x0C, 0x60, 0x03, 0x30, 0x01, 0xB0, 0x00, 0x60, 0x60,
  0x00, 0xD8, 0x00, 0x36, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00,
  0x61, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x02,
  0x18, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x01, 0x30, 0x00, 0x6C,
  0x00, 0x1B, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x37, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x78, 0x0F, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x78, 0x03, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF8, 0x00, 0x78, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x70, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x38, 0x0F, 0xC0, 0x3C, 0x00, 0x3F, 0x80, 0x3E, 0x7C, 0x07, 0x01, 0xF7,
  0xC0, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Condensed_ExtraLight51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 36, 11, 4, -36 },
  { 15, 10, 13, 16, 3, -36 },
  { 32, 23, 36, 25, 1, -36 },
  { 136, 19, 42, 23, 2, -39 },
  { 236, 29, 37, 33, 2, -37 },
  { 371, 23, 38, 25, 2, -37 },
  { 481, 3, 13, 9, 3, -36 },
  { 486, 10, 44, 14, 2, -36 },
  { 541, 9, 44, 14, 2, -36 },
  { 591, 16, 16, 21, 2, -39 },
  { 623, 19, 24, 23, 2, -30 },
  { 680, 5, 12, 10, 2, -5 },
  { 688, 11, 2, 14, 2, -15 },
  { 691, 3, 4, 10, 4, -4 },
  { 693, 15, 36, 17, 1, -36 },
  { 761, 18, 37, 23, 3, -37 },
  { 845, 10, 36, 23, 4, -36 },
  { 890, 18, 37, 23, 2, -37 },
  { 974, 18, 38, 23, 2, -37 },
  { 1060, 21, 37, 23, 1, -37 },
  { 1158, 18, 36, 23, 3, -36 },
  { 1239, 18, 38, 23, 3, -37 },
  { 1325, 18, 36, 23, 2, -36 },
  { 1406, 19, 38, 23, 2, -37 },
  { 1497, 18, 38, 23, 2, -37 },
  { 1583, 3, 27, 10, 4, -27 },
  { 1594, 5, 34, 10, 2, -27 },
  { 1616, 19, 22, 23, 2, -29 },
  { 1669, 19, 12, 23, 2, -24 },
  { 1698, 19, 22, 23, 2, -29 },
  { 1751, 14, 37, 16, 1, -37 },
  { 1816, 30, 41, 35, 3, -36 },
  { 1970, 23, 36, 23, 0, -36 },
  { 2074, 19, 36, 25, 4, -36 },
  { 2160, 20, 38, 24, 3, -37 },
  { 2255, 21, 36, 28, 4, -36 },
  { 2350, 16, 36, 22, 4, -36 },
  { 2422, 16, 36, 20, 4, -36 },
  { 2494, 24, 38, 30, 3, -37 },
  { 2608, 20, 36, 29, 4, -36 },
  { 2698, 9, 36, 13, 2, -36 },
  { 2739, 9, 45, 11, -3, -36 },
  { 2790, 19, 36, 23, 4, -36 },
  { 2876, 15, 36, 20, 4, -36 },
  { 2944, 28, 36, 37, 4, -36 },
  { 3070, 21, 36, 29, 4, -36 },
  { 3165, 24, 38, 30, 3, -37 },
  { 3279, 17, 36, 23, 4, -36 },
  { 3356, 24, 46, 30, 3, -37 },
  { 3494, 19, 36, 24, 4, -36 },
  { 3580, 18, 38, 22, 2, -37 },
  { 3666, 20, 36, 20, 0, -36 },
  { 3756, 21, 37, 29, 4, -36 },
  { 3854, 22, 36, 22, 0, -36 },
  { 3953, 36, 36, 37, 1, -36 },
  { 4115, 20, 36, 20, 0, -36 },
  { 4205, 20, 36, 20, 0, -36 },
  { 4295, 17, 36, 21, 2, -36 },
  { 4372, 10, 44, 16, 4, -36 },
  { 4427, 15, 36, 17, 1, -36 },
  { 4495, 10, 44, 16, 2, -36 },
  { 4550, 21, 19, 23, 1, -36 },
  { 4600, 21, 1, 20, 0, 5 },
  { 4603, 8, 8, 12, 2, -39 },
  { 4611, 16, 28, 21, 2, -27 },
  { 4667, 18, 40, 24, 4, -39 },
  { 4757, 15, 28, 19, 3, -27 },
  { 4810, 19, 40, 24, 2, -39 },
  { 4905, 17, 28, 22, 3, -27 },
  { 4965, 13, 39, 12, 1, -39 },
  { 5029, 19, 39, 24, 2, -27 },
  { 5122, 16, 39, 24, 4, -39 },
  { 5200, 4, 37, 10, 3, -37 },
  { 5219, 8, 49, 10, -1, -37 },
  { 5268, 15, 39, 19, 4, -39 },
  { 5342, 2, 39, 10, 4, -39 },
  { 5352, 28, 27, 36, 4, -27 },
  { 5447, 16, 27, 24, 4, -27 },
  { 5501, 19, 28, 24, 2, -27 },
  { 5568, 18, 39, 24, 4, -27 },
  { 5656, 19, 39, 24, 2, -27 },
  { 5749, 11, 27, 16, 4, -27 },
  { 5787, 14, 28, 18, 2, -27 },
  { 5836, 11, 35, 13, 1, -34 },
  { 5885, 16, 28, 24, 4, -27 },
  { 5941, 18, 27, 18, 0, -27 },
  { 6002, 28, 27, 30, 1, -27 },
  { 6097, 17, 27, 19, 1, -27 },
  { 6155, 18, 39, 18, 0, -27 },
  { 6243, 13, 27, 17, 2, -27 },
  { 6287, 13, 44, 18, 2, -36 },
  { 6359, 2, 51, 22, 10, -39 },
  { 6372, 14, 44, 18, 2, -36 },
  { 6449, 19, 4, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_ExtraLight51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight51pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT51PT7B_H_
