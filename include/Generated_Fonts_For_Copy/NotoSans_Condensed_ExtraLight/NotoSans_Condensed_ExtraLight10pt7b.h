#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT10PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xE0, 0x52, 0xBE, 0xAF, 0x29, 0x80, 0x25, 0xAA, 0x63, 0x3E,
  0x20, 0xEA, 0xAB, 0x2B, 0x74, 0xB2, 0xC0, 0x72, 0x98, 0x8A, 0xC9, 0xE0,
  0xC0, 0x5A, 0xA5, 0x40, 0xD5, 0x55, 0x80, 0x2F, 0x26, 0x22, 0xF2, 0x20,
  0xC0, 0xE0, 0x80, 0x24, 0xA5, 0x20, 0x79, 0x99, 0x99, 0x70, 0xD5, 0x54,
  0xF1, 0x11, 0x24, 0xF0, 0xF1, 0x16, 0x11, 0xF0, 0x22, 0x55, 0x97, 0x10,
  0xF3, 0x12, 0x78, 0xF3, 0x5B, 0x78, 0xF1, 0x22, 0x24, 0x40, 0x79, 0x56,
  0x99, 0x70, 0x79, 0x9D, 0x31, 0x60, 0x08, 0x0C, 0x12, 0xC2, 0x10, 0xF0,
  0xF0, 0x86, 0x16, 0x80, 0xE4, 0xA4, 0x10, 0x7C, 0x7F, 0xBD, 0xFE, 0x0E,
  0x23, 0x14, 0xAB, 0x4A, 0x20, 0xE9, 0xAE, 0x99, 0xE0, 0xF8, 0x88, 0x88,
  0xF0, 0xE9, 0x99, 0x99, 0xE0, 0xF2, 0x79, 0x38, 0xF2, 0x79, 0x20, 0xF8,
  0x8B, 0x99, 0xF0, 0x99, 0x9F, 0x99, 0x90, 0xD5, 0x5C, 0x55, 0x55, 0xC0,
  0xBB, 0x6D, 0x68, 0x92, 0x49, 0x38, 0x8C, 0x63, 0xBD, 0xD6, 0xA0, 0x99,
  0xDD, 0xBB, 0x90, 0xF9, 0x99, 0x99, 0xF0, 0xF6, 0xF9, 0x20, 0xF9, 0x99,
  0x99, 0xD2, 0x10, 0xF6, 0xEB, 0x68, 0x78, 0xC2, 0x11, 0xF0, 0xF4, 0x44,
  0x44, 0x40, 0x99, 0x99, 0x99, 0xF0, 0x99, 0x95, 0x62, 0x20, 0x93, 0x26,
  0x4B, 0x56, 0xCC, 0x91, 0x00, 0x96, 0x62, 0x69, 0x90, 0x99, 0x64, 0x44,
  0x40, 0xF2, 0x24, 0x44, 0xF0, 0xEA, 0xAA, 0xC0, 0x91, 0x22, 0x48, 0xD5,
  0x55, 0xC0, 0x25, 0x59, 0xF0, 0x90, 0x65, 0xDE, 0x93, 0x5B, 0x6F, 0x72,
  0x46, 0x11, 0x35, 0x99, 0x97, 0x79, 0xE8, 0x70, 0x6B, 0x24, 0x92, 0x79,
  0x99, 0x71, 0x70, 0x93, 0x5B, 0x6D, 0xBE, 0xBF, 0x80, 0x92, 0xE9, 0x35,
  0xFF, 0xFD, 0x6B, 0x5A, 0x80, 0xF6, 0xDA, 0x79, 0x99, 0x70, 0xF6, 0xDF,
  0x20, 0x79, 0x99, 0x71, 0x10, 0xEA, 0x80, 0xF1, 0x9E, 0xBA, 0xA4, 0xB6,
  0xDE, 0xB5, 0xA4, 0xA6, 0xDB, 0x92, 0x48, 0xA6, 0x46, 0x90, 0x9A, 0x64,
  0x44, 0xC0, 0xE5, 0x2E, 0x69, 0x2C, 0x92, 0x20, 0xFF, 0xC0, 0xC9, 0x22,
  0x92, 0x80, 0xF0,
};

const GFXglyph NotoSans_Condensed_ExtraLight10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 1, -7 },
  { 2, 2, 2, 3, 1, -7 },
  { 3, 5, 7, 5, 0, -7 },
  { 8, 4, 9, 5, 0, -8 },
  { 13, 6, 7, 7, 0, -7 },
  { 19, 5, 7, 5, 0, -7 },
  { 24, 1, 2, 2, 0, -7 },
  { 25, 2, 9, 3, 0, -7 },
  { 28, 2, 9, 3, 0, -7 },
  { 31, 4, 4, 4, 0, -8 },
  { 33, 4, 5, 5, 0, -6 },
  { 36, 1, 2, 2, 0, -1 },
  { 37, 3, 1, 3, 0, -3 },
  { 38, 1, 1, 2, 1, -1 },
  { 39, 3, 7, 3, 0, -7 },
  { 42, 4, 7, 5, 0, -7 },
  { 46, 2, 7, 5, 1, -7 },
  { 48, 4, 7, 5, 0, -7 },
  { 52, 4, 7, 5, 0, -7 },
  { 56, 4, 7, 5, 0, -7 },
  { 60, 3, 7, 5, 1, -7 },
  { 63, 3, 7, 5, 1, -7 },
  { 66, 4, 7, 5, 0, -7 },
  { 70, 4, 7, 5, 0, -7 },
  { 74, 4, 7, 5, 0, -7 },
  { 78, 1, 5, 2, 1, -5 },
  { 79, 1, 6, 2, 0, -5 },
  { 80, 4, 5, 5, 0, -6 },
  { 83, 4, 3, 5, 0, -5 },
  { 85, 4, 5, 5, 0, -6 },
  { 88, 3, 7, 3, 0, -7 },
  { 91, 5, 8, 7, 1, -7 },
  { 96, 5, 7, 5, 0, -7 },
  { 101, 4, 7, 5, 1, -7 },
  { 105, 4, 7, 5, 1, -7 },
  { 109, 4, 7, 5, 1, -7 },
  { 113, 3, 7, 4, 1, -7 },
  { 116, 3, 7, 4, 1, -7 },
  { 119, 4, 7, 6, 1, -7 },
  { 123, 4, 7, 6, 1, -7 },
  { 127, 2, 7, 3, 0, -7 },
  { 129, 2, 9, 2, -1, -7 },
  { 132, 3, 7, 4, 1, -7 },
  { 135, 3, 7, 4, 1, -7 },
  { 138, 5, 7, 7, 1, -7 },
  { 143, 4, 7, 6, 1, -7 },
  { 147, 4, 7, 6, 1, -7 },
  { 151, 3, 7, 5, 1, -7 },
  { 154, 4, 9, 6, 1, -7 },
  { 159, 3, 7, 5, 1, -7 },
  { 162, 4, 7, 4, 0, -7 },
  { 166, 4, 7, 4, 0, -7 },
  { 170, 4, 7, 6, 1, -7 },
  { 174, 4, 7, 4, 0, -7 },
  { 178, 7, 7, 7, 0, -7 },
  { 185, 4, 7, 4, 0, -7 },
  { 189, 4, 7, 4, 0, -7 },
  { 193, 4, 7, 4, 0, -7 },
  { 197, 2, 9, 3, 1, -7 },
  { 200, 3, 7, 3, 0, -7 },
  { 203, 2, 9, 3, 0, -7 },
  { 206, 4, 4, 5, 0, -7 },
  { 208, 4, 1, 4, 0, 1 },
  { 209, 2, 2, 2, 0, -8 },
  { 210, 3, 5, 4, 0, -5 },
  { 212, 3, 8, 5, 1, -8 },
  { 215, 3, 5, 4, 0, -5 },
  { 217, 4, 8, 5, 0, -8 },
  { 221, 4, 5, 4, 0, -5 },
  { 224, 3, 8, 2, 0, -8 },
  { 227, 4, 7, 5, 0, -5 },
  { 231, 3, 8, 5, 1, -8 },
  { 234, 1, 7, 2, 0, -7 },
  { 235, 1, 9, 2, 0, -7 },
  { 237, 3, 8, 4, 1, -8 },
  { 240, 1, 8, 2, 0, -8 },
  { 241, 5, 5, 7, 1, -5 },
  { 245, 3, 5, 5, 1, -5 },
  { 247, 4, 5, 5, 0, -5 },
  { 250, 3, 7, 5, 1, -5 },
  { 253, 4, 7, 5, 0, -5 },
  { 257, 2, 5, 3, 1, -5 },
  { 259, 3, 5, 4, 0, -5 },
  { 261, 2, 7, 3, 0, -7 },
  { 263, 3, 5, 5, 1, -5 },
  { 265, 3, 5, 4, 0, -5 },
  { 267, 6, 5, 6, 0, -5 },
  { 271, 4, 5, 4, 0, -5 },
  { 274, 4, 7, 4, 0, -5 },
  { 278, 3, 5, 3, 0, -5 },
  { 280, 3, 9, 3, 0, -7 },
  { 284, 1, 10, 4, 2, -8 },
  { 286, 3, 9, 3, 0, -7 },
  { 290, 4, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_ExtraLight10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight10pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT10PT7B_H_
