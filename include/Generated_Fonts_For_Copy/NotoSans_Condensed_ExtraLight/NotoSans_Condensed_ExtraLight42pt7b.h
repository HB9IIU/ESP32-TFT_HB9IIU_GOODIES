#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT42PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight42pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x90, 0x00, 0x7F,
  0xC0, 0xC3, 0xC3, 0xC3, 0xC3, 0x83, 0x82, 0x82, 0x82, 0x82, 0x82, 0x82,
  0x01, 0x03, 0x00, 0x20, 0x60, 0x04, 0x08, 0x00, 0x81, 0x00, 0x30, 0x20,
  0x06, 0x04, 0x00, 0xC0, 0x80, 0x10, 0x30, 0x02, 0x06, 0x0F, 0xFF, 0xFC,
  0x08, 0x10, 0x03, 0x02, 0x00, 0x60, 0x40, 0x0C, 0x08, 0x01, 0x03, 0x00,
  0x20, 0x60, 0x04, 0x0C, 0x00, 0x81, 0x00, 0x30, 0x20, 0x7F, 0xFF, 0xE0,
  0xC0, 0x80, 0x10, 0x30, 0x02, 0x06, 0x00, 0x40, 0xC0, 0x08, 0x10, 0x01,
  0x02, 0x00, 0x60, 0x40, 0x0C, 0x08, 0x01, 0x03, 0x00, 0x20, 0x60, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xFF, 0x83, 0xB1, 0xCC, 0x60, 0xB0,
  0xC0, 0x61, 0x80, 0x83, 0x01, 0x06, 0x02, 0x0C, 0x06, 0x18, 0x0C, 0x30,
  0x0C, 0x60, 0x0C, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x07, 0x80, 0x0D, 0xC0,
  0x18, 0xC0, 0x30, 0xC0, 0x60, 0x80, 0xC1, 0x81, 0x83, 0x03, 0x06, 0x06,
  0x0C, 0x0C, 0x10, 0x18, 0x68, 0x31, 0x9F, 0xFE, 0x07, 0xF0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x3E, 0x00, 0x40, 0xC6, 0x01, 0x81, 0x86, 0x02,
  0x02, 0x0C, 0x04, 0x0C, 0x08, 0x18, 0x18, 0x10, 0x20, 0x30, 0x20, 0xC0,
  0x40, 0x41, 0x00, 0x80, 0x82, 0x01, 0x01, 0x0C, 0x02, 0x02, 0x10, 0x06,
  0x04, 0x60, 0x0C, 0x08, 0x8F, 0x98, 0x11, 0x31, 0x90, 0x66, 0x41, 0xB0,
  0x88, 0x83, 0x63, 0x33, 0x02, 0x7C, 0x46, 0x04, 0x00, 0x8C, 0x08, 0x03,
  0x10, 0x10, 0x04, 0x20, 0x20, 0x18, 0x40, 0x40, 0x20, 0x80, 0x80, 0x41,
  0x81, 0x01, 0x83, 0x02, 0x02, 0x06, 0x04, 0x0C, 0x04, 0x18, 0x10, 0x0C,
  0x20, 0x20, 0x08, 0xC0, 0xC0, 0x1F, 0x00, 0x0F, 0xC0, 0x06, 0x18, 0x01,
  0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x04, 0x03, 0x03, 0x00, 0xC0,
  0xC0, 0x10, 0x30, 0x06, 0x08, 0x01, 0x86, 0x00, 0x33, 0x00, 0x05, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x64, 0x00, 0x31, 0x80, 0x58, 0x30, 0x24,
  0x04, 0x0B, 0x01, 0x82, 0x80, 0x31, 0xA0, 0x06, 0x48, 0x01, 0xB2, 0x00,
  0x3C, 0x80, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xF1, 0x80, 0x66, 0x30, 0x70,
  0x87, 0xF0, 0x30, 0xFF, 0xEA, 0xA8, 0x03, 0x06, 0x0C, 0x08, 0x18, 0x10,
  0x30, 0x20, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x60, 0x60, 0x20, 0x30,
  0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0xC0, 0x81, 0x81, 0x83, 0x03,
  0x06, 0x04, 0x0C, 0x18, 0x10, 0x30, 0x60, 0xC1, 0x83, 0x02, 0x04, 0x08,
  0x10, 0x20, 0xC1, 0x83, 0x06, 0x08, 0x30, 0x60, 0xC3, 0x06, 0x08, 0x30,
  0x41, 0x86, 0x08, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x08, 0x20,
  0xF9, 0x1C, 0x7F, 0x00, 0x60, 0x05, 0x00, 0x64, 0x06, 0x30, 0x20, 0xC3,
  0x02, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x23, 0x66, 0x66, 0x4C, 0xC8, 0xFF,
  0xC0, 0xDF, 0x00, 0x00, 0x10, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x0F, 0xE0, 0x38, 0xE0, 0xC0, 0x61, 0x80, 0xC6, 0x00, 0x8C, 0x01, 0x98,
  0x03, 0x20, 0x02, 0x40, 0x05, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x68, 0x00, 0x90, 0x01, 0x30, 0x06, 0x60, 0x0C, 0x40,
  0x10, 0xC0, 0x60, 0xC0, 0x81, 0xC7, 0x01, 0xFC, 0x00, 0x01, 0x07, 0x0D,
  0x19, 0x31, 0xE1, 0x41, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x1F, 0xE1, 0xE0, 0xE1, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xC0,
  0x3F, 0xE0, 0xE0, 0xE3, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03,
  0x00, 0x38, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x10, 0x00, 0x30,
  0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x34, 0x00, 0xCE, 0x07, 0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xA0, 0x00, 0x68, 0x00, 0x32, 0x00, 0x0C,
  0x80, 0x06, 0x20, 0x01, 0x08, 0x00, 0xC2, 0x00, 0x20, 0x80, 0x18, 0x20,
  0x04, 0x08, 0x03, 0x02, 0x01, 0x80, 0x80, 0x60, 0x20, 0x30, 0x08, 0x08,
  0x02, 0x06, 0x00, 0x81, 0x00, 0x20, 0xC0, 0x08, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x05, 0xFC, 0x0F, 0xFE, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x64, 0x01, 0xCE, 0x07, 0x0F,
  0xF8, 0x00, 0x03, 0xF8, 0x0E, 0x08, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x7F, 0x1B, 0x07, 0x34, 0x03, 0x70, 0x06, 0xE0, 0x05, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xD0, 0x01, 0xA0, 0x03, 0x60,
  0x06, 0xC0, 0x08, 0xC0, 0x31, 0x80, 0xC1, 0xC3, 0x81, 0xFC, 0x00, 0x40,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x00, 0x0F, 0xE0,
  0x70, 0x70, 0xC0, 0x63, 0x00, 0x64, 0x00, 0xC8, 0x00, 0x90, 0x01, 0x20,
  0x02, 0x60, 0x0C, 0xC0, 0x18, 0xC0, 0x60, 0xC1, 0x80, 0xC6, 0x00, 0xF8,
  0x01, 0xE0, 0x06, 0x70, 0x38, 0x30, 0x60, 0x31, 0x80, 0x36, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0D, 0x00,
  0x33, 0x00, 0x63, 0x83, 0x83, 0xFC, 0x00, 0x0F, 0xC0, 0x70, 0xE0, 0xC0,
  0x43, 0x00, 0xC4, 0x00, 0x98, 0x01, 0xB0, 0x03, 0x60, 0x02, 0xC0, 0x05,
  0x00, 0x0B, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xD0, 0x03, 0xB0,
  0x0B, 0x30, 0x36, 0x3F, 0x88, 0x08, 0x10, 0x00, 0x20, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x04,
  0x1C, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x6F,
  0x80, 0x77, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x36, 0x66,
  0x64, 0xCC, 0x80, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x7F,
  0x18, 0x38, 0x03, 0x00, 0x30, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x60,
  0x0C, 0x01, 0x00, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x01, 0x80, 0x30, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0xF0, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0x40, 0x00, 0x08, 0x60, 0x00, 0x06, 0x20, 0x06, 0x01, 0x30, 0x1F, 0xE0,
  0x98, 0x18, 0x20, 0x68, 0x18, 0x10, 0x34, 0x0C, 0x08, 0x1E, 0x04, 0x04,
  0x0F, 0x06, 0x02, 0x07, 0x83, 0x01, 0x01, 0xC1, 0x80, 0x81, 0xE0, 0xC0,
  0x40, 0xF0, 0x60, 0x60, 0x78, 0x30, 0x30, 0x3C, 0x18, 0x18, 0x16, 0x0C,
  0x0C, 0x09, 0x02, 0x0F, 0x0C, 0x81, 0x8C, 0x8C, 0x60, 0x7C, 0x7C, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x02, 0x80, 0x00,
  0x50, 0x00, 0x1B, 0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x18, 0xC0, 0x03,
  0x18, 0x00, 0x41, 0x00, 0x08, 0x20, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x08,
  0x08, 0x03, 0x01, 0x80, 0x60, 0x30, 0x08, 0x02, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0C, 0x01, 0x81, 0x00, 0x10, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80,
  0x0C, 0x20, 0x00, 0x8C, 0x00, 0x19, 0x80, 0x03, 0x20, 0x00, 0x2C, 0x00,
  0x07, 0x80, 0x00, 0xC0, 0xFF, 0xC1, 0x07, 0xE2, 0x00, 0x64, 0x00, 0x68,
  0x00, 0xD0, 0x01, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x0D, 0x00, 0x1A, 0x00,
  0x34, 0x00, 0xC8, 0x03, 0x10, 0x7C, 0x3F, 0xF0, 0x40, 0x38, 0x80, 0x19,
  0x00, 0x1A, 0x00, 0x14, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x1A, 0x00, 0x34, 0x00, 0xC8, 0x1F, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x01, 0xC1, 0xC3, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x18, 0x0F, 0xF8, 0xFF, 0x80, 0x43, 0xF0, 0x20, 0x0E, 0x10,
  0x03, 0x88, 0x00, 0xC4, 0x00, 0x32, 0x00, 0x19, 0x00, 0x06, 0x80, 0x03,
  0x40, 0x01, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28,
  0x00, 0x34, 0x00, 0x1A, 0x00, 0x0D, 0x00, 0x0C, 0x80, 0x06, 0x40, 0x06,
  0x20, 0x07, 0x10, 0x07, 0x08, 0x7E, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x00, 0xFF, 0xC0, 0x38, 0x0F, 0x06, 0x00, 0x20, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03,
  0x40, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00,
  0x33, 0x00, 0x03, 0x30, 0x00, 0x31, 0x80, 0x03, 0x1C, 0x00, 0x30, 0xE0,
  0x03, 0x03, 0x80, 0xF0, 0x1F, 0xFC, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xFE, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x1F, 0xC0, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x86, 0xFC, 0x80, 0x0D,
  0x00, 0x32, 0x00, 0x64, 0x01, 0x88, 0x06, 0x10, 0x0C, 0x20, 0x30, 0x40,
  0xC0, 0x83, 0x01, 0x06, 0x02, 0x18, 0x04, 0x60, 0x08, 0xC0, 0x13, 0x80,
  0x2F, 0x00, 0x53, 0x00, 0xC6, 0x01, 0x86, 0x02, 0x0C, 0x04, 0x0C, 0x08,
  0x08, 0x10, 0x18, 0x20, 0x18, 0x40, 0x30, 0x80, 0x31, 0x00, 0x62, 0x00,
  0x64, 0x00, 0x48, 0x00, 0xD0, 0x00, 0xC0, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFA, 0x00, 0x01, 0x76, 0x00, 0x02, 0xEC, 0x00, 0x0D,
  0xC8, 0x00, 0x13, 0x98, 0x00, 0x27, 0x30, 0x00, 0xCE, 0x20, 0x01, 0x1C,
  0x60, 0x02, 0x38, 0xC0, 0x0C, 0x70, 0x80, 0x10, 0xE1, 0x80, 0x21, 0xC3,
  0x00, 0xC3, 0x82, 0x01, 0x07, 0x06, 0x02, 0x0E, 0x0C, 0x0C, 0x1C, 0x08,
  0x10, 0x38, 0x18, 0x20, 0x70, 0x30, 0xC0, 0xE0, 0x21, 0x01, 0xC0, 0x62,
  0x03, 0x80, 0xCC, 0x07, 0x00, 0x98, 0x0E, 0x01, 0xA0, 0x1C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3B, 0x00, 0x1D, 0x80, 0x0E, 0x60, 0x07, 0x30, 0x03,
  0x8C, 0x01, 0xC6, 0x00, 0xE1, 0x80, 0x70, 0xC0, 0x38, 0x30, 0x1C, 0x18,
  0x0E, 0x06, 0x07, 0x01, 0x03, 0x80, 0xC1, 0xC0, 0x20, 0xE0, 0x18, 0x70,
  0x04, 0x38, 0x03, 0x1C, 0x00, 0x8E, 0x00, 0x67, 0x00, 0x13, 0x80, 0x0D,
  0xC0, 0x02, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0C, 0x03,
  0xFE, 0x00, 0x70, 0x70, 0x0C, 0x01, 0x81, 0x80, 0x0C, 0x30, 0x00, 0x43,
  0x00, 0x06, 0x20, 0x00, 0x26, 0x00, 0x03, 0x60, 0x00, 0x34, 0x00, 0x03,
  0x40, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00,
  0x01, 0x40, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x32, 0x00, 0x02, 0x30,
  0x00, 0x63, 0x00, 0x04, 0x18, 0x00, 0xC0, 0xC0, 0x18, 0x07, 0x07, 0x00,
  0x3F, 0xE0, 0xFF, 0x82, 0x1F, 0x88, 0x07, 0x20, 0x06, 0x80, 0x1A, 0x00,
  0x28, 0x00, 0xA0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xA0, 0x06, 0x80,
  0x1A, 0x00, 0x68, 0x03, 0x20, 0x38, 0xFF, 0x82, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x70, 0x70,
  0x0C, 0x01, 0x81, 0x80, 0x0C, 0x30, 0x00, 0x43, 0x00, 0x06, 0x20, 0x00,
  0x26, 0x00, 0x03, 0x60, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x36,
  0x00, 0x03, 0x60, 0x00, 0x32, 0x00, 0x02, 0x30, 0x00, 0x63, 0x00, 0x04,
  0x18, 0x00, 0xC0, 0xC0, 0x18, 0x07, 0x07, 0x00, 0x3F, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0xFF, 0x81, 0x1F, 0xC2, 0x01, 0xC4, 0x00, 0xC8,
  0x01, 0x90, 0x01, 0x20, 0x02, 0x40, 0x06, 0x80, 0x0D, 0x00, 0x12, 0x00,
  0x24, 0x00, 0xC8, 0x01, 0x90, 0x06, 0x20, 0x18, 0x7F, 0xE0, 0xFF, 0x01,
  0x03, 0x02, 0x06, 0x04, 0x06, 0x08, 0x0C, 0x10, 0x0C, 0x20, 0x18, 0x40,
  0x18, 0x80, 0x31, 0x00, 0x32, 0x00, 0x64, 0x00, 0x68, 0x00, 0xD0, 0x00,
  0xC0, 0x0F, 0xF8, 0x78, 0x38, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xCE, 0x07, 0x1F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0x40, 0x01, 0xB0, 0x00, 0x98, 0x00, 0xC6, 0x00, 0xC1, 0xC1, 0xC0,
  0x7F, 0xC0, 0xC0, 0x00, 0x70, 0x00, 0x34, 0x00, 0x0D, 0x80, 0x02, 0x60,
  0x00, 0x88, 0x00, 0x62, 0x00, 0x18, 0xC0, 0x04, 0x30, 0x03, 0x04, 0x00,
  0xC1, 0x00, 0x20, 0x60, 0x08, 0x18, 0x06, 0x02, 0x01, 0x80, 0xC0, 0x40,
  0x30, 0x10, 0x04, 0x0C, 0x01, 0x03, 0x00, 0x60, 0x80, 0x18, 0x60, 0x02,
  0x18, 0x00, 0x84, 0x00, 0x31, 0x00, 0x0C, 0xC0, 0x01, 0x30, 0x00, 0x68,
  0x00, 0x1A, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0D, 0x00, 0x0C, 0x00, 0x36, 0x00, 0x38, 0x00, 0xD8, 0x00, 0xE0,
  0x02, 0x20, 0x07, 0x80, 0x18, 0x80, 0x1A, 0x00, 0x63, 0x00, 0x68, 0x01,
  0x8C, 0x01, 0x30, 0x04, 0x30, 0x04, 0xC0, 0x30, 0x40, 0x31, 0x00, 0xC1,
  0x80, 0xC4, 0x03, 0x06, 0x02, 0x18, 0x08, 0x18, 0x08, 0x60, 0x60, 0x20,
  0x61, 0x81, 0x80, 0x81, 0x82, 0x06, 0x03, 0x06, 0x08, 0x10, 0x0C, 0x10,
  0x30, 0x40, 0x10, 0x40, 0xC3, 0x00, 0x43, 0x01, 0x0C, 0x01, 0x8C, 0x04,
  0x30, 0x06, 0x20, 0x18, 0x80, 0x18, 0x80, 0x66, 0x00, 0x26, 0x01, 0x98,
  0x00, 0x98, 0x02, 0x60, 0x03, 0x60, 0x09, 0x00, 0x0D, 0x00, 0x34, 0x00,
  0x14, 0x00, 0xF0, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x18, 0x01, 0x8C, 0x01, 0x82, 0x00, 0xC1,
  0x80, 0xC0, 0x40, 0x60, 0x30, 0x20, 0x08, 0x30, 0x06, 0x10, 0x03, 0x18,
  0x00, 0xC8, 0x00, 0x6C, 0x00, 0x14, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0x60, 0x01, 0xB0, 0x00, 0x88, 0x00, 0xC6, 0x00, 0x41, 0x00,
  0x60, 0xC0, 0x20, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x18, 0x03, 0x0C, 0x01,
  0x8C, 0x00, 0x46, 0x00, 0x36, 0x00, 0x0C, 0xC0, 0x03, 0x40, 0x03, 0x60,
  0x02, 0x60, 0x06, 0x20, 0x04, 0x30, 0x0C, 0x10, 0x0C, 0x18, 0x08, 0x18,
  0x18, 0x08, 0x10, 0x0C, 0x30, 0x04, 0x30, 0x06, 0x20, 0x06, 0x60, 0x02,
  0x60, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7F, 0xFE, 0xFF, 0xF8, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1F, 0xFF, 0xF8, 0xC0, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40,
  0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0xFF, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x7F, 0xFF,
  0xF8, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x58, 0x00, 0x6C, 0x00, 0x23, 0x00,
  0x31, 0x80, 0x10, 0x60, 0x18, 0x30, 0x08, 0x08, 0x0C, 0x06, 0x04, 0x01,
  0x06, 0x00, 0xC2, 0x00, 0x23, 0x00, 0x19, 0x00, 0x05, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0x40, 0x03, 0x01, 0xFF, 0x18,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x7E, 0x3F, 0xB3, 0x01, 0xB0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0F, 0x80, 0x7C, 0x05, 0xB0, 0x6C, 0xFE, 0x60, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x83, 0x03, 0x3F, 0xC6, 0xC1, 0xCF, 0x00, 0x9C, 0x01,
  0xB8, 0x01, 0x60, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x17, 0x00, 0x6E, 0x00, 0xDE, 0x03, 0x36, 0x0C, 0x47, 0xF0, 0x00, 0xC0,
  0xFF, 0x1C, 0x13, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0xC1, 0x0F, 0xF0, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x07, 0x0C, 0x3F, 0x98, 0xC1, 0xB3, 0x01, 0xEC, 0x01, 0xD8,
  0x01, 0xA0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0D, 0x00, 0x1B,
  0x00, 0x76, 0x00, 0xA6, 0x03, 0x46, 0x0C, 0x87, 0xF1, 0x01, 0x00, 0x3F,
  0x81, 0x83, 0x0C, 0x06, 0x60, 0x09, 0x80, 0x34, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x04, 0x70, 0x60,
  0xFF, 0x80, 0x03, 0xF0, 0x72, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0xFF, 0x80, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x03, 0x80, 0x1F, 0xC4, 0x60, 0xC9, 0x80, 0x76, 0x00, 0xEC,
  0x00, 0xD0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x06, 0x80, 0x0D,
  0x80, 0x3B, 0x00, 0x73, 0x01, 0xE3, 0x06, 0xC3, 0xF9, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x90, 0x06,
  0x3C, 0x78, 0x1F, 0xE0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x0E, 0x0C, 0xFE, 0x36,
  0x0C, 0xF0, 0x1B, 0x80, 0x6E, 0x00, 0xB0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xF4, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x30, 0x40, 0x00,
  0x00, 0x00, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x29, 0xBC, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x0D, 0x80, 0xCC, 0x0C, 0x60,
  0x63, 0x06, 0x18, 0x60, 0xC2, 0x06, 0x30, 0x33, 0x01, 0x98, 0x0D, 0x60,
  0x79, 0x03, 0x8C, 0x18, 0x20, 0xC1, 0x86, 0x04, 0x30, 0x31, 0x80, 0x8C,
  0x06, 0x60, 0x1B, 0x00, 0xD8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0x80, 0x61, 0x1F, 0x87, 0xF2, 0x61, 0x98, 0x37, 0x01,
  0xA0, 0x3E, 0x03, 0x80, 0x78, 0x03, 0x00, 0xF0, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0x80, 0x03, 0x82, 0x3F,
  0x89, 0x83, 0x3C, 0x06, 0xE0, 0x1B, 0x00, 0x2C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xC0, 0x01, 0x80, 0x1F, 0xE0, 0x60, 0x61, 0x80, 0x66, 0x00, 0xCC,
  0x00, 0x90, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x06, 0x80, 0x0D,
  0x80, 0x13, 0x00, 0x63, 0x01, 0x83, 0x07, 0x03, 0xF8, 0x00, 0x01, 0x81,
  0x1F, 0xE2, 0x60, 0xE6, 0x80, 0xCE, 0x00, 0xDC, 0x00, 0xB0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0B, 0x80, 0x37, 0x00, 0x6D,
  0x01, 0x9B, 0x06, 0x33, 0xF8, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x1F, 0xC4, 0x60, 0xC9, 0x80, 0xF6, 0x00, 0xEC, 0x00, 0xD0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x06, 0x80, 0x0D, 0x80, 0x3B,
  0x00, 0x73, 0x01, 0x63, 0x06, 0xC3, 0xF9, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x03, 0x47, 0xF6, 0x1A, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x00, 0x06, 0x03, 0xFE, 0x60, 0x2C, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x60, 0x02, 0x00, 0x20, 0x03, 0x00, 0x30, 0x02, 0x80, 0x6C,
  0x0C, 0xFF, 0x80, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x83, 0xFE, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x03, 0xF0, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0E, 0xC0, 0x57, 0x0C, 0x9F, 0xC4, 0xC0,
  0x06, 0x80, 0x19, 0x80, 0x33, 0x00, 0x46, 0x00, 0x84, 0x03, 0x0C, 0x06,
  0x18, 0x08, 0x10, 0x30, 0x20, 0x60, 0x60, 0x80, 0xC1, 0x00, 0x86, 0x01,
  0x8C, 0x03, 0x10, 0x02, 0x20, 0x04, 0xC0, 0x0D, 0x00, 0x1A, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x03, 0x40, 0x1C, 0x03, 0x60,
  0x14, 0x02, 0x60, 0x14, 0x02, 0x20, 0x34, 0x06, 0x20, 0x36, 0x06, 0x30,
  0x26, 0x04, 0x30, 0x22, 0x04, 0x10, 0x62, 0x0C, 0x10, 0x63, 0x0C, 0x18,
  0x43, 0x0C, 0x18, 0x41, 0x08, 0x08, 0xC1, 0x08, 0x08, 0xC1, 0x98, 0x0C,
  0x81, 0x98, 0x0C, 0x80, 0x90, 0x05, 0x80, 0x90, 0x05, 0x80, 0xF0, 0x05,
  0x00, 0xF0, 0x07, 0x00, 0x60, 0x07, 0x00, 0x60, 0x03, 0x00, 0x60, 0xC0,
  0x1D, 0x80, 0x62, 0x03, 0x0C, 0x0C, 0x10, 0x60, 0x61, 0x80, 0x8C, 0x03,
  0x30, 0x05, 0x80, 0x1C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x80, 0x32, 0x00,
  0xCC, 0x06, 0x10, 0x10, 0x60, 0xC0, 0xC2, 0x03, 0x18, 0x06, 0x40, 0x1B,
  0x00, 0x30, 0x40, 0x06, 0xC0, 0x0D, 0x80, 0x11, 0x00, 0x63, 0x00, 0xC6,
  0x01, 0x04, 0x06, 0x08, 0x0C, 0x18, 0x10, 0x30, 0x20, 0x20, 0xC0, 0x61,
  0x80, 0xC2, 0x00, 0x8C, 0x01, 0x18, 0x03, 0x20, 0x06, 0x40, 0x05, 0x80,
  0x0B, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x26, 0x00,
  0x78, 0x00, 0x7F, 0xE0, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x60,
  0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0xFF, 0xC0, 0x01, 0xE0, 0x78,
  0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x0E, 0x03, 0x80, 0x1C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x01, 0xF0, 0x06,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0x0F, 0x00, 0x30, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00, 0x78,
  0x03, 0x81, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x60, 0x78,
  0x0C, 0x00, 0x3C, 0x01, 0xFF, 0x01, 0x81, 0xC6, 0x80, 0x7C,
};

const GFXglyph NotoSans_Condensed_ExtraLight42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 30, 9, 3, -30 },
  { 13, 8, 11, 13, 3, -30 },
  { 24, 19, 30, 21, 1, -30 },
  { 96, 15, 34, 19, 2, -32 },
  { 160, 23, 30, 27, 2, -30 },
  { 247, 18, 30, 21, 2, -30 },
  { 315, 2, 11, 7, 3, -30 },
  { 318, 8, 37, 11, 2, -30 },
  { 355, 7, 37, 11, 2, -30 },
  { 388, 13, 13, 17, 2, -32 },
  { 410, 16, 20, 19, 2, -25 },
  { 450, 4, 10, 8, 2, -5 },
  { 455, 10, 1, 12, 1, -12 },
  { 457, 3, 3, 8, 3, -3 },
  { 459, 12, 30, 14, 1, -30 },
  { 504, 15, 30, 19, 2, -30 },
  { 561, 8, 30, 19, 3, -30 },
  { 591, 15, 30, 19, 2, -30 },
  { 648, 15, 30, 19, 2, -30 },
  { 705, 18, 30, 19, 1, -30 },
  { 773, 15, 30, 19, 2, -30 },
  { 830, 15, 31, 19, 2, -30 },
  { 889, 15, 30, 19, 2, -30 },
  { 946, 15, 30, 19, 2, -30 },
  { 1003, 15, 30, 19, 2, -30 },
  { 1060, 3, 22, 8, 3, -22 },
  { 1069, 4, 27, 8, 2, -22 },
  { 1083, 16, 18, 19, 2, -24 },
  { 1119, 16, 10, 19, 2, -20 },
  { 1139, 16, 18, 19, 2, -24 },
  { 1175, 11, 30, 13, 1, -30 },
  { 1217, 25, 34, 29, 2, -30 },
  { 1324, 19, 30, 19, 0, -30 },
  { 1396, 15, 30, 21, 4, -30 },
  { 1453, 17, 30, 20, 2, -30 },
  { 1517, 17, 30, 23, 4, -30 },
  { 1581, 12, 30, 18, 4, -30 },
  { 1626, 12, 30, 17, 4, -30 },
  { 1671, 20, 30, 25, 2, -30 },
  { 1746, 16, 30, 24, 4, -30 },
  { 1806, 7, 30, 11, 2, -30 },
  { 1833, 8, 37, 9, -3, -30 },
  { 1870, 15, 30, 19, 4, -30 },
  { 1927, 12, 30, 17, 4, -30 },
  { 1972, 23, 30, 30, 4, -30 },
  { 2059, 17, 30, 24, 4, -30 },
  { 2123, 20, 30, 25, 2, -30 },
  { 2198, 14, 30, 19, 4, -30 },
  { 2251, 20, 37, 25, 2, -30 },
  { 2344, 15, 30, 20, 4, -30 },
  { 2401, 15, 30, 18, 2, -30 },
  { 2458, 16, 30, 17, 0, -30 },
  { 2518, 17, 30, 24, 3, -30 },
  { 2582, 18, 30, 18, 0, -30 },
  { 2650, 30, 30, 31, 0, -30 },
  { 2763, 17, 30, 17, 0, -30 },
  { 2827, 16, 30, 16, 0, -30 },
  { 2887, 15, 30, 17, 1, -30 },
  { 2944, 9, 37, 13, 3, -30 },
  { 2986, 12, 30, 14, 1, -30 },
  { 3031, 9, 37, 13, 1, -30 },
  { 3073, 17, 16, 19, 1, -30 },
  { 3107, 17, 1, 17, 0, 4 },
  { 3110, 6, 7, 10, 2, -32 },
  { 3116, 13, 23, 18, 2, -23 },
  { 3154, 15, 32, 20, 3, -32 },
  { 3214, 12, 23, 15, 2, -23 },
  { 3249, 15, 32, 20, 2, -32 },
  { 3309, 14, 23, 18, 2, -23 },
  { 3350, 12, 32, 10, 0, -32 },
  { 3398, 15, 33, 20, 2, -23 },
  { 3460, 14, 32, 20, 3, -32 },
  { 3516, 2, 30, 8, 3, -30 },
  { 3524, 6, 40, 8, -1, -30 },
  { 3554, 13, 32, 16, 3, -32 },
  { 3606, 2, 32, 8, 3, -32 },
  { 3614, 23, 23, 29, 3, -23 },
  { 3681, 14, 23, 20, 3, -23 },
  { 3722, 15, 23, 19, 2, -23 },
  { 3766, 15, 33, 20, 3, -23 },
  { 3828, 15, 33, 20, 2, -23 },
  { 3890, 9, 23, 13, 3, -23 },
  { 3916, 12, 23, 15, 2, -23 },
  { 3951, 9, 28, 11, 1, -28 },
  { 3983, 13, 22, 20, 3, -22 },
  { 4019, 15, 22, 15, 0, -22 },
  { 4061, 24, 22, 24, 0, -22 },
  { 4127, 14, 22, 16, 1, -22 },
  { 4166, 15, 32, 15, 0, -22 },
  { 4226, 11, 22, 14, 1, -22 },
  { 4257, 11, 37, 15, 2, -30 },
  { 4308, 2, 42, 18, 8, -32 },
  { 4319, 11, 37, 15, 2, -30 },
  { 4370, 16, 4, 19, 2, -17 },
};

const GFXfont NotoSans_Condensed_ExtraLight42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight42pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT42PT7B_H_
