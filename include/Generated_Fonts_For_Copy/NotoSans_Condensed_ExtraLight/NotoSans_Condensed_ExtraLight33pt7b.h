#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT33PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight33pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x48, 0x00, 0x3A, 0xC7, 0x1C,
  0x71, 0xC6, 0x18, 0x61, 0x84, 0x04, 0x10, 0x08, 0x20, 0x10, 0x40, 0x20,
  0x80, 0x41, 0x00, 0x84, 0x03, 0x08, 0x3F, 0xFF, 0x7F, 0xFE, 0x10, 0x40,
  0x20, 0x80, 0x41, 0x00, 0x86, 0x03, 0x08, 0x04, 0x10, 0x7F, 0xFE, 0x10,
  0x40, 0x20, 0x80, 0x41, 0x00, 0x82, 0x01, 0x08, 0x06, 0x10, 0x08, 0x20,
  0x10, 0x40, 0x02, 0x00, 0x20, 0x1F, 0xC3, 0x26, 0x62, 0x04, 0x20, 0xC2,
  0x0C, 0x20, 0xC2, 0x04, 0x20, 0x62, 0x03, 0x20, 0x0E, 0x00, 0x38, 0x02,
  0xC0, 0x22, 0x02, 0x30, 0x21, 0x02, 0x10, 0x21, 0x02, 0x10, 0x23, 0xC2,
  0x67, 0xF8, 0x02, 0x00, 0x20, 0x02, 0x00, 0x38, 0x04, 0x13, 0x03, 0x08,
  0x40, 0x82, 0x18, 0x20, 0x82, 0x10, 0x20, 0x84, 0x08, 0x23, 0x02, 0x08,
  0x80, 0x82, 0x20, 0x20, 0x90, 0x08, 0x24, 0xF2, 0x1B, 0x62, 0x84, 0x90,
  0x93, 0x24, 0x13, 0x91, 0x04, 0x04, 0x41, 0x03, 0x10, 0x40, 0x84, 0x10,
  0x21, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x20, 0x80, 0x88, 0x20,
  0x3C, 0x0F, 0x00, 0x33, 0x00, 0x43, 0x01, 0x82, 0x02, 0x04, 0x06, 0x08,
  0x0C, 0x10, 0x08, 0x60, 0x10, 0x80, 0x12, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xA0, 0x04, 0x60, 0x98, 0x41, 0x20, 0x42, 0xC0, 0xC5, 0x80, 0xD3, 0x00,
  0xA6, 0x00, 0xC4, 0x03, 0x88, 0x05, 0x08, 0x31, 0x0F, 0xC3, 0xFF, 0xFA,
  0x80, 0x0C, 0x61, 0x0C, 0x21, 0x84, 0x10, 0xC2, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0xC3, 0x04, 0x10, 0x60, 0x83, 0x04, 0x0C, 0xC1,
  0x02, 0x0C, 0x10, 0x40, 0x82, 0x08, 0x30, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x43, 0x0C, 0x20, 0x86, 0x10, 0x42, 0x18, 0xC0, 0x08, 0x02, 0x00,
  0x82, 0x21, 0xFB, 0x83, 0x01, 0xC0, 0x48, 0x23, 0x10, 0x60, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x1F, 0xFF, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x24,
  0xB6, 0x96, 0xFF, 0xFC, 0xF0, 0x00, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00,
  0xC0, 0x20, 0x08, 0x06, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x30, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x0E,
  0x07, 0x31, 0x82, 0x20, 0x24, 0x05, 0x80, 0xE0, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x01, 0xE0, 0x24, 0x04, 0xC1, 0x8C, 0x60, 0xF8, 0x04, 0x31, 0x59, 0xC6,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x0F, 0x03, 0x9C, 0x40, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x00, 0x30, 0x06, 0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x40,
  0x0F, 0xFF, 0x1F, 0x07, 0x1C, 0xC0, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC1, 0xF0, 0x03, 0x80, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x02, 0xC0,
  0xC7, 0xF8, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x50, 0x01, 0x40, 0x09,
  0x00, 0x64, 0x01, 0x10, 0x0C, 0x40, 0x21, 0x01, 0x84, 0x04, 0x10, 0x20,
  0x40, 0x81, 0x04, 0x04, 0x30, 0x10, 0x80, 0x43, 0xFF, 0xF0, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x7F, 0xCF, 0xF9, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xFC, 0x20,
  0xC0, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x30,
  0x06, 0x01, 0xA0, 0x67, 0xF8, 0x03, 0xC3, 0x88, 0xC0, 0x10, 0x06, 0x00,
  0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0xC2, 0x7E, 0x50, 0x6C, 0x07, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x14, 0x06, 0xC0, 0x88,
  0x30, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x0F, 0x81, 0x8C, 0x20, 0x26, 0x03, 0x40, 0x34, 0x01, 0x40,
  0x36, 0x03, 0x20, 0x21, 0x04, 0x0D, 0x80, 0x70, 0x0D, 0x83, 0x04, 0x20,
  0x24, 0x03, 0x40, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x40, 0x16, 0x03, 0x30,
  0x61, 0xFC, 0x0F, 0x03, 0x9C, 0x20, 0x46, 0x02, 0x40, 0x24, 0x03, 0xC0,
  0x1C, 0x01, 0xC0, 0x14, 0x01, 0x40, 0x34, 0x03, 0x60, 0x53, 0x0D, 0x1F,
  0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x01,
  0x83, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x2C, 0x80, 0x00, 0x00, 0x00,
  0x09, 0x2D, 0xA5, 0x80, 0x00, 0x08, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07,
  0x00, 0x60, 0x00, 0x7C, 0x63, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x06, 0x02,
  0x01, 0x01, 0x81, 0x80, 0x80, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x00, 0x7F, 0x80, 0x30,
  0x0C, 0x0C, 0x00, 0xC3, 0x00, 0x08, 0x40, 0x00, 0x90, 0x00, 0x12, 0x07,
  0xC3, 0xC1, 0x88, 0x30, 0x61, 0x06, 0x08, 0x20, 0xC3, 0x04, 0x18, 0x40,
  0x83, 0x08, 0x10, 0x61, 0x02, 0x0C, 0x20, 0x41, 0x84, 0x18, 0x30, 0xC3,
  0x0A, 0x08, 0xF1, 0x40, 0xF3, 0xC4, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0x81, 0x80, 0x0F, 0xC0, 0x00, 0x01,
  0x00, 0x07, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x28, 0x00, 0x98, 0x01, 0x10,
  0x02, 0x20, 0x0C, 0x60, 0x10, 0x40, 0x20, 0x80, 0x41, 0x01, 0x83, 0x02,
  0x02, 0x07, 0xFC, 0x18, 0x0C, 0x20, 0x18, 0x40, 0x10, 0x80, 0x23, 0x00,
  0x64, 0x00, 0x48, 0x00, 0xB0, 0x01, 0x40, 0x03, 0xFC, 0x0F, 0xF8, 0x80,
  0x48, 0x06, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x04, 0x80,
  0xCF, 0xF0, 0x81, 0xC8, 0x06, 0x80, 0x28, 0x03, 0x80, 0x38, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x28, 0x06, 0x80, 0xCF, 0xF0, 0x03, 0xE0, 0x71, 0xC6,
  0x00, 0x60, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x70, 0x20, 0xFF, 0xFC,
  0x07, 0xFC, 0x20, 0x31, 0x00, 0xC8, 0x03, 0x40, 0x0A, 0x00, 0x50, 0x03,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x05, 0x00, 0x68, 0x02, 0x40, 0x32, 0x06,
  0x1F, 0xE0, 0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x03, 0xFE, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF,
  0xA0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x01, 0xF8, 0x1E, 0x3C, 0x60, 0x09, 0x80, 0x02, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x07, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x05,
  0x00, 0x0B, 0x00, 0x12, 0x00, 0x22, 0x00, 0x43, 0x01, 0x83, 0xFE, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0xFC, 0xC1, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x3F, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x43, 0x9B, 0xC0, 0x80, 0x28, 0x06, 0x80, 0xC8,
  0x08, 0x81, 0x88, 0x30, 0x82, 0x08, 0x40, 0x8C, 0x08, 0x80, 0x90, 0x0B,
  0x80, 0xE8, 0x0C, 0xC0, 0x84, 0x08, 0x20, 0x83, 0x08, 0x10, 0x81, 0x88,
  0x08, 0x80, 0xC8, 0x04, 0x80, 0x68, 0x03, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x05, 0xA0, 0x01, 0x68, 0x00, 0xDB,
  0x00, 0x26, 0x40, 0x09, 0x90, 0x06, 0x66, 0x01, 0x18, 0x80, 0x46, 0x20,
  0x31, 0x8C, 0x08, 0x61, 0x02, 0x18, 0x41, 0x86, 0x18, 0x41, 0x82, 0x10,
  0x60, 0x8C, 0x18, 0x32, 0x06, 0x04, 0x81, 0x81, 0x60, 0x60, 0x70, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1A, 0x00,
  0xD8, 0x06, 0x40, 0x33, 0x01, 0x88, 0x0C, 0x60, 0x61, 0x03, 0x0C, 0x18,
  0x20, 0xC1, 0x86, 0x04, 0x30, 0x11, 0x80, 0x8C, 0x02, 0x60, 0x13, 0x00,
  0x58, 0x02, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x07, 0xC0, 0x1C, 0x70, 0x30,
  0x18, 0x20, 0x0C, 0x60, 0x04, 0x40, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0x80,
  0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x02, 0x80, 0x02, 0xC0, 0x02, 0x40, 0x06, 0x40, 0x04, 0x20,
  0x04, 0x30, 0x08, 0x18, 0x18, 0x0F, 0xE0, 0xF0, 0x1F, 0xE2, 0x03, 0x40,
  0x28, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x40, 0x68,
  0x39, 0xFC, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x07, 0xC0, 0x1C, 0x70, 0x30, 0x18, 0x20, 0x0C,
  0x60, 0x04, 0x40, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0x80, 0x02, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02,
  0x80, 0x02, 0xC0, 0x02, 0x40, 0x06, 0x40, 0x06, 0x20, 0x04, 0x30, 0x08,
  0x18, 0x18, 0x0F, 0xE0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0xF8, 0x0F, 0xF0, 0x80, 0xC8, 0x04, 0x80, 0x68,
  0x06, 0x80, 0x68, 0x06, 0x80, 0x68, 0x04, 0x80, 0x48, 0x08, 0xFF, 0x0F,
  0xE0, 0x82, 0x08, 0x20, 0x81, 0x08, 0x10, 0x80, 0x88, 0x08, 0x80, 0x48,
  0x04, 0x80, 0x28, 0x02, 0x0F, 0xC1, 0x87, 0x20, 0x06, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x30,
  0x02, 0xC0, 0xC7, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x3C, 0x01, 0x20, 0x19, 0x81, 0x83, 0xF8, 0x80, 0x07,
  0x00, 0x14, 0x00, 0x50, 0x03, 0x40, 0x09, 0x80, 0x22, 0x01, 0x88, 0x06,
  0x20, 0x10, 0xC0, 0x41, 0x03, 0x04, 0x08, 0x18, 0x20, 0x20, 0x80, 0x86,
  0x02, 0x10, 0x0C, 0x40, 0x13, 0x00, 0x48, 0x01, 0x20, 0x02, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0xC0, 0x18, 0x03, 0x40, 0x18, 0x02, 0x40, 0x18,
  0x02, 0x40, 0x18, 0x02, 0x60, 0x38, 0x06, 0x20, 0x2C, 0x04, 0x20, 0x24,
  0x04, 0x20, 0x24, 0x04, 0x30, 0x24, 0x0C, 0x30, 0x66, 0x0C, 0x10, 0x42,
  0x08, 0x10, 0x42, 0x08, 0x10, 0x42, 0x18, 0x18, 0xC2, 0x18, 0x08, 0x81,
  0x10, 0x08, 0x81, 0x10, 0x08, 0x81, 0x10, 0x0C, 0x81, 0x30, 0x05, 0x81,
  0xA0, 0x05, 0x00, 0xA0, 0x05, 0x00, 0xA0, 0x05, 0x00, 0xE0, 0x07, 0x00,
  0xC0, 0x02, 0x00, 0x40, 0x40, 0x1B, 0x00, 0x88, 0x0C, 0x60, 0x41, 0x02,
  0x0C, 0x20, 0x21, 0x01, 0x18, 0x04, 0x80, 0x2C, 0x01, 0xC0, 0x06, 0x00,
  0x30, 0x02, 0x80, 0x16, 0x01, 0x90, 0x08, 0xC0, 0xC2, 0x04, 0x18, 0x60,
  0x42, 0x02, 0x30, 0x19, 0x00, 0x58, 0x03, 0x80, 0x1E, 0x00, 0x90, 0x04,
  0xC0, 0x62, 0x02, 0x10, 0x30, 0xC1, 0x02, 0x08, 0x18, 0xC0, 0x44, 0x02,
  0x60, 0x1A, 0x00, 0x50, 0x03, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0xFF, 0xEF,
  0xFE, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFC, 0x80, 0x20, 0x0C, 0x01,
  0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x80, 0x20, 0x08,
  0x03, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x30, 0x04, 0x01, 0x00, 0x60,
  0x08, 0x03, 0xFF, 0xF0, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0xFC,
  0x02, 0x00, 0x18, 0x01, 0x40, 0x0B, 0x00, 0x88, 0x04, 0x60, 0x41, 0x02,
  0x0C, 0x20, 0x21, 0x01, 0x90, 0x04, 0x80, 0x38, 0x00, 0x80, 0xFF, 0xF8,
  0xC1, 0x83, 0x06, 0x0C, 0x0F, 0x0E, 0x60, 0x0C, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x0F, 0xCE, 0x16, 0x05, 0x01, 0xC0, 0x70, 0x1C, 0x05, 0x03,
  0x61, 0x4F, 0xD0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x70, 0xD8, 0xCF, 0x06, 0xE0, 0x2C, 0x03, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x02,
  0xE0, 0x2D, 0x04, 0xCF, 0x80, 0x0F, 0x1C, 0xD8, 0x08, 0x0C, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0x00, 0x80, 0x30,
  0x8F, 0xC0, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x71, 0x33, 0xAC, 0x1D, 0x01, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0xD0, 0x1B, 0x05, 0x3F,
  0x20, 0x0E, 0x07, 0x71, 0x82, 0x20, 0x2C, 0x05, 0x00, 0xA0, 0x1C, 0x01,
  0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x30,
  0x43, 0xF8, 0x0F, 0x84, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0xFE,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x00, 0x0E, 0x07, 0x35, 0x81, 0xA0,
  0x3C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x70, 0x1A, 0x03, 0x60, 0xA7, 0xE4, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x18, 0x02, 0xC1, 0x87, 0xE0, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x38, 0xB3, 0xB0, 0x2C, 0x0E, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x40, 0xF4, 0x01, 0x55, 0x55, 0x55, 0x55, 0x18, 0xC2, 0x00,
  0x00, 0x01, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x11, 0x8C, 0x5C, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x81, 0x41, 0xA1, 0x90, 0x88, 0x84, 0xC2, 0x41, 0x70, 0xC8,
  0x66, 0x21, 0x10, 0xC8, 0x24, 0x1A, 0x05, 0x03, 0x80, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0x1E, 0x0E, 0x2D, 0xCC, 0xCC, 0x1E, 0x0B, 0x03, 0x02, 0x80,
  0x80, 0xE0, 0x20, 0x38, 0x08, 0x0E, 0x02, 0x03, 0x80, 0x80, 0xE0, 0x20,
  0x38, 0x08, 0x0E, 0x02, 0x03, 0x80, 0x80, 0xE0, 0x20, 0x38, 0x08, 0x0E,
  0x02, 0x03, 0x80, 0x80, 0xE0, 0x20, 0x30, 0x0E, 0x2E, 0xEC, 0x0B, 0x03,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0F, 0x03, 0x18, 0x60, 0x44, 0x06,
  0xC0, 0x28, 0x02, 0x80, 0x28, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x28, 0x02, 0xC0, 0x24, 0x04, 0x20, 0xC1, 0xF8, 0x0E, 0x16, 0x33,
  0x83, 0x60, 0x28, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xF0, 0x16, 0x02, 0xA0, 0x93, 0xE2, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x0E, 0x06, 0x75,
  0x83, 0xA0, 0x3C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x70, 0x1A, 0x03, 0x60, 0xA7, 0xE4, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x0F, 0x7B, 0x86,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x00, 0x0F, 0x0C, 0x74, 0x01, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x30, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x81, 0x9F, 0xC0,
  0x20, 0x40, 0x81, 0x02, 0x1F, 0xC8, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x07, 0xC0, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x3C, 0x06, 0x80, 0xD0, 0x2B, 0x0D, 0x3F, 0x20, 0xC0, 0x28, 0x05, 0x01,
  0xA0, 0x22, 0x04, 0x41, 0x88, 0x21, 0x84, 0x10, 0x82, 0x30, 0x44, 0x0C,
  0x80, 0x90, 0x14, 0x02, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x60, 0x68, 0x0C,
  0x09, 0x02, 0x81, 0x30, 0x50, 0x22, 0x0B, 0x0C, 0x41, 0x21, 0x08, 0x64,
  0x21, 0x88, 0x84, 0x11, 0x18, 0x82, 0x21, 0x30, 0x4C, 0x24, 0x09, 0x04,
  0x81, 0xA0, 0xD0, 0x14, 0x0E, 0x03, 0x81, 0x80, 0x60, 0x30, 0x0C, 0x06,
  0x00, 0xC0, 0x68, 0x11, 0x82, 0x10, 0x81, 0x10, 0x24, 0x03, 0x80, 0x60,
  0x0C, 0x01, 0xC0, 0x48, 0x09, 0x82, 0x10, 0xC1, 0x10, 0x26, 0x02, 0x80,
  0x60, 0xC0, 0x34, 0x02, 0x60, 0x22, 0x06, 0x20, 0x42, 0x04, 0x30, 0xC1,
  0x08, 0x10, 0x81, 0x88, 0x09, 0x80, 0x90, 0x09, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x09,
  0x00, 0xE0, 0x00, 0x7F, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x10, 0x10,
  0x08, 0x08, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0xFF, 0x80, 0x00,
  0x83, 0xC3, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0xC3, 0x80, 0xE0, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x78, 0x02, 0x01, 0x00, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x40, 0x20, 0x0E, 0x0E, 0x04,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03,
  0x0F, 0x00, 0x7C, 0x0E, 0x18, 0xE0, 0x38,
};

const GFXglyph NotoSans_Condensed_ExtraLight33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 24, 7, 2, -24 },
  { 10, 6, 9, 11, 2, -24 },
  { 17, 15, 24, 16, 1, -24 },
  { 62, 12, 27, 15, 1, -25 },
  { 103, 18, 24, 22, 2, -24 },
  { 157, 15, 24, 16, 1, -24 },
  { 202, 2, 9, 6, 2, -24 },
  { 205, 6, 29, 9, 2, -24 },
  { 227, 6, 29, 9, 1, -24 },
  { 249, 10, 10, 14, 2, -25 },
  { 262, 13, 15, 15, 1, -19 },
  { 287, 3, 8, 6, 1, -4 },
  { 290, 7, 2, 9, 1, -10 },
  { 292, 2, 2, 7, 2, -2 },
  { 293, 10, 24, 11, 1, -24 },
  { 323, 11, 24, 15, 2, -24 },
  { 356, 6, 24, 15, 3, -24 },
  { 374, 12, 24, 15, 1, -24 },
  { 410, 12, 24, 15, 1, -24 },
  { 446, 14, 24, 15, 1, -24 },
  { 488, 11, 24, 15, 2, -24 },
  { 521, 11, 24, 15, 2, -24 },
  { 554, 12, 24, 15, 1, -24 },
  { 590, 12, 24, 15, 1, -24 },
  { 626, 12, 24, 15, 1, -24 },
  { 662, 2, 18, 7, 2, -18 },
  { 667, 3, 22, 7, 1, -18 },
  { 676, 13, 14, 15, 1, -19 },
  { 699, 13, 8, 15, 1, -16 },
  { 712, 13, 14, 15, 1, -19 },
  { 735, 9, 24, 10, 1, -24 },
  { 762, 19, 27, 23, 2, -24 },
  { 827, 15, 24, 15, 0, -24 },
  { 872, 12, 24, 16, 3, -24 },
  { 908, 13, 24, 16, 2, -24 },
  { 947, 13, 24, 18, 3, -24 },
  { 986, 10, 24, 14, 3, -24 },
  { 1016, 10, 24, 13, 3, -24 },
  { 1046, 15, 24, 19, 2, -24 },
  { 1091, 13, 24, 19, 3, -24 },
  { 1130, 6, 24, 8, 1, -24 },
  { 1148, 6, 30, 7, -2, -24 },
  { 1171, 12, 24, 15, 3, -24 },
  { 1207, 9, 24, 13, 3, -24 },
  { 1234, 18, 24, 24, 3, -24 },
  { 1288, 13, 24, 19, 3, -24 },
  { 1327, 16, 24, 20, 2, -24 },
  { 1375, 11, 24, 15, 3, -24 },
  { 1408, 16, 30, 20, 2, -24 },
  { 1468, 12, 24, 15, 3, -24 },
  { 1504, 12, 24, 14, 1, -24 },
  { 1540, 13, 24, 13, 0, -24 },
  { 1579, 13, 24, 18, 3, -24 },
  { 1618, 14, 24, 14, 0, -24 },
  { 1660, 24, 24, 24, 0, -24 },
  { 1732, 13, 24, 13, 0, -24 },
  { 1771, 13, 24, 13, 0, -24 },
  { 1810, 12, 24, 13, 1, -24 },
  { 1846, 6, 29, 10, 3, -24 },
  { 1868, 10, 24, 11, 1, -24 },
  { 1898, 6, 29, 10, 1, -24 },
  { 1920, 13, 13, 15, 1, -24 },
  { 1942, 13, 1, 13, 0, 3 },
  { 1944, 6, 5, 8, 1, -25 },
  { 1948, 10, 18, 14, 1, -18 },
  { 1971, 12, 25, 16, 2, -25 },
  { 2009, 9, 18, 12, 2, -18 },
  { 2030, 11, 25, 16, 2, -25 },
  { 2065, 11, 18, 14, 2, -18 },
  { 2090, 9, 25, 8, 0, -25 },
  { 2119, 11, 26, 16, 2, -18 },
  { 2155, 10, 25, 15, 3, -25 },
  { 2187, 2, 24, 6, 2, -24 },
  { 2193, 5, 32, 6, -1, -24 },
  { 2213, 9, 25, 13, 3, -25 },
  { 2242, 1, 25, 6, 3, -25 },
  { 2246, 18, 18, 23, 3, -18 },
  { 2287, 10, 18, 15, 3, -18 },
  { 2310, 12, 18, 15, 2, -18 },
  { 2337, 11, 26, 16, 3, -18 },
  { 2373, 11, 26, 16, 2, -18 },
  { 2409, 7, 18, 10, 3, -18 },
  { 2425, 10, 18, 12, 1, -18 },
  { 2448, 7, 22, 8, 1, -22 },
  { 2468, 11, 17, 15, 2, -17 },
  { 2492, 11, 17, 12, 0, -17 },
  { 2516, 19, 17, 19, 0, -17 },
  { 2557, 11, 17, 12, 1, -17 },
  { 2581, 12, 25, 12, 0, -17 },
  { 2619, 9, 17, 11, 1, -17 },
  { 2639, 9, 29, 11, 1, -24 },
  { 2672, 2, 33, 14, 6, -25 },
  { 2681, 9, 29, 11, 1, -24 },
  { 2714, 13, 3, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_ExtraLight33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight33pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT33PT7B_H_
