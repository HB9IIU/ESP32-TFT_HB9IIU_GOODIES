#ifndef _NOTOSANS_CONDENSED_EXTRALIGHT46PT7B_H_
#define _NOTOSANS_CONDENSED_EXTRALIGHT46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-ExtraLight.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_ExtraLight46pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x00,
  0x1F, 0x60, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x05, 0x82, 0xC1,
  0x60, 0xB0, 0x58, 0x20, 0x00, 0x80, 0x80, 0x04, 0x04, 0x00, 0x60, 0x20,
  0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x04, 0x06, 0x00, 0x20,
  0x20, 0x01, 0x01, 0x00, 0x08, 0x08, 0x1F, 0xFF, 0xFE, 0x06, 0x06, 0x00,
  0x30, 0x30, 0x01, 0x01, 0x80, 0x08, 0x08, 0x00, 0x40, 0x40, 0x02, 0x02,
  0x00, 0x30, 0x10, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x0C, 0x04, 0x00, 0x60, 0x60,
  0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0x80, 0xC0, 0x04, 0x04, 0x00, 0x20,
  0x20, 0x03, 0x01, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x0F, 0xF8, 0x1F, 0xFE, 0x31, 0x82, 0x61, 0x80, 0xC1, 0x80, 0xC1,
  0x80, 0xC1, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0x61,
  0x80, 0x31, 0x80, 0x1D, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x01,
  0x9C, 0x01, 0x8E, 0x01, 0x87, 0x01, 0x83, 0x01, 0x81, 0x01, 0x81, 0x01,
  0x81, 0x01, 0x81, 0x01, 0x83, 0x01, 0x83, 0x01, 0x86, 0xE1, 0x8C, 0xFF,
  0xF8, 0x0F, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x1F,
  0x00, 0x10, 0x0C, 0x60, 0x0C, 0x06, 0x08, 0x02, 0x01, 0x83, 0x01, 0x80,
  0x40, 0xC0, 0x60, 0x10, 0x10, 0x10, 0x0C, 0x04, 0x0C, 0x03, 0x01, 0x02,
  0x00, 0xC0, 0x61, 0x80, 0x30, 0x18, 0x60, 0x0C, 0x06, 0x10, 0x03, 0x01,
  0x8C, 0x00, 0xC0, 0x42, 0x00, 0x30, 0x11, 0x8F, 0x84, 0x04, 0x67, 0x31,
  0x03, 0x11, 0x86, 0x60, 0xCC, 0xC1, 0x98, 0x22, 0x30, 0x23, 0x39, 0x88,
  0x0C, 0x7C, 0x62, 0x03, 0x00, 0x10, 0x80, 0xC0, 0x0C, 0x20, 0x30, 0x02,
  0x08, 0x0C, 0x01, 0x82, 0x03, 0x00, 0x60, 0x80, 0xC0, 0x10, 0x20, 0x30,
  0x0C, 0x08, 0x0C, 0x02, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x80, 0x60, 0x30,
  0x60, 0x10, 0x04, 0x18, 0x0C, 0x01, 0x8C, 0x03, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0xE7, 0x00, 0x18, 0x18, 0x01, 0x81, 0x80, 0x10, 0x08, 0x01,
  0x00, 0x80, 0x10, 0x08, 0x01, 0x00, 0x80, 0x10, 0x18, 0x01, 0x81, 0x80,
  0x18, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0x6E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0D, 0x80, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x26, 0x06,
  0x02, 0x60, 0x30, 0x6C, 0x03, 0x06, 0xC0, 0x18, 0x6C, 0x00, 0xC4, 0xC0,
  0x0C, 0xCC, 0x00, 0x6C, 0xC0, 0x03, 0x8C, 0x00, 0x38, 0xC0, 0x03, 0x86,
  0x00, 0x6C, 0x70, 0x0C, 0x63, 0xC3, 0x86, 0x1F, 0xE0, 0x30, 0xFF, 0xFF,
  0xFF, 0x01, 0x81, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x20, 0x30, 0x18,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xC0,
  0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x07, 0xC0, 0x60,
  0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30,
  0x60, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x1C,
  0x21, 0x9F, 0x5F, 0x83, 0xE0, 0x03, 0x80, 0x0D, 0x80, 0x11, 0x00, 0x63,
  0x01, 0x83, 0x06, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x33, 0x33, 0x66, 0x64, 0xCC, 0x80, 0xFF, 0xE0, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x07, 0xF0,
  0x0F, 0x78, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x60, 0x02,
  0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x40, 0x03, 0x40, 0x03, 0x60, 0x03, 0x60, 0x03,
  0x60, 0x03, 0x60, 0x02, 0x30, 0x06, 0x30, 0x06, 0x18, 0x0C, 0x18, 0x0C,
  0x0F, 0x78, 0x07, 0xF0, 0x01, 0x81, 0xC3, 0xE3, 0xB3, 0x1B, 0x0F, 0x07,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x0F, 0xE0, 0x3C, 0x78, 0x60, 0x1C,
  0x40, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xE0, 0x7C, 0x78, 0xE0, 0x0C, 0x80, 0x06, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x80, 0x0C, 0xF0, 0x78, 0x7F, 0xF0, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0B, 0x00, 0x03, 0x60, 0x00, 0x4C, 0x00, 0x19, 0x80, 0x02,
  0x30, 0x00, 0xC6, 0x00, 0x10, 0xC0, 0x06, 0x18, 0x01, 0x83, 0x00, 0x30,
  0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00,
  0xC0, 0xC0, 0x18, 0x18, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x01,
  0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0xF0, 0x3F, 0xFC, 0x20, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xA0, 0x0E, 0x70,
  0x78, 0x7F, 0xC0, 0x00, 0xFE, 0x01, 0xE3, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x1F, 0x81, 0x3C, 0xF0, 0xB0,
  0x1C, 0xD0, 0x06, 0x70, 0x01, 0xB8, 0x00, 0xDC, 0x00, 0x2C, 0x00, 0x16,
  0x00, 0x0D, 0x00, 0x06, 0x80, 0x03, 0x60, 0x01, 0xB0, 0x00, 0x98, 0x00,
  0xCC, 0x00, 0x63, 0x00, 0x31, 0x80, 0x30, 0x60, 0x38, 0x1C, 0x38, 0x07,
  0xF8, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x07, 0xF0,
  0x0F, 0x1E, 0x0E, 0x03, 0x86, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x19, 0x80,
  0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x88, 0x01, 0x86, 0x00, 0xC1,
  0x80, 0xC0, 0x61, 0xC0, 0x1D, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x06, 0x1C,
  0x06, 0x03, 0x06, 0x00, 0xC6, 0x00, 0x73, 0x00, 0x1B, 0x00, 0x05, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x24, 0x00, 0x33,
  0x00, 0x18, 0xC0, 0x18, 0x38, 0x38, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x1C,
  0x78, 0x30, 0x1C, 0x70, 0x0C, 0x60, 0x06, 0x40, 0x06, 0xC0, 0x02, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x60, 0x07, 0x60, 0x07, 0x30, 0x0B, 0x1C, 0x3B, 0x0F,
  0xE3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x20,
  0xE0, 0x3F, 0xC0, 0x5F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x27, 0x73, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33,
  0x33, 0x66, 0x64, 0xCC, 0x80, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x3F, 0x8F, 0x1C, 0x80, 0x60,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x06,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x10, 0x06, 0x20, 0x0F, 0xE0, 0x66,
  0x03, 0x82, 0x06, 0x60, 0x30, 0x20, 0x26, 0x06, 0x02, 0x02, 0x40, 0x40,
  0x20, 0x24, 0x0C, 0x06, 0x03, 0x40, 0xC0, 0x60, 0x3C, 0x0C, 0x06, 0x03,
  0xC0, 0xC0, 0x60, 0x3C, 0x0C, 0x06, 0x02, 0xC0, 0xC0, 0x60, 0x2C, 0x0C,
  0x06, 0x02, 0x40, 0xC0, 0x60, 0x64, 0x0C, 0x0E, 0x06, 0x40, 0x40, 0xA0,
  0x46, 0x06, 0x1B, 0x0C, 0x60, 0x3F, 0x1F, 0x86, 0x01, 0xE0, 0xF0, 0x20,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x10, 0x00,
  0x1E, 0x1F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x14, 0x00, 0x01, 0xA0, 0x00, 0x0D, 0x80, 0x00, 0x4C, 0x00, 0x02,
  0x20, 0x00, 0x31, 0x80, 0x01, 0x8C, 0x00, 0x08, 0x60, 0x00, 0xC1, 0x00,
  0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x01, 0x00, 0x18, 0x0C, 0x00, 0xC0,
  0x60, 0x04, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x30, 0x00,
  0x41, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x40, 0x00, 0xC6, 0x00, 0x02, 0x30,
  0x00, 0x19, 0x80, 0x00, 0xD8, 0x00, 0x02, 0xC0, 0x00, 0x18, 0xFF, 0xC0,
  0x7F, 0xFC, 0x30, 0x07, 0x18, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x1B, 0x00,
  0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xCC,
  0x00, 0x66, 0x00, 0x63, 0x00, 0xE1, 0xFF, 0xC0, 0xFF, 0xF8, 0x60, 0x06,
  0x30, 0x01, 0x98, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x58, 0x00, 0x6C, 0x00, 0x36,
  0x00, 0x33, 0x00, 0x31, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0xF1, 0xF0, 0xE0, 0x08, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x0F, 0x01, 0xFF, 0x80,
  0xFF, 0x80, 0x1F, 0xFE, 0x03, 0x00, 0xF0, 0x60, 0x07, 0x0C, 0x00, 0x71,
  0x80, 0x06, 0x30, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x1B,
  0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x05, 0x80, 0x00, 0xB0, 0x00, 0x16,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0x60, 0x00, 0x2C,
  0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x00, 0xD8,
  0x00, 0x33, 0x00, 0x06, 0x60, 0x01, 0x8C, 0x00, 0x71, 0x80, 0x1C, 0x30,
  0x07, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFE, 0xFF,
  0xFB, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFB, 0xFF,
  0xEC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0x8F, 0xC1, 0xC0, 0x0C, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8,
  0x00, 0x06, 0x60, 0x00, 0x31, 0x80, 0x01, 0x8E, 0x00, 0x0C, 0x38, 0x00,
  0x60, 0x78, 0x1F, 0x01, 0xFF, 0xE0, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0xFF, 0x3C, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x18, 0x0D, 0xFC, 0xFC, 0x00, 0xC0, 0x03, 0x60, 0x03, 0x30, 0x03, 0x98,
  0x01, 0x8C, 0x01, 0x86, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xC0, 0xC0, 0xC0,
  0x60, 0xE0, 0x30, 0x60, 0x18, 0x60, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x30,
  0x01, 0xBC, 0x00, 0xD6, 0x00, 0x79, 0x80, 0x38, 0xC0, 0x18, 0x30, 0x0C,
  0x0C, 0x06, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x30, 0x60, 0x18,
  0x30, 0x06, 0x18, 0x03, 0x0C, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x19, 0x80,
  0x06, 0xC0, 0x03, 0x80, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF6, 0x00, 0x00, 0x5F, 0x00,
  0x00, 0x6F, 0x80, 0x00, 0x37, 0x60, 0x00, 0x13, 0xB0, 0x00, 0x19, 0xD8,
  0x00, 0x0C, 0xE6, 0x00, 0x04, 0x73, 0x00, 0x06, 0x39, 0x80, 0x03, 0x1C,
  0x60, 0x01, 0x0E, 0x30, 0x01, 0x87, 0x18, 0x00, 0xC3, 0x86, 0x00, 0x41,
  0xC3, 0x00, 0x60, 0xE1, 0x80, 0x30, 0x70, 0x60, 0x10, 0x38, 0x30, 0x18,
  0x1C, 0x18, 0x0C, 0x0E, 0x06, 0x04, 0x07, 0x03, 0x06, 0x03, 0x81, 0x83,
  0x01, 0xC0, 0x61, 0x00, 0xE0, 0x31, 0x80, 0x70, 0x18, 0xC0, 0x38, 0x06,
  0x40, 0x1C, 0x03, 0x60, 0x0E, 0x01, 0xB0, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0x80, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xD8, 0x00, 0x3F, 0x00, 0x07, 0xB0, 0x00, 0xF6, 0x00, 0x1E, 0x60,
  0x03, 0xCC, 0x00, 0x78, 0xC0, 0x0F, 0x18, 0x01, 0xE1, 0x80, 0x3C, 0x30,
  0x07, 0x83, 0x00, 0xF0, 0x60, 0x1E, 0x06, 0x03, 0xC0, 0xC0, 0x78, 0x0C,
  0x0F, 0x01, 0x81, 0xE0, 0x18, 0x3C, 0x03, 0x07, 0x80, 0x30, 0xF0, 0x06,
  0x1E, 0x00, 0x63, 0xC0, 0x0C, 0x78, 0x00, 0xCF, 0x00, 0x19, 0xE0, 0x01,
  0xBC, 0x00, 0x37, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0x3E, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0x30,
  0x30, 0x00, 0x60, 0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x04, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00,
  0x0A, 0x00, 0x00, 0x28, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00,
  0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0x40, 0x00, 0x19, 0x80, 0x00,
  0x46, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x60, 0x03, 0x80,
  0xC0, 0x1C, 0x01, 0xE1, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0xE3,
  0x00, 0xE6, 0x00, 0xEC, 0x00, 0xD8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0x60, 0x06, 0xC0, 0x39, 0x83, 0xE3, 0xFF, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0x3E, 0x00, 0xC0, 0x1C, 0x06, 0x00, 0x30, 0x30, 0x00, 0x60,
  0xC0, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x04, 0xC0, 0x00, 0x1B, 0x00,
  0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x0A, 0x00, 0x00,
  0x28, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x6C, 0x00,
  0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x46, 0x00, 0x03,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x60, 0x60, 0x03, 0x80, 0xC0, 0x1C, 0x01,
  0xE1, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0xFF, 0x80, 0x7F, 0xF8, 0x30, 0x0E, 0x18, 0x01, 0x8C,
  0x00, 0xC6, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03,
  0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x63, 0x00, 0x31, 0x80,
  0x30, 0xC0, 0xF0, 0x7F, 0xE0, 0x30, 0x60, 0x18, 0x18, 0x0C, 0x0C, 0x06,
  0x03, 0x03, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x0C, 0x30, 0x06,
  0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x19, 0x80, 0x06, 0xC0,
  0x03, 0x80, 0x07, 0xFC, 0x1F, 0x3F, 0x38, 0x02, 0x70, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x80, 0x0C, 0xF0, 0x78, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x60, 0x01, 0x98, 0x00, 0x63, 0x00, 0x70, 0x78, 0x78, 0x0F,
  0xF8, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x40, 0x00, 0x36, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0x43, 0x00, 0x0C, 0x30, 0x00,
  0xC1, 0x00, 0x0C, 0x18, 0x00, 0x81, 0x80, 0x18, 0x18, 0x01, 0x80, 0x80,
  0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x60, 0x20, 0x06,
  0x06, 0x00, 0x60, 0x60, 0x02, 0x06, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00,
  0x30, 0xC0, 0x01, 0x08, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x09, 0x80,
  0x00, 0x90, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x01, 0x80, 0x03, 0xC0, 0x03, 0x80,
  0x02, 0xC0, 0x03, 0x80, 0x06, 0x40, 0x02, 0xC0, 0x06, 0x60, 0x02, 0xC0,
  0x06, 0x60, 0x06, 0xC0, 0x04, 0x60, 0x06, 0xC0, 0x0C, 0x60, 0x06, 0x40,
  0x0C, 0x20, 0x04, 0x60, 0x0C, 0x30, 0x04, 0x60, 0x0C, 0x30, 0x0C, 0x60,
  0x18, 0x30, 0x0C, 0x20, 0x18, 0x10, 0x0C, 0x30, 0x18, 0x18, 0x08, 0x30,
  0x18, 0x18, 0x18, 0x30, 0x10, 0x18, 0x18, 0x30, 0x30, 0x08, 0x18, 0x10,
  0x30, 0x0C, 0x10, 0x18, 0x30, 0x0C, 0x10, 0x18, 0x20, 0x0C, 0x30, 0x18,
  0x60, 0x0C, 0x30, 0x08, 0x60, 0x04, 0x30, 0x0C, 0x60, 0x06, 0x20, 0x0C,
  0x40, 0x06, 0x60, 0x0C, 0xC0, 0x06, 0x60, 0x04, 0xC0, 0x02, 0x60, 0x04,
  0xC0, 0x03, 0x40, 0x06, 0xC0, 0x03, 0x40, 0x06, 0x80, 0x03, 0xC0, 0x07,
  0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x60, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x18, 0x60, 0x0C, 0x18, 0x03,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x10, 0x06, 0x0C, 0x00, 0x82, 0x00,
  0x31, 0x80, 0x0C, 0x60, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03, 0x18,
  0x00, 0xC6, 0x00, 0x60, 0x80, 0x18, 0x30, 0x0C, 0x0C, 0x03, 0x01, 0x81,
  0x80, 0x60, 0x60, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0x66, 0x00, 0x19, 0x80,
  0x06, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xD0, 0x00, 0x66, 0x00, 0x19, 0x80,
  0x04, 0x30, 0x03, 0x0C, 0x00, 0xC1, 0x00, 0x60, 0x60, 0x18, 0x18, 0x04,
  0x03, 0x03, 0x00, 0xC0, 0xC0, 0x10, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00,
  0x33, 0x00, 0x0C, 0xC0, 0x01, 0x20, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0xC0, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x0C, 0xFF, 0xFF, 0xC0, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x03, 0xFF, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0xD8, 0x00, 0x19, 0x00, 0x06, 0x30, 0x00, 0xC2, 0x00, 0x30, 0x60,
  0x06, 0x04, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x0C, 0x01, 0x81, 0x80, 0x10,
  0x60, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0xD8, 0x00, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0xC0, 0xC1, 0xC1, 0x81, 0x81, 0x80,
  0x03, 0x80, 0xFF, 0xC3, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x7F, 0x0F, 0xCC, 0xE0,
  0x36, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0x00, 0x76, 0x02, 0xDC, 0x19, 0x3F, 0xC4, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x78, 0x18, 0xFF, 0x0C, 0xC0, 0xC6,
  0xC0, 0x33, 0x40, 0x09, 0xC0, 0x06, 0xE0, 0x03, 0x70, 0x00, 0xB0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x2E, 0x00, 0x37, 0x00, 0x1B,
  0x80, 0x0D, 0xA0, 0x0C, 0xD8, 0x0E, 0x67, 0x0E, 0x31, 0xFC, 0x00, 0x01,
  0xF0, 0x1F, 0xF0, 0xE0, 0x46, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x83, 0x07, 0xFC, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0xF0, 0x61, 0xFE, 0x31, 0xC1, 0x99, 0xC0,
  0x2C, 0xC0, 0x1E, 0xC0, 0x07, 0x60, 0x03, 0xB0, 0x01, 0xD0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x68, 0x00, 0x36, 0x00, 0x3B, 0x00, 0x1D, 0x80,
  0x0E, 0x60, 0x0B, 0x38, 0x0D, 0x8E, 0x0C, 0xC3, 0xFC, 0x60, 0x01, 0xC0,
  0x0F, 0xF0, 0x1C, 0x18, 0x38, 0x0C, 0x30, 0x06, 0x60, 0x06, 0x60, 0x02,
  0x60, 0x02, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x02, 0x0E, 0x0E, 0x07, 0xFC,
  0x01, 0xF8, 0x3C, 0x81, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x01, 0xFF, 0x80, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x03, 0xE0, 0x07,
  0xFC, 0xC7, 0x03, 0x67, 0x00, 0xB3, 0x00, 0x7B, 0x00, 0x1D, 0x80, 0x0E,
  0xC0, 0x07, 0x40, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xA0, 0x01, 0xD8,
  0x00, 0xEC, 0x00, 0x76, 0x00, 0x39, 0x80, 0x2C, 0xE0, 0x36, 0x38, 0x33,
  0x0F, 0xF1, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x30, 0x06, 0x1F, 0xBE, 0x01,
  0xFE, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x07, 0x86, 0x3F,
  0xCC, 0xC1, 0xDB, 0x01, 0xBC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x18, 0xFF, 0x80, 0x00, 0x09,
  0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x40, 0x0E, 0x1C, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x06, 0x0C, 0x1B, 0xE7, 0x80,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x06, 0xC0, 0x33, 0x00,
  0xCC, 0x06, 0x30, 0x30, 0xC0, 0x83, 0x06, 0x0C, 0x30, 0x31, 0x80, 0xC6,
  0x03, 0x38, 0x0D, 0xB0, 0x34, 0x40, 0xF1, 0x83, 0x82, 0x0C, 0x0C, 0x30,
  0x10, 0xC0, 0x63, 0x00, 0x8C, 0x03, 0x30, 0x04, 0xC0, 0x1B, 0x00, 0x3C,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xC0, 0x38, 0x33, 0xFC, 0x3F, 0xCD, 0x83, 0x98, 0x33, 0x40, 0x6C, 0x06,
  0xE0, 0x0A, 0x01, 0xB8, 0x03, 0x80, 0x3E, 0x00, 0xC0, 0x0F, 0x00, 0x30,
  0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00,
  0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F,
  0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00, 0xC0,
  0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00,
  0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0xC0, 0x01, 0xE1, 0x8F,
  0xF3, 0x30, 0x76, 0xC0, 0x6F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x06, 0x01, 0xE0, 0x07, 0xFC,
  0x07, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0,
  0x02, 0x40, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xA0, 0x00, 0xD8, 0x00,
  0x4C, 0x00, 0x62, 0x00, 0x31, 0x80, 0x30, 0x60, 0x18, 0x38, 0x38, 0x07,
  0xF8, 0x00, 0x01, 0xE0, 0x63, 0xFC, 0x33, 0x03, 0x1B, 0x00, 0xCD, 0x00,
  0x67, 0x00, 0x1B, 0x80, 0x0D, 0xC0, 0x02, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xB8, 0x00, 0xDC, 0x00, 0x6F, 0x00, 0x36, 0x80,
  0x33, 0x60, 0x31, 0x9C, 0x38, 0xC7, 0xF0, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xF8, 0xC7,
  0x06, 0x67, 0x00, 0xB3, 0x00, 0x7B, 0x00, 0x1D, 0x80, 0x0E, 0xC0, 0x07,
  0x40, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xA0, 0x01, 0xD8, 0x00, 0xEC,
  0x00, 0x76, 0x00, 0x39, 0x80, 0x2C, 0xE0, 0x36, 0x38, 0x73, 0x0F, 0xF1,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x03, 0xF1, 0xFC, 0xC3, 0x60, 0xD0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x0F, 0xC1, 0xFF, 0xDC,
  0x04, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0A, 0x00, 0xDC, 0x1C, 0x7F,
  0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x0F, 0xFC, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x60,
  0x1C, 0x43, 0xF0, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1A, 0x00, 0x76, 0x00, 0xAE, 0x02, 0x4E, 0x1C, 0x8F, 0xE1,
  0xC0, 0x03, 0x40, 0x02, 0x60, 0x06, 0x60, 0x06, 0x20, 0x06, 0x30, 0x0C,
  0x30, 0x0C, 0x30, 0x0C, 0x10, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x0C, 0x10, 0x0C, 0x30, 0x0C, 0x30, 0x04, 0x20, 0x06, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x02, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0xC0, 0x0E, 0x00, 0xD8, 0x03, 0x80, 0x36, 0x00, 0xE0, 0x0D, 0x80, 0x28,
  0x02, 0x20, 0x1B, 0x01, 0x8C, 0x06, 0xC0, 0x63, 0x01, 0x90, 0x18, 0xC0,
  0x44, 0x04, 0x10, 0x31, 0x81, 0x06, 0x0C, 0x60, 0xC1, 0x83, 0x08, 0x30,
  0x60, 0x82, 0x0C, 0x08, 0x60, 0xC2, 0x03, 0x18, 0x31, 0x80, 0xC6, 0x0C,
  0x60, 0x31, 0x01, 0x18, 0x04, 0xC0, 0x64, 0x01, 0xB0, 0x1B, 0x00, 0x6C,
  0x06, 0xC0, 0x1A, 0x00, 0xB0, 0x02, 0x80, 0x28, 0x00, 0xE0, 0x0E, 0x00,
  0x38, 0x03, 0x80, 0x0C, 0x00, 0x60, 0xE0, 0x06, 0xC0, 0x18, 0xC0, 0x31,
  0x80, 0xC1, 0x81, 0x03, 0x06, 0x03, 0x08, 0x06, 0x30, 0x06, 0xC0, 0x05,
  0x80, 0x0E, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xD8, 0x01, 0xB0, 0x06, 0x30,
  0x0C, 0x60, 0x30, 0x60, 0x60, 0x41, 0x80, 0xC3, 0x00, 0x8C, 0x01, 0x98,
  0x01, 0xE0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x20, 0x02, 0x30,
  0x06, 0x30, 0x06, 0x10, 0x04, 0x18, 0x0C, 0x18, 0x0C, 0x18, 0x0C, 0x08,
  0x18, 0x0C, 0x18, 0x0C, 0x18, 0x04, 0x10, 0x06, 0x30, 0x06, 0x30, 0x02,
  0x30, 0x02, 0x60, 0x03, 0x60, 0x03, 0x60, 0x01, 0x40, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x7F, 0xF8, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x1F, 0x03, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x0F, 0x80, 0xF0, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0F, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x1F, 0x00, 0xF0,
  0x18, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x3C, 0x0F, 0x00, 0x7F, 0x00, 0xF1, 0xE0, 0xE0, 0x3F, 0xF0, 0x03,
  0xC0,
};

const GFXglyph NotoSans_Condensed_ExtraLight46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 33, 10, 3, -33 },
  { 14, 9, 12, 15, 3, -33 },
  { 28, 21, 33, 23, 1, -33 },
  { 115, 16, 38, 21, 2, -35 },
  { 191, 26, 33, 30, 2, -33 },
  { 299, 20, 33, 23, 2, -33 },
  { 382, 2, 12, 8, 3, -33 },
  { 385, 9, 40, 12, 2, -33 },
  { 430, 8, 40, 12, 2, -33 },
  { 470, 15, 14, 19, 2, -35 },
  { 497, 17, 21, 21, 2, -27 },
  { 542, 4, 11, 9, 2, -5 },
  { 548, 11, 1, 13, 1, -13 },
  { 550, 3, 3, 9, 3, -3 },
  { 552, 14, 33, 15, 1, -33 },
  { 610, 16, 33, 21, 2, -33 },
  { 676, 9, 33, 21, 4, -33 },
  { 714, 16, 33, 21, 2, -33 },
  { 780, 16, 33, 21, 2, -33 },
  { 846, 19, 33, 21, 1, -33 },
  { 925, 15, 33, 21, 3, -33 },
  { 987, 17, 34, 21, 2, -33 },
  { 1060, 16, 33, 21, 2, -33 },
  { 1126, 17, 33, 21, 2, -33 },
  { 1197, 16, 33, 21, 2, -33 },
  { 1263, 3, 25, 9, 3, -25 },
  { 1273, 4, 31, 9, 2, -25 },
  { 1289, 17, 20, 21, 2, -26 },
  { 1332, 17, 11, 21, 2, -22 },
  { 1356, 17, 20, 21, 2, -26 },
  { 1399, 12, 33, 15, 1, -33 },
  { 1449, 28, 37, 32, 2, -33 },
  { 1579, 21, 33, 21, 0, -33 },
  { 1666, 17, 33, 23, 4, -33 },
  { 1737, 18, 33, 22, 3, -33 },
  { 1812, 19, 33, 25, 4, -33 },
  { 1891, 14, 33, 20, 4, -33 },
  { 1949, 14, 33, 18, 4, -33 },
  { 2007, 21, 33, 27, 3, -33 },
  { 2094, 18, 33, 26, 4, -33 },
  { 2169, 8, 33, 12, 2, -33 },
  { 2202, 9, 41, 10, -3, -33 },
  { 2249, 17, 33, 21, 4, -33 },
  { 2320, 13, 33, 18, 4, -33 },
  { 2374, 25, 33, 33, 4, -33 },
  { 2478, 19, 33, 26, 4, -33 },
  { 2557, 22, 33, 27, 3, -33 },
  { 2648, 15, 33, 21, 4, -33 },
  { 2710, 22, 41, 27, 3, -33 },
  { 2823, 17, 33, 21, 4, -33 },
  { 2894, 16, 33, 20, 2, -33 },
  { 2960, 18, 33, 18, 0, -33 },
  { 3035, 18, 33, 26, 4, -33 },
  { 3110, 20, 33, 20, 0, -33 },
  { 3193, 32, 33, 33, 1, -33 },
  { 3325, 18, 33, 18, 0, -33 },
  { 3400, 18, 33, 18, 0, -33 },
  { 3475, 16, 33, 19, 1, -33 },
  { 3541, 9, 40, 14, 4, -33 },
  { 3586, 14, 33, 15, 1, -33 },
  { 3644, 9, 40, 14, 1, -33 },
  { 3689, 19, 18, 21, 1, -33 },
  { 3732, 19, 2, 18, 0, 4 },
  { 3737, 7, 7, 11, 2, -35 },
  { 3744, 14, 25, 19, 2, -25 },
  { 3788, 17, 35, 22, 3, -35 },
  { 3863, 14, 25, 17, 2, -25 },
  { 3907, 17, 35, 22, 2, -35 },
  { 3982, 16, 25, 20, 2, -25 },
  { 4032, 13, 35, 11, 0, -35 },
  { 4089, 17, 36, 22, 2, -25 },
  { 4166, 15, 35, 21, 3, -35 },
  { 4232, 3, 33, 9, 3, -33 },
  { 4245, 7, 44, 9, -1, -33 },
  { 4284, 14, 35, 17, 3, -35 },
  { 4346, 2, 35, 9, 3, -35 },
  { 4355, 26, 25, 32, 3, -25 },
  { 4437, 15, 25, 21, 3, -25 },
  { 4484, 17, 25, 21, 2, -25 },
  { 4538, 17, 36, 22, 3, -25 },
  { 4615, 17, 36, 22, 2, -25 },
  { 4692, 10, 25, 14, 3, -25 },
  { 4724, 13, 25, 17, 2, -25 },
  { 4765, 10, 30, 12, 1, -30 },
  { 4803, 15, 24, 21, 3, -24 },
  { 4848, 16, 24, 16, 0, -24 },
  { 4896, 26, 24, 27, 0, -24 },
  { 4974, 15, 24, 17, 1, -24 },
  { 5019, 16, 35, 17, 0, -24 },
  { 5089, 13, 24, 15, 1, -24 },
  { 5128, 12, 40, 16, 2, -33 },
  { 5188, 2, 46, 20, 9, -35 },
  { 5200, 12, 40, 16, 2, -33 },
  { 5260, 17, 4, 21, 2, -18 },
};

const GFXfont NotoSans_Condensed_ExtraLight46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_ExtraLight46pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_ExtraLight46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_CONDENSED_EXTRALIGHT46PT7B_H_
