#ifndef _JETBRAINSMONO_BOLDITALIC46PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0x7F, 0x0F,
  0xF0, 0xFF, 0x07, 0xE0, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xEF, 0x83,
  0xFF, 0xC1, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7C,
  0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0x81, 0xE0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0x1F, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0x81, 0xE0, 0x00,
  0xF0, 0x3E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x07,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0xF8, 0x00,
  0x3C, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x3C, 0x00,
  0x1F, 0x03, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0,
  0x78, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xEE, 0xFE,
  0x07, 0xE3, 0x9F, 0x81, 0xF0, 0xC3, 0xE0, 0xFC, 0x70, 0xF8, 0x3F, 0x1C,
  0x00, 0x0F, 0xC7, 0x00, 0x03, 0xF1, 0xC0, 0x00, 0xFE, 0x70, 0x00, 0x3F,
  0xD8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x73, 0xF8, 0x00, 0x1C, 0x7F, 0x00, 0x07, 0x0F, 0xC0, 0x01,
  0xC3, 0xE1, 0xF8, 0x70, 0xF8, 0x7E, 0x18, 0x7E, 0x1F, 0x8E, 0x1F, 0x87,
  0xF3, 0x9F, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x7F, 0xC0, 0x07, 0x80,
  0x7F, 0xF0, 0x07, 0x80, 0x7F, 0xF8, 0x07, 0x80, 0x7C, 0x3C, 0x07, 0xC0,
  0x3C, 0x1E, 0x07, 0xC0, 0x1E, 0x0F, 0x03, 0xC0, 0x0F, 0x07, 0x83, 0xC0,
  0x07, 0x83, 0xC3, 0xC0, 0x07, 0xC1, 0xE3, 0xC0, 0x03, 0xE1, 0xF3, 0xC0,
  0x01, 0xF0, 0xF3, 0xE0, 0x00, 0x7F, 0xFB, 0xE0, 0x00, 0x3F, 0xFB, 0xE0,
  0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x00, 0x61, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF3,
  0xF8, 0x00, 0x01, 0xF3, 0xFE, 0x00, 0x00, 0xF3, 0xFF, 0x80, 0x00, 0xF3,
  0xE7, 0xC0, 0x00, 0xF3, 0xE1, 0xE0, 0x00, 0xF1, 0xE0, 0xF8, 0x00, 0xF0,
  0xF0, 0x78, 0x00, 0xF8, 0x78, 0x3C, 0x00, 0xF8, 0x3C, 0x1E, 0x00, 0x78,
  0x1E, 0x0F, 0x00, 0x78, 0x1F, 0x0F, 0x80, 0x78, 0x07, 0xCF, 0x80, 0x78,
  0x03, 0xFF, 0x80, 0x78, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x0F,
  0x80, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x03, 0xF3, 0xF7,
  0xE1, 0xF9, 0xF8, 0xF8, 0x7C, 0x7E, 0x3F, 0x3F, 0x1F, 0x07, 0xFF, 0x87,
  0xC1, 0xFF, 0xC1, 0xF0, 0x3F, 0xF0, 0xFC, 0x0F, 0xF8, 0x3F, 0x01, 0xFC,
  0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xF0, 0x3F, 0xCF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFB, 0xF0, 0x3F, 0xFC, 0x7E, 0x07,
  0xFC, 0x1F, 0x80, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x3C, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x3C, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0,
  0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0xC0, 0x78, 0x0C, 0x7C, 0x3C, 0x3E, 0x7F, 0x1E,
  0x7F, 0x3F, 0xEE, 0x7F, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x03,
  0xEF, 0x80, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x00, 0x78, 0x07, 0x00, 0x08, 0x02, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFC,
  0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x1F,
  0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1,
  0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x70, 0xFC, 0x7C, 0x7C, 0x7C,
  0x3E, 0x7E, 0x3E, 0x1F, 0x3F, 0x1F, 0x0F, 0x8F, 0x9F, 0x8F, 0xC7, 0x8F,
  0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0xF8, 0x7C, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x0F, 0x80,
  0x3F, 0x07, 0xE0, 0x3F, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0xFF, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xC0, 0x38, 0x3F,
  0x01, 0xC0, 0xFC, 0x04, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F,
  0x87, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F,
  0x80, 0x1F, 0x88, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x87, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFF, 0xDF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7E,
  0x1F, 0xC0, 0x7C, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x8F, 0xE0, 0x1F, 0xBF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0x81, 0xFC,
  0x3F, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x70, 0x03, 0xF7, 0xFC, 0x0F, 0xDF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0xFE, 0x07, 0xFB, 0xF8, 0x07, 0xF7, 0xE0, 0x07,
  0xEF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xE0, 0x3F, 0x8F,
  0xFB, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07,
  0xF0, 0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0xFE, 0x0F,
  0xE1, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x1F, 0xE7, 0xF8, 0x3F, 0x81, 0xF8, 0x3F,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x7F,
  0xDF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xF8, 0x3F, 0x8F, 0xC0, 0x3F, 0xBF, 0x00,
  0x3F, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x7F, 0x7F, 0x01, 0xFC,
  0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0x00,
  0xFE, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xC0, 0xFE, 0x1F, 0xE1, 0xFF, 0x1F, 0xE1,
  0xFE, 0x1F, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0x0F,
  0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x30, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x08,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFE,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x3E, 0x07, 0xE0, 0x03,
  0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F,
  0x00, 0x01, 0xF1, 0xF0, 0x02, 0x1F, 0x1F, 0x03, 0xF9, 0xF1, 0xF0, 0x7F,
  0xDF, 0x1E, 0x0F, 0xFD, 0xE3, 0xE0, 0xF8, 0x7E, 0x3E, 0x1F, 0x03, 0xE3,
  0xE1, 0xF0, 0x3E, 0x3E, 0x1F, 0x03, 0xE3, 0xE1, 0xF0, 0x3E, 0x3C, 0x1E,
  0x03, 0xC7, 0xC3, 0xE0, 0x7C, 0x7C, 0x3E, 0x07, 0xC7, 0xC3, 0xE0, 0x7C,
  0x7C, 0x3E, 0x07, 0xC7, 0xC3, 0xE0, 0x7C, 0x78, 0x3E, 0x0F, 0x87, 0x83,
  0xF1, 0xF8, 0xF8, 0x3F, 0xF7, 0x8F, 0x81, 0xFF, 0x78, 0xF8, 0x0F, 0xCF,
  0x8F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C,
  0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C,
  0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0x80, 0x3E,
  0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x7E, 0x07, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x0F, 0x80,
  0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8,
  0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xC0, 0x3F, 0x83,
  0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x3F,
  0x8F, 0xC0, 0x3F, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x3F, 0x83, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x0F, 0x87, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0x07,
  0xF0, 0x3F, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xFC,
  0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0xC1, 0xF8,
  0x07, 0xF0, 0x7E, 0x07, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x81, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0x83, 0xF8, 0x3F,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0x87,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xFE, 0x1F, 0x87, 0xFF,
  0x0F, 0x83, 0xFF, 0x87, 0xC3, 0xFF, 0xC7, 0xE1, 0xFF, 0xE3, 0xF0, 0x03,
  0xF1, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00,
  0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x3F, 0x83, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07,
  0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0,
  0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x87, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7C,
  0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x7C, 0x01,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07,
  0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x7E,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0x7C, 0x07, 0xF0, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC1, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0xF8, 0x3F,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x07,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00,
  0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC,
  0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x1F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1E, 0xE0,
  0x7F, 0xC3, 0xDC, 0x0F, 0xF0, 0x7B, 0xC3, 0xDE, 0x0F, 0x78, 0x7F, 0xC3,
  0xEF, 0x1E, 0xF8, 0x7D, 0xE3, 0xDF, 0x0F, 0xBC, 0xF3, 0xE1, 0xF3, 0x9E,
  0x78, 0x3E, 0x73, 0x9F, 0x07, 0xCE, 0xF3, 0xE1, 0xF9, 0xFE, 0x7C, 0x3E,
  0x3F, 0x8F, 0x87, 0xC7, 0xF3, 0xF0, 0xF8, 0xFC, 0x7C, 0x1F, 0x1F, 0x8F,
  0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0,
  0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xF8, 0x07, 0xE0, 0xFF, 0x00, 0xF8, 0x1F, 0xE0, 0x1F, 0x03, 0xFC,
  0x03, 0xE0, 0x7F, 0x80, 0x7C, 0x0F, 0xF8, 0x0F, 0x81, 0xFF, 0x03, 0xF0,
  0x7F, 0xE0, 0x7C, 0x0F, 0xBC, 0x0F, 0x81, 0xF7, 0x81, 0xF0, 0x3E, 0xF0,
  0x3E, 0x07, 0xDF, 0x07, 0xC0, 0xFB, 0xE1, 0xF8, 0x1F, 0x7C, 0x3F, 0x07,
  0xE7, 0x87, 0xC0, 0xF8, 0xF0, 0xF8, 0x1F, 0x1F, 0x1F, 0x03, 0xE3, 0xE3,
  0xE0, 0x7C, 0x7C, 0x7C, 0x0F, 0x87, 0x9F, 0x83, 0xF0, 0xF3, 0xE0, 0x7E,
  0x1F, 0x7C, 0x0F, 0x83, 0xEF, 0x81, 0xF0, 0x7D, 0xF0, 0x3E, 0x07, 0xBE,
  0x07, 0xC0, 0xF7, 0xC1, 0xF8, 0x1E, 0xF0, 0x3F, 0x03, 0xFE, 0x07, 0xC0,
  0x7F, 0xC0, 0xF8, 0x0F, 0xF8, 0x1F, 0x00, 0xFF, 0x03, 0xE0, 0x1F, 0xE0,
  0x7C, 0x03, 0xFC, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F,
  0x83, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F,
  0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x03, 0xF1,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0xC7, 0xE0, 0x07,
  0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xF0,
  0x3F, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0xFC, 0x03, 0xF8, 0x3E, 0x00, 0x7F, 0x0F, 0x80, 0x0F, 0xC7,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x1F,
  0x87, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0xFC, 0x03, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1, 0xF0,
  0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x3F,
  0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8,
  0x7C, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x3F, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xF8, 0x3F, 0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0x00, 0x3F, 0x07,
  0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7E, 0x07,
  0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x3F,
  0x01, 0xF8, 0x07, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0,
  0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x1F,
  0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x0F,
  0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x1F,
  0x80, 0x1F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1,
  0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x1F,
  0x81, 0xF8, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0xF8,
  0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0x7E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x07, 0xC1, 0xF3, 0xE0, 0xFC,
  0x1F, 0x3E, 0x0F, 0xC1, 0xF3, 0xE0, 0xF8, 0x3E, 0x3E, 0x1F, 0x83, 0xE3,
  0xE1, 0xF8, 0x3E, 0x3C, 0x1F, 0x83, 0xE3, 0xC1, 0xF8, 0x3C, 0x3C, 0x3B,
  0x87, 0xC3, 0xC3, 0xB8, 0x7C, 0x7C, 0x3B, 0x87, 0xC7, 0xC3, 0xB8, 0x78,
  0x7C, 0x73, 0x8F, 0x87, 0xC7, 0x38, 0xF8, 0x7C, 0x73, 0x8F, 0x07, 0xCF,
  0x38, 0xF0, 0x7C, 0xE3, 0x9F, 0x07, 0xCE, 0x39, 0xF0, 0x7C, 0xE3, 0x9E,
  0x07, 0xDE, 0x39, 0xE0, 0x79, 0xC3, 0xBE, 0x07, 0x9C, 0x7B, 0xE0, 0x79,
  0xC7, 0xBC, 0x07, 0xB8, 0x73, 0xC0, 0x7B, 0x87, 0x7C, 0x07, 0xB8, 0x77,
  0x80, 0x7F, 0x87, 0x78, 0x07, 0xF0, 0x77, 0x80, 0xFF, 0x07, 0xF8, 0x0F,
  0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xE0,
  0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x7E, 0x3F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF9, 0xF8,
  0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F,
  0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7D,
  0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xC0, 0x07,
  0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x1E, 0x03, 0xF0, 0xF8,
  0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0xC0,
  0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xFE, 0x1F,
  0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x00, 0x38, 0x00, 0x01, 0xFF, 0x3F,
  0x03, 0xFF, 0xBF, 0x07, 0xFF, 0xBF, 0x0F, 0xFF, 0xFE, 0x1F, 0xE1, 0xFE,
  0x1F, 0x80, 0xFE, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xF8,
  0x7C, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFD, 0xF0, 0x3F, 0xF9, 0xF0, 0x0F, 0xF3, 0xF0,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x83, 0xC0, 0x1F, 0x9F, 0xF0, 0x1F, 0xBF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0x7E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x3E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8,
  0xFF, 0x03, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xF9, 0xFF, 0xC0, 0xF8, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xF1, 0xFE,
  0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0xFC,
  0x7C, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x38, 0x3F, 0x00, 0xFF, 0x9F, 0x80, 0xFF, 0xEF, 0xC0, 0xFF,
  0xF7, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x03, 0xF8, 0x7F,
  0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87,
  0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7E,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFB, 0xE0, 0x3F, 0xF9, 0xF0, 0x07, 0xF9, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC1, 0xF8, 0x1F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00,
  0x7E, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F,
  0xE0, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0x3F, 0x03, 0xFF, 0xBF, 0x07,
  0xFF, 0xBF, 0x0F, 0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0x80, 0xFE, 0x3F,
  0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3E,
  0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0xDE, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFD, 0xF8, 0x1F, 0xFD, 0xF8, 0x0F,
  0xF1, 0xF0, 0x01, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xC0, 0x3F, 0x3F,
  0xE0, 0x7E, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE3, 0xFC, 0x3F,
  0xC7, 0xF0, 0x3F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F,
  0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF0,
  0x03, 0xE3, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF0, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x43, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0,
  0x7E, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0x80, 0x7C, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xC3, 0xF8, 0x03, 0xF0,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x83, 0xF0,
  0x07, 0xE0, 0xFE, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F,
  0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0E, 0x06, 0x01, 0xF7, 0xE3, 0xF0, 0x3E,
  0xFE, 0xFF, 0x07, 0xFF, 0xDF, 0xE0, 0xFC, 0xFC, 0xFC, 0x1F, 0x0F, 0x0F,
  0x87, 0xE1, 0xE1, 0xF0, 0xF8, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xE0, 0xF8, 0x7C, 0x3C, 0x1F, 0x0F, 0x87, 0x87, 0xE3, 0xF0, 0xF0, 0xF8,
  0x7C, 0x1E, 0x1F, 0x0F, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E,
  0x0F, 0x87, 0xC3, 0xC3, 0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x0F, 0x0F, 0x87,
  0xC1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0xC3, 0xE1, 0xE0,
  0xF8, 0x7C, 0x3C, 0x3E, 0x1F, 0x87, 0x87, 0xC0, 0x00, 0x03, 0xC0, 0x3F,
  0x3F, 0xE0, 0x7E, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE3, 0xFC,
  0x3F, 0xC7, 0xF0, 0x3F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00,
  0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F,
  0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF1,
  0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F,
  0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF0, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC3, 0xFC, 0x3F, 0xC7, 0xE0, 0x3F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0xFC, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xF7, 0xE0, 0x07,
  0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xF8, 0x01, 0xF9, 0xF0, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xF9, 0xFF, 0x00, 0x7E, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x03,
  0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x0F, 0xC1,
  0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3E, 0x7F, 0xF0, 0x0F,
  0x8F, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0x3F, 0x03,
  0xFF, 0xBF, 0x07, 0xFF, 0xBF, 0x0F, 0xFF, 0xBE, 0x1F, 0xE1, 0xFE, 0x1F,
  0x80, 0xFE, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFD, 0xF0, 0x3F, 0xF9, 0xF0, 0x0F, 0xF3, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x07, 0xE7, 0xFC, 0x03, 0xE7, 0xFF, 0x81, 0xF7, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xE0, 0x07,
  0xE3, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8,
  0xFF, 0x07, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x3F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x03, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0x7C,
  0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x7E,
  0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x3E,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F,
  0x3F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xF8, 0x3E, 0x07, 0xFE, 0x0F, 0x81, 0xEF,
  0x83, 0xE0, 0xFB, 0xC1, 0xF8, 0x3C, 0xF0, 0x7E, 0x0F, 0x3C, 0x1F, 0x87,
  0xCF, 0x0E, 0xE1, 0xF3, 0xC3, 0xB8, 0x78, 0xF0, 0xEE, 0x3E, 0x3C, 0x73,
  0x8F, 0x8F, 0x1C, 0xE3, 0xC3, 0xC7, 0x39, 0xF0, 0xF3, 0xCE, 0x7C, 0x3C,
  0xE3, 0x9E, 0x0F, 0x38, 0xE7, 0x83, 0xDE, 0x3B, 0xE0, 0xF7, 0x0E, 0xF0,
  0x3D, 0xC3, 0xBC, 0x0F, 0x70, 0xFF, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F,
  0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xFC, 0x00,
  0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xF0,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFD, 0xF8, 0x1F, 0xF9, 0xF0, 0x0F, 0xE1,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0xF8, 0x07, 0xC7, 0xFE, 0x07, 0xC7, 0xFF, 0x83, 0xE7,
  0xFF, 0xE1, 0xF3, 0xE3, 0xF0, 0xF9, 0xF0, 0xFC, 0xFC, 0xF0, 0x7F, 0xFC,
  0xF8, 0x1F, 0xFC, 0x7C, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00,
};

const GFXglyph JetBrainsMono_BoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 12, 34, 28, 8, -34 },
  { 52, 17, 14, 28, 8, -34 },
  { 82, 28, 34, 28, 0, -34 },
  { 201, 26, 46, 28, 1, -40 },
  { 351, 33, 34, 28, -2, -34 },
  { 492, 26, 34, 28, 1, -34 },
  { 603, 8, 14, 28, 12, -34 },
  { 617, 19, 45, 28, 7, -39 },
  { 724, 20, 45, 28, 2, -39 },
  { 837, 25, 24, 28, 2, -28 },
  { 912, 23, 22, 28, 3, -26 },
  { 976, 13, 14, 28, 4, -7 },
  { 999, 16, 5, 28, 6, -18 },
  { 1009, 9, 8, 28, 8, -8 },
  { 1018, 29, 43, 28, 0, -38 },
  { 1174, 25, 34, 28, 2, -34 },
  { 1281, 22, 34, 28, 2, -34 },
  { 1375, 25, 34, 28, 2, -34 },
  { 1482, 24, 34, 28, 2, -34 },
  { 1584, 24, 34, 28, 2, -34 },
  { 1686, 24, 34, 28, 2, -34 },
  { 1788, 23, 34, 28, 2, -34 },
  { 1886, 24, 34, 28, 4, -34 },
  { 1988, 24, 34, 28, 2, -34 },
  { 2090, 23, 34, 28, 4, -34 },
  { 2188, 12, 26, 28, 8, -26 },
  { 2227, 16, 33, 28, 4, -26 },
  { 2293, 23, 25, 28, 3, -28 },
  { 2365, 23, 16, 28, 3, -23 },
  { 2411, 23, 25, 28, 2, -28 },
  { 2483, 20, 34, 28, 6, -34 },
  { 2568, 28, 42, 28, 0, -34 },
  { 2715, 24, 34, 28, 0, -34 },
  { 2817, 25, 34, 28, 2, -34 },
  { 2924, 25, 34, 28, 2, -34 },
  { 3031, 26, 34, 28, 1, -34 },
  { 3142, 26, 34, 28, 2, -34 },
  { 3253, 26, 34, 28, 2, -34 },
  { 3364, 25, 34, 28, 2, -34 },
  { 3471, 25, 34, 28, 2, -34 },
  { 3578, 25, 34, 28, 2, -34 },
  { 3685, 27, 35, 28, 0, -34 },
  { 3804, 28, 34, 28, 1, -34 },
  { 3923, 21, 34, 28, 3, -34 },
  { 4013, 27, 34, 28, 1, -34 },
  { 4128, 27, 34, 28, 1, -34 },
  { 4243, 25, 34, 28, 2, -34 },
  { 4350, 26, 34, 28, 2, -34 },
  { 4461, 25, 42, 28, 2, -34 },
  { 4593, 26, 34, 28, 1, -34 },
  { 4704, 26, 34, 28, 1, -34 },
  { 4815, 24, 34, 28, 5, -34 },
  { 4917, 26, 34, 28, 2, -34 },
  { 5028, 24, 34, 28, 5, -34 },
  { 5130, 28, 34, 28, 2, -34 },
  { 5249, 30, 34, 28, -1, -34 },
  { 5377, 26, 34, 28, 4, -34 },
  { 5488, 25, 34, 28, 2, -34 },
  { 5595, 19, 43, 28, 6, -38 },
  { 5698, 15, 43, 28, 7, -38 },
  { 5779, 20, 43, 28, 3, -38 },
  { 5887, 21, 18, 28, 4, -34 },
  { 5935, 23, 5, 28, 0, 1 },
  { 5950, 10, 6, 28, 11, -36 },
  { 5958, 24, 26, 28, 2, -26 },
  { 6036, 24, 34, 28, 2, -34 },
  { 6138, 24, 26, 28, 2, -26 },
  { 6216, 25, 34, 28, 2, -34 },
  { 6323, 23, 26, 28, 2, -26 },
  { 6398, 32, 42, 28, -3, -34 },
  { 6566, 24, 34, 28, 2, -26 },
  { 6668, 23, 34, 28, 2, -34 },
  { 6766, 23, 36, 28, 1, -36 },
  { 6870, 25, 44, 28, 0, -36 },
  { 7008, 26, 34, 28, 2, -34 },
  { 7119, 20, 34, 28, 4, -34 },
  { 7204, 27, 26, 28, 0, -26 },
  { 7292, 23, 26, 28, 2, -26 },
  { 7367, 23, 26, 28, 2, -26 },
  { 7442, 26, 34, 28, 0, -26 },
  { 7553, 24, 34, 28, 2, -26 },
  { 7655, 25, 26, 28, 2, -26 },
  { 7737, 24, 26, 28, 2, -26 },
  { 7815, 23, 32, 28, 3, -32 },
  { 7907, 24, 25, 28, 2, -25 },
  { 7982, 24, 25, 28, 4, -25 },
  { 8057, 26, 25, 28, 3, -25 },
  { 8139, 27, 25, 28, 0, -25 },
  { 8224, 24, 33, 28, 2, -25 },
  { 8323, 23, 25, 28, 2, -25 },
  { 8395, 24, 43, 28, 4, -38 },
  { 8524, 13, 43, 28, 8, -38 },
  { 8594, 24, 43, 28, 1, -38 },
  { 8723, 25, 11, 28, 2, -22 },
};

const GFXfont JetBrainsMono_BoldItalic46pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic46pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _JETBRAINSMONO_BOLDITALIC46PT7B_H_
