#ifndef _JETBRAINSMONO_BOLDITALIC24PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0x80,
  0x00, 0x00, 0x38, 0xF0, 0xE0, 0x73, 0xB9, 0xF8, 0xFC, 0x7E, 0x77, 0x3B,
  0x9D, 0x8E, 0x01, 0x8C, 0x06, 0x18, 0x0C, 0x70, 0x18, 0xC0, 0x61, 0x87,
  0xFF, 0xCF, 0xFF, 0x86, 0x18, 0x0C, 0x70, 0x18, 0xC0, 0x61, 0x80, 0xC7,
  0x0F, 0xFF, 0x9F, 0xFF, 0x0C, 0x70, 0x18, 0xC0, 0x61, 0x80, 0xC7, 0x00,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x80, 0xFF, 0x0F, 0xF8, 0xF5, 0xE7,
  0x27, 0x3B, 0x01, 0xD8, 0x0F, 0xC0, 0x7F, 0x81, 0xFE, 0x01, 0xF0, 0x1B,
  0xC0, 0xCE, 0xE6, 0x77, 0x27, 0x3F, 0x78, 0xFF, 0x83, 0xF8, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x02, 0x01, 0x87, 0xC1, 0x86, 0x61, 0x83, 0x39, 0xC3,
  0x99, 0xC1, 0x8C, 0xC0, 0xEE, 0xC0, 0x3E, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xEF, 0x00, 0xEF, 0xC0, 0x6C, 0x60, 0x66, 0x30, 0x63, 0x38, 0x61,
  0x98, 0x60, 0xFC, 0x70, 0x7C, 0x00, 0x01, 0xC0, 0x1F, 0xC0, 0xFF, 0x83,
  0x8E, 0x1C, 0x38, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0xFC, 0x77,
  0x3B, 0x9C, 0xEE, 0x71, 0xF1, 0xC7, 0x86, 0x0E, 0x1C, 0xF8, 0x7F, 0xF0,
  0xF9, 0xE0, 0x77, 0x77, 0x77, 0x6E, 0x00, 0x60, 0x3C, 0x1F, 0x07, 0x80,
  0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1C,
  0x00, 0x80, 0x0C, 0x03, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0xF8, 0x78, 0x3C, 0x0C, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x86, 0x17, 0x33, 0xFD, 0x7D, 0xFF, 0xC0, 0xE0, 0x0F, 0x80, 0xCE, 0x0E,
  0x70, 0xE3, 0xC2, 0x08, 0x00, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07,
  0x07, 0xFF, 0x7F, 0xF8, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E,
  0x38, 0xF1, 0xC7, 0x8E, 0x38, 0x70, 0xFF, 0xFF, 0x80, 0x77, 0xFF, 0xE0,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x7F, 0x87,
  0xFC, 0x78, 0xF3, 0x83, 0x98, 0x1D, 0xC0, 0xEE, 0x06, 0x77, 0x73, 0xBB,
  0x9C, 0x9C, 0xC0, 0xEE, 0x07, 0x70, 0x33, 0x83, 0x9F, 0x7C, 0x7F, 0xC1,
  0xF8, 0x00, 0x01, 0xC0, 0x7C, 0x0F, 0xC3, 0xDC, 0x39, 0xC2, 0x3C, 0x43,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07,
  0x0F, 0xFF, 0xFF, 0xEF, 0xFE, 0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x78, 0xF3,
  0x83, 0xB8, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0xFC, 0xFF, 0xE7, 0xFF, 0x00, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFC, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x00, 0xF8,
  0x07, 0xE0, 0x4F, 0x00, 0x3C, 0x00, 0xE0, 0x0E, 0x70, 0x73, 0x83, 0x9E,
  0x3C, 0x7F, 0xC1, 0xF8, 0x00, 0x00, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x77, 0x87, 0x70, 0xF6, 0x0E, 0xFF,
  0xEF, 0xFE, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x1F, 0xF8, 0xFF, 0xC7,
  0xFE, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE4, 0x07, 0xFC, 0x3F, 0xE3, 0xC7,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x73, 0x83, 0x9F, 0x7C, 0x7F, 0xC1,
  0xF8, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0xDC, 0x3F, 0xE7, 0xFF, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xEF, 0x1E, 0x7F, 0xC3, 0xF0, 0x7F, 0xFB, 0xFF, 0xDF, 0xFC, 0xE0, 0xEF,
  0x07, 0x70, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x7F, 0x87, 0xFC, 0x78, 0xF3, 0x83, 0x9C, 0x38, 0xE1, 0xC7, 0x9C,
  0x1F, 0xC0, 0xFE, 0x0F, 0x78, 0xE1, 0xCE, 0x07, 0x70, 0x3B, 0x83, 0x9E,
  0x3C, 0x7F, 0xC1, 0xFC, 0x00, 0x07, 0x81, 0xFE, 0x3F, 0xE7, 0x0F, 0x70,
  0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xF1, 0xE7, 0xFE, 0x3D, 0xC0, 0x38, 0x07,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x3C, 0xF3, 0xC4, 0x00,
  0x00, 0x00, 0x01, 0xCF, 0xBE, 0xF0, 0x0F, 0x0F, 0x0F, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x60, 0xE0, 0x00,
  0x30, 0x1F, 0x07, 0xE1, 0xF8, 0xFE, 0x0F, 0x00, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x1C, 0x00, 0x40, 0x3F, 0xF3, 0xFF, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x30, 0x03, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x00, 0xF0, 0x3F, 0x1F, 0x87, 0xE0, 0xF8, 0x0E,
  0x00, 0x80, 0x00, 0x3C, 0x1F, 0xE7, 0xFC, 0x0F, 0x01, 0xC0, 0x70, 0x1C,
  0x0E, 0x3F, 0x8F, 0xC3, 0x80, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0xF0,
  0x3C, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3D, 0xF0, 0xE0, 0x63, 0x80, 0xE6,
  0x01, 0xCC, 0x3B, 0x38, 0xFE, 0x73, 0x9C, 0xE6, 0x39, 0x8C, 0x73, 0x38,
  0xE6, 0x71, 0xDC, 0xE3, 0x39, 0xCE, 0x71, 0xEC, 0xE1, 0x81, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x06, 0xC0, 0x76, 0x03, 0xB0, 0x39, 0x81, 0xCE, 0x0E, 0x70, 0xE3,
  0x87, 0x1C, 0x7F, 0xE3, 0xFF, 0x1F, 0xF9, 0xC1, 0xCE, 0x0E, 0xF0, 0x77,
  0x03, 0xC0, 0x1F, 0x81, 0xFF, 0x8F, 0xFC, 0x70, 0xF3, 0x83, 0x9C, 0x1C,
  0xE1, 0xCE, 0x1E, 0x7F, 0xC3, 0xFF, 0x1C, 0x3C, 0xE0, 0xE7, 0x07, 0x70,
  0x3B, 0x83, 0x9F, 0xFC, 0xFF, 0xC7, 0xF8, 0x00, 0x03, 0xC0, 0x7F, 0x87,
  0xFC, 0x78, 0xF3, 0x83, 0x9C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x7B, 0xC3, 0x8F, 0x7C, 0x7F, 0xC1,
  0xF8, 0x00, 0x1F, 0x01, 0xFF, 0x0F, 0xFC, 0x70, 0xF3, 0x87, 0x9C, 0x1C,
  0xE0, 0xEE, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x70,
  0x73, 0x83, 0x9F, 0xF8, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0xC7,
  0xFE, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xE3, 0xFF,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1F, 0xFC, 0xFF, 0xE7,
  0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xE3, 0xFF, 0x8E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x7F, 0xF1, 0xFF, 0x87, 0xFE, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x7F, 0x87, 0xFC, 0x78, 0xF3, 0x83, 0x9C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x9F, 0x9C, 0xFC, 0xE0, 0xE7, 0x07, 0x70, 0x73, 0xC3, 0x8F, 0x7C,
  0x7F, 0xC1, 0xF8, 0x00, 0x1C, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x83,
  0x9C, 0x3C, 0xE1, 0xCE, 0x0E, 0x7F, 0xF3, 0xFF, 0x9C, 0x1C, 0xE1, 0xE7,
  0x0E, 0x78, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x0F, 0x00, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFE, 0x47, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x1F, 0xFC,
  0xFF, 0xC7, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x8F, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x10, 0x73, 0x81, 0xCF, 0x0F, 0x1E, 0x78, 0x7F, 0xC0, 0xFE, 0x00,
  0x1C, 0x1C, 0xE0, 0xF3, 0x83, 0x8E, 0x1C, 0x38, 0xF0, 0xE3, 0x83, 0x9C,
  0x1C, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0x38, 0x1C, 0x70, 0x71, 0xC3, 0x87,
  0x0E, 0x1E, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0xC0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFF, 0x7F, 0xFF, 0xFC, 0x1E, 0x1E, 0x3C,
  0x3C, 0x78, 0xF0, 0xF1, 0xE3, 0xE6, 0xC7, 0xCD, 0x8F, 0xB7, 0x1D, 0xEE,
  0x33, 0xDC, 0x67, 0x31, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C,
  0x0E, 0x30, 0x18, 0x60, 0x71, 0xC0, 0xE0, 0x3C, 0x19, 0xE1, 0xCF, 0x0E,
  0x7C, 0x73, 0xE3, 0x9B, 0x1D, 0xD8, 0xCE, 0xC6, 0x77, 0x73, 0xBB, 0x9C,
  0xDC, 0xC6, 0xE6, 0x37, 0x71, 0xF3, 0x8F, 0x9C, 0x3C, 0xE1, 0xE6, 0x0F,
  0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x78, 0xF3, 0x83, 0x9C, 0x1D, 0xC1,
  0xCE, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x0F, 0x70, 0x73,
  0xC3, 0x8F, 0x7C, 0x7F, 0xC1, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xC3, 0xFF,
  0x8E, 0x1E, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x9C, 0x0E, 0x70, 0xF1, 0xFF,
  0xC7, 0xFC, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x78, 0xF3, 0x83, 0x9C,
  0x1D, 0xC0, 0xEE, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xEE, 0x07,
  0x70, 0x73, 0x83, 0x8F, 0x7C, 0x7F, 0xC1, 0xF8, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x1F, 0x01, 0xFF, 0x8F, 0xFC, 0x70, 0xF3, 0x83, 0x9C,
  0x1C, 0xE0, 0xEE, 0x0E, 0x7F, 0xF3, 0xFF, 0x1F, 0xE0, 0xE7, 0x07, 0x3C,
  0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE0, 0xE7, 0x07, 0x00, 0x03, 0xC0, 0x7F,
  0x87, 0xFC, 0x78, 0xF3, 0x83, 0x9C, 0x00, 0xE0, 0x07, 0x80, 0x3F, 0x80,
  0xFF, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x70, 0x3B, 0x83, 0x9F, 0x7C, 0x7F,
  0xC1, 0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x39, 0xC1,
  0xCE, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1D, 0xE1, 0xCE, 0x0E, 0x70, 0x73,
  0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x0F, 0x70, 0x73, 0xC3, 0x8F, 0x78, 0x7F,
  0xC1, 0xF8, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C,
  0xE1, 0xCE, 0x38, 0xE3, 0x8E, 0x38, 0xE7, 0x06, 0x70, 0x66, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x71, 0x8E, 0xE7, 0x19, 0x8E, 0x33,
  0x14, 0xE6, 0x39, 0xCC, 0xF3, 0x19, 0xE6, 0x32, 0xDC, 0x6D, 0xB8, 0xDB,
  0x61, 0xB6, 0xC7, 0x4F, 0x8F, 0x9F, 0x1F, 0x3C, 0x3C, 0x78, 0x68, 0xF0,
  0xF1, 0xC1, 0xE3, 0x80, 0x1C, 0x0E, 0x38, 0x38, 0x78, 0xF0, 0x71, 0xC0,
  0xE7, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1F,
  0x00, 0x7E, 0x01, 0xFE, 0x03, 0x9C, 0x0E, 0x38, 0x3C, 0x38, 0x70, 0x71,
  0xC0, 0xF0, 0xE0, 0x3D, 0xC0, 0xE7, 0x07, 0x1C, 0x1C, 0x78, 0xE0, 0xE7,
  0x03, 0x9C, 0x0E, 0xE0, 0x1B, 0x80, 0x7C, 0x01, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1F, 0xF8,
  0xFF, 0xCF, 0xFE, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x80, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1F, 0xFC,
  0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x70, 0x1C, 0x07, 0x03,
  0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x03, 0x80, 0xFE, 0x3F, 0x8F, 0xE0, 0xE1, 0xC3, 0x87,
  0x0F, 0x0E, 0x1C, 0x38, 0x70, 0x70, 0xE1, 0xC3, 0x87, 0x07, 0x0E, 0x1C,
  0x38, 0x38, 0x70, 0xE1, 0xC3, 0x80, 0x1F, 0xC7, 0xF1, 0xFC, 0x07, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xFE, 0x3F, 0x8F, 0xE0, 0x07,
  0x00, 0xF0, 0x3E, 0x06, 0xC1, 0xDC, 0x73, 0x8E, 0x73, 0x86, 0x70, 0xFC,
  0x1C, 0xFF, 0xFF, 0xFF, 0xE3, 0x9E, 0x70, 0x1F, 0xF9, 0xFF, 0x8E, 0x3C,
  0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x1C, 0xE0, 0xE7, 0x87, 0x3E,
  0xF8, 0xFD, 0xC3, 0xEE, 0x00, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0xBE, 0x3F, 0xF7, 0xCF, 0x78, 0x77, 0x07, 0x70, 0x77, 0x07, 0x70,
  0xFF, 0x0E, 0xF0, 0xEF, 0x9E, 0xFF, 0xCE, 0xF8, 0x0F, 0xE3, 0xFF, 0x3C,
  0xF7, 0x07, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0xFF, 0x0E, 0x7B,
  0xE7, 0xFC, 0x3F, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x8F, 0xFC, 0xFF, 0xC7, 0x1E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7,
  0x0E, 0x70, 0x73, 0xC3, 0x9F, 0x7C, 0x7E, 0xE1, 0xF7, 0x00, 0x0F, 0xE1,
  0xFE, 0x38, 0x77, 0x07, 0x70, 0x77, 0xFF, 0x7F, 0xF6, 0x00, 0xE0, 0x0E,
  0x0E, 0x71, 0xE7, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xFF,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x8E, 0x3C, 0xE0, 0xE7, 0x07, 0x38, 0x39,
  0xC1, 0xCE, 0x1C, 0xF0, 0xE3, 0xDF, 0x1F, 0xF8, 0x7D, 0xC0, 0x0E, 0x00,
  0xE0, 0x0F, 0x0F, 0xF0, 0x7F, 0x00, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0xBE, 0x3F, 0xF7, 0x8F, 0x78, 0x77, 0x07, 0x70, 0x77, 0x07,
  0x70, 0xEF, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x30, 0x03, 0xC0, 0x1E, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0xF8,
  0x7F, 0x83, 0xF8, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x04, 0xE0, 0xE3, 0x87, 0x0E, 0x38, 0x71, 0xE1, 0xCF, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xCE, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xE3, 0x83, 0xC0,
  0xFF, 0x1F, 0xC3, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xFF, 0x1F, 0xE1,
  0xF8, 0x3F, 0xB8, 0xDF, 0xF3, 0x99, 0xCC, 0x67, 0x33, 0x99, 0xCC, 0x67,
  0x33, 0x9C, 0xCE, 0x73, 0x39, 0x8C, 0xE6, 0x73, 0xB9, 0x8C, 0xE6, 0x70,
  0x3B, 0xE3, 0xFF, 0x78, 0xF7, 0x87, 0x70, 0x77, 0x07, 0x70, 0x77, 0x0E,
  0xF0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xE0, 0x0F, 0xE3, 0xFE, 0x38,
  0xF7, 0x07, 0x70, 0x77, 0x07, 0x70, 0x77, 0x0F, 0xE0, 0xEF, 0x0E, 0x7B,
  0xE7, 0xFC, 0x3F, 0x00, 0x1D, 0xF0, 0xFF, 0xCF, 0x9E, 0x78, 0x73, 0x83,
  0x9C, 0x1C, 0xE0, 0xE7, 0x0F, 0x78, 0x73, 0xC3, 0x9F, 0x3C, 0xFF, 0xC7,
  0x7C, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x00, 0x1F, 0xB9, 0xFF, 0x8E,
  0x3C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x1C, 0xE0, 0xE7, 0x87,
  0x3E, 0xF8, 0xFD, 0xC3, 0xCE, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x3B, 0xF1, 0xFF, 0x8F, 0x1E, 0x70, 0xF3, 0x87, 0xB8, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x1F, 0xE3,
  0xFF, 0x38, 0x77, 0x00, 0x78, 0x03, 0xF8, 0x1F, 0xE0, 0x1E, 0x00, 0xEE,
  0x0E, 0xF1, 0xEF, 0xFC, 0x7F, 0x80, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0xFF, 0xFF, 0xFE, 0xFF, 0xE1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x3F, 0xC3, 0xFC, 0x1F, 0x80, 0x38, 0x39, 0xC3, 0x9C,
  0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x1C, 0xE0, 0xE7, 0x87,
  0x1E, 0xF0, 0xFF, 0x83, 0xF0, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0xE7, 0x0E,
  0x71, 0xC7, 0x1C, 0x73, 0x87, 0x38, 0x77, 0x03, 0x70, 0x3E, 0x03, 0xE0,
  0x3C, 0x00, 0xE3, 0x1F, 0x9C, 0x6E, 0x71, 0xB9, 0x4E, 0xE5, 0x33, 0xB4,
  0xCE, 0xD3, 0x3A, 0x5C, 0xF9, 0x63, 0xE5, 0x8F, 0x1E, 0x3C, 0x70, 0xF1,
  0xC0, 0x3C, 0x3C, 0x71, 0xE0, 0xE7, 0x03, 0xB8, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x77, 0x83, 0x8E, 0x1E, 0x3C, 0xF0, 0x70,
  0x38, 0x7B, 0xC3, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC3, 0x8E,
  0x1C, 0xF0, 0xE3, 0xFF, 0x1F, 0xB8, 0x79, 0xC0, 0x0E, 0x00, 0xE0, 0x0F,
  0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0,
  0x00, 0x78, 0x0F, 0x80, 0xFC, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0x07, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF8, 0x07, 0xC0,
  0x0E, 0x00, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x1C, 0x38, 0x00, 0x0F,
  0x00, 0x7C, 0x03, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x3C, 0x00, 0xFE, 0x03, 0xF0, 0x7F, 0x83, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x07, 0xC0, 0x3E, 0x03, 0xC0,
  0x00, 0x3E, 0x3B, 0xF1, 0xD9, 0xCD, 0xC7, 0xEE, 0x3E, 0x00,
};

const GFXglyph JetBrainsMono_BoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 7, 18, 14, 4, -18 },
  { 17, 9, 8, 14, 4, -18 },
  { 26, 15, 18, 14, 0, -18 },
  { 60, 13, 24, 14, 1, -21 },
  { 99, 17, 18, 14, -1, -18 },
  { 138, 14, 18, 14, 0, -18 },
  { 170, 4, 8, 14, 6, -18 },
  { 174, 11, 23, 14, 3, -20 },
  { 206, 10, 23, 14, 1, -20 },
  { 235, 13, 13, 14, 1, -15 },
  { 257, 12, 12, 14, 1, -14 },
  { 275, 7, 8, 14, 2, -4 },
  { 282, 9, 2, 14, 3, -9 },
  { 285, 5, 4, 14, 4, -4 },
  { 288, 15, 23, 14, 0, -20 },
  { 332, 13, 18, 14, 1, -18 },
  { 362, 12, 18, 14, 1, -18 },
  { 389, 13, 18, 14, 1, -18 },
  { 419, 13, 18, 14, 1, -18 },
  { 449, 12, 18, 14, 1, -18 },
  { 476, 13, 18, 14, 1, -18 },
  { 506, 12, 18, 14, 1, -18 },
  { 533, 13, 18, 14, 2, -18 },
  { 563, 13, 18, 14, 1, -18 },
  { 593, 12, 18, 14, 2, -18 },
  { 620, 6, 13, 14, 4, -13 },
  { 630, 8, 17, 14, 2, -13 },
  { 647, 12, 13, 14, 2, -14 },
  { 667, 12, 8, 14, 1, -12 },
  { 679, 12, 13, 14, 1, -14 },
  { 699, 10, 18, 14, 3, -18 },
  { 722, 15, 22, 14, 0, -18 },
  { 764, 13, 18, 14, 0, -18 },
  { 794, 13, 18, 14, 1, -18 },
  { 824, 13, 18, 14, 1, -18 },
  { 854, 13, 18, 14, 1, -18 },
  { 884, 13, 18, 14, 1, -18 },
  { 914, 14, 18, 14, 1, -18 },
  { 946, 13, 18, 14, 1, -18 },
  { 976, 13, 18, 14, 1, -18 },
  { 1006, 13, 18, 14, 1, -18 },
  { 1036, 14, 18, 14, 0, -18 },
  { 1068, 14, 18, 14, 1, -18 },
  { 1100, 11, 18, 14, 1, -18 },
  { 1125, 15, 18, 14, 0, -18 },
  { 1159, 13, 18, 14, 1, -18 },
  { 1189, 13, 18, 14, 1, -18 },
  { 1219, 14, 18, 14, 1, -18 },
  { 1251, 13, 22, 14, 1, -18 },
  { 1287, 13, 18, 14, 1, -18 },
  { 1317, 13, 18, 14, 1, -18 },
  { 1347, 13, 18, 14, 2, -18 },
  { 1377, 13, 18, 14, 1, -18 },
  { 1407, 12, 18, 14, 3, -18 },
  { 1434, 15, 18, 14, 1, -18 },
  { 1468, 15, 18, 14, 0, -18 },
  { 1502, 14, 18, 14, 2, -18 },
  { 1534, 13, 18, 14, 1, -18 },
  { 1564, 10, 23, 14, 3, -20 },
  { 1593, 7, 23, 14, 4, -20 },
  { 1614, 10, 23, 14, 2, -20 },
  { 1643, 11, 10, 14, 2, -18 },
  { 1657, 12, 2, 14, 0, 1 },
  { 1660, 5, 4, 14, 6, -19 },
  { 1663, 13, 13, 14, 1, -13 },
  { 1685, 12, 18, 14, 1, -18 },
  { 1712, 12, 13, 14, 1, -13 },
  { 1732, 13, 18, 14, 1, -18 },
  { 1762, 12, 13, 14, 1, -13 },
  { 1782, 16, 22, 14, -1, -18 },
  { 1826, 13, 17, 14, 1, -13 },
  { 1854, 12, 18, 14, 1, -18 },
  { 1881, 12, 19, 14, 1, -19 },
  { 1910, 13, 23, 14, 0, -19 },
  { 1948, 14, 18, 14, 1, -18 },
  { 1980, 11, 18, 14, 2, -18 },
  { 2005, 14, 13, 14, 0, -13 },
  { 2028, 12, 13, 14, 1, -13 },
  { 2048, 12, 13, 14, 1, -13 },
  { 2068, 13, 17, 14, 0, -13 },
  { 2096, 13, 17, 14, 1, -13 },
  { 2124, 13, 13, 14, 1, -13 },
  { 2146, 12, 13, 14, 1, -13 },
  { 2166, 12, 17, 14, 2, -17 },
  { 2192, 13, 13, 14, 1, -13 },
  { 2214, 12, 13, 14, 2, -13 },
  { 2234, 14, 13, 14, 1, -13 },
  { 2257, 14, 13, 14, 0, -13 },
  { 2280, 13, 17, 14, 1, -13 },
  { 2308, 12, 13, 14, 1, -13 },
  { 2328, 13, 23, 14, 2, -20 },
  { 2366, 7, 23, 14, 4, -20 },
  { 2387, 13, 23, 14, 0, -20 },
  { 2425, 13, 5, 14, 1, -11 },
};

const GFXfont JetBrainsMono_BoldItalic24pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic24pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _JETBRAINSMONO_BOLDITALIC24PT7B_H_
