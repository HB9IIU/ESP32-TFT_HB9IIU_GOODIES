#ifndef _JETBRAINSMONO_BOLDITALIC17PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x33, 0x36, 0x66, 0x00, 0xEE, 0xEF, 0x3C, 0xF3, 0xC8, 0x0C,
  0xC3, 0x30, 0x88, 0xFF, 0x59, 0x84, 0x43, 0x33, 0xFE, 0xFF, 0x99, 0x86,
  0x41, 0x30, 0x04, 0x02, 0x03, 0x07, 0xE7, 0xFB, 0x4D, 0xA0, 0xF0, 0x3E,
  0x0F, 0x82, 0xC2, 0x6D, 0x37, 0xF1, 0xF0, 0x20, 0x30, 0x00, 0x08, 0x01,
  0xE3, 0x32, 0x62, 0x6C, 0x26, 0x83, 0xD0, 0x02, 0x00, 0x68, 0x0F, 0xE1,
  0xA6, 0x32, 0x66, 0x24, 0xC3, 0xC0, 0x06, 0x07, 0xE1, 0x98, 0xC6, 0x30,
  0x06, 0x03, 0x81, 0xB7, 0x6F, 0x99, 0xCC, 0x73, 0xFC, 0x79, 0x80, 0xFF,
  0x80, 0x03, 0x0E, 0x1C, 0x38, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0x60,
  0x60, 0x60, 0x74, 0x38, 0x08, 0x30, 0x78, 0x30, 0x70, 0x60, 0xC1, 0x87,
  0x0C, 0x18, 0x30, 0x61, 0x86, 0x38, 0x60, 0x0C, 0x06, 0x32, 0x7F, 0xF0,
  0x81, 0xE1, 0x99, 0xCC, 0x44, 0x00, 0x0C, 0x0C, 0x1C, 0xFF, 0xFF, 0x18,
  0x18, 0x18, 0x19, 0xCC, 0xE6, 0x60, 0x7F, 0xF0, 0x7F, 0x80, 0x00, 0xE0,
  0x18, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x00, 0x0C, 0x1F, 0x9C, 0xEC,
  0x36, 0x1B, 0x1B, 0x6D, 0xB6, 0xC3, 0x61, 0xB1, 0xDF, 0xC7, 0xC0, 0x1E,
  0x3E, 0x6E, 0x4C, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0xFF, 0xFF, 0x0C,
  0x1F, 0x9C, 0xEC, 0x70, 0x38, 0x18, 0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x1F,
  0xEF, 0xE0, 0x3F, 0xA1, 0x81, 0x81, 0x81, 0xE0, 0xF8, 0x0C, 0x06, 0x03,
  0x63, 0xBF, 0x8F, 0x80, 0x07, 0x87, 0x03, 0x03, 0x03, 0x03, 0x1B, 0x8D,
  0x86, 0xFF, 0x7F, 0x01, 0x80, 0xC0, 0x3F, 0xBF, 0x98, 0x0C, 0x07, 0xE3,
  0xF8, 0x0C, 0x06, 0x03, 0x63, 0xBF, 0x8F, 0x80, 0x0F, 0x0C, 0x18, 0x38,
  0x74, 0x7F, 0xE3, 0xC3, 0xC3, 0xC7, 0xFE, 0x7C, 0xFF, 0xFF, 0xC7, 0x06,
  0x0C, 0x0C, 0x18, 0x18, 0x30, 0x70, 0x60, 0xC0, 0x0C, 0x1F, 0x9C, 0xEC,
  0x36, 0x33, 0xB8, 0xF0, 0xFC, 0xC3, 0x61, 0xB1, 0xDF, 0xC7, 0xC0, 0x0C,
  0x1F, 0x9C, 0xEC, 0x36, 0x1F, 0x1D, 0xDC, 0xFE, 0x06, 0x06, 0x06, 0x07,
  0x07, 0x00, 0x27, 0x70, 0x00, 0x06, 0xEE, 0x08, 0x71, 0xC0, 0x00, 0x00,
  0x06, 0x38, 0xC7, 0x18, 0xC0, 0x01, 0x83, 0xC7, 0x8E, 0x0C, 0x07, 0x80,
  0xF0, 0x1E, 0x02, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x60, 0x78,
  0x1E, 0x0F, 0x03, 0x0F, 0x7C, 0xE0, 0x80, 0x7C, 0xFC, 0x18, 0x30, 0xE7,
  0x9E, 0x30, 0x00, 0x03, 0x87, 0x00, 0x03, 0x03, 0xF8, 0xC3, 0x10, 0x26,
  0x04, 0xCE, 0x9B, 0x32, 0x66, 0x4C, 0xD9, 0x1B, 0x36, 0x67, 0x4C, 0x01,
  0x80, 0x1F, 0x01, 0xE0, 0x07, 0x07, 0x83, 0xC3, 0x61, 0xB0, 0xD8, 0xCC,
  0x7E, 0x7F, 0xB0, 0xF8, 0x78, 0x30, 0x7F, 0x31, 0xD8, 0x6C, 0x76, 0x33,
  0xE3, 0x1D, 0x86, 0xC3, 0x61, 0xBF, 0x9F, 0x80, 0x0C, 0x1F, 0x9C, 0xEC,
  0x36, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x61, 0xB1, 0xDF, 0xC7, 0xC0, 0x7F,
  0x3F, 0xD8, 0x6C, 0x36, 0x3B, 0x1B, 0x8D, 0x86, 0xC3, 0x63, 0xBF, 0x9F,
  0x80, 0x3F, 0xB8, 0x18, 0x0C, 0x06, 0x03, 0xF9, 0xF9, 0xC0, 0xC0, 0x60,
  0x3F, 0x9F, 0xC0, 0x7F, 0xBF, 0xD8, 0x0C, 0x06, 0x03, 0xFB, 0xFD, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x00, 0x0C, 0x1F, 0x9C, 0xEC, 0x36, 0x03, 0x03,
  0xBD, 0x9E, 0xC3, 0x61, 0xB1, 0xDF, 0xC7, 0xC0, 0x71, 0xB0, 0xD8, 0x6C,
  0x66, 0x33, 0xFB, 0xFD, 0x86, 0xC3, 0x63, 0xB1, 0x98, 0xC0, 0x3F, 0xA6,
  0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x3F, 0x9F, 0xC0,
  0x07, 0xC1, 0xF0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0xC3, 0x38,
  0xC7, 0xF1, 0xF0, 0x71, 0xD8, 0xE6, 0x31, 0x98, 0x6E, 0x1F, 0x0F, 0xC3,
  0x38, 0xC6, 0x31, 0x8C, 0x63, 0x1C, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60,
  0x60, 0x60, 0x60, 0xE0, 0xFF, 0xFE, 0x39, 0xCA, 0x52, 0x9C, 0xAF, 0x6A,
  0xDB, 0xB6, 0xD9, 0x86, 0x61, 0x98, 0x6C, 0x1B, 0x06, 0x38, 0xCE, 0x33,
  0xCC, 0xF3, 0x3D, 0x8B, 0x66, 0x59, 0x9E, 0x67, 0x99, 0xE6, 0x73, 0x0C,
  0x0C, 0x1F, 0x9C, 0xEC, 0x36, 0x3B, 0x1B, 0x8D, 0x86, 0xC3, 0x61, 0xB1,
  0xDF, 0xC7, 0xC0, 0x7F, 0x3F, 0xD8, 0x6C, 0x36, 0x1B, 0xFB, 0xF9, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x00, 0x0C, 0x1F, 0x9C, 0xEC, 0x36, 0x1B, 0x1B,
  0x8D, 0x86, 0xC3, 0x61, 0xB1, 0xDF, 0xC7, 0xC0, 0x60, 0x30, 0x0C, 0x7F,
  0x31, 0xD8, 0x6C, 0x36, 0x3B, 0xFB, 0xF9, 0x98, 0xCE, 0x63, 0x31, 0x98,
  0xE0, 0x0C, 0x1F, 0x9C, 0xEC, 0x36, 0x03, 0x80, 0xF8, 0x3E, 0x03, 0x01,
  0xB0, 0xDF, 0xC7, 0xC0, 0xFF, 0xFF, 0x86, 0x03, 0x03, 0x81, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x0E, 0x00, 0x71, 0xB0, 0xD8, 0x6C, 0x76, 0x33,
  0x1B, 0x0D, 0x86, 0xC3, 0x63, 0xBF, 0x8F, 0x80, 0xC3, 0xE1, 0xB0, 0xD8,
  0xCC, 0x66, 0x63, 0x30, 0xD8, 0x78, 0x3C, 0x1C, 0x0E, 0x00, 0xCC, 0xF3,
  0x3C, 0xCB, 0x56, 0xD5, 0xB5, 0x6D, 0x53, 0x9C, 0xE7, 0x39, 0xCE, 0x63,
  0x38, 0x38, 0xE3, 0x30, 0x6E, 0x0F, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0,
  0x37, 0x0E, 0x61, 0x8C, 0x60, 0xC0, 0xC3, 0xE1, 0xB9, 0x8D, 0xC6, 0xC3,
  0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x00, 0x3F, 0xBF, 0xC1, 0xC0,
  0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x60, 0x70, 0x3F, 0x9F, 0xC0, 0x1E, 0x7C,
  0xC1, 0x83, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0x83, 0x06, 0x1C, 0x3E, 0x7C,
  0xE1, 0x86, 0x18, 0x30, 0xC3, 0x0C, 0x38, 0x61, 0x86, 0x18, 0x70, 0xC3,
  0x1F, 0x3E, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x1C, 0x18, 0xF8, 0xF8, 0x0E, 0x1E, 0x16, 0x32, 0x63, 0xE3, 0xFF, 0xFF,
  0xE7, 0x08, 0x1F, 0xDD, 0xCC, 0x6C, 0x36, 0x1B, 0x0D, 0x8E, 0xFE, 0x3B,
  0x00, 0x70, 0x60, 0x64, 0x7F, 0x77, 0x63, 0xE3, 0xC3, 0xC3, 0xC7, 0xFE,
  0xFC, 0x08, 0x1F, 0x9C, 0xCC, 0x6C, 0x06, 0x03, 0x01, 0x8E, 0xFE, 0x3E,
  0x00, 0x01, 0x80, 0xC2, 0x67, 0xF7, 0x73, 0x1B, 0x0D, 0x86, 0xC3, 0x63,
  0xBF, 0x8E, 0xC0, 0x08, 0x3F, 0x63, 0x63, 0xCF, 0xFF, 0xC0, 0xC1, 0xFE,
  0x7C, 0x03, 0xF0, 0x30, 0x06, 0x00, 0x60, 0x3F, 0xE3, 0xFC, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x0F, 0x80, 0xF0, 0x00,
  0x08, 0x1F, 0xDD, 0xCC, 0x6C, 0x36, 0x1B, 0x1D, 0xDE, 0x7E, 0x03, 0x01,
  0x8F, 0xCF, 0x80, 0x70, 0x60, 0x64, 0x7F, 0x77, 0x63, 0xE3, 0xC3, 0xC3,
  0xC7, 0xC6, 0xC6, 0x0E, 0x0E, 0x00, 0x00, 0x7C, 0x7C, 0x0C, 0x0C, 0x1C,
  0x18, 0x18, 0xFF, 0xFF, 0x01, 0x81, 0xC0, 0x00, 0x11, 0xF1, 0xF8, 0x0C,
  0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x73, 0xF1, 0xF0, 0x70, 0x30,
  0x18, 0x0C, 0x76, 0x73, 0x33, 0xF1, 0xF8, 0xCC, 0x67, 0x31, 0x98, 0xE0,
  0x7C, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x3F, 0x1F,
  0x04, 0x9F, 0x76, 0x6D, 0x93, 0x6C, 0x9B, 0x66, 0xD9, 0x36, 0xC9, 0xB2,
  0x60, 0x04, 0x7F, 0x77, 0x63, 0xE3, 0xC3, 0xC3, 0xC7, 0xC6, 0xC6, 0x08,
  0x3F, 0x77, 0x63, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0x7C, 0x02, 0x1F, 0xCE,
  0xE6, 0x37, 0x1B, 0x0D, 0x86, 0xC7, 0x7F, 0x3F, 0x38, 0x18, 0x0C, 0x00,
  0x08, 0x1F, 0xDD, 0xCC, 0x6C, 0x36, 0x1B, 0x0D, 0x8E, 0xFE, 0x3B, 0x01,
  0x80, 0xC0, 0x60, 0x04, 0x37, 0x9C, 0xEC, 0x76, 0x3B, 0x03, 0x81, 0x80,
  0xC0, 0x60, 0x00, 0x08, 0x3F, 0x63, 0x60, 0x78, 0x3E, 0x07, 0xC3, 0xFE,
  0x7C, 0x1C, 0x0C, 0x06, 0x1F, 0xFF, 0xF0, 0xC0, 0xE0, 0x60, 0x30, 0x18,
  0x0F, 0x83, 0xC0, 0x63, 0xB1, 0x98, 0xDC, 0x6C, 0x36, 0x1B, 0x19, 0xFC,
  0x7C, 0x00, 0xE1, 0xB1, 0x98, 0xCC, 0xC6, 0x63, 0x60, 0xF0, 0x70, 0x38,
  0x00, 0xCC, 0xF5, 0x6D, 0x5B, 0x54, 0xF7, 0x39, 0xCE, 0xE3, 0xB8, 0xCE,
  0x00, 0x31, 0xC6, 0xE1, 0xF0, 0x38, 0x0E, 0x07, 0x83, 0x71, 0xCC, 0xE3,
  0x80, 0x63, 0xB1, 0xB8, 0xD8, 0x6C, 0x36, 0x3B, 0xFC, 0xFC, 0x06, 0x03,
  0x1F, 0x9F, 0x00, 0x7F, 0x7F, 0x06, 0x0C, 0x18, 0x30, 0xE0, 0xFE, 0xFE,
  0x03, 0x83, 0xC1, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0xF0, 0xF8, 0x06, 0x03,
  0x03, 0x01, 0x80, 0xC0, 0x78, 0x1C, 0x39, 0x8C, 0x63, 0x19, 0xCC, 0x63,
  0x18, 0xC6, 0x73, 0x18, 0x1C, 0x0F, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30,
  0x1F, 0x0F, 0x8E, 0x06, 0x03, 0x01, 0x80, 0xC1, 0xC1, 0xC0, 0x71, 0xFC,
  0xF3, 0xD9, 0xC0,
};

const GFXglyph JetBrainsMono_BoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 6, 5, 10, 3, -12 },
  { 11, 10, 12, 10, 0, -12 },
  { 26, 9, 17, 10, 1, -15 },
  { 46, 12, 13, 10, -1, -13 },
  { 66, 10, 13, 10, 0, -13 },
  { 83, 2, 5, 10, 5, -12 },
  { 85, 8, 16, 10, 2, -14 },
  { 101, 7, 16, 10, 1, -14 },
  { 115, 9, 9, 10, 1, -10 },
  { 126, 8, 8, 10, 1, -10 },
  { 134, 5, 6, 10, 1, -3 },
  { 138, 6, 2, 10, 2, -7 },
  { 140, 3, 3, 10, 3, -3 },
  { 142, 11, 16, 10, 0, -14 },
  { 164, 9, 13, 10, 1, -13 },
  { 179, 8, 12, 10, 1, -12 },
  { 191, 9, 13, 10, 1, -13 },
  { 206, 9, 12, 10, 1, -12 },
  { 220, 9, 12, 10, 1, -12 },
  { 234, 9, 12, 10, 1, -12 },
  { 248, 8, 12, 10, 1, -12 },
  { 260, 8, 12, 10, 2, -12 },
  { 272, 9, 13, 10, 1, -13 },
  { 287, 9, 13, 10, 1, -13 },
  { 302, 4, 10, 10, 3, -10 },
  { 307, 6, 13, 10, 1, -10 },
  { 317, 9, 9, 10, 1, -10 },
  { 328, 8, 6, 10, 1, -9 },
  { 334, 8, 9, 10, 1, -10 },
  { 343, 7, 12, 10, 2, -12 },
  { 354, 11, 16, 10, 0, -13 },
  { 376, 9, 12, 10, 0, -12 },
  { 390, 9, 12, 10, 1, -12 },
  { 404, 9, 13, 10, 1, -13 },
  { 419, 9, 12, 10, 1, -12 },
  { 433, 9, 12, 10, 1, -12 },
  { 447, 9, 12, 10, 1, -12 },
  { 461, 9, 13, 10, 1, -13 },
  { 476, 9, 12, 10, 1, -12 },
  { 490, 9, 12, 10, 1, -12 },
  { 504, 10, 12, 10, 0, -12 },
  { 519, 10, 12, 10, 1, -12 },
  { 534, 8, 12, 10, 1, -12 },
  { 546, 10, 12, 10, 0, -12 },
  { 561, 10, 12, 10, 0, -12 },
  { 576, 9, 13, 10, 1, -13 },
  { 591, 9, 12, 10, 1, -12 },
  { 605, 9, 16, 10, 1, -13 },
  { 623, 9, 12, 10, 1, -12 },
  { 637, 9, 13, 10, 1, -13 },
  { 652, 9, 12, 10, 2, -12 },
  { 666, 9, 12, 10, 1, -12 },
  { 680, 9, 12, 10, 2, -12 },
  { 694, 10, 12, 10, 1, -12 },
  { 709, 11, 12, 10, 0, -12 },
  { 726, 9, 12, 10, 2, -12 },
  { 740, 9, 12, 10, 1, -12 },
  { 754, 7, 16, 10, 2, -14 },
  { 768, 6, 16, 10, 2, -14 },
  { 780, 8, 16, 10, 1, -14 },
  { 796, 8, 6, 10, 1, -12 },
  { 802, 8, 2, 10, 0, 0 },
  { 804, 4, 2, 10, 4, -13 },
  { 805, 9, 10, 10, 1, -10 },
  { 817, 8, 12, 10, 1, -12 },
  { 829, 9, 10, 10, 1, -10 },
  { 841, 9, 12, 10, 1, -12 },
  { 855, 8, 10, 10, 1, -10 },
  { 865, 12, 15, 10, -1, -12 },
  { 888, 9, 13, 10, 1, -10 },
  { 903, 8, 12, 10, 1, -12 },
  { 915, 8, 13, 10, 1, -13 },
  { 928, 9, 16, 10, 0, -13 },
  { 946, 9, 12, 10, 1, -12 },
  { 960, 8, 12, 10, 1, -12 },
  { 972, 10, 10, 10, 0, -10 },
  { 985, 8, 10, 10, 1, -10 },
  { 995, 8, 10, 10, 1, -10 },
  { 1005, 9, 13, 10, 0, -10 },
  { 1020, 9, 13, 10, 1, -10 },
  { 1035, 9, 10, 10, 1, -10 },
  { 1047, 8, 10, 10, 1, -10 },
  { 1057, 9, 12, 10, 1, -12 },
  { 1071, 9, 9, 10, 1, -9 },
  { 1082, 9, 9, 10, 1, -9 },
  { 1093, 10, 9, 10, 1, -9 },
  { 1105, 10, 9, 10, 0, -9 },
  { 1117, 9, 12, 10, 1, -9 },
  { 1131, 8, 9, 10, 1, -9 },
  { 1140, 9, 16, 10, 1, -14 },
  { 1158, 5, 16, 10, 3, -14 },
  { 1168, 9, 16, 10, 0, -14 },
  { 1186, 9, 4, 10, 1, -8 },
};

const GFXfont JetBrainsMono_BoldItalic17pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic17pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _JETBRAINSMONO_BOLDITALIC17PT7B_H_
