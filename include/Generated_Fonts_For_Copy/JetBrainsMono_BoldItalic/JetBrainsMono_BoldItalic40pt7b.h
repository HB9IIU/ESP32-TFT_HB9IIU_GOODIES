#ifndef _JETBRAINSMONO_BOLDITALIC40PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F,
  0xC3, 0xF8, 0x7F, 0x07, 0xC0, 0x7C, 0x3E, 0xF8, 0xFF, 0xF1, 0xF7, 0xC3,
  0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3C, 0xF0, 0x79, 0xE0, 0xF3,
  0xC3, 0xE7, 0x87, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x07, 0x00, 0x0F,
  0x07, 0x80, 0x07, 0x03, 0xC0, 0x07, 0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x01,
  0xC0, 0xF0, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC0, 0x3C, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x07, 0x00,
  0x0F, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x07, 0x81, 0xC0, 0x03, 0xC1, 0xE0,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC0, 0x78, 0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x07,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0xFC, 0xCF, 0xC3, 0xE3, 0x1F, 0x0F, 0x8C, 0x7C, 0x7E,
  0x70, 0x01, 0xF1, 0xC0, 0x07, 0xE7, 0x00, 0x1F, 0xD8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x0D, 0xFC, 0x00, 0x31, 0xF0, 0x01, 0xC7, 0xC0, 0x07,
  0x1F, 0x1F, 0x1C, 0x7C, 0x7C, 0x71, 0xF1, 0xF1, 0x8F, 0x87, 0xE6, 0x7E,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x78, 0x1F, 0xF8, 0x07, 0x81,
  0xFF, 0xC0, 0x78, 0x0F, 0x1E, 0x07, 0x80, 0x70, 0x70, 0x78, 0x07, 0x83,
  0x87, 0x80, 0x3C, 0x3C, 0x78, 0x01, 0xE1, 0xE3, 0x80, 0x0F, 0x0F, 0x3C,
  0x00, 0x78, 0xF3, 0xC0, 0x03, 0xFF, 0xBC, 0x00, 0x0F, 0xFB, 0xC0, 0x00,
  0x1F, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x7E, 0x00, 0x01, 0xEF, 0xF8, 0x00, 0x1E, 0xFF,
  0xE0, 0x01, 0xE7, 0x8F, 0x00, 0x1E, 0x78, 0x78, 0x00, 0xE3, 0xC3, 0xC0,
  0x0E, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0xF0, 0x0F, 0x07, 0x07, 0x00, 0xF0,
  0x3C, 0x78, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x07, 0xFC, 0x0F, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7C, 0x1F, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0x7C, 0x3E, 0x7C, 0xF8, 0xF8, 0xF8, 0xFB, 0xE1, 0xE1, 0xF7, 0xC7,
  0xC1, 0xFF, 0x0F, 0x83, 0xFC, 0x1F, 0x03, 0xF8, 0x3E, 0x03, 0xE0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF,
  0x9F, 0x03, 0xFE, 0x1F, 0x00, 0x7D, 0xF7, 0xDF, 0xFF, 0xEF, 0xBE, 0xFB,
  0xCF, 0x3C, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01,
  0x80, 0x02, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x03, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x18, 0x3C, 0x1D, 0xF1, 0xE3, 0xEF, 0xE6, 0x7F, 0xFF, 0xB7, 0xFB,
  0xFF, 0xFF, 0x83, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xCE,
  0x00, 0x3E, 0x78, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x03, 0xF0, 0x7C, 0x0F,
  0x03, 0xC0, 0x30, 0x0C, 0x00, 0x80, 0x40, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x0F,
  0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C,
  0x0F, 0x80, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C,
  0x7E, 0xFF, 0xFF, 0xFE, 0xFE, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xC0, 0xFC, 0x7C, 0x03, 0xE3, 0xC0, 0x1F, 0x3E,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xC0, 0x0F,
  0x1E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE3,
  0x8F, 0x1F, 0x00, 0x78, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3,
  0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xF0, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0x3E, 0x07,
  0xC7, 0xC0, 0xE0, 0xF8, 0x18, 0x3E, 0x04, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x01, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x07, 0xF0, 0xF8,
  0x0F, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7E,
  0x0F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC3, 0xF1, 0xF8, 0x3E,
  0x3F, 0x03, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0x80, 0x3E, 0xF8, 0x07,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x3D, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0xFC, 0x1F, 0x87, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF3,
  0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xFC, 0x1F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x9F, 0x00, 0xFB, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF0,
  0x7E, 0x3E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7,
  0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x7E, 0x07,
  0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xC0,
  0x1F, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0xF8, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x03, 0xF0, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83,
  0xF0, 0x7C, 0x07, 0xE7, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0x1F, 0x81, 0xF0, 0x3E, 0x0F, 0x80, 0x7C,
  0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C,
  0x03, 0xE1, 0xF8, 0x1F, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0x81, 0xF8, 0xF8, 0x07, 0xCF, 0x80,
  0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9E, 0x00, 0x7D, 0xF0, 0x03, 0xEF,
  0xC0, 0x3F, 0x3E, 0x03, 0xF1, 0xFC, 0x3F, 0x8F, 0xFF, 0xF8, 0x3F, 0xF7,
  0xC0, 0xFF, 0x7C, 0x01, 0xE7, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x87, 0xF1, 0xFC, 0xFF, 0x1F, 0x87, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x08, 0x1F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0x10, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00,
  0x01, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00,
  0xE0, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x87,
  0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x1F, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x03, 0xF0, 0x3E,
  0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F,
  0x00, 0x07, 0x87, 0x80, 0x63, 0xC7, 0xC1, 0xFD, 0xE3, 0xC1, 0xFE, 0xF1,
  0xE0, 0xFB, 0xF8, 0xF0, 0xF8, 0x7C, 0x78, 0x78, 0x3C, 0x3C, 0x7C, 0x1E,
  0x1E, 0x3C, 0x0F, 0x1F, 0x1E, 0x07, 0x8F, 0x0F, 0x03, 0xC7, 0x87, 0x83,
  0xE3, 0xC3, 0xC1, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF0, 0x78, 0xF8, 0x7C,
  0xFC, 0x78, 0x3F, 0xDE, 0x3C, 0x0F, 0xEF, 0x1E, 0x03, 0xC0, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x7C,
  0x00, 0xFB, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0x78, 0x03, 0xE3, 0xC0, 0x3E,
  0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0xF8, 0x3E, 0x07, 0xC1, 0xF0,
  0x7C, 0x0F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x1E, 0x7E, 0x00, 0xF3, 0xE0, 0x07, 0xDF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0x81, 0xFC, 0x3E, 0x03,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0x7C, 0x7C, 0x03, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFC, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F,
  0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F,
  0x00, 0xFC, 0x7C, 0x0F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xE0, 0xFC, 0x7C, 0x03, 0xE3, 0xE0,
  0x1F, 0x3F, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xFC, 0x07, 0xC3, 0xF0, 0xFE,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0x87,
  0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C,
  0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07,
  0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xE0, 0xFC, 0x7C, 0x03, 0xE3, 0xE0, 0x1F,
  0x3F, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0xFF, 0xCF, 0x87, 0xFE, 0x7C, 0x3F, 0xF3,
  0xE1, 0xFF, 0x9F, 0x1F, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x01,
  0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xFC, 0x07, 0xC3, 0xF0, 0xFE, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xF8,
  0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x0F, 0xC0,
  0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0x7E, 0x0F, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E,
  0x0F, 0x80, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF0,
  0x0F, 0x83, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0xC0,
  0x1F, 0x1F, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0,
  0x7C, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F,
  0xE0, 0xFF, 0x0F, 0xF0, 0x7B, 0x87, 0x78, 0x3D, 0xC3, 0xBC, 0x1E, 0xE3,
  0xFC, 0x0F, 0x71, 0xDE, 0x07, 0xB9, 0xEF, 0x07, 0xDC, 0xE7, 0x83, 0xEF,
  0xF7, 0xC1, 0xF7, 0xF3, 0xE0, 0xF1, 0xF9, 0xE0, 0x78, 0xF8, 0xF0, 0x3C,
  0x7C, 0x78, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07,
  0xC0, 0x0F, 0x83, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0xC0, 0xF0, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3C,
  0x0F, 0x00, 0x1E, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x1F, 0xC0,
  0x7C, 0x3F, 0x80, 0xF8, 0x7F, 0x01, 0xE0, 0xFF, 0x03, 0xC1, 0xFE, 0x07,
  0x83, 0xFC, 0x1F, 0x07, 0xF8, 0x3E, 0x1F, 0xF0, 0x7C, 0x3E, 0xF0, 0xF0,
  0x79, 0xE1, 0xE0, 0xF3, 0xC3, 0xC1, 0xE7, 0x8F, 0x83, 0xCF, 0x1F, 0x0F,
  0x8F, 0x3E, 0x1F, 0x1E, 0x7C, 0x3E, 0x3C, 0xF0, 0x7C, 0x79, 0xE0, 0xF0,
  0xF3, 0xC1, 0xE0, 0xE7, 0x87, 0xC1, 0xFF, 0x0F, 0x83, 0xFE, 0x1F, 0x07,
  0xF8, 0x3E, 0x0F, 0xF0, 0x78, 0x1F, 0xE0, 0xF0, 0x1F, 0xC1, 0xE0, 0x3F,
  0x87, 0xC0, 0x7F, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE0, 0xFC, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7C,
  0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF, 0x80,
  0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7,
  0xC0, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0xFC, 0x0F,
  0xC3, 0xF0, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0xF8, 0x1F, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x0F, 0x87, 0xC0,
  0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x03,
  0xE1, 0xF0, 0x1F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xC0, 0xFC, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x3E,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F,
  0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0,
  0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3,
  0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0xFC, 0x07, 0xC7, 0xF0, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0xF8, 0x1F, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0xF8, 0x07, 0xC1, 0xF0, 0x3F, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0xF8, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x83, 0xE0, 0x1F,
  0x0F, 0x80, 0x3F, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x03, 0xF0, 0xF8, 0x07, 0xC3,
  0xE0, 0x1F, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03,
  0xE1, 0xF8, 0x1F, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x7E,
  0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03,
  0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC3,
  0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xC0,
  0x1F, 0x1F, 0x00, 0xFC, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E,
  0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7C, 0x3F,
  0x03, 0xF0, 0x7E, 0x1F, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x7C,
  0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80,
  0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07,
  0xC1, 0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF0, 0x03, 0xEF, 0x80, 0x1F,
  0x7C, 0x00, 0xFB, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x1E, 0x0F,
  0x7C, 0x3E, 0x0F, 0x7C, 0x3E, 0x1F, 0x78, 0x3E, 0x1E, 0x78, 0x7E, 0x1E,
  0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x3C, 0x78, 0x6E, 0x3C, 0x78, 0xEE, 0x3C,
  0x78, 0xEE, 0x3C, 0x78, 0xEE, 0x78, 0x79, 0xCC, 0x78, 0x79, 0xCC, 0x78,
  0x79, 0xCC, 0x78, 0x79, 0x8C, 0xF0, 0x7B, 0x8C, 0xF0, 0x7B, 0x8C, 0xF0,
  0x73, 0x9C, 0xF0, 0xF3, 0x1D, 0xE0, 0xF7, 0x1D, 0xE0, 0xF7, 0x1D, 0xE0,
  0xF7, 0x1D, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x07, 0xC0,
  0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x03,
  0xF3, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0xF8, 0xF8, 0x00,
  0x7C, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0x7C, 0x03,
  0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x80,
  0x7C, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x7C, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x03,
  0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x3C,
  0x78, 0x0F, 0x8F, 0x81, 0xE0, 0xF0, 0x7C, 0x1E, 0x1F, 0x03, 0xE3, 0xE0,
  0x7C, 0xF8, 0x07, 0xBE, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xFC, 0x3E, 0x0F, 0x87, 0xC1,
  0xF8, 0x03, 0xF8, 0xF8, 0x3F, 0xEF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3,
  0xF8, 0x7F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7C,
  0x01, 0xF3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xFC, 0x0F, 0xC7, 0xF0, 0xFE,
  0x1F, 0xFF, 0xF0, 0xFF, 0xEF, 0x83, 0xFE, 0x78, 0x0F, 0xE7, 0xC0, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF3, 0xF8, 0x0F, 0x3F, 0xE0, 0xFB,
  0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0x87, 0xF1, 0xF8, 0x1F, 0x8F, 0x80, 0x7C,
  0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80,
  0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF8, 0x0F, 0x8F,
  0xC0, 0x7C, 0x7F, 0x0F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xF3, 0xFE,
  0x0F, 0x8F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x1F, 0x83, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x1F,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xFC, 0x07, 0xC7, 0xE1,
  0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xFE, 0x3E, 0x07, 0xFD, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xE1, 0xFC, 0x3E, 0x03, 0xF0, 0xF8,
  0x0F, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F,
  0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x0F,
  0x80, 0x7C, 0x3F, 0x03, 0xF0, 0xFE, 0x1F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF,
  0x7C, 0x0F, 0xF9, 0xE0, 0x1F, 0xCF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xFC,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0x03, 0xE3, 0xE0, 0x1F, 0x3E, 0x01,
  0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x07, 0xC7, 0xC0, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0xF8, 0x3F, 0xEF, 0x83, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE3, 0xF8, 0x7F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xCF, 0xC0,
  0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7,
  0xC0, 0x3E, 0x3E, 0x03, 0xF3, 0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFD, 0xF0, 0x3F, 0xCF, 0x80, 0x70, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF3, 0xF8, 0x0F, 0xBF, 0xE0, 0xFB, 0xFF, 0x87,
  0xFF, 0xFC, 0x3F, 0x87, 0xF1, 0xF8, 0x1F, 0x8F, 0x80, 0xFC, 0x7C, 0x07,
  0xE7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C,
  0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x8F, 0x80,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x3F, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x7C, 0x07,
  0xE0, 0xF8, 0x1F, 0x81, 0xF0, 0x7E, 0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xE0,
  0x0F, 0x8F, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x83, 0xE0,
  0x1F, 0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F,
  0x7C, 0x7C, 0x1F, 0xFD, 0xFC, 0x7B, 0xFF, 0xF8, 0xF8, 0xF9, 0xF1, 0xF1,
  0xE3, 0xE3, 0xC3, 0xC7, 0xC7, 0x87, 0x8F, 0x8F, 0x0E, 0x1E, 0x3E, 0x1C,
  0x3C, 0x7C, 0x78, 0x78, 0xF8, 0xF0, 0xF1, 0xE1, 0xE3, 0xE3, 0xC3, 0xC7,
  0xC7, 0x87, 0x0F, 0x9F, 0x0E, 0x1E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78,
  0xF0, 0xF1, 0xF1, 0xE1, 0xE3, 0xE3, 0xC3, 0x87, 0xC7, 0x87, 0x0F, 0x1F,
  0x1E, 0x1E, 0x00, 0x0F, 0x9F, 0xC0, 0x79, 0xFF, 0x07, 0xDF, 0xFC, 0x3F,
  0xFF, 0xE1, 0xFC, 0x3F, 0x8F, 0xC0, 0xFC, 0x7C, 0x07, 0xE3, 0xE0, 0x3F,
  0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0x00, 0xF9, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3,
  0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x03,
  0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F,
  0x87, 0xE3, 0xE0, 0x3F, 0x3E, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7,
  0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xFC, 0x07, 0xC7, 0xE1, 0xF8, 0x7F, 0xFF,
  0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xCF, 0xE0, 0x1E,
  0x7F, 0xC0, 0xFB, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x03,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xF0,
  0x0F, 0x8F, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xFE, 0x1F, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3E, 0xFF, 0x81, 0xF1, 0xFC, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0xF8, 0x3F, 0xEF, 0x83, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE3, 0xF8, 0x7F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xCF, 0x80,
  0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7,
  0xC0, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xFC, 0x0F,
  0xC7, 0xF0, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xEF, 0x83, 0xFE, 0xF8, 0x0F,
  0xE7, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x1F, 0xC0,
  0xFB, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xF8, 0x3F, 0x8F, 0x80,
  0xFC, 0xFC, 0x07, 0xE7, 0xC0, 0x3F, 0x3E, 0x01, 0xF9, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xF8, 0x1F, 0x8F, 0x80, 0x7C, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x1F, 0xF0, 0x1F, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x0F, 0xC3,
  0xF0, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0xF8, 0x00, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x07, 0xC7,
  0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F,
  0x81, 0xF0, 0x7C, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE3, 0xE0, 0x0F,
  0x1F, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xF8,
  0x3C, 0x1F, 0xF0, 0xF8, 0x7B, 0xE1, 0xF0, 0xF7, 0x83, 0xE1, 0xEF, 0x0F,
  0xC3, 0xDE, 0x1F, 0x8F, 0x3C, 0x37, 0x1E, 0x78, 0xEE, 0x3C, 0xF1, 0xDC,
  0xF1, 0xE3, 0x39, 0xE3, 0xCE, 0x73, 0xC7, 0x9C, 0xEF, 0x0F, 0x31, 0xDE,
  0x1E, 0xE3, 0xBC, 0x3D, 0xC7, 0x70, 0x7B, 0x8F, 0xE0, 0xF6, 0x1F, 0xC1,
  0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF0, 0x1F,
  0x83, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0xFC,
  0x03, 0xE1, 0xF8, 0x03, 0xE3, 0xF0, 0x01, 0xF3, 0xE0, 0x01, 0xF7, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xEF, 0x80,
  0x07, 0xEF, 0x80, 0x0F, 0xC7, 0xC0, 0x1F, 0x87, 0xC0, 0x1F, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x1F, 0x01, 0xF9,
  0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x7E, 0x03, 0xE3, 0xF0, 0x3F,
  0x0F, 0xC3, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xBE, 0x0F, 0xF9, 0xF0, 0x3F,
  0x8F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x83, 0xF0, 0x7C, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x03,
  0xCF, 0xFC, 0x1E, 0xFF, 0xE1, 0xF7, 0x9F, 0x8F, 0xFC, 0x7E, 0xFB, 0xC1,
  0xFF, 0xDE, 0x07, 0xFC, 0xF0, 0x3F, 0xC0, 0x00, 0x30, 0x00,
};

const GFXglyph JetBrainsMono_BoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 11, 29, 24, 7, -29 },
  { 41, 15, 12, 24, 7, -29 },
  { 64, 25, 29, 24, 0, -29 },
  { 155, 22, 41, 24, 1, -35 },
  { 268, 29, 29, 24, -2, -29 },
  { 374, 23, 30, 24, 0, -30 },
  { 461, 6, 12, 24, 11, -29 },
  { 470, 17, 39, 24, 6, -34 },
  { 553, 17, 39, 24, 2, -34 },
  { 636, 21, 21, 24, 2, -24 },
  { 692, 20, 19, 24, 2, -23 },
  { 740, 12, 12, 24, 3, -6 },
  { 758, 14, 5, 24, 5, -16 },
  { 767, 8, 7, 24, 7, -7 },
  { 774, 25, 37, 24, 0, -33 },
  { 890, 21, 30, 24, 2, -30 },
  { 969, 19, 29, 24, 2, -29 },
  { 1038, 22, 30, 24, 1, -30 },
  { 1121, 22, 29, 24, 1, -29 },
  { 1201, 20, 29, 24, 2, -29 },
  { 1274, 21, 29, 24, 2, -29 },
  { 1351, 21, 29, 24, 1, -29 },
  { 1428, 21, 29, 24, 4, -29 },
  { 1505, 22, 30, 24, 1, -30 },
  { 1588, 21, 30, 24, 3, -30 },
  { 1667, 10, 22, 24, 7, -22 },
  { 1695, 14, 28, 24, 3, -22 },
  { 1744, 20, 22, 24, 3, -24 },
  { 1799, 20, 14, 24, 2, -20 },
  { 1834, 20, 22, 24, 2, -24 },
  { 1889, 17, 29, 24, 5, -29 },
  { 1951, 25, 37, 24, 0, -30 },
  { 2067, 21, 29, 24, 0, -29 },
  { 2144, 22, 29, 24, 1, -29 },
  { 2224, 21, 30, 24, 2, -30 },
  { 2303, 22, 29, 24, 1, -29 },
  { 2383, 22, 29, 24, 2, -29 },
  { 2463, 23, 29, 24, 1, -29 },
  { 2547, 21, 30, 24, 2, -30 },
  { 2626, 23, 29, 24, 1, -29 },
  { 2710, 21, 29, 24, 2, -29 },
  { 2787, 23, 29, 24, 0, -29 },
  { 2871, 24, 29, 24, 1, -29 },
  { 2958, 18, 29, 24, 2, -29 },
  { 3024, 25, 29, 24, 0, -29 },
  { 3115, 23, 29, 24, 1, -29 },
  { 3199, 21, 30, 24, 2, -30 },
  { 3278, 23, 29, 24, 1, -29 },
  { 3362, 21, 37, 24, 2, -30 },
  { 3460, 23, 29, 24, 1, -29 },
  { 3544, 22, 30, 24, 1, -30 },
  { 3627, 21, 29, 24, 4, -29 },
  { 3704, 22, 29, 24, 2, -29 },
  { 3784, 21, 29, 24, 4, -29 },
  { 3861, 24, 29, 24, 2, -29 },
  { 3948, 26, 29, 24, -1, -29 },
  { 4043, 22, 29, 24, 4, -29 },
  { 4123, 22, 29, 24, 1, -29 },
  { 4203, 17, 37, 24, 5, -33 },
  { 4282, 13, 37, 24, 6, -33 },
  { 4343, 17, 37, 24, 3, -33 },
  { 4422, 19, 15, 24, 3, -29 },
  { 4458, 20, 5, 24, 0, 1 },
  { 4471, 9, 5, 24, 10, -31 },
  { 4477, 21, 22, 24, 2, -22 },
  { 4535, 21, 29, 24, 1, -29 },
  { 4612, 20, 22, 24, 2, -22 },
  { 4667, 22, 29, 24, 2, -29 },
  { 4747, 20, 22, 24, 2, -22 },
  { 4802, 27, 36, 24, -2, -29 },
  { 4924, 21, 29, 24, 2, -22 },
  { 5001, 21, 29, 24, 1, -29 },
  { 5078, 20, 31, 24, 1, -31 },
  { 5156, 22, 38, 24, 0, -31 },
  { 5261, 23, 29, 24, 1, -29 },
  { 5345, 18, 29, 24, 3, -29 },
  { 5411, 23, 22, 24, 0, -22 },
  { 5475, 21, 22, 24, 1, -22 },
  { 5533, 20, 22, 24, 2, -22 },
  { 5588, 22, 29, 24, 0, -22 },
  { 5668, 21, 29, 24, 2, -22 },
  { 5745, 21, 22, 24, 2, -22 },
  { 5803, 21, 22, 24, 1, -22 },
  { 5861, 20, 28, 24, 3, -28 },
  { 5931, 21, 22, 24, 2, -22 },
  { 5989, 21, 22, 24, 3, -22 },
  { 6047, 23, 22, 24, 2, -22 },
  { 6111, 24, 22, 24, 0, -22 },
  { 6177, 21, 29, 24, 2, -22 },
  { 6254, 21, 22, 24, 1, -22 },
  { 6312, 21, 37, 24, 3, -33 },
  { 6410, 11, 37, 24, 7, -33 },
  { 6461, 21, 37, 24, 1, -33 },
  { 6559, 21, 10, 24, 2, -19 },
};

const GFXfont JetBrainsMono_BoldItalic40pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic40pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _JETBRAINSMONO_BOLDITALIC40PT7B_H_
