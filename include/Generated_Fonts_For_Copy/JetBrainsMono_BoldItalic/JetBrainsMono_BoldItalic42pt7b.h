#ifndef _JETBRAINSMONO_BOLDITALIC42PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E,
  0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x00, 0x7E, 0x1F, 0x7C, 0x3F,
  0x7C, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xF8, 0x3E,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF0, 0x7C, 0xF0, 0x78, 0x00, 0x0E,
  0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x70, 0x3C, 0x00,
  0x3C, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x78,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x1E, 0x00,
  0x1E, 0x07, 0x80, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC2, 0x3C, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07,
  0x81, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x07, 0xEE, 0x7E, 0x0F, 0xCE, 0x3E, 0x0F, 0x8E, 0x3E, 0x0F, 0x8E, 0x00,
  0x0F, 0x8C, 0x00, 0x0F, 0x8C, 0x00, 0x0F, 0xCC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x39, 0xF8, 0x00, 0x38, 0xF8,
  0x00, 0x38, 0xF8, 0x00, 0x30, 0xF8, 0x7C, 0x30, 0xF8, 0x7C, 0x71, 0xF8,
  0x7E, 0x71, 0xF0, 0x7F, 0x77, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x3C, 0x07, 0xFC, 0x01, 0xE0, 0x3F, 0xF0, 0x07, 0x01,
  0xF3, 0xE0, 0x3C, 0x07, 0x87, 0x81, 0xE0, 0x1C, 0x1E, 0x0F, 0x00, 0x70,
  0x78, 0x78, 0x03, 0xC1, 0xE3, 0xC0, 0x0F, 0x07, 0x1E, 0x00, 0x3C, 0x3C,
  0x70, 0x00, 0xF0, 0xF3, 0xC0, 0x03, 0xFF, 0x9E, 0x00, 0x07, 0xFC, 0xF0,
  0x00, 0x0F, 0xE7, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xEF, 0xF8, 0x00,
  0x0F, 0x7F, 0xF0, 0x00, 0x79, 0xE7, 0xC0, 0x03, 0xCF, 0x0F, 0x00, 0x1E,
  0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0xF0, 0x03, 0xC3, 0x83, 0xC0, 0x1E, 0x0E,
  0x0F, 0x00, 0xF0, 0x78, 0x3C, 0x07, 0x81, 0xF1, 0xE0, 0x3C, 0x03, 0xFF,
  0x81, 0xE0, 0x0F, 0xFC, 0x0F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xF8, 0xFC,
  0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x1F,
  0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1F, 0x7C, 0x3E, 0x1F, 0xF8,
  0x7C, 0x0F, 0xF8, 0x7C, 0x0F, 0xF0, 0x7C, 0x07, 0xE0, 0x7C, 0x07, 0xE0,
  0x7C, 0x07, 0xE0, 0x7E, 0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFE, 0xF8,
  0x3F, 0xFC, 0xF8, 0x0F, 0xF0, 0x7C, 0x3E, 0x7D, 0xFB, 0xF7, 0xEF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xE7, 0xCF, 0x80, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x03, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x0C,
  0x0F, 0x03, 0x3E, 0x1C, 0x3E, 0x7F, 0x39, 0xFD, 0xFF, 0x77, 0xF9, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xF7,
  0x80, 0x03, 0xEF, 0x80, 0x0F, 0x9F, 0x00, 0x3F, 0x1F, 0x00, 0xFC, 0x3F,
  0x03, 0xF0, 0x7E, 0x03, 0xC0, 0x78, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E,
  0x3F, 0x9F, 0xDF, 0xEF, 0xF7, 0xF1, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x07,
  0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF,
  0x80, 0x1F, 0x3E, 0x00, 0xF8, 0xF9, 0xE3, 0xE3, 0xE7, 0xCF, 0x9F, 0x3F,
  0x3E, 0x7C, 0xFC, 0xF9, 0xF1, 0xE3, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x01, 0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xFC,
  0x03, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x80, 0xFE, 0xF8, 0x0F, 0xCF,
  0x81, 0xF1, 0xF8, 0x1E, 0x1F, 0x81, 0x81, 0xF0, 0x10, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x3F,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x3E, 0x00,
  0xF8, 0xF8, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xE0, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x7E, 0x07,
  0xC3, 0xF0, 0x3E, 0x3F, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x00, 0xFC, 0xF8,
  0x07, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xCF, 0xE0, 0x1F, 0x7F, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFF,
  0x0F, 0xE1, 0xFC, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xE1, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0xF0, 0x0F, 0xDF, 0xE0, 0x7F, 0xFF,
  0x87, 0xFF, 0xFE, 0x7F, 0x87, 0xF3, 0xF0, 0x1F, 0xDF, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00, 0x3E,
  0xF8, 0x03, 0xF7, 0xE0, 0x3F, 0x3F, 0x83, 0xF8, 0xFF, 0xFF, 0x83, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xF0, 0x03, 0xE7,
  0xC0, 0x1F, 0x3F, 0x00, 0xFC, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0x9F, 0xE0,
  0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x1F,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7E, 0x07, 0xC0, 0x7E, 0x3F, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xDF,
  0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xFC, 0x07, 0xE1,
  0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xFC, 0x1F, 0xE7, 0xF8, 0xFC, 0x07, 0xE3, 0xE0, 0x0F, 0x9F, 0x80,
  0x3E, 0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E,
  0x7C, 0x01, 0xF9, 0xF8, 0x0F, 0xC7, 0xF0, 0x7F, 0x1F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0x7F, 0xDF, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0x01, 0xF8, 0x3F, 0x8F, 0xF1, 0xFE,
  0x3F, 0x83, 0xE0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0xFC, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F,
  0xC3, 0xF0, 0x00, 0x20, 0x07, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xE0, 0x1F, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x7E, 0x03,
  0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0,
  0x18, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x03, 0xF0, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x3E, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xE0, 0x08, 0x78, 0x78,
  0x1F, 0xDE, 0x3E, 0x0F, 0xF7, 0x8F, 0x87, 0xFF, 0xE3, 0xE1, 0xE0, 0xF8,
  0xF0, 0xF8, 0x3E, 0x3C, 0x3C, 0x0F, 0x0F, 0x0F, 0x03, 0xC7, 0xC3, 0xC0,
  0xF1, 0xF0, 0xF0, 0x3C, 0x7C, 0x7C, 0x1F, 0x1E, 0x1F, 0x07, 0xC7, 0x87,
  0x81, 0xF1, 0xE1, 0xE0, 0x78, 0x78, 0x7C, 0x3E, 0x3E, 0x1F, 0xFF, 0x8F,
  0x83, 0xFD, 0xE3, 0xC0, 0xFE, 0x78, 0xF0, 0x06, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F,
  0x00, 0x3E, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3F, 0x0F, 0x00,
  0xF8, 0x3C, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0x9F, 0x80, 0x3F, 0x7C,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F,
  0xC0, 0x7E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0xFC, 0x1F, 0x01, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F,
  0x03, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x3E,
  0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7C,
  0x03, 0xF0, 0x7C, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xF8, 0x1F, 0x87, 0xE0,
  0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x7C, 0x7E,
  0x01, 0xF8, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC1, 0xF8, 0x3F, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0xFC, 0x03, 0xF1, 0xF0, 0x07,
  0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87,
  0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF0, 0xF8,
  0x0F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE1, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xF8, 0x1F, 0x87, 0xE0,
  0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x0F, 0xFC, 0x7E, 0x3F, 0xF8, 0xFC, 0x7F, 0xF1, 0xF0, 0xFF, 0xE3,
  0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7E,
  0x01, 0xF8, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x7E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F,
  0x80, 0x7C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E,
  0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x7E,
  0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C,
  0x03, 0xF0, 0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01,
  0xF0, 0x7E, 0x03, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xC0, 0x0F, 0xC1, 0xF0,
  0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF8,
  0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x3F, 0x00,
  0x3E, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F,
  0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF0,
  0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0x70, 0x3F, 0x81, 0xDC,
  0x1F, 0xE0, 0xF7, 0x07, 0x78, 0x3D, 0xE3, 0xDE, 0x0F, 0x78, 0xEF, 0x83,
  0xDE, 0x7B, 0xC0, 0xF3, 0x9E, 0xF0, 0x3C, 0xEF, 0x3C, 0x1F, 0x3B, 0xDF,
  0x07, 0xCE, 0xE7, 0xC1, 0xF3, 0xF9, 0xF0, 0x7C, 0xFC, 0x78, 0x1F, 0x3F,
  0x1E, 0x07, 0x8F, 0x8F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0,
  0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x80, 0x07,
  0xE0, 0x1F, 0x07, 0xF0, 0x1F, 0x07, 0xF0, 0x1F, 0x07, 0xF0, 0x1F, 0x0F,
  0xF0, 0x1F, 0x0F, 0xF0, 0x1E, 0x0F, 0xF8, 0x3E, 0x0F, 0x78, 0x3E, 0x0F,
  0x78, 0x3E, 0x0F, 0x78, 0x3E, 0x1F, 0x78, 0x3E, 0x1F, 0x78, 0x3C, 0x1F,
  0x3C, 0x7C, 0x1F, 0x3C, 0x7C, 0x1F, 0x3C, 0x7C, 0x1E, 0x3C, 0x7C, 0x3E,
  0x3C, 0x7C, 0x3E, 0x3E, 0x78, 0x3E, 0x1E, 0x78, 0x3E, 0x1E, 0x78, 0x3E,
  0x1E, 0xF8, 0x3C, 0x1E, 0xF8, 0x3C, 0x1F, 0xF8, 0x7C, 0x0F, 0xF8, 0x7C,
  0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x78,
  0x07, 0xF0, 0xF8, 0x07, 0xF0, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0x03,
  0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xF3,
  0xF0, 0x0F, 0xCF, 0xC0, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0,
  0x0F, 0x8F, 0x80, 0x3E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0xC0, 0x3F, 0x3F,
  0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x87, 0xF1, 0xFC, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0xFC, 0x01, 0xF3, 0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0x7E, 0x01, 0xF9, 0xF0, 0x07,
  0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xCF,
  0xC0, 0x1F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x87, 0xF1,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F,
  0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F,
  0x80, 0x7E, 0x1F, 0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3E, 0x1F, 0x80, 0x3E,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x7E,
  0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C,
  0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07,
  0xE0, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7E,
  0x01, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F,
  0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8,
  0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0xFC, 0x03, 0xE1, 0xF0,
  0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00,
  0xFC, 0x7E, 0x01, 0xF0, 0xFC, 0x03, 0xE0, 0xF8, 0x0F, 0xC1, 0xFC, 0x7F,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x07,
  0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8,
  0x7C, 0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E,
  0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3,
  0xC0, 0x07, 0xCF, 0x80, 0x07, 0x9F, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3C, 0x1F, 0x07, 0xCF, 0x07,
  0xC1, 0xE3, 0xC1, 0xF0, 0x78, 0xF0, 0xFC, 0x3E, 0x7C, 0x3F, 0x0F, 0x1F,
  0x0F, 0xC3, 0xC7, 0xC3, 0x70, 0xF1, 0xF1, 0xDC, 0x7C, 0x7C, 0x77, 0x1E,
  0x1E, 0x1D, 0x87, 0x87, 0x86, 0x61, 0xE1, 0xE3, 0x98, 0xF8, 0x78, 0xEE,
  0x3C, 0x1E, 0x3B, 0x8F, 0x07, 0x9C, 0xE3, 0xC1, 0xE7, 0x39, 0xF0, 0x79,
  0xCE, 0x78, 0x1E, 0x73, 0x9E, 0x07, 0xB8, 0xE7, 0x81, 0xEE, 0x3B, 0xC0,
  0x7B, 0x8E, 0xF0, 0x3E, 0xC3, 0xBC, 0x0F, 0xF0, 0xEF, 0x03, 0xDC, 0x3F,
  0x80, 0xF7, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8,
  0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x00,
  0x03, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x1F,
  0x00, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x3E,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xF3, 0xE0, 0x07,
  0xC7, 0xE0, 0x1F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xF0,
  0x3F, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xFC, 0xF8, 0x00,
  0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x81, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xE7,
  0x80, 0x3E, 0x78, 0x07, 0xC7, 0x80, 0x78, 0x7C, 0x0F, 0x87, 0xC1, 0xF0,
  0x3C, 0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x1E, 0xF8,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x00, 0xFC, 0x3F, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x00,
  0x20, 0x00, 0x07, 0xF3, 0xF0, 0x7F, 0xEF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x7E, 0x0F, 0xE3, 0xF0, 0x1F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF9,
  0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0,
  0x07, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0xFC, 0x03, 0xE3, 0xF0, 0x0F,
  0x8F, 0xC0, 0x7E, 0x3F, 0x87, 0xF8, 0x7F, 0xFB, 0xE1, 0xFF, 0xFF, 0x83,
  0xFF, 0x7C, 0x07, 0xF1, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x40, 0x0F, 0x8F, 0xE0, 0x3E, 0xFF, 0xC0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x1F, 0xE1, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0,
  0x3F, 0x1F, 0x00, 0xFC, 0x7C, 0x03, 0xF3, 0xF0, 0x0F, 0x8F, 0x80, 0x3E,
  0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7C, 0x7E,
  0x01, 0xF1, 0xF8, 0x0F, 0xC7, 0xF8, 0x7E, 0x1F, 0xFF, 0xF8, 0x7D, 0xFF,
  0xC1, 0xF7, 0xFE, 0x0F, 0xCF, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xE1, 0xFC, 0xFC,
  0x07, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0x3F, 0x01, 0xF8, 0xFE, 0x1F, 0xC7,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x10, 0x3E, 0x01, 0xFC, 0xFC,
  0x0F, 0xFD, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xF8, 0x3F, 0x87,
  0xE0, 0x3F, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0xFC,
  0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80,
  0x7E, 0x1F, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF8, 0x0F,
  0xC3, 0xF8, 0x7F, 0x83, 0xFF, 0xDF, 0x07, 0xFF, 0xFE, 0x07, 0xFE, 0xF8,
  0x07, 0xF1, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xC0, 0xF8, 0xFC, 0x07, 0xE7, 0xC0,
  0x1F, 0x3E, 0x00, 0xFB, 0xF0, 0x07, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0xF8, 0xFC, 0x0F, 0x87, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x07, 0xF3, 0xF0, 0x7F, 0xEF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7E, 0x0F, 0xE3, 0xF0, 0x1F, 0x8F, 0x80, 0x7E, 0x3E, 0x01,
  0xF9, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1,
  0xF0, 0x07, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0x7C, 0x07, 0xE1, 0xF8,
  0x3F, 0x87, 0xFF, 0xFE, 0x1F, 0xFE, 0xF8, 0x3F, 0xF3, 0xE0, 0x7F, 0x9F,
  0x80, 0x70, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x40, 0x0F, 0x9F, 0xE0, 0x3E, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x1F, 0xE1, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F,
  0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E,
  0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7C, 0x7E, 0x01,
  0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0x7C, 0x03, 0xF1,
  0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x7E, 0x3E, 0x01, 0xF8,
  0x7C, 0x07, 0xE0, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F,
  0x83, 0xF0, 0x1F, 0x0F, 0xE0, 0x3E, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0x87, 0xE0, 0x1F, 0x0F,
  0xC0, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x3F,
  0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xFC, 0x3E, 0x00, 0xFC,
  0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00,
  0x08, 0x08, 0x0F, 0x3E, 0x7E, 0x0F, 0x7E, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F,
  0x9F, 0x9F, 0x1F, 0x0F, 0x1F, 0x1F, 0x0E, 0x1F, 0x1F, 0x1E, 0x1F, 0x1E,
  0x1E, 0x1F, 0x1E, 0x1E, 0x1F, 0x3E, 0x1E, 0x1E, 0x3E, 0x1E, 0x1E, 0x3E,
  0x1C, 0x3E, 0x3E, 0x1C, 0x3E, 0x3C, 0x3C, 0x3E, 0x3C, 0x3C, 0x3E, 0x3C,
  0x3C, 0x3C, 0x7C, 0x3C, 0x3C, 0x7C, 0x3C, 0x7C, 0x7C, 0x38, 0x7C, 0x7C,
  0x78, 0x7C, 0x78, 0x78, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0x78, 0x78, 0x00,
  0x01, 0x00, 0x3E, 0x7F, 0x80, 0xFB, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x7F, 0x87, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x00, 0xFC,
  0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3E, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF1, 0xF8, 0x07,
  0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0xC7,
  0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0x00, 0x08, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xE1, 0xF8, 0xFC, 0x07, 0xE7,
  0xC0, 0x3F, 0x3E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7C, 0xF8, 0x03,
  0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x7E, 0xFC,
  0x03, 0xE7, 0xE0, 0x1F, 0x3F, 0x01, 0xF8, 0xFE, 0x3F, 0x87, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x80, 0x0F,
  0x8F, 0xE0, 0x1F, 0x7F, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFE,
  0x1F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0x80, 0x7E, 0x1F, 0x00,
  0xFC, 0x3E, 0x01, 0xF8, 0xFC, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F,
  0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x7E, 0x01, 0xF0,
  0xFE, 0x07, 0xE1, 0xFE, 0x1F, 0x83, 0xFF, 0xFF, 0x07, 0xDF, 0xFC, 0x0F,
  0xBF, 0xF0, 0x3F, 0x3F, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xF1, 0xF0, 0x7F, 0xEF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7E, 0x0F, 0xE3, 0xF0, 0x1F, 0x8F,
  0x80, 0x7E, 0x3E, 0x01, 0xF9, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x00,
  0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3F, 0x3F, 0x00, 0xF8,
  0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x87, 0xF8, 0x7F,
  0xFB, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0x7C, 0x07, 0xF9, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x01, 0x00, 0x3E,
  0x7F, 0x81, 0xF3, 0xFF, 0x07, 0xDF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0x07,
  0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0xFC, 0x03, 0xF3,
  0xF0, 0x0F, 0xCF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x8F, 0x80, 0xFC, 0xF8, 0x03, 0xE7, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xBE, 0x00, 0xF9, 0xF8, 0x0F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00,
  0xFC, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF9, 0xF8,
  0x07, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F,
  0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x87,
  0xF1, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7D, 0xF0, 0x07,
  0xEF, 0x80, 0x3E, 0x7E, 0x03, 0xF1, 0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x7C,
  0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0xFC, 0x3E, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x01, 0xF7,
  0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x00, 0xF0, 0x78, 0x1F, 0xE0, 0xF0, 0x7F, 0xC3, 0xE0, 0xF7,
  0x87, 0xC1, 0xEF, 0x0F, 0x83, 0xDE, 0x1B, 0x0F, 0x3C, 0x76, 0x1E, 0x78,
  0xEC, 0x3C, 0xF1, 0x98, 0xF1, 0xE7, 0x31, 0xE3, 0xCE, 0x63, 0xC7, 0x98,
  0xCF, 0x8F, 0x71, 0x9E, 0x1E, 0xE3, 0x3C, 0x3D, 0xC6, 0x78, 0x7F, 0x0D,
  0xE0, 0xFE, 0x1B, 0xC1, 0xDC, 0x37, 0x83, 0xB0, 0x7E, 0x07, 0xE0, 0xFC,
  0x0F, 0xC3, 0xF8, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x3F, 0x83, 0xE0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x0F, 0x9F, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xEF, 0x80,
  0x07, 0xE7, 0xC0, 0x07, 0xE3, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x1F, 0x00,
  0xFC, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF8,
  0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xF1, 0xF0, 0x0F,
  0xC7, 0xC0, 0x3E, 0x1F, 0x81, 0xF8, 0x7F, 0x1F, 0xE1, 0xFF, 0xEF, 0x87,
  0xFF, 0xBE, 0x0F, 0xFD, 0xF8, 0x1F, 0xC7, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x20, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07,
  0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x7F, 0x80, 0xF3, 0xFF, 0x03, 0xDF, 0xFE, 0x1F,
  0x7F, 0xF8, 0x7D, 0xE1, 0xF1, 0xEF, 0x87, 0xFF, 0xBE, 0x0F, 0xFC, 0xF8,
  0x1F, 0xF0, 0x00, 0x3F, 0x00,
};

const GFXglyph JetBrainsMono_BoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 11, 31, 25, 7, -31 },
  { 44, 16, 13, 25, 7, -31 },
  { 70, 26, 31, 25, 0, -31 },
  { 171, 24, 43, 25, 1, -37 },
  { 300, 30, 31, 25, -2, -31 },
  { 417, 24, 31, 25, 0, -31 },
  { 510, 7, 13, 25, 11, -31 },
  { 522, 18, 40, 25, 6, -35 },
  { 612, 18, 40, 25, 2, -35 },
  { 702, 23, 22, 25, 2, -26 },
  { 766, 21, 20, 25, 2, -24 },
  { 819, 13, 13, 25, 3, -6 },
  { 841, 15, 5, 25, 5, -16 },
  { 851, 9, 7, 25, 7, -7 },
  { 859, 26, 40, 25, 0, -35 },
  { 989, 22, 31, 25, 2, -31 },
  { 1075, 20, 31, 25, 2, -31 },
  { 1153, 23, 31, 25, 1, -31 },
  { 1243, 22, 31, 25, 2, -31 },
  { 1329, 21, 31, 25, 2, -31 },
  { 1411, 22, 31, 25, 2, -31 },
  { 1497, 21, 31, 25, 2, -31 },
  { 1579, 22, 31, 25, 4, -31 },
  { 1665, 23, 31, 25, 1, -31 },
  { 1755, 22, 31, 25, 3, -31 },
  { 1841, 11, 24, 25, 7, -24 },
  { 1874, 14, 31, 25, 4, -24 },
  { 1929, 21, 23, 25, 3, -25 },
  { 1990, 20, 15, 25, 3, -21 },
  { 2028, 21, 23, 25, 2, -25 },
  { 2089, 18, 31, 25, 5, -31 },
  { 2159, 26, 39, 25, 0, -31 },
  { 2286, 22, 31, 25, 0, -31 },
  { 2372, 24, 31, 25, 1, -31 },
  { 2465, 23, 31, 25, 2, -31 },
  { 2555, 23, 31, 25, 1, -31 },
  { 2645, 23, 31, 25, 2, -31 },
  { 2735, 23, 31, 25, 2, -31 },
  { 2825, 23, 31, 25, 2, -31 },
  { 2915, 24, 31, 25, 1, -31 },
  { 3008, 22, 31, 25, 2, -31 },
  { 3094, 24, 31, 25, 0, -31 },
  { 3187, 26, 31, 25, 1, -31 },
  { 3288, 20, 31, 25, 2, -31 },
  { 3366, 26, 31, 25, 0, -31 },
  { 3467, 24, 31, 25, 1, -31 },
  { 3560, 22, 31, 25, 2, -31 },
  { 3646, 25, 31, 25, 1, -31 },
  { 3743, 22, 39, 25, 2, -31 },
  { 3851, 24, 31, 25, 1, -31 },
  { 3944, 24, 31, 25, 1, -31 },
  { 4037, 22, 31, 25, 4, -31 },
  { 4123, 23, 31, 25, 2, -31 },
  { 4213, 23, 31, 25, 4, -31 },
  { 4303, 26, 31, 25, 2, -31 },
  { 4404, 28, 31, 25, -1, -31 },
  { 4513, 23, 31, 25, 4, -31 },
  { 4603, 22, 31, 25, 2, -31 },
  { 4689, 18, 40, 25, 5, -35 },
  { 4779, 14, 40, 25, 6, -35 },
  { 4849, 18, 40, 25, 3, -35 },
  { 4939, 20, 17, 25, 3, -31 },
  { 4982, 21, 5, 25, 0, 1 },
  { 4996, 9, 6, 25, 10, -33 },
  { 5003, 22, 24, 25, 2, -24 },
  { 5069, 22, 31, 25, 1, -31 },
  { 5155, 21, 24, 25, 2, -24 },
  { 5218, 23, 31, 25, 2, -31 },
  { 5308, 21, 24, 25, 2, -24 },
  { 5371, 28, 39, 25, -2, -31 },
  { 5508, 22, 32, 25, 2, -24 },
  { 5596, 22, 31, 25, 1, -31 },
  { 5682, 21, 33, 25, 1, -33 },
  { 5769, 23, 41, 25, 0, -33 },
  { 5887, 23, 31, 25, 2, -31 },
  { 5977, 18, 31, 25, 4, -31 },
  { 6047, 24, 24, 25, 0, -24 },
  { 6119, 22, 24, 25, 1, -24 },
  { 6185, 21, 24, 25, 2, -24 },
  { 6248, 23, 32, 25, 0, -24 },
  { 6340, 22, 32, 25, 2, -24 },
  { 6428, 22, 24, 25, 2, -24 },
  { 6494, 21, 24, 25, 2, -24 },
  { 6557, 21, 29, 25, 3, -29 },
  { 6634, 22, 23, 25, 2, -23 },
  { 6698, 21, 23, 25, 4, -23 },
  { 6759, 23, 23, 25, 3, -23 },
  { 6826, 25, 23, 25, 0, -23 },
  { 6898, 22, 31, 25, 2, -23 },
  { 6984, 22, 23, 25, 1, -23 },
  { 7048, 23, 40, 25, 3, -35 },
  { 7163, 12, 40, 25, 7, -35 },
  { 7223, 22, 40, 25, 1, -35 },
  { 7333, 22, 10, 25, 2, -20 },
};

const GFXfont JetBrainsMono_BoldItalic42pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic42pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _JETBRAINSMONO_BOLDITALIC42PT7B_H_
