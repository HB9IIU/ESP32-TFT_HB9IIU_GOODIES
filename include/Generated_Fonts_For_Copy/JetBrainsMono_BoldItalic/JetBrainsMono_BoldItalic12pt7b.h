#ifndef _JETBRAINSMONO_BOLDITALIC12PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0xB4, 0x82, 0xC0, 0xDE, 0xA5, 0x20, 0x12, 0x25, 0xF9, 0x22,
  0x45, 0x3F, 0x24, 0xD0, 0x08, 0x38, 0xFB, 0x77, 0x07, 0x87, 0x0A, 0x5C,
  0xF0, 0x81, 0x00, 0x18, 0x94, 0x8A, 0x87, 0x80, 0x80, 0xF8, 0x74, 0x52,
  0xCE, 0x00, 0x1C, 0x68, 0x81, 0x07, 0x0A, 0xF7, 0x66, 0x74, 0x7F, 0x19,
  0x98, 0x8C, 0x63, 0x10, 0xC6, 0x18, 0x20, 0x61, 0x84, 0x31, 0x88, 0x42,
  0x33, 0x31, 0x00, 0x32, 0x9D, 0xCC, 0x52, 0x60, 0x30, 0xCF, 0xFF, 0x21,
  0x80, 0x6D, 0x60, 0xFF, 0xF0, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10,
  0x30, 0x60, 0x60, 0xC0, 0x39, 0xBC, 0xF3, 0xBE, 0x28, 0xA6, 0xF0, 0x1C,
  0xE6, 0x82, 0x18, 0x61, 0x84, 0xFC, 0x1C, 0x6D, 0x98, 0x30, 0xC3, 0x0C,
  0x30, 0xFC, 0x3E, 0x7C, 0x30, 0xC1, 0xC0, 0x81, 0x26, 0x78, 0x0C, 0x63,
  0x18, 0xCA, 0x2F, 0x86, 0x18, 0x7D, 0xF4, 0x3E, 0xD8, 0x20, 0xA6, 0xF0,
  0x0C, 0x30, 0x41, 0x07, 0xC8, 0x91, 0x26, 0x78, 0x7F, 0xFC, 0xC2, 0x18,
  0xC2, 0x18, 0xC0, 0x1C, 0x6D, 0x99, 0x21, 0x8D, 0x91, 0x26, 0x78, 0x39,
  0xBC, 0x73, 0xF9, 0xE3, 0x08, 0xE0, 0x6C, 0x01, 0xB0, 0x33, 0x00, 0x07,
  0x64, 0xC0, 0x0C, 0xEE, 0x30, 0x70, 0x60, 0xFC, 0x00, 0x3E, 0x60, 0x70,
  0x38, 0x63, 0x98, 0x00, 0xE7, 0x86, 0x2F, 0x60, 0x10, 0xC0, 0x1C, 0x45,
  0x0A, 0x75, 0x3A, 0x75, 0xCF, 0x81, 0x81, 0xC0, 0x18, 0x71, 0xCF, 0x2D,
  0x97, 0xD1, 0xC4, 0x3C, 0x5D, 0x9B, 0x27, 0x88, 0x91, 0x26, 0xF8, 0x39,
  0xBC, 0xF0, 0xC2, 0x08, 0x26, 0xF0, 0x3C, 0x7D, 0x9B, 0x36, 0x68, 0x91,
  0x26, 0xF8, 0x7D, 0xF4, 0x30, 0xFB, 0x08, 0x20, 0xF8, 0x3E, 0x7D, 0x83,
  0x07, 0xC8, 0x10, 0x20, 0xC0, 0x39, 0xBC, 0xF0, 0xDE, 0xE8, 0xA6, 0xF0,
  0x22, 0x4D, 0x9B, 0x37, 0xC8, 0x91, 0x26, 0xCC, 0x7D, 0xF3, 0x0C, 0x30,
  0x82, 0x08, 0xF8, 0x1E, 0x3C, 0x18, 0x20, 0x40, 0xB3, 0x66, 0x78, 0x23,
  0x26, 0x64, 0x6C, 0x78, 0x48, 0x4C, 0x4C, 0xC4, 0x62, 0x10, 0x8C, 0x63,
  0x10, 0xF8, 0x66, 0xCD, 0x5A, 0xD5, 0xE8, 0xD1, 0x62, 0xC4, 0x32, 0x65,
  0xDB, 0xB5, 0x6B, 0x93, 0x26, 0xCC, 0x39, 0xBC, 0xF3, 0xCE, 0x28, 0xA6,
  0xF0, 0x3C, 0x7D, 0x8B, 0x37, 0xCF, 0x10, 0x20, 0xC0, 0x39, 0xBC, 0xF3,
  0xCE, 0x28, 0xA6, 0xF0, 0xC1, 0x80, 0x3C, 0x7D, 0x8B, 0x37, 0xCF, 0x12,
  0x26, 0xCC, 0x1C, 0x6D, 0x9B, 0x03, 0xC1, 0x81, 0x26, 0x78, 0xFF, 0xF8,
  0xC1, 0x83, 0x04, 0x08, 0x10, 0x60, 0x45, 0x3C, 0xF3, 0xCE, 0x28, 0xA6,
  0xF0, 0xC7, 0x8B, 0x32, 0x45, 0x8A, 0x14, 0x38, 0x60, 0x93, 0x6E, 0xD5,
  0xAB, 0x5B, 0x36, 0x6C, 0x98, 0x63, 0x26, 0x3C, 0x18, 0x18, 0x38, 0x28,
  0x6C, 0xC4, 0xC6, 0x99, 0x23, 0xC7, 0x06, 0x08, 0x10, 0x60, 0x3E, 0x7C,
  0x30, 0x41, 0x86, 0x18, 0x20, 0xFC, 0x3C, 0xC2, 0x08, 0x21, 0x86, 0x18,
  0x41, 0x0F, 0x00, 0x8C, 0xC4, 0x44, 0x66, 0x22, 0x30, 0x3A, 0xC6, 0x21,
  0x08, 0x46, 0x31, 0xB8, 0x10, 0xE6, 0x92, 0xCC, 0xFF, 0xF0, 0xE0, 0x3F,
  0xFC, 0xA2, 0x8A, 0x6F, 0x80, 0x20, 0x41, 0xB3, 0xE6, 0x68, 0x91, 0x26,
  0xF8, 0x31, 0xEC, 0xE0, 0x82, 0x6F, 0x00, 0x04, 0x33, 0xFF, 0xCA, 0x28,
  0xA6, 0xF8, 0x31, 0x6C, 0xFE, 0x82, 0x6F, 0x00, 0x07, 0x87, 0x82, 0x07,
  0xE0, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x3C, 0x00, 0x3F, 0xFC, 0xA2,
  0x8B, 0xE5, 0x86, 0xF0, 0x20, 0x41, 0xB3, 0xE6, 0x68, 0x91, 0x22, 0xCC,
  0x0C, 0x03, 0x9E, 0x18, 0x61, 0x04, 0xFC, 0x06, 0x00, 0xF1, 0xE0, 0xC1,
  0x82, 0x04, 0x08, 0x33, 0xC0, 0x20, 0x41, 0x9B, 0x26, 0xCF, 0x12, 0x26,
  0xCC, 0xF7, 0x88, 0x42, 0x31, 0x8C, 0x38, 0x54, 0xFD, 0x5A, 0xBD, 0x5A,
  0xB5, 0x00, 0x6C, 0xF9, 0x9A, 0x24, 0x48, 0xB3, 0x00, 0x31, 0xEC, 0xE2,
  0x8A, 0x6F, 0x00, 0x6C, 0xF9, 0x9A, 0x24, 0x49, 0xBE, 0x60, 0xC0, 0x3F,
  0xFC, 0xA2, 0x8A, 0x6F, 0x86, 0x18, 0x5B, 0xFC, 0xF0, 0xC2, 0x08, 0x00,
  0x1C, 0xFD, 0x83, 0xE0, 0x48, 0x9E, 0x00, 0x33, 0xFF, 0xD8, 0x61, 0x86,
  0x1E, 0xCF, 0x3C, 0xA2, 0x8A, 0x6F, 0x00, 0xC7, 0x3C, 0x96, 0x51, 0xC6,
  0x00, 0xB6, 0xDB, 0x77, 0xDB, 0x69, 0x80, 0x66, 0x48, 0xE0, 0xC3, 0x8D,
  0x33, 0x00, 0xCF, 0x3C, 0xA2, 0x8B, 0xE5, 0x86, 0xF0, 0x3E, 0xF8, 0x30,
  0xC3, 0x0C, 0x3F, 0x00, 0x0C, 0x61, 0x04, 0x13, 0x83, 0x0C, 0x20, 0x83,
  0x80, 0x24, 0xB6, 0xD2, 0x5B, 0x00, 0x30, 0x30, 0x60, 0x81, 0x03, 0xCC,
  0x18, 0x30, 0x63, 0x80, 0x43, 0x9B, 0x80,
};

const GFXglyph JetBrainsMono_BoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 9, 7, 2, -9 },
  { 5, 5, 4, 7, 2, -9 },
  { 8, 7, 9, 7, 0, -9 },
  { 16, 7, 12, 7, 0, -10 },
  { 27, 9, 9, 7, -1, -9 },
  { 38, 7, 9, 7, 0, -9 },
  { 46, 2, 4, 7, 3, -9 },
  { 47, 5, 12, 7, 2, -10 },
  { 55, 5, 12, 7, 1, -10 },
  { 63, 6, 6, 7, 1, -7 },
  { 68, 6, 6, 7, 1, -7 },
  { 73, 3, 4, 7, 1, -2 },
  { 75, 4, 2, 7, 2, -5 },
  { 76, 2, 2, 7, 2, -2 },
  { 77, 8, 11, 7, 0, -10 },
  { 88, 6, 9, 7, 1, -9 },
  { 95, 6, 9, 7, 0, -9 },
  { 102, 7, 9, 7, 0, -9 },
  { 110, 7, 9, 7, 0, -9 },
  { 118, 6, 9, 7, 1, -9 },
  { 125, 6, 9, 7, 1, -9 },
  { 132, 7, 9, 7, 0, -9 },
  { 140, 6, 9, 7, 1, -9 },
  { 147, 7, 9, 7, 0, -9 },
  { 155, 6, 9, 7, 1, -9 },
  { 162, 3, 7, 7, 2, -7 },
  { 165, 4, 9, 7, 1, -7 },
  { 170, 6, 6, 7, 1, -7 },
  { 175, 6, 4, 7, 1, -6 },
  { 178, 7, 6, 7, 0, -7 },
  { 184, 5, 9, 7, 2, -9 },
  { 190, 7, 11, 7, 0, -9 },
  { 200, 6, 9, 7, 0, -9 },
  { 207, 7, 9, 7, 0, -9 },
  { 215, 6, 9, 7, 1, -9 },
  { 222, 7, 9, 7, 0, -9 },
  { 230, 6, 9, 7, 1, -9 },
  { 237, 7, 9, 7, 0, -9 },
  { 245, 6, 9, 7, 1, -9 },
  { 252, 7, 9, 7, 0, -9 },
  { 260, 6, 9, 7, 1, -9 },
  { 267, 7, 9, 7, 0, -9 },
  { 275, 8, 9, 7, 0, -9 },
  { 284, 5, 9, 7, 1, -9 },
  { 290, 7, 9, 7, 0, -9 },
  { 298, 7, 9, 7, 0, -9 },
  { 306, 6, 9, 7, 1, -9 },
  { 313, 7, 9, 7, 0, -9 },
  { 321, 6, 11, 7, 1, -9 },
  { 330, 7, 9, 7, 0, -9 },
  { 338, 7, 9, 7, 0, -9 },
  { 346, 7, 9, 7, 1, -9 },
  { 354, 6, 9, 7, 1, -9 },
  { 361, 7, 9, 7, 1, -9 },
  { 369, 7, 9, 7, 1, -9 },
  { 377, 8, 9, 7, 0, -9 },
  { 386, 7, 9, 7, 1, -9 },
  { 394, 7, 9, 7, 0, -9 },
  { 402, 6, 11, 7, 1, -10 },
  { 411, 4, 11, 7, 2, -10 },
  { 417, 5, 11, 7, 1, -10 },
  { 424, 6, 5, 7, 1, -9 },
  { 428, 6, 2, 7, 0, 0 },
  { 430, 3, 1, 7, 3, -9 },
  { 431, 6, 7, 7, 1, -7 },
  { 437, 7, 9, 7, 0, -9 },
  { 445, 6, 7, 7, 1, -7 },
  { 451, 6, 9, 7, 1, -9 },
  { 458, 6, 7, 7, 1, -7 },
  { 464, 9, 11, 7, -1, -9 },
  { 477, 6, 9, 7, 1, -7 },
  { 484, 7, 9, 7, 0, -9 },
  { 492, 6, 9, 7, 0, -9 },
  { 499, 7, 11, 7, 0, -9 },
  { 509, 7, 9, 7, 0, -9 },
  { 517, 5, 9, 7, 1, -9 },
  { 523, 7, 7, 7, 0, -7 },
  { 530, 7, 7, 7, 0, -7 },
  { 537, 6, 7, 7, 1, -7 },
  { 543, 7, 9, 7, 0, -7 },
  { 551, 6, 9, 7, 1, -7 },
  { 558, 6, 7, 7, 1, -7 },
  { 564, 7, 7, 7, 0, -7 },
  { 571, 6, 8, 7, 1, -8 },
  { 577, 6, 7, 7, 1, -7 },
  { 583, 6, 7, 7, 1, -7 },
  { 589, 6, 7, 7, 1, -7 },
  { 595, 7, 7, 7, 0, -7 },
  { 602, 6, 9, 7, 1, -7 },
  { 609, 7, 7, 7, 0, -7 },
  { 616, 6, 11, 7, 1, -10 },
  { 625, 3, 11, 7, 2, -10 },
  { 630, 7, 11, 7, 0, -10 },
  { 640, 6, 3, 7, 1, -6 },
};

const GFXfont JetBrainsMono_BoldItalic12pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic12pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _JETBRAINSMONO_BOLDITALIC12PT7B_H_
