#ifndef _JETBRAINSMONO_BOLDITALIC16PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x36, 0x66, 0x66, 0x00, 0xEC, 0xCF, 0x3D, 0xB6, 0x98, 0x0C,
  0xC2, 0x20, 0x98, 0xFF, 0x7F, 0xC4, 0xC3, 0x20, 0x88, 0xFF, 0x99, 0x04,
  0x43, 0x30, 0x02, 0x01, 0x03, 0xC3, 0xF3, 0x59, 0xA0, 0xD0, 0x7C, 0x1F,
  0x05, 0x82, 0x6D, 0x67, 0xF1, 0xF0, 0x20, 0x20, 0x1C, 0x33, 0x66, 0x26,
  0xC2, 0x48, 0x3D, 0x01, 0xA0, 0x04, 0x00, 0xFC, 0x1A, 0x43, 0x64, 0x26,
  0xCC, 0x38, 0x0E, 0x0F, 0x8C, 0x66, 0x03, 0x01, 0xC1, 0xE6, 0xDA, 0x47,
  0x63, 0x3B, 0xCF, 0x60, 0x6D, 0xEC, 0x02, 0x0C, 0x79, 0xC3, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x0E, 0x0C, 0x20, 0x60, 0xE0, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xC1, 0x8E, 0x38, 0x40, 0x0C, 0x08,
  0x89, 0xEF, 0x7E, 0x38, 0x6C, 0xEE, 0x44, 0x1C, 0x18, 0x18, 0xFF, 0xFF,
  0x18, 0x30, 0x30, 0x39, 0x98, 0xCC, 0x00, 0xFF, 0xF0, 0xDF, 0x00, 0x01,
  0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x60, 0x18, 0x0C, 0x00, 0x1E, 0x3F, 0x63, 0x63, 0x43, 0xDB,
  0xDB, 0xC3, 0xC6, 0xC6, 0xFE, 0x7C, 0x0E, 0x79, 0xF2, 0x60, 0xC1, 0x83,
  0x0C, 0x18, 0x33, 0xFF, 0xF0, 0x1E, 0x3F, 0x63, 0x63, 0x03, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xFE, 0xFE, 0x3F, 0x7F, 0x06, 0x0C, 0x18, 0x1E, 0x06,
  0x06, 0x06, 0xC6, 0xFE, 0x78, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x73, 0xE6,
  0xC6, 0xFE, 0xFE, 0x06, 0x06, 0x3F, 0x7F, 0x60, 0x60, 0x6C, 0x7E, 0x67,
  0x06, 0x06, 0xC6, 0xFE, 0x7C, 0x06, 0x0C, 0x18, 0x38, 0x30, 0x7E, 0xE7,
  0xC3, 0xC3, 0xC6, 0xFE, 0x7C, 0xFF, 0xFF, 0xC6, 0xC6, 0x0C, 0x0C, 0x18,
  0x38, 0x30, 0x60, 0x60, 0xC0, 0x1E, 0x3F, 0x63, 0x63, 0x67, 0x3E, 0x7C,
  0xE6, 0xC6, 0xC6, 0xFE, 0x7C, 0x1E, 0x3F, 0x63, 0x63, 0xC3, 0xE7, 0x7E,
  0x26, 0x0C, 0x18, 0x30, 0x70, 0x77, 0x60, 0x00, 0x4E, 0xC0, 0x1C, 0x71,
  0x80, 0x00, 0x00, 0x0E, 0x31, 0x86, 0x30, 0x01, 0x03, 0x1E, 0x78, 0xE0,
  0xF0, 0x38, 0x0E, 0x02, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x40, 0x60,
  0x78, 0x1E, 0x07, 0x0E, 0x3C, 0xE0, 0x80, 0x78, 0xF8, 0x38, 0x30, 0xEF,
  0x9E, 0x30, 0x60, 0x03, 0x87, 0x00, 0x0F, 0x07, 0xE3, 0x0D, 0x83, 0x66,
  0xDB, 0x64, 0x89, 0x26, 0xD9, 0xB6, 0x6C, 0xFB, 0x00, 0xC0, 0x1E, 0x03,
  0x80, 0x06, 0x0E, 0x0E, 0x1B, 0x1B, 0x13, 0x33, 0x33, 0x7F, 0x63, 0xE3,
  0xC3, 0x7C, 0x7F, 0x63, 0x63, 0x63, 0x7E, 0xFE, 0xC7, 0xC3, 0xC6, 0xFE,
  0xFC, 0x1E, 0x3F, 0x63, 0x63, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC6, 0xFE,
  0x7C, 0x3E, 0x1F, 0xCC, 0x66, 0x33, 0x19, 0x8D, 0x86, 0xC3, 0x63, 0x31,
  0x9F, 0x9F, 0x80, 0x3F, 0xBF, 0x98, 0x0C, 0x06, 0x03, 0xF1, 0xF9, 0x80,
  0xC0, 0x60, 0x3F, 0x9F, 0xC0, 0x7F, 0xBF, 0xD8, 0x0C, 0x06, 0x03, 0xF3,
  0xF9, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x1E, 0x3F, 0x63, 0x63, 0x60,
  0xC0, 0xCF, 0xCF, 0xC6, 0xC6, 0xFE, 0x7C, 0x63, 0xB1, 0x98, 0xCC, 0x66,
  0x33, 0xFB, 0xFD, 0x8C, 0xC6, 0x63, 0x31, 0x98, 0xC0, 0x3F, 0x7F, 0x0C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0xFE, 0xFE, 0x07, 0x87, 0xC0,
  0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x61, 0x9F, 0x8F, 0x80, 0x61,
  0xB1, 0x98, 0xCC, 0xC6, 0xE3, 0xE3, 0xF1, 0x98, 0xCC, 0x63, 0x31, 0x98,
  0xC0, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xE1, 0x83, 0xFF, 0xF0,
  0x31, 0xCE, 0x73, 0xBC, 0xAA, 0x6B, 0x9B, 0x66, 0xD9, 0x86, 0x61, 0x90,
  0x4C, 0x33, 0x0C, 0x38, 0xCE, 0x23, 0x98, 0xA6, 0x2D, 0x9B, 0x66, 0xD9,
  0xB4, 0x65, 0x19, 0x46, 0x73, 0x1C, 0x1E, 0x3F, 0x63, 0x63, 0x63, 0xC3,
  0xC3, 0xC6, 0xC6, 0xC6, 0xFE, 0x78, 0x7E, 0x3F, 0x98, 0xEC, 0x36, 0x33,
  0x3B, 0xF9, 0xE0, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x1E, 0x3F, 0x63, 0x63,
  0x63, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6, 0xFE, 0x7C, 0x18, 0x0C, 0x0C, 0x7C,
  0x3F, 0x98, 0xCC, 0x66, 0x33, 0x3B, 0xF9, 0x98, 0xCC, 0x66, 0x31, 0x98,
  0xC0, 0x0F, 0x0F, 0xCC, 0x66, 0x03, 0x01, 0xF0, 0x7C, 0x06, 0x01, 0xB1,
  0x9F, 0xC7, 0xC0, 0xFF, 0xFF, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x70, 0x60, 0x60, 0x61, 0xB1, 0x98, 0xCC, 0x66, 0x36, 0x1B, 0x0D, 0x8C,
  0xC6, 0x63, 0x3F, 0x8F, 0x80, 0xC3, 0xC3, 0xC6, 0xC6, 0xC4, 0xCC, 0xCC,
  0xD8, 0xD8, 0x50, 0x70, 0x70, 0xCC, 0xF3, 0x6D, 0xDB, 0x56, 0xD5, 0x37,
  0x4E, 0xF3, 0xAC, 0xAA, 0x2A, 0x8C, 0xE3, 0x38, 0x30, 0xCC, 0x61, 0xB8,
  0x6C, 0x1E, 0x03, 0x80, 0xC0, 0x78, 0x36, 0x1D, 0x86, 0x33, 0x0C, 0xC3,
  0xC3, 0xC6, 0xCC, 0x6C, 0x78, 0x78, 0x30, 0x30, 0x60, 0x60, 0x60, 0x7F,
  0x7F, 0x03, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x60, 0xE0, 0xFE, 0xFE, 0x3E,
  0x7C, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x1F, 0x3E,
  0x00, 0xE1, 0x86, 0x18, 0x60, 0xC3, 0x0C, 0x30, 0xC1, 0x86, 0x18, 0x60,
  0xC0, 0x3E, 0x7C, 0x18, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1,
  0x9F, 0x3E, 0x00, 0x0C, 0x1C, 0x16, 0x36, 0x66, 0x62, 0xC3, 0xFF, 0xFF,
  0xCD, 0x80, 0x3B, 0x7F, 0x67, 0xC3, 0xC6, 0xC6, 0xC6, 0xFE, 0x76, 0x60,
  0x60, 0x60, 0x6E, 0x7F, 0x63, 0xC3, 0xC6, 0xC6, 0xC6, 0xFE, 0xFC, 0x3E,
  0x7F, 0x63, 0xC0, 0xC0, 0xC0, 0xC6, 0xFE, 0x7C, 0x01, 0x81, 0x80, 0xC7,
  0x67, 0xF3, 0x3B, 0x0D, 0x8C, 0xC6, 0x63, 0x3F, 0x8E, 0xC0, 0x3C, 0x7E,
  0x63, 0xC3, 0xFE, 0xC0, 0xC0, 0xEE, 0x7C, 0x01, 0xE0, 0x7C, 0x18, 0x03,
  0x03, 0xFC, 0x7F, 0x83, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01,
  0x81, 0xF0, 0x3C, 0x00, 0x3B, 0x7F, 0x67, 0xC3, 0xC6, 0xC6, 0xCE, 0xFE,
  0x06, 0x06, 0xFC, 0xF8, 0x60, 0x60, 0x60, 0x6E, 0x7F, 0x63, 0xC3, 0xC6,
  0xC6, 0xC6, 0xC6, 0xC6, 0x02, 0x07, 0x06, 0x00, 0x3E, 0x3E, 0x04, 0x0C,
  0x0C, 0x0C, 0x0C, 0x7F, 0xFF, 0x01, 0x01, 0xC0, 0xC0, 0x03, 0xF1, 0xF8,
  0x0C, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x63, 0xF1, 0xE0, 0x60,
  0x30, 0x18, 0x0C, 0x76, 0x73, 0x33, 0x31, 0xF0, 0xCC, 0x66, 0x33, 0x98,
  0xC0, 0x78, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x3F,
  0x1E, 0x6D, 0xBF, 0xDB, 0x6D, 0xB6, 0xDA, 0x4D, 0x25, 0x92, 0xDB, 0x00,
  0x6E, 0x7F, 0x63, 0xC3, 0xC6, 0xC6, 0xC6, 0xC6, 0xC6, 0x3C, 0x7E, 0x63,
  0xC3, 0xC6, 0xC6, 0xC6, 0xFE, 0x78, 0x37, 0x1F, 0xCC, 0x6C, 0x36, 0x33,
  0x19, 0x8C, 0xFE, 0x7E, 0x60, 0x30, 0x18, 0x00, 0x3B, 0x7F, 0x67, 0xC3,
  0xC6, 0xC6, 0xC6, 0xFE, 0x76, 0x06, 0x0C, 0x0C, 0x6E, 0x7F, 0x63, 0x63,
  0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0x3E, 0x7F, 0x60, 0x60, 0x7E, 0x06, 0x06,
  0xEE, 0xFC, 0x18, 0x18, 0xFF, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3E,
  0x3E, 0x63, 0x63, 0x63, 0xC3, 0xC6, 0xC6, 0xC6, 0xFE, 0x78, 0xC3, 0xB1,
  0x98, 0xCC, 0xC6, 0x63, 0x61, 0xB0, 0x70, 0x38, 0x00, 0xC9, 0xEC, 0xF6,
  0x5B, 0x6E, 0xB7, 0x52, 0xB9, 0x9C, 0xCC, 0x00, 0x71, 0x99, 0x87, 0xC3,
  0xC0, 0xC0, 0xE0, 0xD8, 0xCE, 0xE3, 0x00, 0x63, 0x63, 0xC3, 0xC6, 0xC6,
  0xC6, 0xEE, 0xF6, 0x06, 0x0E, 0xFC, 0xF8, 0x7F, 0x7F, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xFE, 0xFE, 0x07, 0x83, 0x83, 0x01, 0x80, 0xC0, 0x61, 0xE1,
  0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xF0, 0x30, 0x33, 0x33, 0x66,
  0x66, 0x66, 0xEC, 0xCC, 0xC0, 0x1C, 0x1E, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x3E, 0x1F, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x87, 0x83, 0x80, 0x20, 0xF3,
  0xDB, 0x8E,
};

const GFXglyph JetBrainsMono_BoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 6, 5, 10, 3, -12 },
  { 11, 10, 12, 10, 0, -12 },
  { 26, 9, 16, 10, 0, -14 },
  { 44, 12, 12, 10, -1, -12 },
  { 62, 9, 12, 10, 0, -12 },
  { 76, 3, 5, 10, 4, -12 },
  { 78, 7, 16, 10, 2, -14 },
  { 92, 7, 16, 10, 1, -14 },
  { 106, 8, 9, 10, 1, -10 },
  { 115, 8, 8, 10, 1, -9 },
  { 123, 5, 5, 10, 1, -2 },
  { 127, 6, 2, 10, 2, -6 },
  { 129, 3, 3, 10, 3, -3 },
  { 131, 10, 15, 10, 0, -13 },
  { 150, 8, 12, 10, 1, -12 },
  { 162, 7, 12, 10, 1, -12 },
  { 173, 8, 12, 10, 1, -12 },
  { 185, 8, 12, 10, 1, -12 },
  { 197, 8, 12, 10, 1, -12 },
  { 209, 8, 12, 10, 1, -12 },
  { 221, 8, 12, 10, 1, -12 },
  { 233, 8, 12, 10, 2, -12 },
  { 245, 8, 12, 10, 1, -12 },
  { 257, 8, 12, 10, 1, -12 },
  { 269, 4, 9, 10, 3, -9 },
  { 274, 6, 12, 10, 1, -9 },
  { 283, 8, 9, 10, 1, -10 },
  { 292, 8, 6, 10, 1, -8 },
  { 298, 8, 9, 10, 1, -10 },
  { 307, 7, 12, 10, 2, -12 },
  { 318, 10, 15, 10, 0, -12 },
  { 337, 8, 12, 10, 0, -12 },
  { 349, 8, 12, 10, 1, -12 },
  { 361, 8, 12, 10, 1, -12 },
  { 373, 9, 12, 10, 0, -12 },
  { 387, 9, 12, 10, 1, -12 },
  { 401, 9, 12, 10, 1, -12 },
  { 415, 8, 12, 10, 1, -12 },
  { 427, 9, 12, 10, 1, -12 },
  { 441, 8, 12, 10, 1, -12 },
  { 453, 9, 12, 10, 0, -12 },
  { 467, 9, 12, 10, 1, -12 },
  { 481, 7, 12, 10, 1, -12 },
  { 492, 10, 12, 10, 0, -12 },
  { 507, 10, 12, 10, 0, -12 },
  { 522, 8, 12, 10, 1, -12 },
  { 534, 9, 12, 10, 1, -12 },
  { 548, 8, 15, 10, 1, -12 },
  { 563, 9, 12, 10, 1, -12 },
  { 577, 9, 12, 10, 0, -12 },
  { 591, 8, 12, 10, 2, -12 },
  { 603, 9, 12, 10, 1, -12 },
  { 617, 8, 12, 10, 2, -12 },
  { 629, 10, 12, 10, 1, -12 },
  { 644, 10, 12, 10, 0, -12 },
  { 659, 8, 12, 10, 2, -12 },
  { 671, 8, 12, 10, 1, -12 },
  { 683, 7, 15, 10, 2, -13 },
  { 697, 6, 15, 10, 2, -13 },
  { 709, 7, 15, 10, 1, -13 },
  { 723, 8, 7, 10, 1, -12 },
  { 730, 8, 2, 10, 0, 0 },
  { 732, 3, 3, 10, 4, -13 },
  { 734, 8, 9, 10, 1, -9 },
  { 743, 8, 12, 10, 1, -12 },
  { 755, 8, 9, 10, 1, -9 },
  { 764, 9, 12, 10, 1, -12 },
  { 778, 8, 9, 10, 1, -9 },
  { 787, 11, 15, 10, -1, -12 },
  { 808, 8, 12, 10, 1, -9 },
  { 820, 8, 12, 10, 1, -12 },
  { 832, 8, 13, 10, 0, -13 },
  { 845, 9, 16, 10, 0, -13 },
  { 863, 9, 12, 10, 1, -12 },
  { 877, 8, 12, 10, 1, -12 },
  { 889, 9, 9, 10, 0, -9 },
  { 900, 8, 9, 10, 1, -9 },
  { 909, 8, 9, 10, 1, -9 },
  { 918, 9, 12, 10, 0, -9 },
  { 932, 8, 12, 10, 1, -9 },
  { 944, 8, 9, 10, 1, -9 },
  { 953, 8, 9, 10, 1, -9 },
  { 962, 8, 11, 10, 1, -11 },
  { 973, 8, 9, 10, 1, -9 },
  { 982, 9, 9, 10, 1, -9 },
  { 993, 9, 9, 10, 1, -9 },
  { 1004, 9, 9, 10, 0, -9 },
  { 1015, 8, 12, 10, 1, -9 },
  { 1027, 8, 9, 10, 1, -9 },
  { 1036, 9, 15, 10, 1, -13 },
  { 1053, 4, 15, 10, 3, -13 },
  { 1061, 9, 15, 10, 0, -13 },
  { 1078, 8, 4, 10, 1, -8 },
};

const GFXfont JetBrainsMono_BoldItalic16pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic16pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _JETBRAINSMONO_BOLDITALIC16PT7B_H_
