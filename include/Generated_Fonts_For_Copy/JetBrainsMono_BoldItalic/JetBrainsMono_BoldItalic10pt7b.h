#ifndef _JETBRAINSMONO_BOLDITALIC10PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x8C, 0xB6, 0x80, 0x35, 0xF2, 0x92, 0xF9, 0x49, 0x00, 0x10,
  0x43, 0xD7, 0x70, 0xE2, 0xBA, 0x70, 0x80, 0x77, 0x31, 0xC0, 0x83, 0xCA,
  0xA6, 0x00, 0x39, 0x82, 0x19, 0xDA, 0x4F, 0x80, 0xE0, 0x19, 0x10, 0x84,
  0x21, 0x08, 0x20, 0x62, 0x33, 0x22, 0x24, 0x80, 0x11, 0x5F, 0x8C, 0x58,
  0x21, 0x3E, 0xC4, 0x00, 0x6B, 0x40, 0xF0, 0xB0, 0x04, 0x21, 0x84, 0x30,
  0x86, 0x10, 0xC0, 0x3D, 0x14, 0xDE, 0x49, 0x27, 0x00, 0x3A, 0x84, 0x21,
  0x0B, 0xE0, 0x3D, 0x30, 0x86, 0x31, 0x0F, 0x80, 0x7C, 0x63, 0x02, 0x0B,
  0x27, 0x00, 0x0C, 0x42, 0x12, 0x7B, 0xE1, 0x80, 0x3D, 0x85, 0x9A, 0x09,
  0x27, 0x00, 0x19, 0x98, 0xF4, 0xE5, 0xC0, 0xFC, 0xC4, 0x42, 0x23, 0x00,
  0x3D, 0x36, 0x8E, 0x4B, 0x27, 0x00, 0x7C, 0x67, 0xE3, 0x33, 0x00, 0x70,
  0xB0, 0x2C, 0x06, 0xB4, 0x0B, 0xA1, 0x83, 0x00, 0xF8, 0x3D, 0xE0, 0x41,
  0x82, 0x7E, 0x00, 0x70, 0x84, 0xC4, 0x03, 0x00, 0x3D, 0x15, 0xE9, 0xA6,
  0xB9, 0x30, 0x60, 0x19, 0x4A, 0xD7, 0xA6, 0x20, 0x7D, 0x34, 0x9E, 0x49,
  0x2F, 0x00, 0x3D, 0x34, 0x10, 0x41, 0x27, 0x00, 0x79, 0x34, 0xD2, 0x49,
  0x2F, 0x00, 0x7D, 0x84, 0x1E, 0x41, 0x0F, 0x80, 0x7D, 0x04, 0x1E, 0x41,
  0x0C, 0x00, 0x3D, 0x34, 0x17, 0x49, 0x27, 0x00, 0x65, 0x34, 0xDE, 0x49,
  0x2C, 0x80, 0x7C, 0x41, 0x0C, 0x30, 0x8F, 0x80, 0x1C, 0x30, 0x82, 0x0B,
  0x67, 0x00, 0x6D, 0x25, 0x9C, 0x51, 0x6C, 0x80, 0x4C, 0xC8, 0x88, 0xF0,
  0x6D, 0xB7, 0x5F, 0x4B, 0x28, 0x80, 0x65, 0x96, 0xD6, 0x59, 0x6D, 0x80,
  0x3D, 0x34, 0xD2, 0x49, 0x27, 0x00, 0x7D, 0x14, 0xDE, 0x41, 0x0C, 0x00,
  0x3D, 0x34, 0xD2, 0x49, 0x27, 0x04, 0x18, 0x7D, 0x14, 0xDE, 0x51, 0x6C,
  0x80, 0x3D, 0x36, 0x0E, 0x0B, 0x27, 0x00, 0xF9, 0x08, 0xC6, 0x21, 0x00,
  0x65, 0x34, 0xD2, 0x49, 0x27, 0x00, 0x8C, 0xF5, 0xA6, 0x31, 0x80, 0x56,
  0xA9, 0xD3, 0xA7, 0x8B, 0x36, 0x00, 0x6C, 0xA3, 0x0C, 0x31, 0x6C, 0x80,
  0x8E, 0x9C, 0xC6, 0x21, 0x00, 0x7C, 0x21, 0x0C, 0x21, 0x0F, 0x80, 0x3B,
  0x18, 0x84, 0x21, 0x18, 0xE0, 0xC4, 0x46, 0x22, 0x22, 0x30, 0x73, 0x32,
  0x22, 0x22, 0xE0, 0x35, 0xD9, 0xF8, 0xCC, 0x3D, 0xF4, 0x92, 0x49, 0xE0,
  0x61, 0x67, 0x92, 0x49, 0x2F, 0x00, 0x11, 0xE4, 0x50, 0x49, 0xC0, 0x04,
  0xF7, 0xD2, 0x49, 0x27, 0x80, 0x11, 0xA4, 0x9E, 0x49, 0xC0, 0x0E, 0x30,
  0xF8, 0x81, 0x02, 0x04, 0x18, 0xE0, 0x7F, 0xE5, 0x2B, 0x68, 0xDC, 0x61,
  0x67, 0x92, 0x49, 0x2C, 0x80, 0x18, 0x9C, 0xE1, 0x08, 0xDF, 0x08, 0x4E,
  0xF1, 0x8C, 0x42, 0x37, 0x00, 0x61, 0x14, 0x94, 0x71, 0x6C, 0x80, 0xE6,
  0x64, 0x44, 0x70, 0x69, 0x55, 0xFA, 0xAA, 0xA0, 0x59, 0xE4, 0x92, 0x4B,
  0x20, 0x11, 0xE4, 0x92, 0x49, 0xC0, 0x59, 0xA4, 0x92, 0x4B, 0xCC, 0x20,
  0x3D, 0xE4, 0x92, 0x49, 0xE1, 0x86, 0x79, 0xB4, 0xD0, 0x43, 0x00, 0x31,
  0xA4, 0x0E, 0xC9, 0xE0, 0x27, 0xFE, 0x84, 0x21, 0xC0, 0x4D, 0x34, 0x92,
  0x49, 0xC0, 0x8C, 0xE5, 0xE6, 0x30, 0xAD, 0x7B, 0xEB, 0x58, 0x4D, 0xA3,
  0x0C, 0x73, 0x20, 0x9C, 0xA5, 0x2F, 0x28, 0xDC, 0x7D, 0xE1, 0x08, 0x43,
  0xE0, 0x19, 0x88, 0x4C, 0x10, 0x8C, 0x30, 0x69, 0x2D, 0xA4, 0x80, 0x70,
  0x8C, 0x61, 0x90, 0x84, 0xC0, 0x65, 0xF9, 0x80,
};

const GFXglyph JetBrainsMono_BoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 3, 3, 6, 2, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 6, 10, 6, 0, -9 },
  { 19, 7, 7, 6, 0, -7 },
  { 26, 6, 7, 6, 0, -7 },
  { 32, 1, 3, 6, 3, -7 },
  { 33, 5, 9, 6, 1, -8 },
  { 39, 4, 9, 6, 1, -8 },
  { 44, 6, 5, 6, 0, -6 },
  { 48, 5, 5, 6, 1, -6 },
  { 52, 3, 4, 6, 1, -2 },
  { 54, 4, 1, 6, 1, -4 },
  { 55, 2, 2, 6, 2, -2 },
  { 56, 6, 9, 6, 0, -8 },
  { 63, 6, 7, 6, 0, -7 },
  { 69, 5, 7, 6, 0, -7 },
  { 74, 6, 7, 6, 0, -7 },
  { 80, 6, 7, 6, 0, -7 },
  { 86, 6, 7, 6, 0, -7 },
  { 92, 6, 7, 6, 0, -7 },
  { 98, 5, 7, 6, 0, -7 },
  { 103, 5, 7, 6, 1, -7 },
  { 108, 6, 7, 6, 0, -7 },
  { 114, 5, 7, 6, 1, -7 },
  { 119, 2, 6, 6, 2, -6 },
  { 121, 3, 8, 6, 1, -6 },
  { 124, 5, 5, 6, 1, -6 },
  { 128, 5, 4, 6, 1, -5 },
  { 131, 5, 5, 6, 0, -6 },
  { 135, 5, 7, 6, 1, -7 },
  { 140, 6, 9, 6, 0, -7 },
  { 147, 5, 7, 6, 0, -7 },
  { 152, 6, 7, 6, 0, -7 },
  { 158, 6, 7, 6, 0, -7 },
  { 164, 6, 7, 6, 0, -7 },
  { 170, 6, 7, 6, 0, -7 },
  { 176, 6, 7, 6, 0, -7 },
  { 182, 6, 7, 6, 0, -7 },
  { 188, 6, 7, 6, 0, -7 },
  { 194, 6, 7, 6, 0, -7 },
  { 200, 6, 7, 6, 0, -7 },
  { 206, 6, 7, 6, 0, -7 },
  { 212, 4, 7, 6, 1, -7 },
  { 216, 6, 7, 6, 0, -7 },
  { 222, 6, 7, 6, 0, -7 },
  { 228, 6, 7, 6, 0, -7 },
  { 234, 6, 7, 6, 0, -7 },
  { 240, 6, 9, 6, 0, -7 },
  { 247, 6, 7, 6, 0, -7 },
  { 253, 6, 7, 6, 0, -7 },
  { 259, 5, 7, 6, 1, -7 },
  { 264, 6, 7, 6, 0, -7 },
  { 270, 5, 7, 6, 1, -7 },
  { 275, 7, 7, 6, 0, -7 },
  { 282, 6, 7, 6, 0, -7 },
  { 288, 5, 7, 6, 1, -7 },
  { 293, 6, 7, 6, 0, -7 },
  { 299, 5, 9, 6, 1, -8 },
  { 305, 4, 9, 6, 1, -8 },
  { 310, 4, 9, 6, 1, -8 },
  { 315, 4, 4, 6, 1, -7 },
  { 317, 5, 1, 6, 0, 0 },
  { 318, 3, 2, 6, 2, -8 },
  { 319, 6, 6, 6, 0, -6 },
  { 324, 6, 7, 6, 0, -7 },
  { 330, 6, 6, 6, 0, -6 },
  { 335, 6, 7, 6, 0, -7 },
  { 341, 6, 6, 6, 0, -6 },
  { 346, 7, 9, 6, -1, -7 },
  { 354, 5, 8, 6, 1, -6 },
  { 359, 6, 7, 6, 0, -7 },
  { 365, 5, 8, 6, 0, -8 },
  { 370, 5, 10, 6, 0, -8 },
  { 377, 6, 7, 6, 0, -7 },
  { 383, 4, 7, 6, 1, -7 },
  { 387, 6, 6, 6, 0, -6 },
  { 392, 6, 6, 6, 0, -6 },
  { 397, 6, 6, 6, 0, -6 },
  { 402, 6, 8, 6, 0, -6 },
  { 408, 6, 8, 6, 0, -6 },
  { 414, 6, 6, 6, 0, -6 },
  { 419, 6, 6, 6, 0, -6 },
  { 424, 5, 7, 6, 1, -7 },
  { 429, 6, 6, 6, 0, -6 },
  { 434, 5, 6, 6, 1, -6 },
  { 438, 5, 6, 6, 1, -6 },
  { 442, 6, 6, 6, 0, -6 },
  { 447, 5, 8, 6, 1, -6 },
  { 452, 6, 6, 6, 0, -6 },
  { 457, 5, 9, 6, 1, -8 },
  { 463, 3, 9, 6, 2, -8 },
  { 467, 5, 9, 6, 0, -8 },
  { 473, 6, 3, 6, 0, -5 },
};

const GFXfont JetBrainsMono_BoldItalic10pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic10pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _JETBRAINSMONO_BOLDITALIC10PT7B_H_
