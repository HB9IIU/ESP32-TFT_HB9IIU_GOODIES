#ifndef _JETBRAINSMONO_BOLDITALIC33PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x87, 0xE3, 0xE1, 0xF0, 0x7C, 0x7B, 0xC3, 0xDE, 0x3E, 0xF1, 0xE7, 0x8F,
  0x3C, 0x79, 0xE3, 0xCE, 0x1E, 0x70, 0xE7, 0x87, 0x00, 0x00, 0x70, 0xF0,
  0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x1E, 0x00, 0xE1, 0xC0, 0x1C, 0x1C,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x38, 0x70, 0x03, 0x87,
  0x00, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x07, 0xFF,
  0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x38,
  0x38, 0x03, 0x87, 0x00, 0x38, 0x70, 0x07, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x7F,
  0xF8, 0x3F, 0xFE, 0x0F, 0xBF, 0xC7, 0xDC, 0xF1, 0xE6, 0x3C, 0x79, 0x80,
  0x1E, 0x60, 0x07, 0x98, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x0F, 0xF0, 0x03, 0x7C, 0x00, 0xCF, 0x80, 0x33, 0xE0, 0x1C,
  0xF3, 0xE6, 0x3C, 0xF9, 0x9F, 0x1F, 0xEF, 0x87, 0xFF, 0xE0, 0xFF, 0xE0,
  0x1F, 0xF0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xF0, 0x07, 0x07, 0xF8, 0x0E, 0x07, 0xBC, 0x1C, 0x0E,
  0x1C, 0x38, 0x0E, 0x1C, 0x70, 0x0E, 0x1C, 0xE0, 0x0E, 0x38, 0xE0, 0x0E,
  0x39, 0xC0, 0x0F, 0xFB, 0x80, 0x0F, 0xF7, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x77, 0xF0, 0x00,
  0xEF, 0xF8, 0x01, 0xCE, 0x38, 0x03, 0x9C, 0x38, 0x07, 0x1C, 0x38, 0x0E,
  0x1C, 0x38, 0x1E, 0x1C, 0x70, 0x1C, 0x1E, 0xF0, 0x38, 0x1F, 0xE0, 0xF0,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xE3, 0xC0,
  0x78, 0x3C, 0x0E, 0x07, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x1E, 0x79, 0xE7, 0x9E,
  0x3C, 0xF3, 0xC3, 0xFC, 0x78, 0x7F, 0x0F, 0x07, 0xE1, 0xE0, 0xF8, 0x3C,
  0x1F, 0x07, 0xC7, 0xF0, 0xFF, 0xFE, 0x0F, 0xF9, 0xE0, 0xFE, 0x3C, 0x7B,
  0xDE, 0xFF, 0xFB, 0xDE, 0xF7, 0x00, 0x00, 0x04, 0x00, 0xF0, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3E, 0x00, 0x78,
  0x00, 0x60, 0x04, 0x00, 0x1C, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x04, 0x1E, 0x1B, 0xCE, 0x3F, 0xF3,
  0x7F, 0xFD, 0x7F, 0x3F, 0xFE, 0x00, 0xE0, 0x01, 0xF8, 0x01, 0xDE, 0x01,
  0xE7, 0x01, 0xE3, 0xC1, 0xF1, 0xF0, 0xF0, 0x70, 0x10, 0x30, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x8F, 0x87, 0xC7, 0xC3,
  0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xFF,
  0xFF, 0x3B, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xE3,
  0xF3, 0xE0, 0x79, 0xE0, 0x3C, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC,
  0x07, 0x9E, 0x73, 0xCF, 0x7D, 0xE7, 0xBC, 0xF7, 0x8E, 0x7B, 0xC0, 0x3D,
  0xE0, 0x1C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8F, 0x87,
  0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7E, 0x01, 0xFC, 0x03,
  0xFC, 0x0F, 0xFC, 0x1F, 0x3C, 0x1E, 0x3C, 0x18, 0x7C, 0x10, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3E, 0x3F, 0x1F, 0x07, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x1E, 0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x78, 0x7C, 0x3E,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC1, 0xE3, 0xE1, 0xF3, 0xE0, 0xF3, 0xE0,
  0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0x90,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE1, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xC1, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x3C, 0x07, 0x9E, 0x07, 0x8F, 0x8F, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F,
  0xC0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x9E, 0x07, 0xBF,
  0x87, 0xFF, 0xE3, 0xF3, 0xF3, 0xE0, 0x7D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78,
  0x07, 0xFC, 0x07, 0xFE, 0x03, 0xCF, 0x03, 0xE7, 0xC3, 0xE3, 0xFF, 0xE0,
  0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF7, 0x80, 0xF7, 0xC0, 0xFB, 0xC0, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3E, 0x1F, 0x1F, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x7C, 0x78,
  0x1E, 0x1F, 0x0F, 0x83, 0xE7, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xFC,
  0x07, 0xCF, 0x83, 0xE1, 0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xCF,
  0x80, 0xF1, 0xE0, 0x7C, 0x7C, 0x3E, 0x1F, 0xFF, 0x83, 0xFF, 0x80, 0x7F,
  0xC0, 0x07, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x8F, 0xC3, 0xE7, 0x80, 0xF7,
  0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0xBE, 0x0F,
  0x9F, 0xDF, 0xC7, 0xFF, 0xC1, 0xFF, 0xE0, 0x79, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xFC, 0xFC, 0xFC, 0xF8, 0x03, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x07,
  0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x10, 0x00, 0x0E,
  0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0xE0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x60, 0x00, 0x00,
  0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x03, 0xE1, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x7C,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x07,
  0xFF, 0xE0, 0xF8, 0x1F, 0x0F, 0x00, 0xF1, 0xE0, 0x07, 0x1C, 0x00, 0x73,
  0xC0, 0x07, 0x3C, 0x3E, 0x73, 0x87, 0xF7, 0x38, 0x79, 0xF3, 0x8F, 0x0E,
  0x78, 0xE0, 0xE7, 0x8E, 0x0E, 0x78, 0xE1, 0xE7, 0x1E, 0x1E, 0x71, 0xE1,
  0xE7, 0x1E, 0x1C, 0x71, 0xE1, 0xCF, 0x1E, 0x7C, 0xF0, 0xFD, 0xCE, 0x0F,
  0x9C, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0E, 0xE0, 0x0F, 0x70, 0x07, 0xBC,
  0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0,
  0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0xCF,
  0x01, 0xE7, 0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F,
  0x0F, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0x78, 0x3F, 0x1E, 0x07, 0xC7,
  0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x1F, 0x1E, 0x07, 0x8F, 0x07, 0xC3, 0xFF,
  0xE0, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0x07, 0xC3, 0xC0, 0xF9, 0xE0, 0x1E,
  0x78, 0x07, 0x9E, 0x03, 0xE7, 0x80, 0xF1, 0xE0, 0x7C, 0x78, 0x7E, 0x3F,
  0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0x03, 0xFC, 0x03, 0xFF, 0x83, 0xFF,
  0xC3, 0xE3, 0xF3, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07,
  0xCF, 0xCF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFC, 0x03,
  0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1E, 0x07, 0xC7, 0x80, 0xF1, 0xE0,
  0x3C, 0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF0, 0x1E,
  0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x79, 0xE0, 0x3E, 0x78, 0x0F, 0x1E,
  0x03, 0xC7, 0x81, 0xF1, 0xE0, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0x80, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE1, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFC, 0x03,
  0xFF, 0x83, 0xFF, 0xC3, 0xE3, 0xF3, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x1F, 0xE7, 0x8F,
  0xF3, 0xC7, 0xFB, 0xE7, 0xFD, 0xE0, 0x3E, 0xF0, 0x1E, 0x78, 0x0F, 0x3C,
  0x07, 0x9E, 0x07, 0xCF, 0xC7, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xC0,
  0x0F, 0x03, 0xE1, 0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C,
  0x3C, 0x07, 0x87, 0x81, 0xF0, 0xF0, 0x3C, 0x1E, 0x07, 0x87, 0xC0, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x78, 0x1E, 0x0F, 0x03, 0xC3,
  0xE0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x0F, 0x87,
  0x81, 0xE1, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x0F, 0x87,
  0xE7, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0x01, 0xF0,
  0xF0, 0x3E, 0x1F, 0x03, 0xC1, 0xE0, 0x7C, 0x1E, 0x0F, 0x81, 0xE0, 0xF0,
  0x1E, 0x1F, 0x01, 0xE1, 0xE0, 0x1E, 0x3E, 0x03, 0xC7, 0xC0, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0xC7,
  0xC0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x3E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x83, 0xF0, 0xFC, 0x37, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1D, 0xCE, 0xE1,
  0xDC, 0xEE, 0x1C, 0xDD, 0xE1, 0xCD, 0xDE, 0x1C, 0xD9, 0xE3, 0xCF, 0x9E,
  0x3C, 0xF9, 0xC3, 0xCF, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x38, 0x03,
  0xC7, 0x80, 0x3C, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80,
  0x78, 0x78, 0x07, 0x8F, 0x00, 0x78, 0x0F, 0x81, 0xE3, 0xF0, 0x3C, 0x7E,
  0x07, 0x0F, 0xC1, 0xE1, 0xFC, 0x3C, 0x3B, 0x87, 0x87, 0x70, 0xF0, 0xEE,
  0x1E, 0x3D, 0xC3, 0x87, 0xBC, 0xF0, 0xF7, 0x9E, 0x1E, 0x73, 0xC3, 0xCE,
  0x78, 0x71, 0xCF, 0x1E, 0x39, 0xC3, 0xC7, 0xB8, 0x78, 0x77, 0x0F, 0x0E,
  0xE1, 0xE1, 0xFC, 0x38, 0x3F, 0x8F, 0x07, 0xF1, 0xE0, 0x7C, 0x3C, 0x0F,
  0x87, 0x81, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0xC3, 0xE3, 0xF3,
  0xE0, 0xF9, 0xE0, 0x3C, 0xF0, 0x1E, 0xF8, 0x1F, 0x7C, 0x0F, 0x3C, 0x07,
  0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x7B, 0xE0, 0x7D, 0xE0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8F, 0xCF, 0xC3,
  0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE1, 0xE0, 0x3E, 0x3C, 0x07, 0xC7, 0x80, 0x78, 0xF0,
  0x0F, 0x1E, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x3F, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFC, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xE3, 0xF3,
  0xE0, 0xF9, 0xE0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0x78, 0x0F, 0xBC, 0x07,
  0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF7, 0xC0, 0x7B, 0xC0, 0x7D, 0xE0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8F, 0xCF, 0xC7,
  0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xE0, 0x7C, 0x3C, 0x07, 0x87, 0x80, 0xF0,
  0xF0, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x7E, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0x1E, 0x03, 0xE3, 0xC0, 0x78, 0x78, 0x0F,
  0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xE1, 0xF0, 0x3C, 0x3C,
  0x07, 0x87, 0x80, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3E,
  0x3F, 0x1F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xCF, 0x80, 0xF3, 0xE0,
  0x7C, 0x7E, 0x3E, 0x1F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x03, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0xF0,
  0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3E, 0x7C, 0x0F,
  0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0xCF,
  0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xE3, 0xC0,
  0xF0, 0xFC, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0xF0, 0x07,
  0xF8, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xEF, 0x01, 0xE7, 0x80, 0xF3, 0xC0,
  0xF1, 0xE0, 0x78, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x1E, 0x07,
  0x8F, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0,
  0x1E, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x70, 0xF0, 0xF7, 0x0F, 0x0E, 0x70, 0xF1, 0xE7, 0x1F, 0x1E, 0x71,
  0xB1, 0xC7, 0x1B, 0x1C, 0x71, 0xB3, 0xCF, 0x3F, 0x3C, 0xF3, 0x73, 0x8F,
  0x37, 0x38, 0xF3, 0x73, 0x8F, 0x77, 0x78, 0xE6, 0x67, 0x0E, 0x66, 0x70,
  0xEE, 0x67, 0x0E, 0xC6, 0xF0, 0xEC, 0x6E, 0x0E, 0xC6, 0xE0, 0xFC, 0x6E,
  0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x07,
  0x80, 0x07, 0x80, 0x7C, 0x1F, 0x03, 0xE0, 0x3C, 0x1F, 0x00, 0xF0, 0x78,
  0x03, 0xE3, 0xE0, 0x07, 0x9F, 0x00, 0x1E, 0x78, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xDF, 0x00,
  0x1E, 0x3C, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xE0, 0x1E, 0x07, 0x80, 0xF8,
  0x1E, 0x07, 0xC0, 0x7C, 0x3E, 0x00, 0xF0, 0xF8, 0x03, 0xDE, 0x01, 0xE7,
  0x80, 0xF9, 0xE0, 0x3C, 0x3C, 0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xC0, 0xF9,
  0xF0, 0x1E, 0x78, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7F, 0xFE,
  0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0xFF,
  0xC3, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F,
  0xF8, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0xFE, 0x0F,
  0xF8, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x77, 0x81, 0xEF, 0x07, 0x8E, 0x0F, 0x1C, 0x3C,
  0x3C, 0x70, 0x79, 0xE0, 0x77, 0x80, 0xFF, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0xF1, 0xF1, 0xE0, 0x07, 0xF7,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0x7C, 0x7E, 0x3E, 0x0F, 0x8F, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x3E, 0x7C, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0,
  0x3C, 0x78, 0x1F, 0x1E, 0x07, 0xC7, 0xC7, 0xE1, 0xFF, 0xF8, 0x3F, 0xDE,
  0x07, 0xE7, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x79, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x9F, 0x87,
  0xCF, 0x83, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x3E, 0xF8,
  0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x83, 0xE7, 0xE3, 0xE7,
  0xFF, 0xE3, 0xDF, 0xF1, 0xE7, 0xE0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF,
  0x3E, 0x1F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0xF0, 0x3E, 0xFC, 0x7C,
  0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x81, 0xFD, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x83, 0xE3, 0xF0, 0xF8, 0x3E, 0x1E, 0x03, 0xC3, 0xC0,
  0x78, 0x78, 0x1F, 0x1F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01,
  0xE1, 0xE0, 0x7C, 0x3C, 0x0F, 0x87, 0xC7, 0xE0, 0xFF, 0xFC, 0x0F, 0xF7,
  0x80, 0xFC, 0xF0, 0x07, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x3C, 0x1F, 0x78,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x3E, 0xF8, 0x7C, 0x7F, 0xF8, 0x7F,
  0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xEF, 0x8F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xC7, 0xE7, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x3E, 0xF8,
  0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0xCF, 0x83, 0xE7, 0xFE, 0xF1,
  0xFF, 0xF0, 0xFF, 0x78, 0x1E, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x83, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x79, 0xF8,
  0x3F, 0xFE, 0x1F, 0xFF, 0x9F, 0x87, 0xCF, 0x83, 0xE7, 0x80, 0xF3, 0xC0,
  0x79, 0xE0, 0x7C, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E,
  0x03, 0xCF, 0x03, 0xE7, 0x81, 0xE7, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0xF8, 0xF0, 0x3E, 0x1E,
  0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x78, 0x1E, 0x1F, 0x03, 0xC7, 0xC0, 0x7F,
  0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7C, 0xF8, 0x0F, 0x0F, 0x01, 0xE1,
  0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x3E, 0x07, 0xC7, 0x80,
  0xF8, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x1F, 0xF7,
  0xC3, 0xBE, 0xFC, 0x7B, 0xFF, 0x8E, 0x38, 0xF3, 0xC7, 0x1E, 0x78, 0xE3,
  0xCF, 0x1C, 0x71, 0xE3, 0x8E, 0x38, 0xE1, 0xC7, 0x1C, 0x79, 0xE3, 0x8F,
  0x3C, 0x71, 0xE7, 0x8E, 0x3C, 0xF1, 0xC7, 0x1C, 0x38, 0xE3, 0x8E, 0x3C,
  0xF1, 0xC7, 0x9E, 0x38, 0xF0, 0x1E, 0x7E, 0x0F, 0xFF, 0x87, 0xFF, 0xE7,
  0xE1, 0xF3, 0xE0, 0xF9, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x1F, 0x3C, 0x0F,
  0x3E, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF9, 0xE0,
  0x79, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x00, 0x07, 0xF8, 0x1F, 0xFE,
  0x1F, 0xFE, 0x3E, 0x1F, 0x7C, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C,
  0xFC, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x0F, 0x3F, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7E, 0x1F, 0x1F, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x3C,
  0x78, 0x0F, 0x1E, 0x07, 0xCF, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C,
  0x07, 0x8F, 0x83, 0xC3, 0xF1, 0xF1, 0xFF, 0xF8, 0x7B, 0xFE, 0x1E, 0x7E,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xF3, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0x7C, 0x7E, 0x3E,
  0x0F, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x7C, 0x0F, 0x1E, 0x03,
  0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x1F, 0x1E, 0x07, 0xC7, 0xC7, 0xE1,
  0xFF, 0xF8, 0x3F, 0xDE, 0x07, 0xE7, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0xFE, 0x1E, 0xFF,
  0x8F, 0xFF, 0xC7, 0xE3, 0xF3, 0xC0, 0xF9, 0xE0, 0x7D, 0xF0, 0x3E, 0xF0,
  0x1F, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x00,
  0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x01,
  0xE0, 0x00, 0xF7, 0xC0, 0x7B, 0xE0, 0x7C, 0xFF, 0xFC, 0x7F, 0xFC, 0x0F,
  0xFC, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x03, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF0, 0x3C, 0x07, 0x9E, 0x07, 0x9F, 0x03, 0xCF, 0x01, 0xE7,
  0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x3E, 0x78, 0x1E, 0x78, 0x0F,
  0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xF3, 0xF0, 0xFF,
  0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x07,
  0xDE, 0x03, 0xC7, 0x83, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF0, 0x78,
  0x78, 0x3C, 0x78, 0x0E, 0x3C, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0xE1, 0xE1, 0xFC,
  0x3C, 0x3B, 0x87, 0x8F, 0x71, 0xF1, 0xCE, 0x36, 0x39, 0xC6, 0xC7, 0x38,
  0xD9, 0xC7, 0x33, 0x38, 0xE6, 0x67, 0x1C, 0xCD, 0xE3, 0xB9, 0xB8, 0x76,
  0x37, 0x0E, 0xC7, 0xE1, 0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8,
  0x78, 0x1E, 0x0F, 0x00, 0x1F, 0x03, 0xF0, 0xF0, 0x3C, 0x0F, 0x87, 0x80,
  0x78, 0xF8, 0x07, 0xDF, 0x00, 0x3D, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7B, 0xC0, 0x0F, 0xBC,
  0x01, 0xF3, 0xE0, 0x1E, 0x1E, 0x03, 0xE1, 0xF0, 0x7C, 0x0F, 0x0F, 0x80,
  0xF8, 0x3C, 0x0F, 0x9E, 0x07, 0x9F, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3,
  0xC0, 0x79, 0xE0, 0x7C, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x3C, 0x07,
  0x9E, 0x07, 0xCF, 0x87, 0xE7, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0x78, 0x0C,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x1F, 0x83, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xFF, 0xF8,
  0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x1F, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x07, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x03,
  0xC0, 0x07, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87,
  0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC0,
  0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x00, 0x04, 0x00, 0x1F, 0x83, 0xDF, 0xE1,
  0xFF, 0xF8, 0xFF, 0x3E, 0x77, 0x0F, 0xFB, 0x83, 0xF9, 0xC0, 0xF8,
};

const GFXglyph JetBrainsMono_BoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 9, 24, 20, 6, -24 },
  { 28, 13, 10, 20, 5, -24 },
  { 45, 20, 24, 20, 0, -24 },
  { 105, 18, 34, 20, 1, -29 },
  { 182, 24, 24, 20, -2, -24 },
  { 254, 19, 24, 20, 0, -24 },
  { 311, 5, 10, 20, 9, -24 },
  { 318, 14, 32, 20, 5, -28 },
  { 374, 14, 32, 20, 2, -28 },
  { 430, 17, 17, 20, 2, -20 },
  { 467, 16, 16, 20, 2, -19 },
  { 499, 9, 10, 20, 3, -5 },
  { 511, 12, 4, 20, 4, -13 },
  { 517, 6, 6, 20, 6, -6 },
  { 522, 21, 31, 20, 0, -27 },
  { 604, 17, 24, 20, 2, -24 },
  { 655, 16, 24, 20, 1, -24 },
  { 703, 18, 24, 20, 1, -24 },
  { 757, 18, 24, 20, 1, -24 },
  { 811, 17, 24, 20, 1, -24 },
  { 862, 17, 24, 20, 2, -24 },
  { 913, 17, 24, 20, 1, -24 },
  { 964, 17, 24, 20, 3, -24 },
  { 1015, 18, 24, 20, 1, -24 },
  { 1069, 17, 24, 20, 3, -24 },
  { 1120, 8, 18, 20, 6, -18 },
  { 1138, 11, 23, 20, 3, -18 },
  { 1170, 17, 18, 20, 2, -20 },
  { 1209, 16, 12, 20, 2, -17 },
  { 1233, 17, 18, 20, 1, -20 },
  { 1272, 14, 24, 20, 4, -24 },
  { 1314, 20, 30, 20, 0, -24 },
  { 1389, 17, 24, 20, 0, -24 },
  { 1440, 18, 24, 20, 1, -24 },
  { 1494, 17, 24, 20, 2, -24 },
  { 1545, 18, 24, 20, 1, -24 },
  { 1599, 19, 24, 20, 1, -24 },
  { 1656, 19, 24, 20, 1, -24 },
  { 1713, 17, 24, 20, 2, -24 },
  { 1764, 19, 24, 20, 1, -24 },
  { 1821, 17, 24, 20, 2, -24 },
  { 1872, 19, 24, 20, 0, -24 },
  { 1929, 20, 24, 20, 1, -24 },
  { 1989, 15, 24, 20, 2, -24 },
  { 2034, 20, 24, 20, 0, -24 },
  { 2094, 19, 24, 20, 1, -24 },
  { 2151, 17, 24, 20, 2, -24 },
  { 2202, 19, 24, 20, 1, -24 },
  { 2259, 17, 30, 20, 2, -24 },
  { 2323, 19, 24, 20, 1, -24 },
  { 2380, 18, 24, 20, 1, -24 },
  { 2434, 18, 24, 20, 3, -24 },
  { 2488, 18, 24, 20, 2, -24 },
  { 2542, 17, 24, 20, 4, -24 },
  { 2593, 20, 24, 20, 2, -24 },
  { 2653, 22, 24, 20, -1, -24 },
  { 2719, 18, 24, 20, 3, -24 },
  { 2773, 18, 24, 20, 1, -24 },
  { 2827, 14, 31, 20, 4, -27 },
  { 2882, 11, 31, 20, 5, -27 },
  { 2925, 15, 31, 20, 2, -27 },
  { 2984, 15, 13, 20, 3, -24 },
  { 3009, 16, 4, 20, 0, 1 },
  { 3017, 7, 5, 20, 8, -26 },
  { 3022, 18, 18, 20, 1, -18 },
  { 3063, 17, 24, 20, 1, -24 },
  { 3114, 16, 18, 20, 2, -18 },
  { 3150, 19, 24, 20, 1, -24 },
  { 3207, 16, 18, 20, 2, -18 },
  { 3243, 23, 30, 20, -2, -24 },
  { 3330, 17, 24, 20, 2, -18 },
  { 3381, 17, 24, 20, 1, -24 },
  { 3432, 16, 26, 20, 1, -26 },
  { 3484, 18, 32, 20, 0, -26 },
  { 3556, 19, 24, 20, 1, -24 },
  { 3613, 15, 24, 20, 3, -24 },
  { 3658, 19, 18, 20, 0, -18 },
  { 3701, 17, 18, 20, 1, -18 },
  { 3740, 16, 18, 20, 2, -18 },
  { 3776, 18, 24, 20, 0, -18 },
  { 3830, 18, 24, 20, 1, -18 },
  { 3884, 17, 18, 20, 2, -18 },
  { 3923, 17, 18, 20, 1, -18 },
  { 3962, 17, 23, 20, 2, -23 },
  { 4011, 17, 18, 20, 2, -18 },
  { 4050, 17, 18, 20, 3, -18 },
  { 4089, 19, 18, 20, 2, -18 },
  { 4132, 20, 18, 20, 0, -18 },
  { 4177, 17, 24, 20, 2, -18 },
  { 4228, 17, 18, 20, 1, -18 },
  { 4267, 17, 31, 20, 3, -27 },
  { 4333, 9, 31, 20, 6, -27 },
  { 4368, 17, 31, 20, 1, -27 },
  { 4434, 17, 8, 20, 2, -16 },
};

const GFXfont JetBrainsMono_BoldItalic33pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic33pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _JETBRAINSMONO_BOLDITALIC33PT7B_H_
