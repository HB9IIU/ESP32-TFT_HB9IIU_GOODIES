#ifndef _JETBRAINSMONO_BOLDITALIC50PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x07, 0xFC, 0x3F, 0xC1, 0xFE, 0x07,
  0xE0, 0x00, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0xBF, 0x87, 0xF7,
  0xF0, 0xFE, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF,
  0xC1, 0xF9, 0xF0, 0x3E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3E,
  0x07, 0xC7, 0xC0, 0xF8, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0xF8, 0x0F, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x7C, 0x07, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0xF0,
  0x00, 0x3C, 0x07, 0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xE0, 0x3E, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xE7, 0x3F, 0xC3, 0xF8,
  0xE3, 0xF8, 0x7E, 0x1C, 0x7F, 0x0F, 0xC3, 0x8F, 0xE1, 0xF8, 0xF0, 0x00,
  0x7F, 0x1C, 0x00, 0x0F, 0xE3, 0x80, 0x00, 0xFE, 0x70, 0x00, 0x1F, 0xEE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0x9F, 0xE0, 0x00, 0xE1, 0xFC, 0x00,
  0x1C, 0x3F, 0x80, 0x03, 0x87, 0xF3, 0xF8, 0x70, 0xFC, 0x7E, 0x0E, 0x1F,
  0x8F, 0xE3, 0xC7, 0xF1, 0xFC, 0x70, 0xFC, 0x3F, 0xEE, 0x7F, 0x83, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x00,
  0x3E, 0x01, 0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0xFE, 0x00, 0x78, 0x03, 0xE1,
  0xF0, 0x0F, 0x00, 0x3C, 0x1F, 0x01, 0xE0, 0x07, 0xC1, 0xF0, 0x3E, 0x00,
  0x7C, 0x1F, 0x07, 0xC0, 0x07, 0x81, 0xE0, 0xF8, 0x00, 0x78, 0x1E, 0x1F,
  0x00, 0x07, 0x81, 0xE3, 0xE0, 0x00, 0x78, 0x3E, 0x3C, 0x00, 0x07, 0xC3,
  0xE7, 0x80, 0x00, 0x7F, 0xFC, 0xF8, 0x00, 0x07, 0xFF, 0x9F, 0x00, 0x00,
  0x3F, 0xF3, 0xE0, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x80, 0x00, 0x00, 0x7C, 0xFF, 0x00, 0x00, 0x0F, 0x9F, 0xFC, 0x00,
  0x01, 0xF3, 0xFF, 0xC0, 0x00, 0x3E, 0x7E, 0x7E, 0x00, 0x03, 0xC7, 0x83,
  0xE0, 0x00, 0x78, 0xF8, 0x3E, 0x00, 0x0F, 0x8F, 0x83, 0xE0, 0x01, 0xF0,
  0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x3C, 0x00,
  0xF8, 0x0F, 0x07, 0xC0, 0x0F, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0x0F, 0xFF,
  0x80, 0x3E, 0x00, 0xFF, 0xF0, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xE3, 0xF8,
  0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x3F, 0x3F, 0x3F, 0x07, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x1F, 0xCF, 0xC7,
  0xE0, 0xFD, 0xF8, 0x7E, 0x0F, 0xFF, 0x07, 0xE0, 0x7F, 0xF0, 0x7E, 0x07,
  0xFE, 0x0F, 0xC0, 0x3F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x80,
  0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xBF, 0x03, 0xFF, 0xE3, 0xF8, 0x0F, 0xF8, 0x1F,
  0x80, 0x08, 0x00, 0x04, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0xFE, 0xFE, 0xFE,
  0xFC, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0x00, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0xC0, 0x7C, 0x02, 0x3E, 0x0F, 0x83, 0xC7, 0xF1, 0xE1, 0xFD,
  0xFF, 0x3C, 0xFF, 0xBF, 0xF3, 0x7F, 0xFF, 0xFF, 0x7F, 0xFE, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1E, 0x78, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x3F,
  0x80, 0x1F, 0x87, 0xF0, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x1F,
  0x00, 0xF0, 0x00, 0xC0, 0x1C, 0x00, 0x08, 0x01, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x0F, 0xE3, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7,
  0xFD, 0xFE, 0x3F, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFD, 0xFF, 0x81, 0xFC, 0x07, 0xF0, 0x7F,
  0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x03, 0xF0, 0xFC, 0x70, 0x7E, 0x3F, 0x1F, 0x0F, 0xC7, 0xE7, 0xF1, 0xF0,
  0xFC, 0xFE, 0x7E, 0x1F, 0x9F, 0xCF, 0xC3, 0xF1, 0xF1, 0xF8, 0x7E, 0x1C,
  0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07,
  0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xE3, 0xF0, 0x0F,
  0x83, 0xF0, 0x0F, 0x03, 0xF0, 0x0C, 0x03, 0xF0, 0x08, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFC, 0x07, 0xF0, 0x7F,
  0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x3F,
  0x87, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xE0,
  0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF7, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xBF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xC3, 0xFC, 0x0F, 0xE0, 0x3F, 0xC1, 0xF8, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xFC,
  0x1F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xCF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC7, 0xFE,
  0x3F, 0xE3, 0xFC, 0x07, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFC,
  0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x03, 0xF8,
  0xFF, 0x03, 0xFC, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFC,
  0xFE, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFC, 0x07, 0xF0, 0x7F,
  0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F,
  0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0xCF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xC3,
  0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x03,
  0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x07, 0xFE, 0x7F, 0xC3, 0xFC, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x7F, 0x00,
  0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xFE,
  0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xF3, 0xF8, 0x01, 0xFC,
  0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x7F, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x1F,
  0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xFE, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x08, 0x00,
  0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x00, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x03, 0xE1, 0xF8, 0x01, 0x87, 0xC3, 0xE0, 0x1F, 0xCF, 0x87,
  0xC0, 0x7F, 0xDF, 0x0F, 0x81, 0xFF, 0xBE, 0x1F, 0x07, 0xF3, 0xFC, 0x3E,
  0x0F, 0x81, 0xF0, 0xFC, 0x3F, 0x03, 0xE1, 0xF0, 0x7C, 0x07, 0xC3, 0xE0,
  0xF8, 0x0F, 0x87, 0xC1, 0xF0, 0x1F, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x0F,
  0xC0, 0xFC, 0x7E, 0x1F, 0x01, 0xF0, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x7C,
  0x07, 0xC3, 0xE0, 0xF8, 0x0F, 0x87, 0xC1, 0xF0, 0x3F, 0x0F, 0x83, 0xF0,
  0xFE, 0x3F, 0x07, 0xFF, 0xF8, 0x7E, 0x0F, 0xFE, 0xF0, 0xF8, 0x0F, 0xFB,
  0xE1, 0xF0, 0x0F, 0xE7, 0xC3, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xEF,
  0x80, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x1F,
  0x00, 0xFC, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7F,
  0x7F, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x83, 0xF8, 0x07, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE1,
  0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x1F, 0xF8, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8,
  0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80,
  0x3F, 0xC3, 0xF0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFC, 0x07, 0xF8, 0x7F, 0x00,
  0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xF0,
  0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x83, 0xF8, 0x1F, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0,
  0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF1,
  0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xE1, 0xF8,
  0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xFC,
  0x1F, 0x80, 0x7F, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFC, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0xFF,
  0x1F, 0x83, 0xFF, 0xC3, 0xF0, 0x7F, 0xF8, 0x7E, 0x0F, 0xFF, 0x0F, 0xC3,
  0xFF, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00,
  0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x0F,
  0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F,
  0xC0, 0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC1, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xF0, 0x03, 0xF0, 0x3F, 0x00,
  0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFE,
  0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x10, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00,
  0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x1F,
  0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFC, 0x1F, 0xC0,
  0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x01,
  0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E,
  0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07,
  0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x03, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x07,
  0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x83, 0xEF,
  0x07, 0xBE, 0x0F, 0xBC, 0x1E, 0xF8, 0x3E, 0xF0, 0xF7, 0xC0, 0xFB, 0xC3,
  0xDF, 0x03, 0xEF, 0x1F, 0x7C, 0x1F, 0xBC, 0x79, 0xF0, 0x7E, 0xFB, 0xEF,
  0xC1, 0xF9, 0xEF, 0x3F, 0x07, 0xC7, 0xBC, 0xF8, 0x1F, 0x1F, 0xE3, 0xE0,
  0x7C, 0x7F, 0x8F, 0x81, 0xF1, 0xFC, 0x7E, 0x0F, 0xC7, 0xF1, 0xF8, 0x3F,
  0x1F, 0xC7, 0xE0, 0xFC, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7C, 0x0F, 0xC0,
  0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E,
  0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x3F, 0x00, 0x03, 0xFC, 0x01, 0xF8, 0x1F, 0xE0, 0x0F, 0xC0, 0xFF,
  0x00, 0x7E, 0x07, 0xF8, 0x03, 0xF0, 0x3F, 0xE0, 0x1F, 0x03, 0xFF, 0x01,
  0xF8, 0x1F, 0xF8, 0x0F, 0xC0, 0xFF, 0xC0, 0x7E, 0x07, 0xFE, 0x03, 0xF0,
  0x3E, 0xF0, 0x1F, 0x81, 0xF7, 0xC0, 0xF8, 0x1F, 0xBE, 0x07, 0xC0, 0xFD,
  0xF0, 0x7E, 0x07, 0xEF, 0x83, 0xF0, 0x3F, 0x7C, 0x1F, 0x81, 0xF1, 0xF0,
  0xFC, 0x0F, 0x8F, 0x87, 0xC0, 0xFC, 0x7C, 0x3E, 0x07, 0xE3, 0xE3, 0xF0,
  0x3F, 0x1F, 0x1F, 0x81, 0xF8, 0x7C, 0xFC, 0x0F, 0xC3, 0xE7, 0xE0, 0x7C,
  0x1F, 0x3F, 0x03, 0xE0, 0xF9, 0xF0, 0x3F, 0x07, 0xCF, 0x81, 0xF8, 0x1E,
  0x7C, 0x0F, 0xC0, 0xFB, 0xE0, 0x7E, 0x07, 0xFF, 0x03, 0xE0, 0x3F, 0xF8,
  0x1F, 0x01, 0xFF, 0x81, 0xF8, 0x0F, 0xFC, 0x0F, 0xC0, 0x3F, 0xE0, 0x7E,
  0x01, 0xFF, 0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0x80, 0x7F, 0xC0, 0xF8, 0x03,
  0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFE,
  0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE3,
  0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F,
  0xC0, 0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xE0, 0x1F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xC0, 0x07, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0xFE, 0x1F,
  0x80, 0x3F, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFC, 0x07,
  0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x7F,
  0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xC7, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7E, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87,
  0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x1F,
  0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xE0,
  0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE1, 0xFC,
  0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x7F,
  0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF0, 0x07,
  0xE0, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0,
  0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xF7, 0xFE, 0x03, 0xF8, 0x0F, 0xF0,
  0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x07,
  0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xF0,
  0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE,
  0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x1F,
  0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F,
  0x00, 0x1F, 0x83, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x83, 0xF0, 0x03,
  0xF0, 0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07,
  0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x00,
  0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x02,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC1,
  0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x03,
  0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0x1F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80,
  0x01, 0xFB, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x7E, 0x7E,
  0x07, 0xC0, 0xFC, 0xFC, 0x1F, 0x81, 0xF1, 0xF0, 0x3F, 0x03, 0xE3, 0xE0,
  0x7E, 0x0F, 0xC7, 0xC0, 0xFC, 0x1F, 0x0F, 0x83, 0xB8, 0x3E, 0x1F, 0x07,
  0x70, 0x7C, 0x3E, 0x0E, 0xE1, 0xF8, 0x7C, 0x3D, 0xC3, 0xE0, 0xF8, 0x7F,
  0x87, 0xC1, 0xF0, 0xEF, 0x0F, 0x83, 0xE1, 0xDE, 0x3F, 0x07, 0xC7, 0xBC,
  0x7C, 0x0F, 0x8E, 0x78, 0xF8, 0x1F, 0x1C, 0xF1, 0xF0, 0x7E, 0x79, 0xE3,
  0xE0, 0xF8, 0xF3, 0x8F, 0x81, 0xF1, 0xC7, 0x1F, 0x03, 0xE3, 0x8E, 0x3E,
  0x07, 0xCF, 0x1C, 0x78, 0x0F, 0x9E, 0x39, 0xF0, 0x1F, 0x38, 0x73, 0xE0,
  0x3E, 0x70, 0xE7, 0xC0, 0x7D, 0xE1, 0xCF, 0x00, 0xFB, 0x83, 0xBE, 0x01,
  0xF7, 0x07, 0x7C, 0x03, 0xFE, 0x0E, 0xF8, 0x07, 0xFC, 0x1D, 0xE0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x1E, 0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8,
  0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xF0,
  0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0xFD,
  0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F,
  0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x07, 0xE0, 0x3F, 0x0F, 0x80, 0x7E,
  0x3F, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0xF3, 0xF0,
  0x3F, 0xFC, 0xFC, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF, 0xEF, 0xC3, 0xFF, 0x7F,
  0xF1, 0xFE, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x8F, 0xE0,
  0x07, 0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F,
  0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x3F, 0xE1, 0xFF, 0xFD, 0xF8, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xBF, 0x01, 0xFF, 0xCF, 0xC0, 0x3F, 0xE3, 0xF0,
  0x00, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0xFC, 0xFF, 0xC0, 0x3F, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xEF,
  0xFF, 0xE1, 0xFF, 0xDF, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87,
  0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0x7E,
  0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0,
  0xFD, 0xFF, 0xFC, 0x3F, 0x7F, 0xFE, 0x0F, 0xDF, 0xFF, 0x03, 0xF3, 0xFF,
  0x80, 0xFC, 0x7F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0x7F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x01,
  0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x1F, 0xE0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFF, 0xCF, 0xC0, 0x3F, 0xFC,
  0xFC, 0x07, 0xFF, 0xEF, 0xC0, 0xFF, 0xFE, 0xFC, 0x0F, 0xFD, 0xFF, 0xC1,
  0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0x83, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x83, 0xF0, 0x03, 0xF0,
  0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x07, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F,
  0xFF, 0x7E, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0xFC, 0x01, 0xFF, 0xCF,
  0xC0, 0x0F, 0xF8, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x03, 0xFC, 0x1F, 0xE0, 0xFC, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x87, 0xF0, 0x0F, 0xC0, 0xFF,
  0xBF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x20, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0xFF, 0xCF, 0xC1, 0xFF, 0xF7, 0xE1, 0xFF, 0xFB, 0xF1,
  0xFF, 0xFD, 0xF8, 0xFF, 0xDF, 0xFC, 0xFF, 0x03, 0xFC, 0x7F, 0x00, 0xFE,
  0x3F, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x0F,
  0xE7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF9, 0xFC, 0x00,
  0xFC, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0,
  0x3F, 0x8F, 0xF0, 0x7F, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFB, 0xF0, 0x7F,
  0xF9, 0xF8, 0x3F, 0xFD, 0xFC, 0x07, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0xFC, 0xFF, 0xC0, 0x3F, 0x7F, 0xF8, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xDF, 0xF8, 0x7F, 0x80, 0xFE, 0x1F,
  0xC0, 0x3F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0x07, 0xF1, 0xF8,
  0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE0,
  0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0xC0,
  0x7F, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x1F, 0xC0,
  0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x7F, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7E,
  0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xC7, 0x83, 0xC0, 0x3E, 0xFE,
  0x7F, 0x83, 0xFF, 0xF3, 0xFC, 0x1F, 0x7F, 0xBF, 0xF0, 0xFE, 0xFF, 0xBF,
  0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0x78, 0x3E, 0x1F,
  0x83, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x3F, 0x0F,
  0x87, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xC1, 0xF8, 0x7C, 0x1E, 0x0F,
  0x87, 0xE0, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F,
  0x83, 0xE1, 0xF8, 0x7C, 0x1E, 0x0F, 0xC3, 0xE0, 0xF0, 0x7C, 0x3F, 0x07,
  0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F,
  0xC3, 0xE0, 0xF0, 0x7E, 0x1F, 0x07, 0x83, 0xE1, 0xF8, 0x3C, 0x1F, 0x00,
  0x0F, 0xC3, 0xF8, 0x03, 0xF3, 0xFF, 0x00, 0xFD, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xBF, 0xFF, 0x87, 0xFF, 0x7F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F,
  0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0xC0, 0x1F, 0xC7, 0xE0,
  0x07, 0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87,
  0xE0, 0x07, 0xE3, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0x7F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0x1F,
  0x8F, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x3F, 0x8F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xF1, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x3F,
  0xF0, 0x03, 0xF7, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xEF, 0xFF, 0xE0,
  0x7F, 0xF7, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC,
  0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x3F,
  0xE0, 0xFF, 0x03, 0xF7, 0xFF, 0xF0, 0x3F, 0x7F, 0xFE, 0x03, 0xF7, 0xFF,
  0xC0, 0x3F, 0x3F, 0xF8, 0x03, 0xF1, 0xFE, 0x00, 0x3F, 0x03, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0xF3, 0xF0, 0x3F,
  0xFC, 0xFC, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF, 0xEF, 0xC3, 0xFF, 0x7F, 0xF1,
  0xFE, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x8F, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x3F, 0xE1, 0xFF, 0xFD, 0xF8, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xBF, 0x01, 0xFF, 0xCF, 0xC0, 0x3F, 0xE3, 0xF0, 0x00,
  0x80, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0xFF, 0xE0,
  0x1F, 0x3F, 0xFE, 0x07, 0xEF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8,
  0xFF, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xC0, 0x0F, 0xE3,
  0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x01,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xF8, 0x0F, 0xE1,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x0F, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xA0, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0xC0,
  0x1F, 0xC7, 0xE0, 0x07, 0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFE,
  0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00,
  0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xF1, 0xF8,
  0x01, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x3F, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xF7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x3F,
  0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E,
  0x00, 0x0F, 0x9F, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0xF8, 0x0F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F,
  0x81, 0xFF, 0x81, 0xF8, 0x3E, 0xF8, 0x3F, 0x83, 0xEF, 0x83, 0xF8, 0x3E,
  0xF8, 0x3F, 0x87, 0xCF, 0x87, 0xF8, 0x7C, 0xF8, 0x77, 0x87, 0xCF, 0x87,
  0x78, 0xF8, 0xF8, 0xF7, 0x8F, 0x8F, 0x8E, 0x78, 0xF8, 0xF8, 0xE7, 0x9F,
  0x0F, 0x8E, 0x79, 0xF0, 0xF9, 0xE7, 0x9F, 0x0F, 0x9C, 0x79, 0xE0, 0xF9,
  0xC7, 0xBE, 0x0F, 0xBC, 0x7B, 0xE0, 0xFB, 0x87, 0x3E, 0x0F, 0xB8, 0x77,
  0xC0, 0xFF, 0x87, 0x7C, 0x0F, 0xF0, 0x77, 0xC0, 0xFF, 0x07, 0x78, 0x0F,
  0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x7E, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7,
  0xF0, 0x07, 0xF3, 0xF0, 0x03, 0xF9, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x9F, 0x80, 0x1F,
  0xCF, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF8, 0x01,
  0xF9, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80,
  0x7F, 0x1F, 0xE0, 0x7F, 0x8F, 0xFD, 0xFF, 0xC3, 0xFF, 0xF7, 0xE1, 0xFF,
  0xFB, 0xF0, 0x7F, 0xFB, 0xF8, 0x1F, 0xF9, 0xF8, 0x07, 0xF0, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0x00, 0x7C,
  0x3F, 0xF0, 0x1F, 0x8F, 0xFF, 0x03, 0xF3, 0xFF, 0xF0, 0x7C, 0xFE, 0xFE,
  0x0F, 0x9F, 0x8F, 0xE3, 0xF3, 0xE0, 0xFF, 0xFE, 0x7C, 0x0F, 0xFF, 0x8F,
  0x81, 0xFF, 0xE3, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0xFE, 0x00,
};

const GFXglyph JetBrainsMono_BoldItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 13, 37, 30, 9, -37 },
  { 62, 19, 16, 30, 8, -37 },
  { 100, 30, 37, 30, 1, -37 },
  { 239, 27, 51, 30, 2, -44 },
  { 412, 36, 37, 30, -2, -37 },
  { 579, 28, 38, 30, 1, -37 },
  { 712, 8, 16, 30, 14, -37 },
  { 728, 22, 48, 30, 7, -42 },
  { 860, 21, 48, 30, 3, -42 },
  { 986, 27, 27, 30, 2, -31 },
  { 1078, 25, 23, 30, 3, -28 },
  { 1150, 15, 16, 30, 4, -8 },
  { 1180, 18, 5, 30, 6, -19 },
  { 1192, 10, 10, 30, 8, -9 },
  { 1205, 31, 48, 30, 0, -42 },
  { 1391, 27, 38, 30, 2, -37 },
  { 1520, 24, 37, 30, 2, -37 },
  { 1631, 27, 37, 30, 2, -37 },
  { 1756, 27, 38, 30, 2, -37 },
  { 1885, 26, 37, 30, 2, -37 },
  { 2006, 27, 38, 30, 2, -37 },
  { 2135, 25, 38, 30, 2, -37 },
  { 2254, 26, 37, 30, 5, -37 },
  { 2375, 27, 38, 30, 2, -37 },
  { 2504, 26, 37, 30, 4, -37 },
  { 2625, 14, 29, 30, 8, -28 },
  { 2676, 18, 36, 30, 4, -28 },
  { 2757, 25, 27, 30, 4, -30 },
  { 2842, 25, 19, 30, 3, -26 },
  { 2902, 25, 27, 30, 2, -30 },
  { 2987, 22, 37, 30, 6, -37 },
  { 3089, 31, 46, 30, 0, -37 },
  { 3268, 26, 37, 30, 0, -37 },
  { 3389, 27, 37, 30, 2, -37 },
  { 3514, 27, 38, 30, 2, -37 },
  { 3643, 27, 37, 30, 2, -37 },
  { 3768, 28, 37, 30, 2, -37 },
  { 3898, 28, 37, 30, 2, -37 },
  { 4028, 27, 38, 30, 2, -37 },
  { 4157, 28, 37, 30, 2, -37 },
  { 4287, 27, 37, 30, 2, -37 },
  { 4412, 29, 38, 30, 0, -37 },
  { 4550, 30, 37, 30, 2, -37 },
  { 4689, 23, 37, 30, 3, -37 },
  { 4796, 30, 37, 30, 1, -37 },
  { 4935, 29, 37, 30, 1, -37 },
  { 5070, 27, 38, 30, 2, -37 },
  { 5199, 28, 37, 30, 2, -37 },
  { 5329, 27, 46, 30, 2, -37 },
  { 5485, 28, 37, 30, 2, -37 },
  { 5615, 28, 38, 30, 1, -37 },
  { 5748, 26, 37, 30, 5, -37 },
  { 5869, 28, 38, 30, 2, -37 },
  { 6002, 27, 37, 30, 5, -37 },
  { 6127, 31, 37, 30, 2, -37 },
  { 6271, 33, 37, 30, -1, -37 },
  { 6424, 27, 37, 30, 5, -37 },
  { 6549, 27, 37, 30, 2, -37 },
  { 6674, 22, 48, 30, 6, -42 },
  { 6806, 17, 48, 30, 7, -42 },
  { 6908, 21, 48, 30, 4, -42 },
  { 7034, 23, 20, 30, 4, -37 },
  { 7092, 25, 6, 30, 0, 1 },
  { 7111, 11, 7, 30, 12, -39 },
  { 7121, 26, 29, 30, 2, -28 },
  { 7216, 26, 38, 30, 2, -37 },
  { 7340, 26, 29, 30, 2, -28 },
  { 7435, 28, 38, 30, 2, -37 },
  { 7568, 26, 29, 30, 2, -28 },
  { 7663, 34, 46, 30, -3, -37 },
  { 7859, 25, 37, 30, 3, -28 },
  { 7975, 26, 37, 30, 2, -37 },
  { 8096, 26, 39, 30, 1, -39 },
  { 8223, 27, 48, 30, 0, -39 },
  { 8385, 28, 37, 30, 2, -37 },
  { 8515, 23, 37, 30, 4, -37 },
  { 8622, 29, 28, 30, 0, -28 },
  { 8724, 26, 28, 30, 2, -28 },
  { 8815, 26, 29, 30, 2, -28 },
  { 8910, 28, 37, 30, 0, -28 },
  { 9040, 26, 37, 30, 2, -28 },
  { 9161, 27, 28, 30, 2, -28 },
  { 9256, 26, 29, 30, 2, -28 },
  { 9351, 26, 35, 30, 3, -35 },
  { 9465, 26, 29, 30, 2, -28 },
  { 9560, 26, 28, 30, 4, -28 },
  { 9651, 28, 28, 30, 3, -28 },
  { 9749, 30, 28, 30, 0, -28 },
  { 9854, 25, 37, 30, 3, -28 },
  { 9970, 26, 28, 30, 2, -28 },
  { 10061, 26, 48, 30, 4, -42 },
  { 10217, 14, 48, 30, 9, -42 },
  { 10301, 26, 48, 30, 1, -42 },
  { 10457, 27, 12, 30, 2, -24 },
};

const GFXfont JetBrainsMono_BoldItalic50pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic50pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic50pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _JETBRAINSMONO_BOLDITALIC50PT7B_H_
