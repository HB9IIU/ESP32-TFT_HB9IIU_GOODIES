#ifndef _JETBRAINSMONO_BOLDITALIC11PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x24, 0x06, 0xDB, 0xB0, 0x16, 0x29, 0xF9, 0x42, 0x9F, 0x94,
  0x68, 0x08, 0x23, 0xDD, 0x71, 0xE1, 0xC7, 0xDD, 0xE2, 0x08, 0x39, 0x2A,
  0x2C, 0x38, 0x0E, 0x1A, 0x2A, 0xCE, 0x3C, 0x92, 0x18, 0x57, 0x6D, 0x9F,
  0xF8, 0x36, 0x4C, 0x88, 0x88, 0xC6, 0x63, 0x11, 0x13, 0x32, 0x6C, 0x18,
  0x4F, 0xC4, 0x29, 0x20, 0x21, 0x3E, 0x46, 0x00, 0x6B, 0x40, 0xF0, 0xF0,
  0x06, 0x08, 0x30, 0x41, 0x06, 0x08, 0x30, 0x41, 0x80, 0x7E, 0x63, 0x5A,
  0xCE, 0x5E, 0x19, 0xA5, 0x86, 0x10, 0x41, 0x3F, 0x3D, 0x90, 0x43, 0x18,
  0xC6, 0x3F, 0x3C, 0x31, 0x8E, 0x0C, 0x3C, 0x9E, 0x0C, 0x63, 0x09, 0x4D,
  0xF8, 0x82, 0x3C, 0x86, 0x1F, 0x0C, 0x34, 0x9E, 0x0C, 0x43, 0x1E, 0x4F,
  0x14, 0xDE, 0xFF, 0x21, 0x84, 0x30, 0x86, 0x30, 0x3D, 0x96, 0x4E, 0x69,
  0x34, 0xDE, 0x7B, 0x28, 0xB6, 0x78, 0xC2, 0x30, 0x68, 0x0D, 0x80, 0x32,
  0x00, 0x64, 0xC8, 0x08, 0xF9, 0x06, 0x0C, 0xFF, 0xC1, 0xF0, 0x41, 0xC1,
  0xC3, 0x3B, 0x00, 0x70, 0xC2, 0xF6, 0x20, 0x18, 0x3C, 0x8D, 0x0A, 0xFD,
  0x56, 0xAF, 0x40, 0xC0, 0xE0, 0x18, 0x62, 0x8A, 0x69, 0xE4, 0xF3, 0x3D,
  0x96, 0x5E, 0x4D, 0x14, 0xFE, 0x7E, 0x71, 0x08, 0x42, 0x7E, 0x3D, 0x96,
  0x51, 0x45, 0x34, 0xBE, 0x3E, 0x41, 0x83, 0xE4, 0x08, 0x10, 0x7C, 0x3E,
  0xC1, 0x83, 0xE7, 0xC8, 0x10, 0x60, 0x7E, 0x71, 0x0B, 0xCE, 0x7E, 0x26,
  0xC9, 0x93, 0xE4, 0xC9, 0x93, 0x64, 0x3C, 0x61, 0x04, 0x10, 0x43, 0x3E,
  0x1C, 0x10, 0x43, 0x0C, 0x3C, 0x9C, 0x26, 0xD9, 0xA3, 0xC5, 0x89, 0x12,
  0x66, 0x42, 0x11, 0x8C, 0x42, 0x1F, 0x66, 0xDD, 0xB2, 0xA5, 0x48, 0xB3,
  0x66, 0x66, 0xE9, 0x52, 0xA5, 0x4A, 0x97, 0x64, 0x7E, 0x73, 0x18, 0xCE,
  0x5E, 0x3C, 0xCD, 0x9A, 0x67, 0x88, 0x10, 0x60, 0x7E, 0x73, 0x18, 0xCE,
  0x5E, 0x20, 0x80, 0x3C, 0xC9, 0x92, 0x67, 0x8B, 0x12, 0x66, 0x3D, 0x96,
  0x1C, 0x1C, 0x3C, 0xDE, 0xFC, 0xC2, 0x08, 0x20, 0x86, 0x18, 0x66, 0xC9,
  0x92, 0x24, 0x49, 0x92, 0x3C, 0xCF, 0x2C, 0x96, 0x51, 0xC6, 0x18, 0xB6,
  0xDB, 0xF6, 0xDB, 0x69, 0x24, 0x66, 0x58, 0xE0, 0xC3, 0x07, 0x12, 0x66,
  0xCD, 0x25, 0x94, 0x60, 0x86, 0x18, 0x3C, 0x30, 0x86, 0x31, 0x84, 0x3E,
  0x39, 0x08, 0xC6, 0x21, 0x08, 0x47, 0x80, 0x93, 0x64, 0x93, 0x24, 0x78,
  0x84, 0x23, 0x18, 0x84, 0x27, 0x00, 0x31, 0x95, 0x90, 0xFF, 0xC0, 0xB0,
  0x3D, 0xB4, 0xD3, 0x4D, 0xE0, 0x21, 0x87, 0xDB, 0x45, 0x34, 0xBE, 0x7E,
  0x61, 0x09, 0xF8, 0x06, 0x08, 0xF3, 0x64, 0xC9, 0x93, 0x3C, 0x7C, 0x7F,
  0x09, 0xF8, 0x0F, 0x08, 0x08, 0x3E, 0x18, 0x18, 0x10, 0x10, 0x10, 0xE0,
  0x7E, 0xE7, 0x3F, 0xA8, 0x5C, 0x21, 0x87, 0xDB, 0x4D, 0x34, 0xF2, 0x08,
  0x60, 0x1E, 0x10, 0x41, 0x04, 0xFC, 0x04, 0x30, 0x0F, 0x48, 0x20, 0x86,
  0x18, 0x4E, 0x00, 0x20, 0xC1, 0x9A, 0x47, 0x8B, 0x12, 0x66, 0xE1, 0x08,
  0xC6, 0x21, 0x0F, 0x7D, 0x55, 0x75, 0xD6, 0xB0, 0x7D, 0xB4, 0xD3, 0x4F,
  0x20, 0x7E, 0xE3, 0x39, 0x78, 0x7D, 0x94, 0x53, 0x4B, 0xEC, 0x20, 0x3D,
  0xB4, 0xD3, 0x4D, 0xE0, 0x82, 0xFE, 0x63, 0x08, 0x40, 0x3D, 0x17, 0x03,
  0xCD, 0xE0, 0x21, 0x3E, 0xC6, 0x21, 0x0E, 0xCC, 0x67, 0x39, 0x78, 0x8F,
  0x6D, 0x14, 0x61, 0x80, 0xA6, 0xAE, 0xBA, 0xD2, 0x40, 0x66, 0x50, 0xC1,
  0x87, 0x99, 0x80, 0xCC, 0x67, 0x3F, 0x28, 0x5C, 0x7C, 0x31, 0x8C, 0x43,
  0xE0, 0x1C, 0x41, 0x0C, 0xE3, 0x82, 0x08, 0x20, 0xC0, 0x6D, 0xA4, 0x96,
  0xD0, 0x30, 0x41, 0x0C, 0x1C, 0x72, 0x08, 0x23, 0x80, 0x77, 0x70,
};

const GFXglyph JetBrainsMono_BoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 8, 7, 2, -8 },
  { 4, 4, 3, 7, 2, -8 },
  { 6, 7, 8, 7, 0, -8 },
  { 13, 6, 12, 7, 0, -10 },
  { 22, 8, 8, 7, -1, -8 },
  { 30, 6, 8, 7, 0, -8 },
  { 36, 2, 3, 7, 3, -8 },
  { 37, 4, 10, 7, 2, -9 },
  { 42, 4, 10, 7, 1, -9 },
  { 47, 6, 6, 7, 0, -7 },
  { 52, 5, 5, 7, 1, -6 },
  { 56, 3, 4, 7, 1, -2 },
  { 58, 4, 1, 7, 1, -4 },
  { 59, 2, 2, 7, 2, -2 },
  { 60, 7, 10, 7, 0, -9 },
  { 69, 5, 8, 7, 1, -8 },
  { 74, 6, 8, 7, 0, -8 },
  { 80, 6, 8, 7, 0, -8 },
  { 86, 6, 8, 7, 0, -8 },
  { 92, 6, 8, 7, 0, -8 },
  { 98, 6, 8, 7, 0, -8 },
  { 104, 6, 8, 7, 0, -8 },
  { 110, 6, 8, 7, 1, -8 },
  { 116, 6, 8, 7, 0, -8 },
  { 122, 6, 8, 7, 1, -8 },
  { 128, 3, 6, 7, 2, -6 },
  { 131, 4, 8, 7, 1, -6 },
  { 135, 5, 6, 7, 1, -7 },
  { 139, 5, 4, 7, 1, -6 },
  { 142, 6, 6, 7, 0, -7 },
  { 147, 5, 8, 7, 1, -8 },
  { 152, 7, 10, 7, 0, -8 },
  { 161, 6, 8, 7, 0, -8 },
  { 167, 6, 8, 7, 0, -8 },
  { 173, 5, 8, 7, 1, -8 },
  { 178, 6, 8, 7, 0, -8 },
  { 184, 7, 8, 7, 0, -8 },
  { 191, 7, 8, 7, 0, -8 },
  { 198, 5, 8, 7, 1, -8 },
  { 203, 7, 8, 7, 0, -8 },
  { 210, 6, 8, 7, 0, -8 },
  { 216, 6, 8, 7, 0, -8 },
  { 222, 7, 8, 7, 0, -8 },
  { 229, 5, 8, 7, 1, -8 },
  { 234, 7, 8, 7, 0, -8 },
  { 241, 7, 8, 7, 0, -8 },
  { 248, 5, 8, 7, 1, -8 },
  { 253, 7, 8, 7, 0, -8 },
  { 260, 5, 10, 7, 1, -8 },
  { 267, 7, 8, 7, 0, -8 },
  { 274, 6, 8, 7, 0, -8 },
  { 280, 6, 8, 7, 1, -8 },
  { 286, 7, 8, 7, 0, -8 },
  { 293, 6, 8, 7, 1, -8 },
  { 299, 6, 8, 7, 1, -8 },
  { 305, 7, 8, 7, 0, -8 },
  { 312, 6, 8, 7, 1, -8 },
  { 318, 6, 8, 7, 0, -8 },
  { 324, 5, 10, 7, 1, -9 },
  { 331, 3, 10, 7, 2, -9 },
  { 335, 5, 10, 7, 1, -9 },
  { 342, 5, 4, 7, 1, -8 },
  { 345, 5, 2, 7, 0, 0 },
  { 347, 2, 2, 7, 3, -9 },
  { 348, 6, 6, 7, 0, -6 },
  { 353, 6, 8, 7, 0, -8 },
  { 359, 5, 6, 7, 1, -6 },
  { 363, 7, 8, 7, 0, -8 },
  { 370, 5, 6, 7, 1, -6 },
  { 374, 8, 10, 7, -1, -8 },
  { 384, 5, 8, 7, 1, -6 },
  { 389, 6, 8, 7, 0, -8 },
  { 395, 6, 9, 7, 0, -9 },
  { 402, 6, 11, 7, 0, -9 },
  { 411, 7, 8, 7, 0, -8 },
  { 418, 5, 8, 7, 1, -8 },
  { 423, 6, 6, 7, 0, -6 },
  { 428, 6, 6, 7, 0, -6 },
  { 433, 5, 6, 7, 1, -6 },
  { 437, 6, 8, 7, 0, -6 },
  { 443, 6, 8, 7, 0, -6 },
  { 449, 5, 6, 7, 1, -6 },
  { 453, 6, 6, 7, 0, -6 },
  { 458, 5, 8, 7, 1, -8 },
  { 463, 5, 6, 7, 1, -6 },
  { 467, 6, 6, 7, 1, -6 },
  { 472, 6, 6, 7, 1, -6 },
  { 477, 7, 6, 7, 0, -6 },
  { 483, 5, 8, 7, 1, -6 },
  { 488, 6, 6, 7, 0, -6 },
  { 493, 6, 10, 7, 1, -9 },
  { 501, 3, 10, 7, 2, -9 },
  { 505, 6, 10, 7, 0, -9 },
  { 513, 6, 2, 7, 0, -5 },
};

const GFXfont JetBrainsMono_BoldItalic11pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic11pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _JETBRAINSMONO_BOLDITALIC11PT7B_H_
