#ifndef _JETBRAINSMONO_BOLDITALIC25PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE1, 0xC0,
  0x00, 0x00, 0x3C, 0x78, 0xE0, 0x73, 0xDC, 0xE7, 0x3B, 0x8E, 0xE3, 0xB8,
  0xEE, 0x30, 0x01, 0x8E, 0x07, 0x18, 0x0C, 0x30, 0x18, 0xE3, 0xFF, 0xE7,
  0xFF, 0xC1, 0x8E, 0x07, 0x18, 0x0C, 0x30, 0x18, 0xE0, 0x71, 0x83, 0xFF,
  0xEF, 0xFF, 0x87, 0x18, 0x0C, 0x30, 0x18, 0xE0, 0x71, 0x80, 0xC3, 0x00,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x07, 0xF0, 0x7F, 0xE1, 0xDF,
  0x8E, 0x4E, 0x39, 0x38, 0xE4, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0x00, 0x9C, 0x06, 0x73, 0x99, 0xCF, 0x6F, 0x3F, 0xF8, 0x7F,
  0xC0, 0xFE, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0F, 0x81,
  0xC7, 0xF0, 0xC1, 0x8C, 0x70, 0xE3, 0x38, 0x39, 0xDC, 0x0E, 0x66, 0x01,
  0xFB, 0x00, 0x7D, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3B, 0xE0, 0x1D,
  0xF8, 0x06, 0xE6, 0x03, 0x31, 0x81, 0x8C, 0x60, 0xC3, 0x18, 0x60, 0xFC,
  0x38, 0x1E, 0x00, 0x00, 0x80, 0x07, 0xE0, 0x3F, 0xE0, 0x71, 0xC0, 0xC3,
  0x83, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x7E, 0x00, 0xFE, 0x7B,
  0x9D, 0xE7, 0x1F, 0x8E, 0x3E, 0x1C, 0x38, 0x38, 0x70, 0x73, 0xF0, 0xFF,
  0xE0, 0xFC, 0xE0, 0x7F, 0xEE, 0xEE, 0xE0, 0x00, 0xC0, 0xF0, 0x7C, 0x3C,
  0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xE0,
  0x18, 0x0C, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03,
  0x80, 0x70, 0x1C, 0x07, 0x83, 0xE0, 0xF8, 0x1C, 0x06, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x18, 0xC2, 0x7B, 0x7B, 0xFB, 0xF1, 0xFE, 0x01, 0xC0,
  0x0D, 0x80, 0xF7, 0x03, 0x9E, 0x1C, 0x38, 0x20, 0x80, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0F, 0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xF0, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1C, 0x00, 0x1E, 0x3C, 0xF1, 0xC7, 0x8E, 0x1C, 0x70,
  0x7F, 0xBF, 0xFF, 0xE0, 0x7F, 0xFE, 0xE0, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x1F, 0xC1, 0xFF,
  0x87, 0x1E, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x9C, 0x0E, 0x73, 0x39, 0xDC,
  0xE7, 0x73, 0x9C, 0x9C, 0x70, 0x73, 0x81, 0xCE, 0x07, 0x3C, 0x3C, 0x7F,
  0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0xFE, 0x1F, 0xC3, 0xDC, 0x31,
  0xC2, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x78, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x80, 0x7F, 0x87,
  0xFE, 0x7C, 0xF3, 0x83, 0x9C, 0x1D, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xF7,
  0xFF, 0xBF, 0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x1C, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x70, 0x3B, 0xC3, 0xDF, 0x7C, 0x7F, 0xC1, 0xFC, 0x00, 0x00, 0x78, 0x07,
  0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x38, 0x03, 0x8E, 0x3C, 0x73,
  0xC3, 0x9C, 0x1C, 0xE0, 0xEF, 0xFF, 0x7F, 0xF8, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xEF, 0x87, 0xFE, 0x3F, 0xF3, 0xC3, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x3B, 0xC3, 0xCF, 0xFC, 0x7F, 0xC1, 0xFC, 0x00, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0xFC, 0x3F, 0xF3,
  0xC7, 0x9C, 0x1F, 0xC0, 0xFE, 0x07, 0x70, 0x3B, 0xC3, 0xCF, 0x7C, 0x7F,
  0xC1, 0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xE0, 0xE7, 0x07, 0x40,
  0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x00, 0x00, 0x80, 0x7F,
  0x87, 0xFE, 0x38, 0xF3, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x8E, 0x1F, 0xE0,
  0x7E, 0x07, 0xF8, 0x71, 0xE7, 0x07, 0x70, 0x3B, 0x81, 0xDE, 0x1E, 0xFB,
  0xE3, 0xFE, 0x0F, 0xE0, 0x01, 0x00, 0xFF, 0x0F, 0xFC, 0xF1, 0xE7, 0x07,
  0xF8, 0x1F, 0x81, 0xFC, 0x0E, 0xF0, 0xF7, 0xDF, 0x9F, 0xF8, 0x7B, 0x80,
  0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x1C,
  0x7C, 0xF9, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3, 0xCF, 0x8E, 0x00,
  0x07, 0x07, 0xC3, 0xE1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x83, 0xC3, 0xC1, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x00, 0x00, 0x10, 0x07,
  0x03, 0xF0, 0xFE, 0x3F, 0x0F, 0xC0, 0xF0, 0x0F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xC0, 0x02, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x20, 0x01, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xC0, 0x1E, 0x07, 0xF0, 0xFC,
  0x1F, 0x81, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x3F, 0x87, 0xF9, 0xFF, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x3E, 0x3F, 0x87, 0xE0, 0xE0, 0x1C, 0x03,
  0x00, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x1E, 0x00, 0x00, 0x40, 0x07, 0xF0,
  0x3F, 0xF0, 0xF0, 0x71, 0x80, 0xE7, 0x00, 0xCC, 0x01, 0x98, 0x7B, 0x71,
  0xFE, 0xE7, 0x1D, 0xCE, 0x3B, 0x98, 0x66, 0x30, 0xCC, 0xE3, 0xB9, 0xC7,
  0x73, 0xDE, 0xE3, 0xFD, 0xC3, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0xFC, 0x07, 0xE0, 0x77,
  0x03, 0xB8, 0x3D, 0xC1, 0xCE, 0x0E, 0x70, 0xE3, 0x87, 0x1C, 0x7F, 0xE3,
  0xFF, 0x9F, 0xFD, 0xC0, 0xEE, 0x07, 0xF0, 0x3F, 0x01, 0xC0, 0x1F, 0xF0,
  0xFF, 0xE3, 0x87, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x87, 0x9F, 0xF8,
  0x7F, 0xC1, 0xFF, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xCE, 0x0F,
  0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0x00, 0x80, 0x1F, 0xC1, 0xFF, 0x87,
  0x9E, 0x38, 0x38, 0xE0, 0xE3, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x07, 0x3C, 0x3C, 0x7F, 0xE1,
  0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x8E, 0x0E, 0x38,
  0x38, 0xE0, 0xE3, 0x83, 0x9E, 0x0E, 0x70, 0x39, 0xC1, 0xE7, 0x07, 0x9C,
  0x1C, 0x70, 0x73, 0xC1, 0xCE, 0x0E, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00,
  0x1F, 0xFC, 0x7F, 0xF1, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF3,
  0xFF, 0xCE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x7F, 0xF1,
  0xFF, 0xC7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x00, 0x00, 0x80, 0x1F, 0xC1, 0xFF, 0x87, 0x9E, 0x38,
  0x38, 0xE0, 0xE3, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC7, 0xE7, 0x3F, 0x9C,
  0xFC, 0x70, 0x71, 0xC1, 0xCF, 0x07, 0x3C, 0x3C, 0x7F, 0xE1, 0xFF, 0x03,
  0xF8, 0x00, 0x1C, 0x1C, 0xF0, 0xF3, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xE0,
  0xE3, 0x83, 0x9F, 0xFE, 0x7F, 0xF1, 0xFF, 0xC7, 0x07, 0x1C, 0x1C, 0x70,
  0x71, 0xC1, 0xCF, 0x0F, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x80, 0x1F, 0xFC,
  0x7F, 0xE1, 0xFF, 0x80, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x9E, 0x0E, 0x3C, 0x1C, 0x3F, 0xF0,
  0x7F, 0xC0, 0x7F, 0x00, 0x1C, 0x1E, 0x78, 0x78, 0xE0, 0xE1, 0xC3, 0xC3,
  0x8F, 0x07, 0x1C, 0x0E, 0x78, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x81, 0xC7,
  0x03, 0x8E, 0x07, 0x1C, 0x1E, 0x3C, 0x3C, 0x38, 0x70, 0x70, 0xE0, 0xF1,
  0xC0, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x07, 0xFF, 0x7F, 0xFF, 0xFE, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0xD8, 0xF1,
  0xF3, 0xF7, 0xE7, 0x6D, 0xCE, 0xDB, 0x1D, 0xEE, 0x3B, 0xDC, 0x77, 0x39,
  0xC0, 0x73, 0x80, 0xE7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x60,
  0x39, 0xC0, 0x70, 0x3E, 0x1C, 0xF8, 0x73, 0xE1, 0xCF, 0x86, 0x36, 0x38,
  0xD8, 0xE3, 0x73, 0x9D, 0xCE, 0x73, 0x39, 0xCC, 0xC7, 0x33, 0x1C, 0xFC,
  0x63, 0xF3, 0x8F, 0xCE, 0x1F, 0x38, 0x7C, 0xE1, 0xE3, 0x87, 0x80, 0x00,
  0x80, 0x3F, 0x87, 0xFE, 0x3C, 0xF3, 0x83, 0x9C, 0x1C, 0xE0, 0xEF, 0x07,
  0x78, 0x3B, 0x83, 0xDC, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x3B, 0xC1, 0xDE,
  0x1C, 0x7F, 0xE3, 0xFE, 0x0F, 0xE0, 0x1F, 0xF0, 0xFF, 0xE3, 0xFF, 0xCE,
  0x0F, 0x38, 0x1C, 0xE0, 0x73, 0x83, 0xDE, 0x0E, 0x7F, 0xF9, 0xFF, 0xC7,
  0xFC, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x80, 0x1F, 0xC1, 0xFF, 0x87, 0x9E, 0x38, 0x38, 0xE0,
  0xE3, 0x83, 0x9E, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x07, 0x9C, 0x1C, 0x70,
  0x73, 0xC1, 0xCE, 0x07, 0x3C, 0x3C, 0x7F, 0xE1, 0xFF, 0x03, 0xF8, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x1F, 0xF0, 0xFF, 0xE3,
  0xFF, 0x8E, 0x0F, 0x38, 0x3C, 0xE0, 0xF3, 0x83, 0x9E, 0x1E, 0x7F, 0xF1,
  0xFF, 0x87, 0xF8, 0x1C, 0x70, 0x71, 0xC3, 0xC7, 0x0E, 0x1E, 0x38, 0x38,
  0xE0, 0xE3, 0x83, 0xC0, 0x00, 0x80, 0x3F, 0xC1, 0xFF, 0x87, 0x9E, 0x38,
  0x38, 0xE0, 0xE3, 0x80, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x7C, 0x00, 0x70, 0x01, 0xCE, 0x07, 0x38, 0x3C, 0xFF, 0xE1, 0xFF, 0x03,
  0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0x81, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x3C, 0x1C,
  0xE0, 0x73, 0x83, 0xCE, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x9E, 0x0E,
  0x70, 0x79, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x73, 0xC1, 0xCF, 0x0E,
  0x1F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0xE0, 0x7F, 0x03, 0xB8, 0x1D, 0xC1,
  0xCE, 0x0E, 0x70, 0xF3, 0x87, 0x1C, 0x38, 0xE3, 0x83, 0x9C, 0x1C, 0xE0,
  0xEE, 0x07, 0x70, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00,
  0x71, 0xC6, 0xE7, 0x9D, 0xCF, 0x3B, 0x9C, 0x67, 0x28, 0xCC, 0xD3, 0x99,
  0xA7, 0x33, 0x4C, 0x64, 0x98, 0xDB, 0x71, 0xB6, 0xE3, 0x4D, 0x8F, 0x9B,
  0x1F, 0x3E, 0x3E, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC0, 0x1C, 0x0F,
  0x1E, 0x1E, 0x0E, 0x3C, 0x0E, 0x38, 0x07, 0x78, 0x07, 0x70, 0x07, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0E, 0xE0, 0x1E, 0xE0,
  0x1C, 0xE0, 0x38, 0x70, 0x78, 0x70, 0x70, 0x78, 0xE0, 0x38, 0xF0, 0x3D,
  0xC0, 0xE7, 0x07, 0x8E, 0x1C, 0x38, 0xE0, 0xE7, 0x83, 0xDC, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1F, 0xFC, 0x7F, 0xE3, 0xFF, 0x80,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3F, 0xF8, 0xFF, 0xE3,
  0xFF, 0x80, 0x0F, 0xE1, 0xFC, 0x7F, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x11, 0xFC, 0x3F, 0x87, 0xF0, 0xE0,
  0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x70, 0x70, 0x78, 0x38, 0x38, 0x38, 0x38,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x07, 0x07, 0x1F,
  0xE3, 0xF8, 0x7F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0x07, 0x80, 0x78, 0x0F,
  0xC0, 0xDC, 0x1C, 0xC3, 0x8C, 0x38, 0xE7, 0x0E, 0x70, 0xEE, 0x07, 0xFF,
  0xFF, 0xFF, 0xF1, 0xC3, 0x8F, 0x0F, 0x38, 0xFD, 0xCF, 0xFE, 0x70, 0xF7,
  0x07, 0xB8, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x77, 0x87, 0xBC, 0x3C, 0xF7,
  0xC7, 0xFE, 0x1F, 0x70, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x9E,
  0x1F, 0xF8, 0xFF, 0xCF, 0x0F, 0x78, 0x7B, 0x83, 0x9C, 0x1C, 0xE0, 0xE7,
  0x07, 0x38, 0x3B, 0xC3, 0xDF, 0xFC, 0xEF, 0xC7, 0x7C, 0x00, 0x07, 0xC0,
  0xFF, 0x8F, 0xFC, 0x70, 0xF7, 0x03, 0xB8, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x83, 0xBC, 0x3C, 0xFF, 0xC7, 0xFC, 0x1F, 0xC0, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x0F, 0x38, 0x7E, 0xE3, 0xFF, 0x8E, 0x1E, 0x70,
  0x79, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x73, 0xC3, 0xCF, 0x0F, 0x1E,
  0xF8, 0x7F, 0xE0, 0xFB, 0x80, 0x07, 0xC0, 0xFF, 0x8F, 0xBC, 0x70, 0xE7,
  0x03, 0xB8, 0x39, 0xFF, 0xCF, 0xFE, 0x70, 0x07, 0x00, 0x3C, 0x3C, 0xE3,
  0xC7, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0xB8, 0xFD, 0xCF, 0xFE, 0x70, 0xF7,
  0x07, 0xB8, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x87, 0x9F, 0xDC, 0xFF,
  0xC3, 0xEE, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x7F, 0xC3, 0xFC, 0x1E, 0x00,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x9E, 0x1F, 0xF8, 0xFF, 0xCF,
  0x0F, 0x78, 0x7B, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x3B, 0xC3,
  0xDC, 0x1C, 0xE0, 0xE7, 0x07, 0x00, 0x00, 0xC0, 0x1E, 0x01, 0xE0, 0x1C,
  0x00, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x3F, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x18, 0x00, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x83, 0xFC, 0x1F, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x1F, 0x07, 0xF8, 0x3F, 0xC0, 0xF8, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x3C, 0xE0, 0xE3, 0x87, 0x0E, 0x3C, 0x79, 0xE1,
  0xCF, 0x07, 0xF8, 0x1F, 0xE0, 0x73, 0xC1, 0xC7, 0x0F, 0x1C, 0x38, 0x78,
  0xE0, 0xE3, 0x83, 0xC0, 0xFF, 0x1F, 0xE3, 0xF8, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xFF, 0x1F, 0xE1, 0xFC, 0x3B, 0x9C, 0x7F, 0x78, 0xE7, 0x71, 0xCC,
  0x63, 0x19, 0xC6, 0x33, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x1C, 0xE6, 0x31,
  0xCC, 0xE3, 0x19, 0xCE, 0x33, 0x9C, 0xE7, 0x00, 0x39, 0xE1, 0xFF, 0x8F,
  0xFC, 0xF0, 0xF7, 0x87, 0xB8, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x83,
  0xBC, 0x3D, 0xC1, 0xCE, 0x0E, 0x70, 0x70, 0x07, 0xC0, 0xFF, 0x8F, 0xFC,
  0x70, 0xF7, 0x07, 0xB8, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x77, 0x83, 0xBC,
  0x38, 0xFF, 0xC7, 0xFC, 0x1F, 0xC0, 0x1C, 0xF0, 0x7F, 0xE1, 0xFF, 0x8F,
  0x0F, 0x3C, 0x3C, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE7,
  0x87, 0x9F, 0xFC, 0x77, 0xE1, 0xDF, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x0F, 0x38, 0xFD, 0xCF, 0xFE, 0x70, 0xF7, 0x07,
  0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x77, 0x87, 0xBC, 0x3C, 0xF7, 0xC7,
  0xFE, 0x1F, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x39,
  0xE0, 0xEF, 0xE3, 0xFF, 0x8F, 0x0E, 0x38, 0x38, 0xE0, 0xE7, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x00,
  0x0F, 0xE0, 0xFF, 0x8F, 0xFE, 0x70, 0x77, 0x00, 0x3C, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0xF0, 0x03, 0xB8, 0x1D, 0xE3, 0xC7, 0xFE, 0x1F, 0xC0, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0xFC, 0x1F,
  0xC0, 0xFC, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0xF0, 0x77, 0x07, 0xB8, 0x39,
  0xC1, 0xCE, 0x0E, 0x70, 0x77, 0x83, 0x9C, 0x38, 0xFF, 0xC7, 0xFC, 0x1F,
  0xC0, 0xE0, 0x3F, 0x03, 0xBC, 0x1C, 0xE1, 0xC7, 0x0E, 0x38, 0xF1, 0xC7,
  0x0E, 0x78, 0x73, 0x81, 0xDC, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0x63, 0x8E, 0xC7, 0x19, 0x8E, 0x73, 0x3C, 0xE6, 0x79, 0x8C, 0xB7, 0x1B,
  0x6E, 0x36, 0xD8, 0x69, 0xB0, 0xF3, 0xE1, 0xE7, 0x87, 0x8F, 0x0F, 0x1E,
  0x1E, 0x38, 0x00, 0x3C, 0x1E, 0x38, 0x78, 0x79, 0xE0, 0x73, 0x80, 0x7E,
  0x00, 0xFC, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x73, 0x81,
  0xC7, 0x87, 0x87, 0x1E, 0x0F, 0x00, 0x38, 0x39, 0xC1, 0xDE, 0x0E, 0xE0,
  0xF7, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x87, 0x9F, 0xF8,
  0xFF, 0xC3, 0xEE, 0x00, 0x70, 0x03, 0x80, 0x38, 0x7F, 0xC3, 0xFC, 0x1E,
  0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xFF, 0xCF, 0xFE, 0x7F, 0xF0,
  0x00, 0x38, 0x07, 0xC0, 0x7E, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x03, 0xC1, 0xFC, 0x0F, 0xE0, 0x0F, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0x78, 0x0E, 0x1C, 0x38, 0x71, 0xE3, 0x87, 0x0E, 0x1C, 0x38,
  0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x78,
  0x0F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x40, 0x7E, 0x03, 0xF8, 0x1F,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x01, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0x1C, 0x03, 0xF0, 0xDF, 0xC7, 0xCF,
  0x7E, 0x3F, 0x70, 0xF0,
};

const GFXglyph JetBrainsMono_BoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 7, 18, 15, 4, -18 },
  { 17, 10, 7, 15, 4, -18 },
  { 26, 15, 18, 15, 0, -18 },
  { 60, 14, 26, 15, 1, -22 },
  { 106, 18, 18, 15, -1, -18 },
  { 147, 15, 19, 15, 0, -19 },
  { 183, 4, 7, 15, 7, -18 },
  { 187, 10, 24, 15, 4, -21 },
  { 217, 11, 24, 15, 1, -21 },
  { 250, 14, 13, 15, 1, -15 },
  { 273, 13, 12, 15, 1, -14 },
  { 293, 7, 8, 15, 2, -4 },
  { 300, 9, 3, 15, 3, -10 },
  { 304, 5, 4, 15, 4, -4 },
  { 307, 16, 24, 15, 0, -21 },
  { 355, 14, 19, 15, 1, -19 },
  { 389, 12, 18, 15, 1, -18 },
  { 416, 13, 19, 15, 1, -19 },
  { 447, 13, 18, 15, 1, -18 },
  { 477, 13, 18, 15, 1, -18 },
  { 507, 13, 18, 15, 1, -18 },
  { 537, 13, 18, 15, 1, -18 },
  { 567, 13, 18, 15, 2, -18 },
  { 597, 13, 19, 15, 1, -19 },
  { 628, 13, 19, 15, 2, -19 },
  { 659, 7, 14, 15, 4, -14 },
  { 672, 9, 18, 15, 2, -14 },
  { 693, 12, 14, 15, 2, -15 },
  { 714, 12, 9, 15, 2, -13 },
  { 728, 13, 14, 15, 1, -15 },
  { 751, 11, 18, 15, 3, -18 },
  { 776, 15, 23, 15, 0, -19 },
  { 820, 13, 18, 15, 0, -18 },
  { 850, 14, 18, 15, 1, -18 },
  { 882, 14, 19, 15, 1, -19 },
  { 916, 14, 18, 15, 1, -18 },
  { 948, 14, 18, 15, 1, -18 },
  { 980, 14, 18, 15, 1, -18 },
  { 1012, 14, 19, 15, 1, -19 },
  { 1046, 14, 18, 15, 1, -18 },
  { 1078, 14, 18, 15, 1, -18 },
  { 1110, 15, 18, 15, 0, -18 },
  { 1144, 15, 18, 15, 1, -18 },
  { 1178, 12, 18, 15, 1, -18 },
  { 1205, 15, 18, 15, 0, -18 },
  { 1239, 14, 18, 15, 1, -18 },
  { 1271, 13, 19, 15, 1, -19 },
  { 1302, 14, 18, 15, 1, -18 },
  { 1334, 14, 24, 15, 1, -19 },
  { 1376, 14, 18, 15, 1, -18 },
  { 1408, 14, 19, 15, 1, -19 },
  { 1442, 14, 18, 15, 2, -18 },
  { 1474, 14, 18, 15, 1, -18 },
  { 1506, 13, 18, 15, 3, -18 },
  { 1536, 15, 18, 15, 1, -18 },
  { 1570, 16, 18, 15, 0, -18 },
  { 1606, 14, 18, 15, 2, -18 },
  { 1638, 14, 18, 15, 1, -18 },
  { 1670, 11, 24, 15, 3, -21 },
  { 1703, 8, 24, 15, 4, -21 },
  { 1727, 11, 24, 15, 2, -21 },
  { 1760, 12, 10, 15, 2, -18 },
  { 1775, 12, 2, 15, 0, 1 },
  { 1778, 6, 4, 15, 6, -20 },
  { 1781, 13, 14, 15, 1, -14 },
  { 1804, 13, 18, 15, 1, -18 },
  { 1834, 13, 14, 15, 1, -14 },
  { 1857, 14, 18, 15, 1, -18 },
  { 1889, 13, 14, 15, 1, -14 },
  { 1912, 17, 23, 15, -1, -18 },
  { 1961, 13, 19, 15, 1, -14 },
  { 1992, 13, 18, 15, 1, -18 },
  { 2022, 12, 20, 15, 1, -20 },
  { 2052, 14, 25, 15, 0, -20 },
  { 2096, 14, 18, 15, 1, -18 },
  { 2128, 11, 18, 15, 2, -18 },
  { 2153, 15, 14, 15, 0, -14 },
  { 2180, 13, 14, 15, 1, -14 },
  { 2203, 13, 14, 15, 1, -14 },
  { 2226, 14, 19, 15, 0, -14 },
  { 2260, 13, 19, 15, 1, -14 },
  { 2291, 14, 14, 15, 1, -14 },
  { 2316, 13, 14, 15, 1, -14 },
  { 2339, 12, 18, 15, 2, -18 },
  { 2366, 13, 14, 15, 1, -14 },
  { 2389, 13, 14, 15, 2, -14 },
  { 2412, 15, 14, 15, 1, -14 },
  { 2439, 15, 14, 15, 0, -14 },
  { 2466, 13, 19, 15, 1, -14 },
  { 2497, 13, 14, 15, 1, -14 },
  { 2520, 13, 24, 15, 2, -21 },
  { 2559, 7, 24, 15, 4, -21 },
  { 2580, 14, 24, 15, 0, -21 },
  { 2622, 13, 6, 15, 1, -12 },
};

const GFXfont JetBrainsMono_BoldItalic25pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic25pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _JETBRAINSMONO_BOLDITALIC25PT7B_H_
