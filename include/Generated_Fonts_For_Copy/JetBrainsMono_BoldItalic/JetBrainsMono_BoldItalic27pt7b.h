#ifndef _JETBRAINSMONO_BOLDITALIC27PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xE1, 0xC7, 0x8F, 0x1E, 0x38, 0x70, 0xE1, 0xC3,
  0x06, 0x00, 0x00, 0x01, 0xE3, 0xC7, 0x80, 0x79, 0xEF, 0x3D, 0xC7, 0x38,
  0xE7, 0x1C, 0xE3, 0x9C, 0xF7, 0x1C, 0x01, 0xC3, 0x00, 0xE3, 0x80, 0x61,
  0x80, 0x70, 0xC0, 0x38, 0xE0, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE, 0x06,
  0x18, 0x07, 0x0C, 0x03, 0x8E, 0x01, 0x86, 0x01, 0xC3, 0x03, 0xFF, 0xF3,
  0xFF, 0xF0, 0x70, 0xC0, 0x38, 0xE0, 0x18, 0x60, 0x1C, 0x30, 0x0E, 0x38,
  0x00, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x1F, 0x80, 0xFF, 0x83, 0xFF,
  0x87, 0xAF, 0x1E, 0xCF, 0x39, 0x80, 0x7B, 0x00, 0xF6, 0x01, 0xFC, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xBC, 0x03, 0x38, 0x06, 0x73, 0xC8,
  0xE7, 0x93, 0xCF, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0x03, 0x00, 0x06, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x03, 0x80, 0x61, 0xF8, 0x18, 0x73, 0x86, 0x0C,
  0x71, 0x81, 0x8C, 0x70, 0x71, 0x9C, 0x0E, 0x77, 0x00, 0xFC, 0xC0, 0x1F,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xEF, 0x00, 0x3B, 0xF0, 0x0E,
  0xE7, 0x03, 0x98, 0xE0, 0x63, 0x18, 0x18, 0xE3, 0x06, 0x1C, 0xE1, 0xC1,
  0xF8, 0x70, 0x3E, 0x00, 0x01, 0xF0, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0x1C,
  0x0E, 0x1C, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x1F, 0x80,
  0x3F, 0x8F, 0x7B, 0xCE, 0x71, 0xDC, 0x71, 0xFC, 0x70, 0xF8, 0x70, 0xF0,
  0x70, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0x1C, 0x7B, 0xDC, 0xE7, 0x3B,
  0xDC, 0x00, 0x30, 0x0E, 0x03, 0xE0, 0x7E, 0x0F, 0x81, 0xE0, 0x1C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3E, 0x03,
  0xF0, 0x1F, 0x00, 0x70, 0x0C, 0x00, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x03, 0x0C, 0x27, 0x99, 0xFF, 0xAF, 0xCF, 0xFE, 0x01, 0xC0, 0x07, 0xC0,
  0x39, 0xC0, 0xF3, 0x83, 0xC7, 0x83, 0x06, 0x02, 0x08, 0x00, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x1F, 0x1E, 0x1E, 0x3C,
  0x38, 0x78, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x77, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0,
  0xF1, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x79, 0x1C, 0xF7,
  0x39, 0xCE, 0xF3, 0x9D, 0xE7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x78, 0x3C,
  0x70, 0x70, 0xFF, 0xE1, 0xFF, 0x80, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x83,
  0xF8, 0x3F, 0xC1, 0xCE, 0x1C, 0xF0, 0x87, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x87,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF1,
  0xE3, 0xC1, 0xC7, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF,
  0xC0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0xF0, 0x1F,
  0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xBC, 0x1E, 0xF0,
  0x71, 0xFF, 0xC7, 0xFE, 0x0F, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x04, 0xF0, 0xE3,
  0x83, 0x9E, 0x0E, 0x70, 0x39, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0xF0, 0x3B, 0xF8, 0x7F, 0xF0,
  0xE1, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x78, 0x3C, 0xF0,
  0x70, 0xFF, 0xE1, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3D, 0xF0, 0xEF,
  0xE7, 0xEF, 0x9E, 0x0F, 0x70, 0x3F, 0xC0, 0xFF, 0x03, 0xBC, 0x0E, 0xF0,
  0x79, 0xFF, 0xC7, 0xFE, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xB8,
  0x0E, 0xE0, 0x7B, 0x83, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF1,
  0xE3, 0xC1, 0xC7, 0x83, 0x8F, 0x0F, 0x1E, 0x1C, 0x1F, 0xF0, 0x1F, 0xC0,
  0x3F, 0x81, 0xF7, 0x87, 0x87, 0x8E, 0x07, 0x3C, 0x0E, 0x78, 0x1C, 0xF0,
  0x78, 0xFF, 0xE1, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xFF,
  0x9F, 0x0E, 0x70, 0x3D, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x79, 0xE3,
  0xE7, 0xFF, 0x0F, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x01, 0xC0, 0x1E, 0x00, 0x3C, 0x79, 0xF1, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x8F, 0x9F, 0x3C, 0x00, 0x07, 0x81, 0xF0, 0xF8,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1E,
  0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1C, 0x0F, 0x00, 0x00, 0x0C, 0x01, 0xE0,
  0x1F, 0x81, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0x3C, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0x80, 0x7F, 0xFB, 0xFF,
  0xDF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF7,
  0xFF, 0x80, 0x30, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0x80, 0x1E, 0x01, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0x80, 0xF8,
  0x03, 0x00, 0x00, 0x3E, 0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0E, 0x03, 0xE1, 0xFC, 0x3F, 0x83, 0xE0, 0x38, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x07, 0x00, 0x01, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xC0, 0xE1, 0xC0, 0x71, 0xC0, 0x18, 0xE0, 0x0C,
  0x71, 0xF6, 0x31, 0xFB, 0x38, 0xE3, 0x9C, 0xE1, 0xCE, 0x70, 0xE7, 0x38,
  0x63, 0x9C, 0x71, 0x8E, 0x39, 0xC7, 0x1C, 0xE3, 0xFE, 0x71, 0xF7, 0x38,
  0x20, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x03, 0xB8,
  0x0E, 0xE0, 0x7B, 0x81, 0xCE, 0x0F, 0x38, 0x38, 0xE0, 0xE3, 0x87, 0x8E,
  0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0xCE, 0x0F, 0x78, 0x3D, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF1, 0xE1, 0xE3, 0xC1, 0xE7,
  0x03, 0x8E, 0x07, 0x1C, 0x1E, 0x3F, 0xF8, 0x7F, 0xC1, 0xFF, 0xC3, 0xC3,
  0xC7, 0x03, 0x8E, 0x07, 0x9C, 0x0E, 0x38, 0x1C, 0xF0, 0x79, 0xFF, 0xE3,
  0xFF, 0x87, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF1, 0xE3,
  0xC1, 0xE7, 0x03, 0xCE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x0E, 0x38, 0x3C, 0x70, 0x70,
  0xFF, 0xE1, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF1,
  0xE3, 0xE3, 0xC1, 0xC7, 0x83, 0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0xF0,
  0x39, 0xE0, 0xF3, 0xC1, 0xE7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x3C,
  0xF0, 0xF1, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xF8, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x3F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFE,
  0x3F, 0xFC, 0x7F, 0xF8, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x00,
  0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF1, 0xE3, 0xC1, 0xE7, 0x03, 0xCE,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE7, 0xF3, 0x8F, 0xE7, 0x03,
  0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x70, 0x70, 0xFF, 0xE1, 0xFF, 0x80,
  0xFC, 0x00, 0x1C, 0x0E, 0x38, 0x3C, 0x70, 0x79, 0xE0, 0xF3, 0xC1, 0xC7,
  0x83, 0x8E, 0x07, 0x1C, 0x0E, 0x3F, 0xFC, 0x7F, 0xF9, 0xFF, 0xE3, 0xC1,
  0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x1E, 0x38, 0x3C, 0xF0, 0x79, 0xE0, 0xE3,
  0xC1, 0xC7, 0x03, 0x80, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0xF0, 0x38,
  0xF0, 0x38, 0x70, 0x78, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0x1C, 0x0F,
  0x1C, 0x0E, 0x1C, 0x1E, 0x3C, 0x3C, 0x3C, 0x38, 0x3C, 0x78, 0x38, 0xF0,
  0x38, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x79, 0xE0, 0x71, 0xE0,
  0x70, 0xE0, 0x70, 0xF0, 0x70, 0xF0, 0xF0, 0x70, 0xF0, 0x70, 0xE0, 0x78,
  0xE0, 0x78, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x0F, 0x8F, 0x87,
  0x86, 0xC3, 0xC3, 0x63, 0x61, 0xB1, 0xF0, 0xD9, 0xF8, 0xEC, 0xDC, 0x76,
  0xEC, 0x3B, 0xEE, 0x1D, 0xF7, 0x0E, 0x73, 0x87, 0x39, 0xC3, 0x80, 0xE3,
  0xC0, 0xF1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x07,
  0x1E, 0x07, 0x80, 0x1E, 0x0E, 0x3C, 0x1C, 0x78, 0x39, 0xF8, 0x73, 0xF1,
  0xE7, 0xE3, 0x8F, 0xC7, 0x1D, 0x8E, 0x3B, 0x9C, 0xF7, 0x39, 0xCE, 0x73,
  0x9D, 0xC7, 0x1B, 0x8E, 0x37, 0x1C, 0x7E, 0x78, 0xFC, 0xE1, 0xF9, 0xC1,
  0xE3, 0x83, 0xC7, 0x07, 0x80, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF1,
  0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0xF0, 0x79,
  0xE0, 0xF3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x70,
  0x70, 0xFF, 0xE1, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xF1, 0xE1, 0xF3, 0xC1, 0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x0F, 0x38, 0x1C,
  0x7F, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0xF0, 0x7F, 0xF0, 0xF1, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E,
  0x78, 0x1C, 0xF0, 0x79, 0xE0, 0xF3, 0x81, 0xE7, 0x03, 0x8E, 0x07, 0x1C,
  0x0E, 0x78, 0x3C, 0x70, 0x70, 0xFF, 0xE1, 0xFF, 0x80, 0xFC, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xF0,
  0x7F, 0xF1, 0xE1, 0xF3, 0xC1, 0xE7, 0x83, 0xCE, 0x07, 0x9C, 0x0E, 0x38,
  0x3C, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0x1C, 0x0E, 0x3C, 0x1C, 0x38,
  0x38, 0x70, 0xF0, 0xF1, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0xC0, 0x03, 0xF0,
  0x1F, 0xF0, 0x7F, 0xF0, 0xF1, 0xE3, 0xC1, 0xE7, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x07,
  0x00, 0x0E, 0x78, 0x1C, 0xF0, 0x79, 0xFF, 0xE1, 0xFF, 0x81, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x1C,
  0x0E, 0x38, 0x1C, 0x70, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x03, 0x8E, 0x07,
  0x1C, 0x0E, 0x38, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xC7, 0x03, 0x8E,
  0x07, 0x1C, 0x0E, 0x38, 0x3C, 0x70, 0x70, 0xFF, 0xE1, 0xFF, 0x80, 0xFC,
  0x00, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xBC, 0x1E, 0xF0, 0x73, 0xC1, 0xCF,
  0x0F, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x07, 0x1C, 0x1C, 0xF0, 0x73, 0x81,
  0xCE, 0x07, 0x70, 0x1D, 0xC0, 0x77, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x70, 0xE3, 0xB8, 0xE1, 0x9C, 0x71, 0xCE, 0x28, 0xE7, 0x34, 0x73, 0x9E,
  0x31, 0xCF, 0x38, 0xE5, 0x9C, 0x76, 0xCE, 0x3B, 0x66, 0x19, 0xB7, 0x0D,
  0x9B, 0x86, 0xCD, 0x83, 0x66, 0xC1, 0xB3, 0xE0, 0xF1, 0xF0, 0xF8, 0xF0,
  0x7C, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x00, 0x1E, 0x07, 0x8F, 0x07, 0x83,
  0x83, 0xC1, 0xE3, 0xC0, 0x73, 0xC0, 0x39, 0xC0, 0x1F, 0xE0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0x80, 0x79, 0xC0, 0x38, 0xF0, 0x3C, 0x78, 0x3C, 0x1C, 0x1C, 0x0F, 0x1E,
  0x07, 0x80, 0xE0, 0x1F, 0xC0, 0x7B, 0xC0, 0xE3, 0x83, 0xC7, 0x0F, 0x0F,
  0x1C, 0x1E, 0x78, 0x1C, 0xE0, 0x3B, 0x80, 0x77, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xE0,
  0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x70, 0x07, 0x00, 0x7F, 0x07, 0xF0, 0xFF, 0x00, 0xF0, 0x78, 0x1C, 0x0E,
  0x07, 0x03, 0xC1, 0xE0, 0x70, 0x38, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xE0,
  0x78, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x07,
  0x80, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0xFF, 0x0F,
  0xF0, 0xFF, 0x00, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0D, 0xC0, 0xEE, 0x0E,
  0x70, 0x71, 0x87, 0x0E, 0x78, 0x73, 0x83, 0xBC, 0x1E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xF1, 0xC7, 0x8F, 0x07, 0x9C, 0x7F, 0x73, 0xFD, 0xCF, 0x0F,
  0x78, 0x3D, 0xE0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC1, 0xEF, 0x07,
  0x9C, 0x3E, 0x7F, 0xF1, 0xFD, 0xC3, 0xE7, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF7, 0xC3, 0xBF, 0x8F, 0xFE, 0x3C, 0x3C,
  0xE0, 0xF7, 0x83, 0xDE, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x1E,
  0xF0, 0x73, 0xFF, 0xCE, 0xFE, 0x39, 0xF0, 0x07, 0xE0, 0x3F, 0xE1, 0xFF,
  0x8F, 0x0F, 0x78, 0x3D, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x07, 0x9C, 0x1E, 0x7F, 0xF1, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0xF3, 0x87, 0xF7, 0x1F,
  0xEE, 0x3C, 0x3C, 0xF0, 0x79, 0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07,
  0x1C, 0x1E, 0x78, 0x3C, 0x70, 0xF8, 0xFF, 0xE1, 0xFD, 0xC1, 0xF3, 0x80,
  0x07, 0xE0, 0x3F, 0xE1, 0xFF, 0x8E, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0xFF,
  0x9F, 0xFE, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x1E, 0x7D, 0xF1, 0xFF,
  0x81, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x08, 0x7F, 0xFC, 0x1F, 0xFF, 0x07,
  0xFF, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x9C, 0x7F, 0x73, 0xFD, 0xCF, 0x0F, 0x78, 0x3D, 0xE0, 0xE7, 0x03,
  0x9C, 0x0E, 0x70, 0x39, 0xC1, 0xE7, 0x87, 0x9F, 0xFE, 0x7F, 0x70, 0xF9,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF7, 0xC3, 0xBF, 0x8F,
  0xFE, 0x3C, 0x3C, 0xE0, 0xF7, 0x83, 0x9E, 0x0E, 0x70, 0x39, 0xC0, 0xE7,
  0x07, 0x9C, 0x1E, 0xF0, 0x7B, 0xC1, 0xCF, 0x07, 0x38, 0x1C, 0x00, 0xE0,
  0x0F, 0x80, 0x78, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x3F,
  0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1C, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFC, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x83, 0xCF, 0x0F, 0x1C,
  0x1E, 0x38, 0x78, 0x71, 0xE1, 0xE7, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1C, 0x78, 0x38, 0xF0, 0x70, 0xF1, 0xE1, 0xE3, 0xC1, 0xC7, 0x03, 0xC0,
  0x7F, 0x87, 0xF8, 0xFF, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x1E, 0x01, 0xFF, 0x0F, 0xF0, 0x7F, 0x3B, 0x9E, 0x3F, 0xFE, 0x3D, 0xEF,
  0x39, 0xCE, 0x39, 0xCE, 0x39, 0xCE, 0x39, 0x8E, 0x71, 0x8E, 0x71, 0x8E,
  0x71, 0x8E, 0x73, 0x9C, 0x73, 0x9C, 0x73, 0x9C, 0xE3, 0x1C, 0xE3, 0x1C,
  0x3D, 0xF0, 0xEF, 0xE3, 0xFF, 0x8F, 0x0F, 0x38, 0x3D, 0xE0, 0xE7, 0x83,
  0x9C, 0x0E, 0x70, 0x39, 0xC1, 0xE7, 0x07, 0xBC, 0x1E, 0xF0, 0x73, 0xC1,
  0xCE, 0x07, 0x00, 0x07, 0xE0, 0x7F, 0xE1, 0xFF, 0x8F, 0x0F, 0x78, 0x3D,
  0xE0, 0xF7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x07, 0x9C, 0x1C,
  0x7F, 0xF1, 0xFF, 0x81, 0xF8, 0x00, 0x1E, 0xF8, 0x3B, 0xF8, 0x7F, 0xF0,
  0xF0, 0xF1, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70,
  0x38, 0xE0, 0xF3, 0xC1, 0xC7, 0xFF, 0x8E, 0xFE, 0x1C, 0xF8, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x9C, 0x7F, 0x73,
  0xFD, 0xCF, 0x0F, 0x78, 0x3D, 0xE0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39,
  0xC1, 0xEF, 0x07, 0xBC, 0x3E, 0x7F, 0xF1, 0xFD, 0xC3, 0xE7, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x1D, 0xF8, 0x7F, 0xF8, 0xFF,
  0xF1, 0xE1, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xF0, 0x7F, 0xE3, 0xFF, 0xCE, 0x0F, 0x38, 0x00, 0xE0, 0x03, 0xFC,
  0x07, 0xFC, 0x07, 0xF8, 0x01, 0xE0, 0x03, 0xBC, 0x1E, 0xFD, 0xF1, 0xFF,
  0xC3, 0xFC, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x3C, 0x1C,
  0xE0, 0x73, 0x81, 0xCE, 0x0F, 0x78, 0x3D, 0xE0, 0xF7, 0x83, 0x9C, 0x0E,
  0x70, 0x39, 0xC1, 0xE7, 0x07, 0x9C, 0x3C, 0x7F, 0xF0, 0xFF, 0x81, 0xF8,
  0x00, 0xF0, 0x1F, 0xC0, 0xF7, 0x03, 0x9C, 0x1E, 0x70, 0x71, 0xC3, 0xC7,
  0x8E, 0x0E, 0x78, 0x39, 0xC0, 0xEF, 0x03, 0xB8, 0x0E, 0xE0, 0x3F, 0x00,
  0xFC, 0x01, 0xE0, 0x00, 0xC3, 0x8F, 0x8F, 0x1B, 0x1E, 0x76, 0x3C, 0xEC,
  0x59, 0x99, 0xB7, 0x33, 0x6E, 0x64, 0xDC, 0xD9, 0xB1, 0xB3, 0xE3, 0x47,
  0xC7, 0x8B, 0x0F, 0x1E, 0x1E, 0x3C, 0x38, 0x70, 0x00, 0x1C, 0x0F, 0x1E,
  0x1E, 0x0E, 0x3C, 0x0F, 0x38, 0x07, 0x70, 0x07, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x1C, 0x70, 0x3C, 0x78, 0x78,
  0x38, 0xF0, 0x3C, 0x38, 0x1C, 0xE0, 0x73, 0x83, 0xCE, 0x0F, 0x78, 0x3D,
  0xE0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x79, 0xC1, 0xE7, 0x8F, 0x9F, 0xFC,
  0x7F, 0x70, 0x79, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE1, 0xFF, 0x87, 0xFC,
  0x1F, 0xC0, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x1F, 0xC0, 0xFE, 0x03, 0xFC, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFE, 0x01, 0xF8, 0x03,
  0xC0, 0x0E, 0x3C, 0x78, 0xF1, 0xC3, 0x87, 0x1E, 0x3C, 0x78, 0xE1, 0xC3,
  0x87, 0x1E, 0x3C, 0x78, 0xE1, 0xC3, 0x8F, 0x1E, 0x3C, 0x70, 0xE0, 0x0F,
  0x80, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xC0,
  0x7F, 0x81, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x0C, 0x00,
  0x7E, 0x1D, 0xFE, 0x73, 0x9C, 0xEE, 0x3F, 0xDC, 0x3F, 0x00, 0x38, 0x00,
};

const GFXglyph JetBrainsMono_BoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 7, 20, 16, 5, -20 },
  { 19, 11, 8, 16, 4, -20 },
  { 30, 17, 20, 16, 0, -20 },
  { 73, 15, 27, 16, 1, -23 },
  { 124, 19, 20, 16, -1, -20 },
  { 172, 16, 20, 16, 0, -20 },
  { 212, 5, 8, 16, 7, -20 },
  { 217, 12, 26, 16, 4, -23 },
  { 256, 12, 26, 16, 1, -23 },
  { 295, 15, 14, 16, 1, -16 },
  { 322, 13, 13, 16, 2, -15 },
  { 344, 8, 8, 16, 2, -4 },
  { 352, 9, 3, 16, 4, -10 },
  { 356, 5, 5, 16, 5, -5 },
  { 360, 17, 25, 16, 0, -22 },
  { 414, 15, 20, 16, 1, -20 },
  { 452, 13, 20, 16, 1, -20 },
  { 485, 15, 20, 16, 1, -20 },
  { 523, 14, 20, 16, 1, -20 },
  { 558, 14, 20, 16, 1, -20 },
  { 593, 15, 20, 16, 1, -20 },
  { 631, 14, 20, 16, 1, -20 },
  { 666, 14, 20, 16, 3, -20 },
  { 701, 15, 20, 16, 1, -20 },
  { 739, 14, 20, 16, 2, -20 },
  { 774, 7, 15, 16, 5, -15 },
  { 788, 10, 19, 16, 2, -15 },
  { 812, 14, 14, 16, 2, -16 },
  { 837, 13, 10, 16, 2, -14 },
  { 854, 14, 14, 16, 1, -16 },
  { 879, 12, 20, 16, 3, -20 },
  { 909, 17, 25, 16, 0, -20 },
  { 963, 14, 20, 16, 0, -20 },
  { 998, 15, 20, 16, 1, -20 },
  { 1036, 15, 20, 16, 1, -20 },
  { 1074, 15, 20, 16, 1, -20 },
  { 1112, 15, 20, 16, 1, -20 },
  { 1150, 15, 20, 16, 1, -20 },
  { 1188, 15, 20, 16, 1, -20 },
  { 1226, 15, 20, 16, 1, -20 },
  { 1264, 15, 20, 16, 1, -20 },
  { 1302, 16, 20, 16, 0, -20 },
  { 1342, 16, 20, 16, 1, -20 },
  { 1382, 12, 20, 16, 2, -20 },
  { 1412, 17, 20, 16, 0, -20 },
  { 1455, 15, 20, 16, 1, -20 },
  { 1493, 15, 20, 16, 1, -20 },
  { 1531, 15, 20, 16, 1, -20 },
  { 1569, 15, 25, 16, 1, -20 },
  { 1616, 15, 20, 16, 1, -20 },
  { 1654, 15, 20, 16, 1, -20 },
  { 1692, 14, 20, 16, 3, -20 },
  { 1727, 15, 20, 16, 1, -20 },
  { 1765, 14, 20, 16, 3, -20 },
  { 1800, 17, 20, 16, 1, -20 },
  { 1843, 17, 20, 16, 0, -20 },
  { 1886, 15, 20, 16, 3, -20 },
  { 1924, 15, 20, 16, 1, -20 },
  { 1962, 12, 25, 16, 3, -22 },
  { 2000, 9, 25, 16, 4, -22 },
  { 2029, 12, 25, 16, 2, -22 },
  { 2067, 13, 11, 16, 2, -20 },
  { 2085, 13, 3, 16, 0, 1 },
  { 2090, 6, 4, 16, 7, -21 },
  { 2093, 14, 15, 16, 1, -15 },
  { 2120, 14, 20, 16, 1, -20 },
  { 2155, 14, 15, 16, 1, -15 },
  { 2182, 15, 20, 16, 1, -20 },
  { 2220, 14, 15, 16, 1, -15 },
  { 2247, 18, 25, 16, -1, -20 },
  { 2304, 14, 20, 16, 1, -15 },
  { 2339, 14, 20, 16, 1, -20 },
  { 2374, 13, 21, 16, 1, -21 },
  { 2409, 15, 26, 16, 0, -21 },
  { 2458, 15, 20, 16, 1, -20 },
  { 2496, 12, 20, 16, 2, -20 },
  { 2526, 16, 15, 16, 0, -15 },
  { 2556, 14, 15, 16, 1, -15 },
  { 2583, 14, 15, 16, 1, -15 },
  { 2610, 15, 20, 16, 0, -15 },
  { 2648, 14, 20, 16, 1, -15 },
  { 2683, 15, 15, 16, 1, -15 },
  { 2712, 14, 15, 16, 1, -15 },
  { 2739, 13, 19, 16, 2, -19 },
  { 2770, 14, 15, 16, 1, -15 },
  { 2797, 14, 15, 16, 2, -15 },
  { 2824, 15, 15, 16, 2, -15 },
  { 2853, 16, 15, 16, 0, -15 },
  { 2883, 14, 20, 16, 1, -15 },
  { 2918, 14, 15, 16, 1, -15 },
  { 2945, 14, 25, 16, 2, -22 },
  { 2989, 7, 25, 16, 5, -22 },
  { 3011, 15, 25, 16, 0, -22 },
  { 3058, 15, 7, 16, 1, -13 },
};

const GFXfont JetBrainsMono_BoldItalic27pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic27pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _JETBRAINSMONO_BOLDITALIC27PT7B_H_
