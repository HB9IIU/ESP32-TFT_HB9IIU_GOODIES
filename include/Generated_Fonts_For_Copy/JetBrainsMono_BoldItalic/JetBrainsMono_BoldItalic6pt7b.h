#ifndef _JETBRAINSMONO_BOLDITALIC6PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0xC0, 0x56, 0xEC, 0x25, 0x42, 0xE4, 0xD6, 0x6E, 0x6A, 0xF0,
  0x80, 0x6A, 0x90, 0x44, 0x95, 0x00, 0x2B, 0xE0, 0x5C, 0x70, 0xC0, 0x80,
  0x12, 0x24, 0x88, 0x7E, 0xF0, 0x65, 0x70, 0x65, 0x70, 0x6C, 0xF0, 0x2F,
  0x90, 0x6C, 0xF0, 0x6E, 0xF0, 0xEA, 0x40, 0x6E, 0xF0, 0x7E, 0x24, 0xC8,
  0xCA, 0x2B, 0x10, 0x7C, 0x8D, 0xC0, 0xFA, 0xFB, 0xDE, 0xC0, 0x6D, 0xD0,
  0x76, 0xAE, 0x78, 0x8E, 0x76, 0xF0, 0x76, 0x8E, 0x76, 0x88, 0x78, 0xAE,
  0x56, 0xAA, 0x69, 0x70, 0x24, 0xF0, 0x76, 0xAA, 0x4A, 0x70, 0x7D, 0xAA,
  0x5E, 0xAA, 0x76, 0xF0, 0x7E, 0x88, 0x76, 0xF2, 0x7E, 0xAA, 0x74, 0x2E,
  0xF2, 0x40, 0x5A, 0xAE, 0xBB, 0x40, 0xBD, 0xEA, 0x74, 0x6A, 0xFA, 0x40,
  0x65, 0x70, 0x6A, 0xB0, 0xA9, 0x50, 0x64, 0x95, 0x80, 0x7C, 0xE0, 0xC0,
  0x77, 0x80, 0x56, 0xF0, 0x73, 0x80, 0x16, 0xAE, 0xFF, 0x80, 0x7E, 0x44,
  0xC0, 0x75, 0xF0, 0x56, 0xD0, 0x21, 0xAE, 0x21, 0x93, 0x80, 0x5A, 0xCA,
  0xAB, 0xFF, 0x80, 0xF6, 0x80, 0x77, 0x80, 0xF7, 0xC0, 0x77, 0x90, 0x72,
  0x00, 0xEF, 0x80, 0x5D, 0x30, 0xB7, 0x80, 0xB6, 0x40, 0xDE, 0xA0, 0x74,
  0xA0, 0xB5, 0xF0, 0x6B, 0x80, 0x32, 0x4A, 0x42, 0x5A, 0xA0, 0x49, 0xA5,
  0x00, 0x74,
};

const GFXglyph JetBrainsMono_BoldItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 4, 4, 1, -4 },
  { 2, 2, 1, 4, 1, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 4, 6, 4, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 3, 4, 4, 0, -4 },
  { 12, 1, 1, 4, 2, -4 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 3, 6, 4, 0, -5 },
  { 18, 4, 3, 4, 0, -4 },
  { 20, 3, 2, 4, 0, -3 },
  { 21, 2, 2, 4, 0, -1 },
  { 22, 2, 1, 4, 1, -2 },
  { 23, 1, 1, 4, 1, -1 },
  { 24, 4, 6, 4, 0, -5 },
  { 27, 3, 4, 4, 0, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 3, 4, 4, 0, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 3, 4, 4, 0, -4 },
  { 41, 3, 4, 4, 1, -4 },
  { 43, 3, 4, 4, 0, -4 },
  { 45, 4, 4, 4, 0, -4 },
  { 47, 2, 3, 4, 1, -3 },
  { 48, 2, 4, 4, 1, -3 },
  { 49, 3, 4, 4, 0, -4 },
  { 51, 3, 2, 4, 0, -3 },
  { 52, 3, 4, 4, 0, -4 },
  { 54, 2, 4, 4, 1, -4 },
  { 55, 4, 5, 4, 0, -4 },
  { 58, 3, 4, 4, 0, -4 },
  { 60, 4, 4, 4, 0, -4 },
  { 62, 4, 4, 4, 0, -4 },
  { 64, 3, 4, 4, 0, -4 },
  { 66, 4, 4, 4, 0, -4 },
  { 68, 4, 4, 4, 0, -4 },
  { 70, 4, 4, 4, 0, -4 },
  { 72, 4, 4, 4, 0, -4 },
  { 74, 3, 4, 4, 0, -4 },
  { 76, 3, 4, 4, 0, -4 },
  { 78, 4, 4, 4, 0, -4 },
  { 80, 3, 4, 4, 0, -4 },
  { 82, 4, 4, 4, 0, -4 },
  { 84, 4, 4, 4, 0, -4 },
  { 86, 3, 4, 4, 0, -4 },
  { 88, 4, 4, 4, 0, -4 },
  { 90, 3, 5, 4, 0, -4 },
  { 92, 4, 4, 4, 0, -4 },
  { 94, 4, 4, 4, 0, -4 },
  { 96, 3, 4, 4, 1, -4 },
  { 98, 4, 4, 4, 0, -4 },
  { 100, 3, 4, 4, 1, -4 },
  { 102, 4, 4, 4, 0, -4 },
  { 104, 4, 4, 4, 0, -4 },
  { 106, 3, 4, 4, 1, -4 },
  { 108, 3, 4, 4, 0, -4 },
  { 110, 2, 6, 4, 1, -5 },
  { 112, 2, 6, 4, 1, -5 },
  { 114, 3, 6, 4, 0, -5 },
  { 117, 3, 2, 4, 0, -4 },
  { 118, 3, 1, 4, 0, 0 },
  { 119, 2, 1, 4, 1, -5 },
  { 120, 3, 3, 4, 0, -3 },
  { 122, 3, 4, 4, 0, -4 },
  { 124, 3, 3, 4, 0, -3 },
  { 126, 4, 4, 4, 0, -4 },
  { 128, 3, 3, 4, 0, -3 },
  { 130, 4, 5, 4, 0, -4 },
  { 133, 3, 4, 4, 0, -3 },
  { 135, 3, 4, 4, 0, -4 },
  { 137, 3, 5, 4, 0, -5 },
  { 139, 3, 6, 4, 0, -5 },
  { 142, 4, 4, 4, 0, -4 },
  { 144, 2, 4, 4, 1, -4 },
  { 145, 3, 3, 4, 0, -3 },
  { 147, 3, 3, 4, 0, -3 },
  { 149, 3, 3, 4, 0, -3 },
  { 151, 3, 4, 4, 0, -3 },
  { 153, 3, 4, 4, 0, -3 },
  { 155, 3, 3, 4, 0, -3 },
  { 157, 3, 3, 4, 0, -3 },
  { 159, 3, 4, 4, 0, -4 },
  { 161, 3, 3, 4, 0, -3 },
  { 163, 4, 3, 4, 0, -3 },
  { 165, 4, 3, 4, 0, -3 },
  { 167, 4, 3, 4, 0, -3 },
  { 169, 3, 4, 4, 0, -3 },
  { 171, 3, 3, 4, 0, -3 },
  { 173, 4, 6, 4, 0, -5 },
  { 176, 2, 6, 4, 1, -5 },
  { 178, 3, 6, 4, 0, -5 },
  { 181, 3, 2, 4, 0, -3 },
};

const GFXfont JetBrainsMono_BoldItalic6pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic6pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _JETBRAINSMONO_BOLDITALIC6PT7B_H_
