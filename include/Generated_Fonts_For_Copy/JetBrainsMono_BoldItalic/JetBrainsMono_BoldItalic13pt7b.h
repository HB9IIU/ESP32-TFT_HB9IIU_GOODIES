#ifndef _JETBRAINSMONO_BOLDITALIC13PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x26, 0x66, 0x04, 0xE0, 0xDE, 0xF6, 0x1B, 0x12, 0x7F, 0x24,
  0x24, 0x24, 0xFE, 0x48, 0xD8, 0x0C, 0x0C, 0x3E, 0x2A, 0x68, 0x38, 0x3E,
  0x16, 0x56, 0x76, 0x7C, 0x10, 0x10, 0x18, 0x4F, 0x22, 0xD0, 0xA8, 0x34,
  0x02, 0x01, 0xF0, 0x54, 0x25, 0x31, 0xC0, 0x0C, 0x3E, 0x26, 0x20, 0x30,
  0x73, 0x5E, 0xCC, 0xCC, 0x76, 0xE8, 0x08, 0xCC, 0xC4, 0x63, 0x18, 0xC6,
  0x18, 0xE1, 0x00, 0x23, 0x86, 0x31, 0x8C, 0x63, 0x11, 0x99, 0x88, 0x00,
  0x10, 0x23, 0x7B, 0xC3, 0x1B, 0x12, 0x00, 0x10, 0xCF, 0xCC, 0x30, 0x80,
  0x36, 0x4C, 0xF0, 0xFC, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10,
  0x30, 0x20, 0x60, 0xC0, 0x18, 0xF9, 0x16, 0x2D, 0x5E, 0xA3, 0x46, 0xD9,
  0xE0, 0x39, 0x69, 0x84, 0x10, 0x43, 0x0C, 0xFC, 0x0C, 0x7D, 0x88, 0x10,
  0x61, 0x86, 0x18, 0x63, 0xF8, 0x3E, 0x0C, 0x20, 0xE0, 0x60, 0xD1, 0xB6,
  0x78, 0x0C, 0x63, 0x18, 0xCE, 0x3F, 0xC2, 0x18, 0x7D, 0x04, 0x3F, 0xCC,
  0x30, 0xF6, 0xF0, 0x0E, 0x30, 0xC1, 0x67, 0x68, 0xD1, 0xB6, 0x78, 0x7F,
  0x8C, 0x30, 0x41, 0x86, 0x0C, 0x30, 0xE0, 0x0C, 0x7C, 0x89, 0x13, 0xC7,
  0x99, 0xA3, 0x6C, 0xF8, 0x18, 0xFB, 0x1E, 0x3C, 0xDF, 0x86, 0x08, 0x30,
  0xC0, 0x76, 0x00, 0x0E, 0xE0, 0x39, 0x80, 0x00, 0x19, 0x88, 0xC0, 0x04,
  0x77, 0x30, 0xE0, 0xE0, 0xC0, 0x7F, 0xF0, 0x00, 0xFC, 0x83, 0x83, 0x83,
  0x1F, 0xC8, 0x00, 0xF8, 0xC6, 0x77, 0x60, 0x18, 0xC0, 0x0C, 0x3F, 0x63,
  0x41, 0x5D, 0x53, 0xD2, 0xD2, 0x9E, 0x80, 0xC0, 0x70, 0x1C, 0x28, 0x51,
  0xA2, 0x4F, 0x9F, 0xA3, 0xC6, 0x3E, 0x22, 0x62, 0x7E, 0x7C, 0x66, 0x46,
  0x4E, 0xFC, 0x18, 0xF9, 0x1E, 0x0C, 0x18, 0x30, 0x46, 0xD9, 0xE0, 0x3E,
  0x22, 0x62, 0x62, 0x66, 0x66, 0x46, 0x7C, 0xF8, 0x7E, 0x81, 0x07, 0xEF,
  0xD8, 0x30, 0x40, 0xF8, 0x3F, 0x20, 0x60, 0x60, 0x7E, 0x60, 0x60, 0x40,
  0xC0, 0x18, 0xF9, 0x1E, 0x0C, 0x1B, 0xB3, 0x46, 0xD9, 0xE0, 0x33, 0x22,
  0x62, 0x7E, 0x7E, 0x66, 0x46, 0x44, 0xC4, 0x7E, 0x20, 0x41, 0x83, 0x06,
  0x0C, 0x10, 0xF8, 0x0F, 0x12, 0x06, 0x06, 0x06, 0x06, 0xC4, 0xCC, 0x78,
  0x33, 0x26, 0x64, 0x7C, 0x78, 0x6C, 0x4C, 0x44, 0xC6, 0x61, 0x84, 0x10,
  0xC3, 0x0C, 0x3F, 0xF8, 0x33, 0x77, 0x77, 0x5A, 0x5A, 0x42, 0x46, 0xC6,
  0xC6, 0x33, 0x32, 0x72, 0x7A, 0x7A, 0x4E, 0x4E, 0x4E, 0xCC, 0x18, 0xF9,
  0x16, 0x2C, 0x59, 0xB3, 0x46, 0xD9, 0xE0, 0x3E, 0x23, 0x63, 0x62, 0x7E,
  0x60, 0x40, 0x40, 0xC0, 0x18, 0xF9, 0x16, 0x2C, 0x59, 0xA3, 0x46, 0xD9,
  0xE0, 0x40, 0xC0, 0x3E, 0x23, 0x63, 0x66, 0x7C, 0x6C, 0x4C, 0x4C, 0xC6,
  0x0C, 0x3E, 0x22, 0x60, 0x38, 0x1C, 0x06, 0x46, 0x66, 0x7C, 0xFE, 0x20,
  0x41, 0x83, 0x06, 0x0C, 0x10, 0x20, 0x66, 0x8B, 0x16, 0x2C, 0xD9, 0xA3,
  0x6C, 0xF0, 0xC6, 0x89, 0x32, 0x64, 0x8B, 0x1C, 0x38, 0x70, 0xDB, 0x92,
  0xB6, 0xB4, 0xB4, 0xD4, 0xDC, 0xD8, 0xD8, 0x73, 0x36, 0x1C, 0x18, 0x18,
  0x3C, 0x2C, 0x64, 0xC6, 0xC6, 0x89, 0xB3, 0xC3, 0x06, 0x0C, 0x10, 0x20,
  0x3F, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x60, 0x7C, 0xFC, 0x7B, 0xD8, 0xC4,
  0x21, 0x18, 0xC6, 0x31, 0xC0, 0xCC, 0xC4, 0x46, 0x66, 0x23, 0x33, 0x3C,
  0xE0, 0x86, 0x18, 0x61, 0x84, 0x10, 0xC3, 0x3C, 0x38, 0xA6, 0x93, 0xC4,
  0xFF, 0xF0, 0xCC, 0x77, 0x3C, 0xF3, 0x8F, 0x6E, 0x80, 0x30, 0x41, 0xFB,
  0x36, 0x6C, 0xD1, 0xB6, 0xFC, 0x7F, 0x3C, 0x30, 0x87, 0x6F, 0x80, 0x06,
  0x09, 0xD6, 0x6C, 0xD9, 0xA3, 0x6C, 0xE8, 0x7F, 0x3C, 0xFF, 0x83, 0x3F,
  0x00, 0x07, 0x86, 0x03, 0x07, 0xE0, 0x80, 0x40, 0x60, 0x30, 0x18, 0x0C,
  0x3C, 0x00, 0x77, 0x3C, 0xF3, 0xCF, 0xE4, 0x86, 0xF0, 0x30, 0x41, 0xFB,
  0x36, 0x6C, 0xD1, 0xA2, 0xC4, 0x0C, 0x18, 0x01, 0xE0, 0x81, 0x06, 0x0C,
  0x19, 0xFC, 0x06, 0x0C, 0x09, 0xE0, 0x41, 0x83, 0x06, 0x0C, 0x10, 0x67,
  0x80, 0x30, 0x20, 0x67, 0x66, 0x6C, 0x78, 0x4C, 0x4C, 0xC6, 0xF0, 0xC3,
  0x0C, 0x20, 0x86, 0x1C, 0x3C, 0x7E, 0x6A, 0x5A, 0x52, 0x52, 0xD6, 0xD6,
  0x7E, 0xCD, 0x9B, 0x34, 0x68, 0xB1, 0x00, 0x7F, 0x3C, 0xF3, 0x8F, 0x6F,
  0x00, 0x7E, 0xCD, 0x9B, 0x34, 0x6D, 0x9F, 0x60, 0xC0, 0x77, 0x3C, 0xF3,
  0x8F, 0x6E, 0x82, 0x18, 0x7C, 0x9B, 0x16, 0x0C, 0x18, 0x20, 0x00, 0x3E,
  0xCD, 0x81, 0xE0, 0x68, 0xDF, 0x00, 0x30, 0xCF, 0xC8, 0x21, 0x86, 0x18,
  0x38, 0xC7, 0x1C, 0xF3, 0x8F, 0x6F, 0x00, 0xC7, 0x99, 0x32, 0xC5, 0x8E,
  0x1C, 0x00, 0x93, 0x6E, 0xD5, 0xAD, 0xDB, 0x36, 0x00, 0x67, 0x34, 0x1C,
  0x18, 0x38, 0x6C, 0xC6, 0xC7, 0x3C, 0xF3, 0xCF, 0xE0, 0x86, 0xF0, 0x3E,
  0x8C, 0x30, 0xC3, 0x0C, 0x3F, 0x00, 0x06, 0x1C, 0x60, 0xC1, 0x86, 0x3C,
  0x08, 0x30, 0x60, 0xC1, 0xC0, 0x33, 0x22, 0x26, 0x66, 0x64, 0x4C, 0x30,
  0x70, 0x60, 0xC1, 0x83, 0x07, 0x88, 0x30, 0x60, 0xC7, 0x00, 0xE7, 0x6A,
  0x70,
};

const GFXglyph JetBrainsMono_BoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 9, 8, 2, -9 },
  { 6, 5, 3, 8, 2, -9 },
  { 8, 8, 9, 8, 0, -9 },
  { 17, 8, 13, 8, 0, -11 },
  { 30, 10, 10, 8, -1, -10 },
  { 43, 8, 10, 8, 0, -10 },
  { 53, 2, 3, 8, 4, -9 },
  { 54, 5, 13, 8, 2, -11 },
  { 63, 5, 13, 8, 1, -11 },
  { 72, 7, 7, 8, 1, -8 },
  { 79, 6, 6, 8, 1, -7 },
  { 84, 4, 4, 8, 1, -2 },
  { 86, 4, 1, 8, 2, -5 },
  { 87, 3, 2, 8, 2, -2 },
  { 88, 8, 12, 8, 0, -11 },
  { 100, 7, 10, 8, 1, -10 },
  { 109, 6, 9, 8, 1, -9 },
  { 116, 7, 10, 8, 0, -10 },
  { 125, 7, 9, 8, 0, -9 },
  { 133, 6, 9, 8, 1, -9 },
  { 140, 6, 9, 8, 1, -9 },
  { 147, 7, 9, 8, 0, -9 },
  { 155, 7, 9, 8, 1, -9 },
  { 163, 7, 10, 8, 0, -10 },
  { 172, 7, 10, 8, 1, -10 },
  { 181, 4, 7, 8, 2, -7 },
  { 185, 5, 9, 8, 1, -7 },
  { 191, 6, 7, 8, 1, -8 },
  { 197, 6, 5, 8, 1, -7 },
  { 201, 6, 7, 8, 1, -8 },
  { 207, 5, 9, 8, 2, -9 },
  { 213, 8, 12, 8, 0, -10 },
  { 225, 7, 9, 8, 0, -9 },
  { 233, 8, 9, 8, 0, -9 },
  { 242, 7, 10, 8, 1, -10 },
  { 251, 8, 9, 8, 0, -9 },
  { 260, 7, 9, 8, 1, -9 },
  { 268, 8, 9, 8, 0, -9 },
  { 277, 7, 10, 8, 1, -10 },
  { 286, 8, 9, 8, 0, -9 },
  { 295, 7, 9, 8, 1, -9 },
  { 303, 8, 9, 8, 0, -9 },
  { 312, 8, 9, 8, 0, -9 },
  { 321, 6, 9, 8, 1, -9 },
  { 328, 8, 9, 8, 0, -9 },
  { 337, 8, 9, 8, 0, -9 },
  { 346, 7, 10, 8, 1, -10 },
  { 355, 8, 9, 8, 0, -9 },
  { 364, 7, 12, 8, 1, -10 },
  { 375, 8, 9, 8, 0, -9 },
  { 384, 8, 10, 8, 0, -10 },
  { 394, 7, 9, 8, 1, -9 },
  { 402, 7, 9, 8, 1, -9 },
  { 410, 7, 9, 8, 1, -9 },
  { 418, 8, 9, 8, 1, -9 },
  { 427, 8, 9, 8, 0, -9 },
  { 436, 7, 9, 8, 1, -9 },
  { 444, 8, 9, 8, 0, -9 },
  { 453, 5, 12, 8, 2, -11 },
  { 461, 4, 12, 8, 2, -11 },
  { 467, 6, 12, 8, 1, -11 },
  { 476, 6, 5, 8, 1, -9 },
  { 480, 6, 2, 8, 0, 0 },
  { 482, 3, 2, 8, 3, -10 },
  { 483, 6, 7, 8, 1, -7 },
  { 489, 7, 9, 8, 0, -9 },
  { 497, 6, 7, 8, 1, -7 },
  { 503, 7, 9, 8, 1, -9 },
  { 511, 6, 7, 8, 1, -7 },
  { 517, 9, 11, 8, -1, -9 },
  { 530, 6, 9, 8, 1, -7 },
  { 537, 7, 9, 8, 0, -9 },
  { 545, 7, 10, 8, 0, -10 },
  { 554, 7, 12, 8, 0, -10 },
  { 565, 8, 9, 8, 0, -9 },
  { 574, 6, 9, 8, 1, -9 },
  { 581, 8, 7, 8, 0, -7 },
  { 588, 7, 7, 8, 0, -7 },
  { 595, 6, 7, 8, 1, -7 },
  { 601, 7, 9, 8, 0, -7 },
  { 609, 6, 9, 8, 1, -7 },
  { 616, 7, 7, 8, 1, -7 },
  { 623, 7, 7, 8, 0, -7 },
  { 630, 6, 9, 8, 1, -9 },
  { 637, 6, 7, 8, 1, -7 },
  { 643, 7, 7, 8, 1, -7 },
  { 650, 7, 7, 8, 1, -7 },
  { 657, 8, 7, 8, 0, -7 },
  { 664, 6, 9, 8, 1, -7 },
  { 671, 7, 7, 8, 0, -7 },
  { 678, 7, 12, 8, 1, -11 },
  { 689, 4, 12, 8, 2, -11 },
  { 695, 7, 12, 8, 0, -11 },
  { 706, 7, 3, 8, 1, -6 },
};

const GFXfont JetBrainsMono_BoldItalic13pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic13pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _JETBRAINSMONO_BOLDITALIC13PT7B_H_
