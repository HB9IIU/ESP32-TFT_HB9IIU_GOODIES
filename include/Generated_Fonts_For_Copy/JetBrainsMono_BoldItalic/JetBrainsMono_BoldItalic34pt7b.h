#ifndef _JETBRAINSMONO_BOLDITALIC34PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x78, 0xFB, 0xC7, 0xBE, 0x3D, 0xF1,
  0xEF, 0x0F, 0x78, 0xFB, 0xC7, 0x9E, 0x3C, 0xE1, 0xE7, 0x0F, 0x00, 0x00,
  0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x3C, 0x01, 0xC1, 0xC0, 0x0E, 0x0E,
  0x00, 0x70, 0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x1C,
  0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x0F, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80,
  0x1C, 0x3C, 0x01, 0xC1, 0xC0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF0, 0x38, 0x38, 0x01, 0xC3, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07,
  0x0E, 0x00, 0x70, 0x70, 0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xC3, 0xE6, 0x7C, 0x78, 0xCF, 0x8F, 0x19, 0xF1, 0xE7, 0x00,
  0x3C, 0xC0, 0x07, 0xD8, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x0C, 0xF8, 0x01, 0x8F, 0x00, 0x31, 0xE7,
  0xC6, 0x3C, 0xF9, 0xCF, 0x9F, 0x31, 0xE1, 0xFE, 0xFC, 0x3F, 0xFF, 0x03,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF0, 0x03, 0x81, 0xFC, 0x03, 0x81,
  0xFF, 0x03, 0x81, 0xE3, 0x83, 0x80, 0xE1, 0xC3, 0x80, 0x70, 0xE3, 0x80,
  0x38, 0x73, 0xC0, 0x1C, 0x7B, 0xC0, 0x0F, 0x79, 0xC0, 0x07, 0xF9, 0xC0,
  0x01, 0xF9, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xEF, 0xC0, 0x00, 0xEF, 0xF0, 0x00, 0xEF, 0xF8, 0x00, 0xE7,
  0x0E, 0x00, 0xE3, 0x8F, 0x00, 0xE3, 0x87, 0x00, 0xE1, 0xC3, 0x80, 0xF0,
  0xE1, 0xC0, 0x70, 0x7F, 0xE0, 0x70, 0x1F, 0xE0, 0xF0, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0x83,
  0xC0, 0x78, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x13, 0xFF, 0x1E, 0x3C,
  0xF3, 0xE7, 0xC7, 0xBC, 0x78, 0x7F, 0x87, 0x83, 0xF8, 0x78, 0x3F, 0x07,
  0x81, 0xE0, 0x78, 0x3F, 0x07, 0xC7, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0x78,
  0x1F, 0xC7, 0xC0, 0x7D, 0xF7, 0x9E, 0x79, 0xEF, 0xBC, 0xF3, 0xC0, 0x00,
  0x02, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x01,
  0x80, 0x04, 0x00, 0x1C, 0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x3C, 0x00, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x38,
  0x6F, 0x8C, 0x7F, 0xFB, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0x00, 0x3C, 0x00,
  0x1D, 0x80, 0x0E, 0x70, 0x07, 0x9E, 0x03, 0xC7, 0xC1, 0xF0, 0xF0, 0x78,
  0x38, 0x04, 0x04, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0xC7, 0xE1, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0xC1, 0xE0,
  0x78, 0x3C, 0x00, 0x7F, 0xFB, 0xFF, 0x9F, 0xFD, 0xFF, 0xE0, 0x38, 0xFB,
  0xF7, 0xEF, 0xDF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F,
  0xFE, 0x1E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x78, 0x07,
  0x9E, 0x01, 0xE7, 0x8C, 0x79, 0xE7, 0x9E, 0x7B, 0xE7, 0x9E, 0x7B, 0xCF,
  0x8C, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x78, 0xF0, 0x3E, 0x3F, 0x3F, 0x07, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFB, 0xC0,
  0xF9, 0xE0, 0x70, 0xF0, 0x30, 0x78, 0x10, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x03, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF0, 0x7C, 0x3C, 0x07, 0x8F, 0x80, 0xF1,
  0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE7,
  0x80, 0xFB, 0xE0, 0x3C, 0x78, 0x1F, 0x1F, 0x8F, 0x87, 0xFF, 0xE0, 0xFF,
  0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x1E, 0x1F, 0x07, 0x8F, 0x81, 0xE7,
  0xC0, 0xF9, 0xE0, 0x3E, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF,
  0xFC, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x7F, 0x03,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x3F, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF3, 0xC0, 0x78, 0xF0, 0x3E,
  0x3F, 0x3F, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF7, 0xE0, 0x7B,
  0xFC, 0x3F, 0xFF, 0x8F, 0x83, 0xE7, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x07,
  0x9E, 0x01, 0xEF, 0x80, 0x79, 0xE0, 0x3E, 0x78, 0x1F, 0x1F, 0x8F, 0xC3,
  0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFD, 0xFF, 0xFE, 0x78, 0x07, 0x9E, 0x03, 0xEF, 0x80, 0xF3, 0xE0,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07,
  0xF7, 0xE0, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E,
  0x07, 0xC3, 0xE1, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x1F,
  0xFC, 0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x00, 0xF1, 0xE0,
  0x1E, 0x3C, 0x07, 0xC7, 0x81, 0xF0, 0xFC, 0x7E, 0x1F, 0xFF, 0x81, 0xFF,
  0xE0, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF,
  0xE7, 0xC0, 0xFB, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x07, 0xBE, 0x07, 0xDF, 0x07, 0xE7, 0xFF, 0xE3, 0xFF, 0xF0, 0xFE, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x0F,
  0x8F, 0xC7, 0xE3, 0xF0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x00, 0x01, 0xE0, 0x3E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x3E,
  0x03, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x80, 0x01,
  0x80, 0x03, 0xC0, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF,
  0x00, 0xFE, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x03,
  0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xCF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF,
  0x9F, 0xFF, 0xC0, 0x10, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF,
  0x00, 0x7C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0xE0,
  0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0xE0, 0xFF, 0xC1, 0xFF, 0x03, 0xF8, 0x07, 0xC0,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF,
  0x00, 0xFF, 0xFC, 0x0F, 0x83, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x3C, 0x78,
  0x01, 0xE3, 0x80, 0x0F, 0x3C, 0x0E, 0x79, 0xE1, 0xFB, 0x8E, 0x1F, 0xFC,
  0x70, 0xF1, 0xE3, 0x8F, 0x0F, 0x3C, 0x78, 0x79, 0xE3, 0x83, 0xCF, 0x1C,
  0x1C, 0x78, 0xE0, 0xE3, 0x8F, 0x07, 0x1C, 0x78, 0x79, 0xE3, 0xC3, 0xCF,
  0x1F, 0xFE, 0x78, 0x7F, 0xF3, 0xC1, 0xE7, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x03,
  0xEF, 0x00, 0xF3, 0xC0, 0x3C, 0x70, 0x1E, 0x1C, 0x07, 0x87, 0x83, 0xE1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF8,
  0xF0, 0x1E, 0x3C, 0x07, 0x9F, 0x01, 0xE7, 0x80, 0x7B, 0xE0, 0x1F, 0xF0,
  0x07, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE1,
  0xE0, 0x7C, 0x3C, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x1E, 0x03, 0xC3,
  0xC0, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0x03, 0xE1, 0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C,
  0x07, 0xC7, 0x81, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF,
  0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1E,
  0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x7C, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x01, 0xF3, 0xC0, 0x78, 0xF8,
  0x3E, 0x3F, 0xBF, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xF0, 0x7C, 0x3C,
  0x07, 0x87, 0x80, 0xF8, 0xF0, 0x1E, 0x1E, 0x03, 0xC7, 0xC0, 0x78, 0xF8,
  0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x8F, 0x01, 0xE1, 0xE0,
  0x3C, 0x7C, 0x07, 0x8F, 0x80, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x87, 0x83,
  0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1E,
  0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x7C, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0xFF, 0x9E, 0x3F, 0xE7, 0x8F, 0xF3,
  0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF8,
  0x3E, 0x3F, 0xBF, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x0F,
  0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x81, 0xF1, 0xF0, 0x3E, 0x3C,
  0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF8, 0xFF,
  0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0x01, 0xE1, 0xE0,
  0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80,
  0xF0, 0xF0, 0x1E, 0x1E, 0x07, 0xC7, 0xC0, 0xF8, 0xF0, 0x1E, 0x00, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x78, 0x07, 0x87, 0x80, 0xF8, 0x78, 0x1F,
  0x07, 0xE7, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x0F,
  0x00, 0xF8, 0x78, 0x0F, 0x83, 0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x7C,
  0x0F, 0x07, 0xC0, 0x78, 0x3E, 0x03, 0xC3, 0xE0, 0x1E, 0x1E, 0x00, 0xF1,
  0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xF1, 0xF0, 0x07, 0x87, 0x80, 0x7C, 0x3C, 0x03, 0xE1, 0xF0, 0x1E, 0x0F,
  0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x83, 0xE0, 0x3C, 0x1F,
  0x01, 0xE0, 0xF0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0xC3, 0xF0, 0x7E,
  0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xE3, 0xB8, 0x7F, 0x1D, 0xC3, 0xD9,
  0xDE, 0x1E, 0xCE, 0xF0, 0xF7, 0x77, 0x07, 0x3F, 0x38, 0x39, 0xFB, 0xC3,
  0xCF, 0x9E, 0x1E, 0x7C, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x03,
  0xC1, 0xE0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C,
  0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x80, 0x0F, 0x81,
  0xE1, 0xF0, 0x3C, 0x3E, 0x07, 0x8F, 0xE0, 0xF1, 0xFC, 0x1E, 0x3F, 0x83,
  0xC7, 0x70, 0x70, 0xEE, 0x1E, 0x1D, 0xE3, 0xC7, 0xBC, 0x78, 0xF3, 0x8F,
  0x1E, 0x71, 0xE3, 0xCE, 0x38, 0x79, 0xEF, 0x0F, 0x3D, 0xE3, 0xC3, 0xBC,
  0x78, 0x77, 0x8F, 0x0E, 0xF1, 0xE1, 0xDE, 0x3C, 0x3F, 0x87, 0x87, 0xF1,
  0xE0, 0x7E, 0x3C, 0x0F, 0xC7, 0x81, 0xF8, 0xF0, 0x3F, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1E, 0x07, 0x8F, 0x81, 0xE3,
  0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x9F, 0x01, 0xE7, 0xC0, 0xF9, 0xE0,
  0x3E, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F,
  0x3C, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF8, 0x3E, 0x3F, 0xBF, 0x07,
  0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x03, 0xE1, 0xE0, 0x1E, 0x1E, 0x01,
  0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x3E, 0x3E, 0x03, 0xC3, 0xE1,
  0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3E, 0x07, 0x8F, 0x81, 0xE3,
  0xC0, 0x78, 0xF0, 0x1E, 0x7C, 0x07, 0x9F, 0x01, 0xE7, 0x80, 0x79, 0xE0,
  0x3E, 0x78, 0x0F, 0x9E, 0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F,
  0x3C, 0x07, 0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF8, 0x3E, 0x3F, 0xBF, 0x07,
  0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x0F, 0xFC, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF0, 0x7E, 0x3C, 0x07, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xC0, 0x78, 0xF8, 0x1F, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xE3, 0xC0, 0x7C, 0x7C,
  0x0F, 0x87, 0x81, 0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0xF0, 0x3C,
  0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF0, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xF0, 0x3E, 0x3C, 0x07, 0xC7, 0x80,
  0xF8, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF3, 0xE0, 0x1E, 0x7C, 0x07, 0xCF, 0x80, 0xF0, 0xFE, 0xFE,
  0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C,
  0xF8, 0x0F, 0x3E, 0x07, 0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C,
  0x07, 0x9F, 0x01, 0xE7, 0xC0, 0xF9, 0xE0, 0x3E, 0x78, 0x0F, 0x1E, 0x03,
  0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x07, 0xCF, 0x01, 0xE3,
  0xC0, 0x78, 0xF8, 0x3E, 0x3F, 0x3F, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F,
  0xE0, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0xFB, 0xC0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF8, 0xF8, 0x3C, 0x1E, 0x0F,
  0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0xF8, 0x1E, 0x3C, 0x07, 0x8F, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x3B,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x78,
  0x70, 0x77, 0x0F, 0x0F, 0x70, 0xF0, 0xF7, 0x0F, 0x0E, 0x70, 0xF0, 0xE7,
  0x1F, 0x1E, 0x71, 0xB1, 0xE7, 0x1B, 0x1C, 0x73, 0xB1, 0xCF, 0x3B, 0x3C,
  0xF3, 0x33, 0xCF, 0x33, 0x38, 0xF7, 0x33, 0x8F, 0x63, 0x78, 0xF6, 0x37,
  0x0E, 0x67, 0x70, 0xEE, 0x77, 0x0E, 0xC7, 0xF0, 0xEC, 0x7E, 0x0F, 0xC7,
  0xE0, 0xFC, 0x7E, 0x0F, 0x86, 0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF0,
  0x7C, 0x00, 0x07, 0xC0, 0x3C, 0x1F, 0x01, 0xF0, 0x3C, 0x0F, 0x80, 0xF8,
  0x7C, 0x03, 0xE1, 0xF0, 0x07, 0x8F, 0x80, 0x1F, 0x7C, 0x00, 0x3D, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF,
  0x00, 0x0F, 0x3C, 0x00, 0x7C, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x07, 0x80,
  0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0xF0, 0xFC, 0x03, 0xE0, 0xF8,
  0x03, 0xEF, 0x00, 0x79, 0xE0, 0x1F, 0x3E, 0x03, 0xC3, 0xC0, 0xF0, 0x78,
  0x3E, 0x0F, 0x07, 0x81, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x7B,
  0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xF0,
  0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFE, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F,
  0x81, 0xE7, 0x03, 0xCE, 0x0F, 0x1E, 0x1E, 0x3C, 0x78, 0x39, 0xE0, 0x7B,
  0xC0, 0xFF, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xE0, 0xF8, 0x7C, 0x3C, 0x3E, 0x1F, 0x03, 0xF3, 0xC1, 0xFE, 0xF0, 0xFF,
  0xBC, 0x7F, 0xEF, 0x1E, 0x0F, 0xCF, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x3C, 0x07, 0x9F, 0x01, 0xE7, 0xC0, 0xF9, 0xE0, 0x3E, 0x78, 0x0F, 0x1E,
  0x03, 0xC7, 0xC1, 0xF1, 0xF9, 0xFC, 0x7F, 0xEF, 0x0F, 0xF7, 0xC1, 0xF9,
  0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xE3, 0xE0, 0x7B, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE3,
  0xF0, 0x78, 0xF8, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0,
  0x1E, 0x7C, 0x07, 0x9F, 0x03, 0xE7, 0x80, 0xF1, 0xE0, 0x3C, 0x7C, 0x1F,
  0x1F, 0x9F, 0x87, 0xFF, 0xE3, 0xFF, 0xF0, 0xF3, 0xF8, 0x00, 0x03, 0xF8,
  0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE3, 0xE0, 0xFB, 0xE0, 0x7D, 0xE0,
  0x3E, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x17, 0x80, 0xF3, 0xE0, 0xF9, 0xFD, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x7E, 0x78, 0x3F, 0xDE, 0x1F, 0xF7, 0x8F,
  0xFD, 0xE3, 0xC1, 0xF9, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80,
  0xF3, 0xE0, 0x3C, 0xF8, 0x1F, 0x3C, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x78,
  0xF8, 0x3E, 0x3F, 0x3F, 0x8F, 0xFD, 0xE1, 0xFE, 0xF8, 0x3F, 0x3C, 0x00,
  0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x87, 0xE3, 0xE3, 0xC0, 0xF3, 0xC0,
  0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x7F, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDE,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x79, 0xF0, 0x78, 0x7F, 0xFC,
  0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xE7, 0x87, 0xFB, 0xC7, 0xFD, 0xE7, 0xFE, 0xF3, 0xE1, 0xFB, 0xE0, 0x79,
  0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x7C, 0x07, 0xBE, 0x07, 0xDE, 0x03,
  0xEF, 0x81, 0xE7, 0xC1, 0xF3, 0xFF, 0xF8, 0xFF, 0xBC, 0x3F, 0x9E, 0x0F,
  0x9F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0xC1, 0xFF, 0xE0,
  0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE3, 0xE0, 0x7B, 0xFC, 0x1F,
  0xFF, 0x87, 0xFF, 0xE3, 0xF0, 0xF8, 0xF8, 0x1E, 0x3C, 0x07, 0x8F, 0x01,
  0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0x80, 0xF1,
  0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xF3, 0xE0, 0x7C, 0xF0,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xFF, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x01,
  0xF1, 0xE0, 0x3E, 0x1E, 0x07, 0xC1, 0xE0, 0xF8, 0x1E, 0x1F, 0x03, 0xE1,
  0xF0, 0x3C, 0x3E, 0x03, 0xC7, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xF8, 0x07, 0xC7, 0x80, 0x7C, 0x7C, 0x07, 0x83, 0xC0, 0x78, 0x3E, 0x07,
  0x83, 0xE0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x80, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x03, 0xFE, 0x1E, 0xF3, 0xC1,
  0xFF, 0x7E, 0x1D, 0xFF, 0xE1, 0xE7, 0x9F, 0x1C, 0x78, 0xE3, 0xC7, 0x0E,
  0x3C, 0x71, 0xE3, 0xC7, 0x1E, 0x3C, 0x71, 0xE3, 0xC7, 0x1E, 0x38, 0x71,
  0xE7, 0x8E, 0x1C, 0x78, 0xE3, 0xC7, 0x8E, 0x3C, 0x78, 0xE3, 0xC7, 0x8E,
  0x3C, 0x70, 0xE3, 0xCF, 0x1C, 0x38, 0xF1, 0xC7, 0x80, 0x1E, 0x3E, 0x07,
  0xBF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x0F, 0x8F, 0x81, 0xE3, 0xC0,
  0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E,
  0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x1F, 0x3E,
  0x07, 0xCF, 0x01, 0xE0, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF,
  0xE3, 0xE1, 0xF3, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x7C,
  0x07, 0xBE, 0x03, 0xDE, 0x03, 0xEF, 0x01, 0xE7, 0x80, 0xF3, 0xE0, 0xF9,
  0xF9, 0xF8, 0x7F, 0xFC, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0x1F, 0x01,
  0xEF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xF8, 0x3C, 0x3E, 0x07, 0x87,
  0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0xF8, 0x0F, 0x1F,
  0x03, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x83, 0xE1, 0xF9, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xC1, 0xE7, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF3, 0xC1,
  0xFE, 0xF0, 0xFF, 0xBC, 0x7F, 0xEF, 0x1E, 0x0F, 0xCF, 0x81, 0xE3, 0xC0,
  0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x9F, 0x01, 0xE7, 0xC0, 0xF9, 0xE0, 0x3C,
  0x78, 0x0F, 0x1E, 0x03, 0xC7, 0xC1, 0xF1, 0xF9, 0xFC, 0x7F, 0xEF, 0x0F,
  0xF7, 0xC1, 0xF9, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x7E, 0x0F, 0x3F, 0xC3, 0xDF,
  0xF8, 0xFF, 0xFE, 0x3E, 0x0F, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7E, 0x7F, 0x1E, 0x07,
  0xCF, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xEF, 0x80, 0xF1, 0xF0,
  0x7C, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x3C,
  0x07, 0x9E, 0x03, 0xCF, 0x01, 0xEF, 0x80, 0xF7, 0xC0, 0xFB, 0xC0, 0x7D,
  0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0xBE, 0x07, 0xDF, 0x03,
  0xEF, 0x01, 0xE7, 0x80, 0xF3, 0xE0, 0xF9, 0xF9, 0xF8, 0x7F, 0xF8, 0x3F,
  0xF8, 0x07, 0xF8, 0x00, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xDF, 0x01,
  0xE7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x7C, 0x3C,
  0x3C, 0x0F, 0x3E, 0x07, 0x9E, 0x03, 0xDF, 0x01, 0xEF, 0x00, 0xF7, 0x80,
  0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xF0, 0xE0, 0xFE,
  0x1C, 0x3F, 0xC7, 0x87, 0xF8, 0xF0, 0xEF, 0x1E, 0x3D, 0xC7, 0xC7, 0xB8,
  0xD8, 0xE7, 0x1B, 0x1C, 0xE7, 0x67, 0x9C, 0xCC, 0xE3, 0x99, 0x9C, 0x77,
  0x37, 0x8E, 0xC6, 0xE1, 0xD8, 0xDC, 0x3B, 0x1B, 0x87, 0xC3, 0xE0, 0xF8,
  0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0xF0, 0x3E,
  0x0F, 0x83, 0xC0, 0x78, 0x7C, 0x07, 0xCF, 0x80, 0x3D, 0xF0, 0x03, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0xFB, 0xE0, 0x1F, 0x1E, 0x01, 0xE1, 0xF0, 0x3E,
  0x0F, 0x07, 0xC0, 0xF8, 0xF8, 0x07, 0xC0, 0x3C, 0x07, 0x9E, 0x03, 0xCF,
  0x01, 0xEF, 0x81, 0xF7, 0x80, 0xFB, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E,
  0x78, 0x0F, 0x7C, 0x0F, 0xBE, 0x07, 0xDE, 0x03, 0xCF, 0x83, 0xE7, 0xE3,
  0xF3, 0xFF, 0x78, 0xFF, 0xBC, 0x3F, 0xBE, 0x06, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x0F, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0,
  0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFF,
  0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x07, 0x83, 0xC1, 0xE1,
  0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x3E, 0x1F, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xF8, 0x78,
  0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0x07, 0xC0, 0x07, 0xF0,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0xF7, 0xFC, 0x3B, 0xFF,
  0x0E, 0xF1, 0xFF, 0xB8, 0x7F, 0xCE, 0x0F, 0xF0, 0x01, 0xF0,
};

const GFXglyph JetBrainsMono_BoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 9, 25, 20, 6, -25 },
  { 30, 13, 10, 20, 6, -25 },
  { 47, 21, 25, 20, 0, -25 },
  { 113, 19, 35, 20, 1, -30 },
  { 197, 25, 25, 20, -2, -25 },
  { 276, 20, 25, 20, 0, -25 },
  { 339, 6, 10, 20, 9, -25 },
  { 347, 15, 33, 20, 5, -29 },
  { 409, 14, 33, 20, 2, -29 },
  { 467, 18, 18, 20, 2, -21 },
  { 508, 17, 16, 20, 2, -19 },
  { 542, 10, 10, 20, 3, -5 },
  { 555, 13, 4, 20, 4, -13 },
  { 562, 7, 6, 20, 6, -6 },
  { 568, 21, 32, 20, 0, -28 },
  { 652, 18, 25, 20, 2, -25 },
  { 709, 17, 25, 20, 1, -25 },
  { 763, 19, 25, 20, 1, -25 },
  { 823, 18, 25, 20, 1, -25 },
  { 880, 18, 25, 20, 1, -25 },
  { 937, 18, 25, 20, 2, -25 },
  { 994, 18, 25, 20, 1, -25 },
  { 1051, 18, 25, 20, 3, -25 },
  { 1108, 19, 25, 20, 1, -25 },
  { 1168, 17, 25, 20, 3, -25 },
  { 1222, 9, 19, 20, 6, -19 },
  { 1244, 12, 24, 20, 3, -19 },
  { 1280, 17, 19, 20, 3, -21 },
  { 1321, 17, 12, 20, 2, -17 },
  { 1347, 17, 19, 20, 1, -21 },
  { 1388, 15, 25, 20, 4, -25 },
  { 1435, 21, 31, 20, 0, -25 },
  { 1517, 18, 25, 20, 0, -25 },
  { 1574, 19, 25, 20, 1, -25 },
  { 1634, 18, 25, 20, 2, -25 },
  { 1691, 19, 25, 20, 1, -25 },
  { 1751, 19, 25, 20, 1, -25 },
  { 1811, 20, 25, 20, 1, -25 },
  { 1874, 18, 25, 20, 2, -25 },
  { 1931, 19, 25, 20, 1, -25 },
  { 1991, 18, 25, 20, 2, -25 },
  { 2048, 20, 25, 20, 0, -25 },
  { 2111, 21, 25, 20, 1, -25 },
  { 2177, 15, 25, 20, 2, -25 },
  { 2224, 21, 25, 20, 0, -25 },
  { 2290, 19, 25, 20, 1, -25 },
  { 2350, 18, 25, 20, 2, -25 },
  { 2407, 20, 25, 20, 1, -25 },
  { 2470, 18, 31, 20, 2, -25 },
  { 2540, 19, 25, 20, 1, -25 },
  { 2600, 19, 25, 20, 1, -25 },
  { 2660, 18, 25, 20, 3, -25 },
  { 2717, 18, 25, 20, 2, -25 },
  { 2774, 18, 25, 20, 4, -25 },
  { 2831, 20, 25, 20, 2, -25 },
  { 2894, 22, 25, 20, -1, -25 },
  { 2963, 19, 25, 20, 3, -25 },
  { 3023, 19, 25, 20, 1, -25 },
  { 3083, 15, 32, 20, 4, -28 },
  { 3143, 11, 32, 20, 5, -28 },
  { 3187, 14, 32, 20, 3, -28 },
  { 3243, 15, 13, 20, 3, -25 },
  { 3268, 17, 4, 20, 0, 1 },
  { 3277, 8, 5, 20, 8, -27 },
  { 3282, 18, 19, 20, 1, -19 },
  { 3325, 18, 25, 20, 1, -25 },
  { 3382, 17, 19, 20, 2, -19 },
  { 3423, 18, 25, 20, 2, -25 },
  { 3480, 17, 19, 20, 2, -19 },
  { 3521, 23, 31, 20, -2, -25 },
  { 3611, 17, 25, 20, 2, -19 },
  { 3665, 18, 25, 20, 1, -25 },
  { 3722, 17, 27, 20, 1, -27 },
  { 3780, 19, 33, 20, 0, -27 },
  { 3859, 20, 25, 20, 1, -25 },
  { 3922, 15, 25, 20, 3, -25 },
  { 3969, 20, 19, 20, 0, -19 },
  { 4017, 18, 19, 20, 1, -19 },
  { 4060, 17, 19, 20, 2, -19 },
  { 4101, 19, 25, 20, 0, -19 },
  { 4161, 18, 25, 20, 1, -19 },
  { 4218, 18, 19, 20, 2, -19 },
  { 4261, 18, 19, 20, 1, -19 },
  { 4304, 17, 24, 20, 2, -24 },
  { 4355, 17, 19, 20, 2, -19 },
  { 4396, 17, 19, 20, 3, -19 },
  { 4437, 19, 19, 20, 2, -19 },
  { 4483, 20, 19, 20, 0, -19 },
  { 4531, 17, 25, 20, 2, -19 },
  { 4585, 18, 19, 20, 1, -19 },
  { 4628, 18, 32, 20, 3, -28 },
  { 4700, 9, 32, 20, 6, -28 },
  { 4736, 17, 32, 20, 1, -28 },
  { 4804, 18, 8, 20, 2, -16 },
};

const GFXfont JetBrainsMono_BoldItalic34pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic34pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _JETBRAINSMONO_BOLDITALIC34PT7B_H_
