#ifndef _JETBRAINSMONO_BOLDITALIC38PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0,
  0x3C, 0x3E, 0xF8, 0x7D, 0xF0, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F, 0x9E,
  0x1F, 0x3C, 0x3C, 0xF8, 0x79, 0xF0, 0xF3, 0xC1, 0xE7, 0x83, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x78, 0x38, 0x00, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07,
  0x83, 0x80, 0x0E, 0x0F, 0x00, 0x3C, 0x1E, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x07, 0x83, 0x80, 0x0E, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0x78, 0x38, 0x00, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0x80,
  0x0E, 0x0F, 0x11, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x03,
  0xC1, 0xE0, 0x07, 0x83, 0x80, 0x0E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78,
  0x38, 0x00, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7E, 0xEF, 0xC3, 0xE6,
  0x3E, 0x3E, 0x31, 0xF1, 0xF1, 0x8F, 0x8F, 0x8C, 0x00, 0x7C, 0xE0, 0x03,
  0xF7, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xDF, 0x80, 0x0C, 0x7C, 0x00,
  0x63, 0xE0, 0x03, 0x1F, 0x1E, 0x18, 0xF8, 0xF9, 0xC7, 0xC7, 0xEE, 0xFC,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0xF0, 0x3F, 0xE0, 0x1E, 0x07, 0xFE, 0x03, 0xC0, 0x78,
  0xE0, 0x78, 0x07, 0x0F, 0x0F, 0x00, 0xF0, 0xE0, 0xE0, 0x0F, 0x0E, 0x1C,
  0x00, 0xE0, 0xE3, 0x80, 0x0E, 0x1E, 0x78, 0x00, 0xF1, 0xEF, 0x00, 0x0F,
  0xFD, 0xE0, 0x00, 0x7F, 0xBC, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE1, 0x00, 0x00, 0x3D, 0xFE, 0x00,
  0x07, 0xBF, 0xE0, 0x00, 0xF7, 0xDF, 0x00, 0x0E, 0x78, 0xF0, 0x01, 0xC7,
  0x0F, 0x00, 0x38, 0x70, 0xF0, 0x07, 0x8F, 0x0F, 0x00, 0xF0, 0xF0, 0xE0,
  0x1E, 0x0F, 0x1E, 0x03, 0xC0, 0x7F, 0xE0, 0x38, 0x07, 0xFC, 0x0F, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x03, 0xE1, 0xF0, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x87, 0xCF, 0xBE, 0x1E, 0x3C, 0x7C,
  0xF8, 0xF0, 0xF7, 0xC7, 0xC3, 0xFE, 0x1F, 0x07, 0xF8, 0x7C, 0x1F, 0xC1,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0x9E, 0x07, 0xF8, 0x7C, 0x3D, 0xF7, 0xDF, 0x7D, 0xF7,
  0x9E, 0x7B, 0xEF, 0x3C, 0x00, 0x01, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x07, 0x07, 0x07, 0x7C, 0x71, 0xFF, 0xE6, 0x7F, 0xFF, 0x6F, 0xF3,
  0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xB8, 0x00, 0xFB, 0xC0,
  0x1F, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x18, 0x0C,
  0x00, 0x80, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x81, 0xF0,
  0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1C, 0x3E, 0x7F, 0x7F, 0x7F, 0x7E, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x83, 0xF1, 0xF0,
  0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x1E, 0x3C,
  0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0xF3, 0xE7, 0xDF, 0x3E, 0x7D, 0xF3, 0xE7,
  0x8F, 0x3E, 0x78, 0x43, 0xC7, 0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x80, 0x7C,
  0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0xC1, 0xF8, 0x7F, 0xFF,
  0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xEF, 0x81, 0xE3, 0xE0,
  0x70, 0xF8, 0x10, 0x3E, 0x08, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFC, 0x3F,
  0x07, 0xC0, 0xFC, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1E, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xE1, 0xF0,
  0x1F, 0x0F, 0x81, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x3C, 0x3E, 0x0F,
  0x8F, 0x81, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0xDF, 0x00, 0xFB, 0xFF, 0xFE,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x7F, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3E, 0x07, 0xC3,
  0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0xC1, 0xF8, 0xFF, 0xFF,
  0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF9, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xF0, 0x3E,
  0x7E, 0x03, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x03,
  0xE7, 0x80, 0x3E, 0x7C, 0x07, 0xC7, 0xE0, 0xFC, 0x7F, 0xFF, 0x83, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0,
  0x7C, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0xFC, 0x1F, 0x07, 0xC0, 0x7C, 0x3C, 0x03, 0xE3, 0xE0, 0x1E, 0x1F, 0x01,
  0xF0, 0x78, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x9F, 0x80, 0x7F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0x8F, 0xC1, 0xF0, 0x3F,
  0x0F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0,
  0x1F, 0x0F, 0xC1, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE3, 0xF0, 0x7E, 0xFC, 0x07, 0xDF, 0x00, 0xFB, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xEF, 0xC0, 0xFC, 0xFE, 0x7F,
  0x9F, 0xFF, 0xE1, 0xFF, 0x7C, 0x1F, 0xDF, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x83,
  0xF1, 0xFC, 0x7F, 0x1F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7C,
  0x00, 0x01, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x7E,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x10, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF9, 0xFF,
  0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xF8, 0x10, 0x00, 0x03, 0x80, 0x00, 0xFC,
  0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0,
  0x03, 0xE0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xF8,
  0x3F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x1F, 0xFC, 0x1F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x1F, 0x87, 0xE0, 0x7C, 0x03, 0xE1, 0xF0, 0x03, 0xC3, 0xC0, 0x07,
  0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x06, 0x3C, 0xF0, 0x7F, 0x79,
  0xE0, 0xFE, 0xF3, 0xC3, 0xE7, 0xE7, 0x8F, 0x87, 0x8F, 0x1E, 0x0F, 0x1E,
  0x3C, 0x1E, 0x78, 0x78, 0x3C, 0xF0, 0xF0, 0x79, 0xE3, 0xC0, 0xF3, 0xC7,
  0x83, 0xC7, 0x8F, 0x07, 0x8F, 0x1E, 0x0F, 0x3C, 0x3E, 0x3E, 0x78, 0x7F,
  0xFC, 0xF0, 0x7F, 0x79, 0xE0, 0x78, 0xE3, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xBC,
  0x00, 0xFB, 0xC0, 0x0F, 0xBC, 0x00, 0xF3, 0xC0, 0x1F, 0x3C, 0x01, 0xE3,
  0xC0, 0x3E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xE0, 0x78,
  0x3E, 0x0F, 0x83, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE3, 0xE0, 0x1E, 0x3E, 0x01, 0xE7, 0xC0, 0x1E, 0x7C, 0x01, 0xE7,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x07, 0xFE, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xF8, 0x3F, 0x87, 0x80, 0x7C, 0x3C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x7C,
  0x3C, 0x0F, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC7,
  0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0x81, 0xF8, 0x7F, 0xFF,
  0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xC3, 0xF1, 0xF0, 0x1F,
  0x1E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x8F, 0xC1, 0xF8, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0x80, 0xFC, 0x3C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3C,
  0x3E, 0x01, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0xC7,
  0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x87, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0xC3, 0xF1, 0xF0, 0x1F, 0x1E, 0x01, 0xF3, 0xE0, 0x1F,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC7, 0xFE, 0x7C, 0x7F, 0xE7, 0xC7, 0xFE, 0x7C, 0x7F, 0xE7, 0x80,
  0x3C, 0x78, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8,
  0x0F, 0x8F, 0xC1, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0xFF, 0x00, 0x07, 0x80, 0x7C, 0x3E, 0x01, 0xE0, 0xF8, 0x0F, 0x83, 0xE0,
  0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF0, 0x0F, 0x87, 0xC0, 0x3C,
  0x1F, 0x00, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3E, 0x03,
  0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x00, 0xF8, 0x7C, 0x03, 0xC1,
  0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xE0,
  0x1F, 0x0F, 0x80, 0x78, 0x3E, 0x03, 0xE0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0x80,
  0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F,
  0x01, 0xF0, 0x3E, 0x03, 0xC0, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xC0,
  0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3E, 0x1E, 0x00, 0x7C,
  0x3E, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x81,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF0, 0x0F,
  0x83, 0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x3E, 0x0F, 0xC0,
  0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F,
  0xC3, 0xF8, 0x77, 0x07, 0xF1, 0xFE, 0x0E, 0xF3, 0xBC, 0x3C, 0xEF, 0x78,
  0x79, 0xDC, 0xF0, 0xF3, 0xBB, 0xE1, 0xE7, 0xE7, 0x83, 0xCF, 0xCF, 0x07,
  0x9F, 0x9E, 0x1F, 0x3E, 0x3C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF0,
  0x03, 0xE1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x07,
  0x87, 0xC0, 0x0F, 0x00, 0x0F, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xFE, 0x07,
  0x83, 0xF8, 0x1E, 0x0F, 0xE0, 0x78, 0x3F, 0x81, 0xE1, 0xEE, 0x0F, 0x87,
  0xBC, 0x3E, 0x1E, 0xF0, 0xF8, 0x7B, 0xC3, 0xC1, 0xEF, 0x0F, 0x07, 0x9C,
  0x3C, 0x1E, 0x78, 0xF0, 0xF9, 0xE7, 0xC3, 0xE7, 0x9F, 0x0F, 0x1E, 0x78,
  0x3C, 0x39, 0xE0, 0xF0, 0xE7, 0x83, 0xC3, 0xDE, 0x1F, 0x0F, 0x78, 0x7C,
  0x3D, 0xE1, 0xE0, 0xF7, 0x07, 0x81, 0xFC, 0x1E, 0x07, 0xF0, 0x78, 0x1F,
  0xC3, 0xE0, 0x7F, 0x0F, 0x81, 0xFC, 0x3C, 0x03, 0xE0, 0x00, 0xFF, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x83, 0xE1, 0xF0, 0x1F,
  0x1E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xE3, 0xE0, 0x1E, 0x3E, 0x03,
  0xE3, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x3C, 0x7C, 0x07, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0xCF, 0x80, 0x7C, 0xF8,
  0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0xC1, 0xF8, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3E, 0x03, 0xF0,
  0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0,
  0x0F, 0x87, 0xC0, 0x3E, 0x1E, 0x03, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x83,
  0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0,
  0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0xC1, 0xF8,
  0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0x87, 0xF8, 0x3E, 0x03, 0xE0, 0xF0, 0x0F, 0x87,
  0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x7C, 0x1E, 0x07, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0xF8, 0xF8, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0xC0, 0x7C,
  0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFC, 0x1F, 0x87, 0xC0,
  0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x3C, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0xC1, 0xF8,
  0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x3C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x0F,
  0x80, 0xF8, 0x78, 0x07, 0xC3, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F,
  0x8F, 0x80, 0x78, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1E, 0x01, 0xF1, 0xF0,
  0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x83, 0xF0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xC7,
  0x80, 0x7C, 0x78, 0x07, 0xC7, 0x80, 0xF8, 0x78, 0x0F, 0x87, 0xC0, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0xC3, 0xE0, 0x7C, 0x3C,
  0x07, 0xC7, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x3C, 0xF8, 0x03, 0xCF,
  0x00, 0x3C, 0xF0, 0x03, 0xDF, 0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x78, 0x3C, 0x1E,
  0xF0, 0x78, 0x3D, 0xE1, 0xF0, 0xF3, 0xC3, 0xE1, 0xE7, 0x86, 0xC3, 0xCF,
  0x0F, 0x87, 0x9E, 0x3F, 0x1E, 0x3C, 0x7E, 0x3C, 0x78, 0xDC, 0x78, 0xF1,
  0xB8, 0xE1, 0xE7, 0x73, 0xC3, 0xCE, 0xE7, 0x87, 0x19, 0xCF, 0x0E, 0x73,
  0x9C, 0x1C, 0xE6, 0x78, 0x79, 0x8C, 0xF0, 0xF3, 0x19, 0xE1, 0xEE, 0x33,
  0x83, 0xDC, 0x6F, 0x07, 0xB0, 0xDE, 0x0F, 0xE1, 0xBC, 0x1F, 0xC3, 0x70,
  0x3F, 0x87, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03,
  0xE0, 0xFC, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x87,
  0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x1F, 0x00, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0xC0, 0x7C, 0x3E,
  0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF1, 0xF0,
  0x07, 0x9F, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xC0, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03,
  0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x79, 0xE0,
  0x1E, 0x78, 0x0F, 0x0F, 0x07, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x3E, 0x3C,
  0x07, 0x9E, 0x01, 0xEF, 0x80, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE0, 0xFC, 0x3E, 0x0F, 0x83, 0xC1, 0xF8, 0x03, 0xF1,
  0xF0, 0xFF, 0x9E, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0x07, 0xE3, 0xE0,
  0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C,
  0x07, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F,
  0x80, 0xF8, 0xFC, 0x1F, 0x8F, 0xFF, 0xF8, 0x7F, 0xEF, 0x87, 0xFE, 0xF0,
  0x3F, 0x8F, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF1, 0xF8, 0x1F,
  0x7F, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF8, 0x3F, 0x1F, 0x01, 0xF1,
  0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E,
  0x3E, 0x03, 0xE3, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x07,
  0xC7, 0xE0, 0xFC, 0x7B, 0xFF, 0x87, 0xBF, 0xF8, 0xFB, 0xFE, 0x0F, 0x9F,
  0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xF0,
  0x7E, 0x7C, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x01,
  0xF7, 0xC0, 0x7C, 0xFC, 0x1F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x3E,
  0x0F, 0xF9, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7E, 0x0F, 0xC3, 0xE0,
  0x7E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3,
  0xE0, 0x3E, 0x1E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x78, 0x7C, 0x07,
  0xC3, 0xE0, 0x3E, 0x1F, 0x83, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0x7C, 0x1F,
  0xFB, 0xC0, 0x3F, 0x1E, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFE,
  0x0F, 0xEF, 0xE3, 0xE0, 0x7C, 0x7C, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F,
  0x7C, 0x03, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0xF8, 0x0F, 0x8F, 0xE7, 0xE1,
  0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF9, 0xF0, 0xFF, 0xDE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F,
  0x07, 0xE3, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7,
  0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8,
  0xFC, 0x0F, 0x87, 0xE3, 0xF8, 0x7F, 0xFF, 0x87, 0xFE, 0xF8, 0x3F, 0xCF,
  0x80, 0xF0, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF1, 0xF8, 0x1F, 0x7F, 0xC1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0xF8, 0x3F, 0x1F, 0x03, 0xF1, 0xE0, 0x1F, 0x3E, 0x01,
  0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xC0,
  0x3E, 0x7C, 0x03, 0xC7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C,
  0x07, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x3F, 0x1F, 0x01, 0xF8,
  0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x1F, 0x0F, 0xC0, 0x78,
  0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x0F, 0x0F, 0x80, 0x3C, 0x3E, 0x01, 0xF0, 0x7C, 0x07,
  0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0x80,
  0x7C, 0x3E, 0x01, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0x3F, 0xF0, 0x0E, 0x78, 0xF8, 0x7B, 0xF7, 0xE1, 0xFF, 0xFF,
  0xC7, 0xCF, 0x9F, 0x1E, 0x1C, 0x3C, 0x78, 0xF1, 0xF1, 0xE3, 0xC7, 0x8F,
  0x8F, 0x1E, 0x3C, 0x38, 0x78, 0xF0, 0xE1, 0xE3, 0xC3, 0x87, 0x8F, 0x0E,
  0x3E, 0x3C, 0x78, 0xF9, 0xF1, 0xE3, 0xC7, 0xC7, 0x0F, 0x1E, 0x1C, 0x3C,
  0x78, 0x70, 0xF1, 0xE1, 0xC3, 0xC7, 0x8F, 0x1F, 0x1E, 0x3C, 0x78, 0xF8,
  0xF1, 0xE0, 0x1F, 0x1F, 0x81, 0xF7, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x1E, 0x01, 0xF3, 0xE0, 0x1E, 0x3E, 0x03,
  0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xE7, 0xC0,
  0x3C, 0x7C, 0x03, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x78,
  0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0xF0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xF0, 0x7C, 0x7C, 0x07, 0xDF, 0x00, 0xFB,
  0xE0, 0x1F, 0x7C, 0x03, 0xCF, 0x80, 0xF9, 0xE0, 0x1F, 0x3C, 0x03, 0xEF,
  0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xE7, 0xC0, 0x7C, 0xFC, 0x1F, 0x8F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0x8F, 0xC0,
  0x7D, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFC, 0x1F, 0x87, 0xC0,
  0x7C, 0x3C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0xF8, 0x0F, 0x87,
  0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0x87, 0xC0, 0x7C, 0x3F, 0x07, 0xE1, 0xEF, 0xFE, 0x0F, 0x7F, 0xE0, 0xFB,
  0xFE, 0x07, 0xCF, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF1, 0xF0, 0xFF, 0x9E, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0x07, 0xE3,
  0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C,
  0x78, 0x07, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F,
  0x8F, 0x80, 0xF8, 0xFC, 0x1F, 0x8F, 0xFF, 0xF8, 0x7F, 0xEF, 0x87, 0xFE,
  0xF0, 0x3F, 0x8F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x1F, 0x3F, 0x81,
  0xE7, 0xFC, 0x1E, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0x83, 0xF3, 0xF0, 0x3F,
  0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xE3, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE7, 0x80, 0x3E, 0x7C, 0x07, 0xC7, 0xFF, 0xFC, 0x7F,
  0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x3E, 0x01, 0xF3, 0xE0, 0x1E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03,
  0xE3, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0,
  0x7C, 0x7C, 0x07, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0xCF, 0x80, 0x78, 0xF8,
  0x0F, 0x8F, 0x80, 0xF8, 0xFC, 0x1F, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x03,
  0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x78, 0x03,
  0xE7, 0x80, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0,
  0xF0, 0x3C, 0x1F, 0x03, 0xC1, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x78,
  0x3F, 0xC1, 0xE1, 0xEF, 0x0F, 0x87, 0xBC, 0x3E, 0x1E, 0xF0, 0xF8, 0x73,
  0xC7, 0xE3, 0xCF, 0x1F, 0x8F, 0x3C, 0x6E, 0x38, 0xF3, 0xB9, 0xE3, 0xCE,
  0xE7, 0x8F, 0x33, 0x9C, 0x3C, 0xCE, 0xF0, 0xF7, 0x3B, 0xC3, 0xD8, 0xEE,
  0x0F, 0x63, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF0, 0xFC, 0x0F,
  0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x3E, 0x00, 0x0F, 0x80, 0x7E, 0x1F,
  0x01, 0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7C,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0,
  0x01, 0xF7, 0xC0, 0x07, 0xE7, 0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x0F, 0x80,
  0xF8, 0x1F, 0x03, 0xE0, 0x1F, 0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x01, 0xE7,
  0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x3E, 0xF8, 0x07, 0xDF,
  0x00, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x1F, 0x3C,
  0x03, 0xEF, 0x80, 0x79, 0xF0, 0x1F, 0x3F, 0x07, 0xE3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFD, 0xF0, 0x7F, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF,
  0xC0, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0x07, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x0F, 0x7F,
  0xE0, 0xF7, 0xFF, 0x0F, 0xF9, 0xF1, 0xEF, 0x0F, 0xFE, 0xF0, 0x7F, 0xCF,
  0x07, 0xFC, 0x00, 0x1F, 0x00,
};

const GFXglyph JetBrainsMono_BoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 10, 28, 23, 7, -28 },
  { 36, 15, 12, 23, 6, -28 },
  { 59, 23, 28, 23, 0, -28 },
  { 140, 21, 38, 23, 1, -33 },
  { 240, 28, 28, 23, -2, -28 },
  { 338, 22, 28, 23, 0, -28 },
  { 415, 6, 12, 23, 10, -28 },
  { 424, 17, 37, 23, 5, -32 },
  { 503, 16, 37, 23, 2, -32 },
  { 577, 20, 20, 23, 2, -23 },
  { 627, 19, 19, 23, 2, -22 },
  { 673, 11, 12, 23, 3, -6 },
  { 690, 13, 5, 23, 5, -15 },
  { 699, 8, 7, 23, 6, -7 },
  { 706, 24, 36, 23, 0, -32 },
  { 814, 20, 28, 23, 2, -28 },
  { 884, 18, 28, 23, 2, -28 },
  { 947, 21, 28, 23, 1, -28 },
  { 1021, 21, 28, 23, 1, -28 },
  { 1095, 19, 28, 23, 2, -28 },
  { 1162, 20, 28, 23, 2, -28 },
  { 1232, 20, 28, 23, 1, -28 },
  { 1302, 19, 28, 23, 4, -28 },
  { 1369, 21, 28, 23, 1, -28 },
  { 1443, 19, 28, 23, 3, -28 },
  { 1510, 10, 21, 23, 6, -21 },
  { 1537, 13, 27, 23, 3, -21 },
  { 1581, 19, 21, 23, 3, -23 },
  { 1631, 19, 13, 23, 2, -19 },
  { 1662, 19, 21, 23, 2, -23 },
  { 1712, 16, 28, 23, 5, -28 },
  { 1768, 23, 35, 23, 0, -28 },
  { 1869, 20, 28, 23, 0, -28 },
  { 1939, 21, 28, 23, 1, -28 },
  { 2013, 20, 28, 23, 2, -28 },
  { 2083, 21, 28, 23, 1, -28 },
  { 2157, 21, 28, 23, 2, -28 },
  { 2231, 22, 28, 23, 1, -28 },
  { 2308, 20, 28, 23, 2, -28 },
  { 2378, 22, 28, 23, 1, -28 },
  { 2455, 20, 28, 23, 2, -28 },
  { 2525, 22, 28, 23, 0, -28 },
  { 2602, 23, 28, 23, 1, -28 },
  { 2683, 17, 28, 23, 2, -28 },
  { 2743, 23, 28, 23, 0, -28 },
  { 2824, 22, 28, 23, 1, -28 },
  { 2901, 20, 28, 23, 2, -28 },
  { 2971, 22, 28, 23, 1, -28 },
  { 3048, 20, 35, 23, 2, -28 },
  { 3136, 22, 28, 23, 1, -28 },
  { 3213, 21, 28, 23, 1, -28 },
  { 3287, 20, 28, 23, 4, -28 },
  { 3357, 21, 28, 23, 2, -28 },
  { 3431, 20, 28, 23, 4, -28 },
  { 3501, 23, 28, 23, 2, -28 },
  { 3582, 25, 28, 23, -1, -28 },
  { 3670, 21, 28, 23, 4, -28 },
  { 3744, 21, 28, 23, 1, -28 },
  { 3818, 16, 36, 23, 5, -32 },
  { 3890, 12, 36, 23, 6, -32 },
  { 3944, 16, 36, 23, 3, -32 },
  { 4016, 18, 15, 23, 3, -28 },
  { 4050, 19, 4, 23, 0, 1 },
  { 4060, 9, 5, 23, 9, -30 },
  { 4066, 20, 21, 23, 2, -21 },
  { 4119, 20, 28, 23, 1, -28 },
  { 4189, 19, 21, 23, 2, -21 },
  { 4239, 21, 28, 23, 2, -28 },
  { 4313, 19, 21, 23, 2, -21 },
  { 4363, 26, 35, 23, -2, -28 },
  { 4477, 20, 28, 23, 2, -21 },
  { 4547, 20, 28, 23, 1, -28 },
  { 4617, 19, 30, 23, 1, -30 },
  { 4689, 21, 37, 23, 0, -30 },
  { 4787, 22, 28, 23, 1, -28 },
  { 4864, 17, 28, 23, 3, -28 },
  { 4924, 22, 21, 23, 0, -21 },
  { 4982, 20, 21, 23, 1, -21 },
  { 5035, 19, 21, 23, 2, -21 },
  { 5085, 21, 28, 23, 0, -21 },
  { 5159, 20, 28, 23, 2, -21 },
  { 5229, 20, 21, 23, 2, -21 },
  { 5282, 20, 21, 23, 1, -21 },
  { 5335, 19, 27, 23, 3, -27 },
  { 5400, 20, 21, 23, 2, -21 },
  { 5453, 20, 21, 23, 3, -21 },
  { 5506, 22, 21, 23, 2, -21 },
  { 5564, 23, 21, 23, 0, -21 },
  { 5625, 19, 28, 23, 2, -21 },
  { 5692, 20, 21, 23, 1, -21 },
  { 5745, 20, 36, 23, 3, -32 },
  { 5835, 10, 36, 23, 7, -32 },
  { 5880, 20, 36, 23, 1, -32 },
  { 5970, 20, 9, 23, 2, -18 },
};

const GFXfont JetBrainsMono_BoldItalic38pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic38pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _JETBRAINSMONO_BOLDITALIC38PT7B_H_
