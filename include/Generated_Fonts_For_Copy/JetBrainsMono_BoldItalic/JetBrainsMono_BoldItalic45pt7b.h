#ifndef _JETBRAINSMONO_BOLDITALIC45PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F,
  0xE0, 0x7C, 0x00, 0x3F, 0x0F, 0xCF, 0x83, 0xE3, 0xE1, 0xF9, 0xF8, 0x7E,
  0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F,
  0x07, 0xC7, 0xC1, 0xF1, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x80, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0,
  0x3C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80,
  0x03, 0xC0, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03,
  0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFE, 0xE7, 0xF0, 0x7E, 0x71, 0xF8,
  0x7E, 0x38, 0xFC, 0x3F, 0x1C, 0x7E, 0x1F, 0x8E, 0x00, 0x0F, 0xC7, 0x00,
  0x07, 0xE7, 0x00, 0x03, 0xFB, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0x3F, 0x80, 0x03, 0x8F, 0xC0, 0x01,
  0xC7, 0xE0, 0x00, 0xC3, 0xF1, 0xF8, 0xE1, 0xF8, 0xFC, 0x70, 0xFC, 0x7E,
  0x38, 0xFC, 0x3F, 0x9C, 0xFE, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0x01, 0xFF, 0x80, 0x1E,
  0x03, 0xFF, 0x80, 0x3C, 0x03, 0xE7, 0xC0, 0x7C, 0x07, 0x83, 0xC0, 0xF8,
  0x07, 0x83, 0xC0, 0xF0, 0x07, 0x83, 0xC1, 0xE0, 0x07, 0x83, 0xC3, 0xC0,
  0x0F, 0x03, 0xC7, 0x80, 0x0F, 0x07, 0x8F, 0x00, 0x0F, 0x07, 0x9E, 0x00,
  0x0F, 0xDF, 0xBE, 0x00, 0x07, 0xFF, 0x3C, 0x00, 0x03, 0xFE, 0x78, 0x00,
  0x01, 0xF8, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x0F, 0x3F, 0xC0,
  0x00, 0x1E, 0x7F, 0xE0, 0x00, 0x3C, 0xFF, 0xF0, 0x00, 0x79, 0xE0, 0xF0,
  0x00, 0xF1, 0xE0, 0xF0, 0x01, 0xE1, 0xE0, 0xF0, 0x03, 0xE1, 0xE0, 0xF0,
  0x07, 0xC3, 0xC0, 0xF0, 0x07, 0x83, 0xC1, 0xE0, 0x0F, 0x03, 0xC1, 0xE0,
  0x1E, 0x03, 0xE3, 0xE0, 0x3C, 0x01, 0xFF, 0xC0, 0x78, 0x01, 0xFF, 0x80,
  0xF8, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0x83, 0xF0, 0x1F,
  0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x0F,
  0xDF, 0x9F, 0x87, 0xCF, 0xC7, 0xC7, 0xC7, 0xC3, 0xF7, 0xE3, 0xE0, 0xFF,
  0xE1, 0xF0, 0x7F, 0xE1, 0xF8, 0x1F, 0xF0, 0xFC, 0x07, 0xF0, 0x7E, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xFE, 0x0F, 0xE3, 0xFF, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFB, 0xE0, 0x7F, 0xF9, 0xF8, 0x1F, 0xF0, 0x7E, 0x00,
  0x3E, 0x7D, 0xFB, 0xF7, 0xEF, 0xDF, 0x3E, 0x7D, 0xFB, 0xF7, 0xCF, 0x9F,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38,
  0x00, 0x00, 0x80, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x20, 0x1E, 0x01, 0x3C, 0x1E, 0x0F, 0x7E, 0x1C, 0x3F,
  0x7F, 0x9C, 0xFF, 0xFF, 0xD9, 0xFF, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xEF, 0x80,
  0x07, 0xCF, 0xC0, 0x0F, 0xC7, 0xC0, 0x1F, 0x87, 0xE0, 0x3F, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x1E, 0x03, 0xC0, 0x0C, 0x01, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8,
  0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1E, 0x3F, 0xBF, 0xDF, 0xEF,
  0xF7, 0xFB, 0xF8, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xE0,
  0x7F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00,
  0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x08,
  0x3E, 0x3E, 0x3C, 0x3E, 0x3E, 0x7E, 0x7E, 0x3E, 0x7E, 0x7E, 0x3E, 0x7E,
  0x7C, 0x7E, 0x3C, 0x7C, 0x7E, 0x08, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0xFC, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7F, 0xDF, 0xF0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xDF, 0x00, 0xFE, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x0F, 0xC0, 0x70,
  0x3F, 0x01, 0x80, 0xFC, 0x04, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x7E, 0x1F,
  0xC0, 0x7F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF0, 0xFF, 0x9F, 0xF0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0xFC,
  0x7E, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x80, 0x3F, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0x00, 0x1F, 0xBF,
  0xE0, 0x1F, 0x7F, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xC3,
  0xFC, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF0, 0x7F, 0xDF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF9, 0xFC, 0x07, 0xEF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x7F, 0x87, 0xF9, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xC0,
  0x07, 0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0x7E, 0x00, 0x7E, 0xFC, 0x00,
  0xFD, 0xF8, 0x01, 0xF3, 0xF0, 0x07, 0xE7, 0xF0, 0x1F, 0xC7, 0xF9, 0xFF,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xFC,
  0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0xFC, 0x0F, 0xC1, 0xFC, 0x0F, 0xF3, 0xF8, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xEF, 0xF0,
  0x1F, 0x83, 0xF8, 0x3F, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8,
  0xFE, 0x03, 0xF8, 0xFF, 0x9F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0x9F,
  0x80, 0x3F, 0x3F, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xF0,
  0x01, 0xF7, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x3F, 0x00,
  0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0xFF, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F,
  0xC7, 0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x30, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x08, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xE0, 0xF8,
  0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x01,
  0xE1, 0xF0, 0x1F, 0x1E, 0x1E, 0x07, 0xF9, 0xE1, 0xE0, 0xFF, 0xDE, 0x3E,
  0x0F, 0xCF, 0xE3, 0xE1, 0xF0, 0x7E, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xE0,
  0x7C, 0x3C, 0x1E, 0x07, 0xC3, 0xC3, 0xE0, 0x7C, 0x7C, 0x3E, 0x07, 0xC7,
  0xC3, 0xE0, 0x7C, 0x7C, 0x3E, 0x07, 0x87, 0xC3, 0xC0, 0x78, 0x7C, 0x3C,
  0x0F, 0x87, 0x83, 0xC0, 0xF8, 0x78, 0x3E, 0x1F, 0x8F, 0x83, 0xFF, 0xF8,
  0xF8, 0x3F, 0xEF, 0x0F, 0x81, 0xFC, 0xF0, 0xF8, 0x02, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8,
  0x00, 0xFD, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0xC0,
  0x1F, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x07,
  0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3E, 0x00,
  0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07,
  0xDF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3E, 0x01, 0xFC, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x0F, 0xC0,
  0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8,
  0x07, 0xE0, 0x7C, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xC0, 0x7F, 0x03, 0xE0, 0x0F, 0xC3,
  0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F,
  0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F,
  0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x04, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x3E, 0x07, 0xF8, 0x1F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01,
  0xF0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xF0,
  0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0xFF, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F,
  0xE0, 0x7F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0xFE, 0x3E,
  0x1F, 0xFE, 0x3E, 0x1F, 0xFC, 0x7E, 0x1F, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7F, 0xDF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x03,
  0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x3E,
  0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x1F, 0x00,
  0x7E, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x03, 0xF0, 0x3F,
  0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x03, 0xF0,
  0x07, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x03,
  0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x7E,
  0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xFC,
  0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x01,
  0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xF8, 0x3F,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0x83, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8,
  0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x1F, 0x00,
  0x3F, 0x03, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03,
  0xFC, 0x1F, 0xE0, 0xF7, 0x83, 0xDC, 0x1F, 0xF0, 0x7B, 0x83, 0xBE, 0x1F,
  0x78, 0xF7, 0x83, 0xEF, 0x1E, 0xF0, 0x7D, 0xE7, 0xBE, 0x0F, 0xBC, 0xF7,
  0xC1, 0xF7, 0xBC, 0xF8, 0x3E, 0x77, 0x9F, 0x0F, 0x8E, 0xE7, 0xC1, 0xF1,
  0xFC, 0xF8, 0x3E, 0x3F, 0x1F, 0x07, 0xC7, 0xE3, 0xE0, 0xF8, 0xFC, 0x7C,
  0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x1F, 0x00,
  0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x00,
  0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x07, 0xC1, 0xFE, 0x01, 0xF0, 0x7F, 0x80, 0xFC, 0x1F, 0xE0,
  0x3E, 0x07, 0xF8, 0x0F, 0x81, 0xFE, 0x03, 0xE0, 0xFF, 0x80, 0xF8, 0x3F,
  0xF0, 0x3E, 0x0F, 0xFC, 0x0F, 0x83, 0xEF, 0x07, 0xE0, 0xFB, 0xC1, 0xF0,
  0x3E, 0xF0, 0x7C, 0x0F, 0xBE, 0x1F, 0x07, 0xCF, 0x87, 0xC1, 0xF1, 0xE1,
  0xF0, 0x7C, 0x78, 0xFC, 0x1F, 0x1E, 0x3E, 0x07, 0xC7, 0xCF, 0x81, 0xF1,
  0xF3, 0xE0, 0xFC, 0x7C, 0xF8, 0x3E, 0x0F, 0x3E, 0x0F, 0x83, 0xCF, 0x83,
  0xE0, 0xF3, 0xC0, 0xF8, 0x3E, 0xF0, 0x3E, 0x0F, 0xFC, 0x1F, 0x81, 0xFF,
  0x07, 0xC0, 0x7F, 0xC1, 0xF0, 0x1F, 0xF0, 0x7C, 0x07, 0xFC, 0x1F, 0x01,
  0xFE, 0x07, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0xF8, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xF8,
  0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xF0, 0x1F, 0xF0, 0x7C,
  0x01, 0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07,
  0xE1, 0xF8, 0x07, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x3F,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F,
  0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C,
  0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xFC,
  0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xF0,
  0x1F, 0xE0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x83,
  0xF0, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F,
  0x83, 0xE0, 0x0F, 0xC1, 0xF8, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80,
  0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xC0, 0x1F, 0x81, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0x81,
  0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x3F, 0x87, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3,
  0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE1, 0xF8, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE1, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3E,
  0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xFD, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x07,
  0xE0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F,
  0x80, 0x7E, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x3F,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x0F, 0x81, 0xF3, 0xE0, 0xF8, 0x3E, 0x3E,
  0x0F, 0x83, 0xE3, 0xC1, 0xF8, 0x3E, 0x3C, 0x1F, 0x83, 0xC3, 0xC1, 0xF8,
  0x7C, 0x3C, 0x1F, 0x87, 0xC3, 0xC3, 0xB8, 0x7C, 0x7C, 0x3B, 0x87, 0x87,
  0xC3, 0xB8, 0xF8, 0x7C, 0x7B, 0x8F, 0x87, 0xC7, 0x38, 0xF8, 0x7C, 0x73,
  0x8F, 0x07, 0xC7, 0x39, 0xF0, 0x7C, 0xE7, 0x1F, 0x07, 0xCE, 0x71, 0xE0,
  0x7C, 0xE7, 0x1E, 0x07, 0x8E, 0x73, 0xE0, 0x79, 0xC7, 0x3E, 0x07, 0x9C,
  0x73, 0xC0, 0x79, 0xC7, 0x3C, 0x07, 0xBC, 0x77, 0xC0, 0x7B, 0x87, 0x7C,
  0x07, 0xB8, 0x77, 0x80, 0x7B, 0x87, 0x78, 0x07, 0xF0, 0x77, 0x80, 0xFF,
  0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x0F,
  0xC3, 0xE0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x1F, 0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF1,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFF,
  0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xE7,
  0x80, 0x3E, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0x83, 0xC1, 0xF0,
  0x3E, 0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0x7E, 0x03, 0xE7, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x1F, 0x83, 0xF0, 0x7C, 0x1F,
  0x83, 0xF0, 0x00, 0xFE, 0x3F, 0x03, 0xFF, 0x3E, 0x07, 0xFF, 0xBE, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C,
  0x01, 0xF8, 0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0x7E,
  0x07, 0xF0, 0x7F, 0xDF, 0xF0, 0x7F, 0xFD, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFB, 0xF0, 0x1F, 0xE3, 0xF0, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC7, 0xF0, 0x0F, 0xCF, 0xF8, 0x0F,
  0xDF, 0xFC, 0x0F, 0xBF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xE0, 0x7E, 0x1F,
  0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F,
  0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0xEF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7D,
  0xFF, 0xE0, 0x7C, 0xFF, 0xC0, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF8,
  0x1F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1,
  0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xFD, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x3F,
  0x01, 0xFF, 0x9F, 0x01, 0xFF, 0xEF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0,
  0x0F, 0xC3, 0xF0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7C,
  0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0xFE, 0x07,
  0xFD, 0xFF, 0x03, 0xFF, 0xEF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xF7, 0xE0,
  0x1F, 0xE3, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x1F,
  0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xE3, 0xF0,
  0x1F, 0x87, 0xF0, 0x7F, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x3F, 0x03, 0xFF, 0x3E, 0x07, 0xFF, 0xBE, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7E,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x8F, 0xF8, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFD, 0xF0, 0x1F, 0xF9, 0xF0, 0x0F, 0xF3, 0xF0, 0x03,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC7, 0xF0, 0x0F, 0xDF, 0xF8, 0x0F,
  0xDF, 0xFC, 0x0F, 0xBF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F,
  0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F,
  0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x3E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7E,
  0x01, 0xF8, 0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x87,
  0xE0, 0x1F, 0xC3, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0xC0, 0xF8, 0x0F, 0xC0,
  0x7C, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xE0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3E, 0x07,
  0xE0, 0x1F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x00,
  0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0x9E, 0x1F, 0x03, 0xEF, 0xCF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3D, 0xFF, 0xFF,
  0x0F, 0x8F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3C,
  0x1E, 0x1F, 0x0F, 0x0F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0xF8,
  0x3C, 0x3E, 0x3E, 0x1F, 0x0F, 0x8F, 0x87, 0x83, 0xE3, 0xE1, 0xE1, 0xF0,
  0xF8, 0x78, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x87, 0x87, 0xC7, 0xC1, 0xE1,
  0xF1, 0xF0, 0xF0, 0x7C, 0x7C, 0x3C, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0xC3,
  0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x00, 0x0F, 0xC7, 0xF0,
  0x0F, 0xDF, 0xF8, 0x0F, 0xDF, 0xFC, 0x0F, 0xBF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E,
  0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0xFC,
  0x3E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xF8,
  0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC3, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x3E, 0x3F,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0,
  0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01,
  0xF8, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xFD, 0xFE,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x07, 0xE3, 0xF8, 0x03, 0xF3, 0xFE, 0x01, 0xFB, 0xFF, 0x80, 0xFB, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80,
  0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0,
  0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x3F,
  0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x0F, 0xE0, 0x1F, 0x87,
  0xF0, 0x1F, 0x83, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0xC0, 0xFB, 0xFF, 0xC0,
  0x7C, 0xFF, 0xC0, 0x3E, 0x3F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x3E, 0x07,
  0xFE, 0x7C, 0x1F, 0xFE, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xF8,
  0x3F, 0xCF, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7C, 0x01,
  0xF8, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F,
  0x1F, 0x80, 0x3E, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF9, 0xF8, 0x03, 0xF3,
  0xF0, 0x0F, 0xE3, 0xF0, 0x3F, 0x87, 0xFD, 0xFF, 0x0F, 0xFF, 0xBE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFD, 0xF8, 0x1F, 0xE3, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x87, 0xF0, 0x0F, 0x9F,
  0xFC, 0x0F, 0xBF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xE0,
  0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFE, 0x1F,
  0xE3, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF3, 0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0xCF, 0xE0, 0x7F, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3E,
  0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0xFC,
  0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xF8,
  0x7E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0x8F,
  0x80, 0x3F, 0x1F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0xFC,
  0x0F, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xC3,
  0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0xFC,
  0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x3E, 0x0F,
  0xF8, 0x1F, 0x07, 0xFC, 0x1F, 0x83, 0xDE, 0x0F, 0xC1, 0xEF, 0x07, 0xE1,
  0xF7, 0x83, 0x70, 0xF3, 0xC3, 0xB8, 0x79, 0xE1, 0xDC, 0x7C, 0xF0, 0xEE,
  0x3C, 0x78, 0xE7, 0x1E, 0x3C, 0x73, 0x9F, 0x1E, 0x39, 0xCF, 0x8F, 0x38,
  0xE7, 0x87, 0x9C, 0x73, 0xC3, 0xCE, 0x3B, 0xE1, 0xEE, 0x1D, 0xE0, 0xF7,
  0x0E, 0xF0, 0x7B, 0x87, 0xF8, 0x3D, 0x87, 0xF8, 0x1F, 0xC3, 0xBC, 0x0F,
  0xE1, 0xDE, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x80,
  0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x1F,
  0x80, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x03, 0xF1, 0xF8,
  0x00, 0x7E, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xF0, 0xF8, 0x01,
  0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07,
  0xF0, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0xFC, 0x7C,
  0x01, 0xF8, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0,
  0x1F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF8, 0xF8, 0x03,
  0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF8, 0xFE, 0x0F, 0xF1, 0xFF, 0xFF, 0xE3,
  0xFF, 0xEF, 0x83, 0xFF, 0xDF, 0x03, 0xFF, 0x7E, 0x03, 0xF8, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xC4, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C,
  0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xF0, 0x1F, 0x3F, 0xF8, 0x1F, 0x7F, 0xFC, 0x1F, 0x7E, 0xFE, 0x1E,
  0x7C, 0x7E, 0x3E, 0x78, 0x3F, 0xFE, 0xF8, 0x1F, 0xFC, 0xF8, 0x1F, 0xF8,
  0xF8, 0x0F, 0xF0,
};

const GFXglyph JetBrainsMono_BoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 12, 33, 27, 8, -33 },
  { 51, 18, 14, 27, 7, -33 },
  { 83, 28, 33, 27, 0, -33 },
  { 199, 25, 45, 27, 1, -39 },
  { 340, 32, 33, 27, -2, -33 },
  { 472, 25, 33, 27, 1, -33 },
  { 576, 7, 14, 27, 12, -33 },
  { 589, 20, 44, 27, 6, -38 },
  { 699, 19, 44, 27, 2, -38 },
  { 804, 24, 23, 27, 2, -27 },
  { 873, 22, 22, 27, 3, -26 },
  { 934, 13, 14, 27, 4, -7 },
  { 957, 16, 5, 27, 6, -17 },
  { 967, 9, 8, 27, 8, -8 },
  { 976, 28, 42, 27, 0, -37 },
  { 1123, 24, 33, 27, 2, -33 },
  { 1222, 22, 33, 27, 2, -33 },
  { 1313, 24, 33, 27, 2, -33 },
  { 1412, 24, 33, 27, 2, -33 },
  { 1511, 23, 33, 27, 2, -33 },
  { 1606, 24, 33, 27, 2, -33 },
  { 1705, 23, 33, 27, 2, -33 },
  { 1800, 24, 33, 27, 4, -33 },
  { 1899, 24, 33, 27, 2, -33 },
  { 1998, 23, 33, 27, 4, -33 },
  { 2093, 11, 25, 27, 8, -25 },
  { 2128, 15, 32, 27, 4, -25 },
  { 2188, 23, 24, 27, 3, -27 },
  { 2257, 22, 16, 27, 3, -23 },
  { 2301, 22, 24, 27, 2, -27 },
  { 2367, 19, 33, 27, 6, -33 },
  { 2446, 28, 41, 27, 0, -33 },
  { 2590, 23, 33, 27, 0, -33 },
  { 2685, 25, 33, 27, 1, -33 },
  { 2789, 24, 33, 27, 2, -33 },
  { 2888, 25, 33, 27, 1, -33 },
  { 2992, 25, 33, 27, 2, -33 },
  { 3096, 25, 33, 27, 2, -33 },
  { 3200, 24, 33, 27, 2, -33 },
  { 3299, 26, 33, 27, 1, -33 },
  { 3407, 24, 33, 27, 2, -33 },
  { 3506, 26, 34, 27, 0, -33 },
  { 3617, 27, 33, 27, 1, -33 },
  { 3729, 20, 33, 27, 3, -33 },
  { 3812, 27, 33, 27, 1, -33 },
  { 3924, 26, 33, 27, 1, -33 },
  { 4032, 24, 33, 27, 2, -33 },
  { 4131, 26, 33, 27, 1, -33 },
  { 4239, 24, 41, 27, 2, -33 },
  { 4362, 26, 33, 27, 1, -33 },
  { 4470, 25, 33, 27, 1, -33 },
  { 4574, 24, 33, 27, 4, -33 },
  { 4673, 25, 33, 27, 2, -33 },
  { 4777, 24, 33, 27, 5, -33 },
  { 4876, 28, 33, 27, 2, -33 },
  { 4992, 29, 33, 27, -1, -33 },
  { 5112, 25, 33, 27, 4, -33 },
  { 5216, 24, 33, 27, 2, -33 },
  { 5315, 19, 42, 27, 6, -37 },
  { 5415, 15, 42, 27, 7, -37 },
  { 5494, 20, 42, 27, 3, -37 },
  { 5599, 20, 18, 27, 4, -33 },
  { 5644, 22, 5, 27, 0, 1 },
  { 5658, 10, 6, 27, 11, -35 },
  { 5666, 24, 25, 27, 2, -25 },
  { 5741, 24, 33, 27, 1, -33 },
  { 5840, 23, 25, 27, 2, -25 },
  { 5912, 25, 33, 27, 2, -33 },
  { 6016, 23, 25, 27, 2, -25 },
  { 6088, 30, 41, 27, -2, -33 },
  { 6242, 24, 33, 27, 2, -25 },
  { 6341, 24, 33, 27, 1, -33 },
  { 6440, 23, 35, 27, 1, -35 },
  { 6541, 25, 43, 27, 0, -35 },
  { 6676, 25, 33, 27, 2, -33 },
  { 6780, 20, 33, 27, 4, -33 },
  { 6863, 26, 25, 27, 0, -25 },
  { 6945, 24, 25, 27, 1, -25 },
  { 7020, 23, 25, 27, 2, -25 },
  { 7092, 25, 33, 27, 0, -25 },
  { 7196, 23, 33, 27, 2, -25 },
  { 7291, 24, 25, 27, 2, -25 },
  { 7366, 23, 25, 27, 2, -25 },
  { 7438, 23, 32, 27, 3, -32 },
  { 7530, 24, 25, 27, 2, -25 },
  { 7605, 23, 25, 27, 4, -25 },
  { 7677, 25, 25, 27, 3, -25 },
  { 7756, 27, 25, 27, 0, -25 },
  { 7841, 23, 33, 27, 2, -25 },
  { 7936, 23, 25, 27, 2, -25 },
  { 8008, 23, 42, 27, 4, -37 },
  { 8129, 12, 42, 27, 8, -37 },
  { 8192, 23, 42, 27, 1, -37 },
  { 8313, 24, 10, 27, 2, -21 },
};

const GFXfont JetBrainsMono_BoldItalic45pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic45pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _JETBRAINSMONO_BOLDITALIC45PT7B_H_
