#ifndef _JETBRAINSMONO_BOLDITALIC37PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE1, 0xF8, 0xFC, 0x7E, 0x3E, 0x00, 0x7C, 0x7D, 0xF1, 0xF7,
  0xC7, 0xDE, 0x1F, 0x78, 0x7B, 0xE1, 0xEF, 0x87, 0xBE, 0x3E, 0xF0, 0xFB,
  0xC3, 0xCF, 0x0F, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x78, 0x01, 0xE0,
  0xE0, 0x03, 0x83, 0xC0, 0x07, 0x07, 0x80, 0x1E, 0x0E, 0x00, 0x38, 0x3C,
  0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x07, 0x07, 0x80,
  0x1E, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0x70, 0x78, 0x01, 0xE0, 0xE0, 0x03,
  0x83, 0xC0, 0x07, 0x07, 0x80, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x81, 0xE0, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x07, 0x80, 0x1E, 0x0E,
  0x00, 0x38, 0x3C, 0x00, 0x70, 0x78, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x7C, 0xCF,
  0x83, 0xC6, 0x7C, 0x3E, 0x31, 0xE1, 0xF3, 0x80, 0x0F, 0x9C, 0x00, 0x7C,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x37, 0xF0, 0x01, 0x8F, 0x80, 0x0C,
  0x7C, 0x00, 0xE3, 0xE3, 0xC7, 0x1E, 0x1E, 0x39, 0xF0, 0xF9, 0x9F, 0x87,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0xF8, 0x01, 0xE0, 0x7F, 0x80, 0x78, 0x1F, 0xF8, 0x1E, 0x03, 0x87,
  0x07, 0x80, 0xF0, 0xE0, 0xE0, 0x1E, 0x1C, 0x38, 0x03, 0x83, 0x8E, 0x00,
  0x70, 0xF3, 0xC0, 0x0E, 0x1C, 0xF0, 0x01, 0xFF, 0xBC, 0x00, 0x1F, 0xEF,
  0x00, 0x01, 0xF9, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x7B, 0xFE, 0x00, 0x1E, 0xFF,
  0xC0, 0x03, 0x9C, 0x38, 0x00, 0xE3, 0x87, 0x00, 0x38, 0xF0, 0xE0, 0x0E,
  0x1E, 0x1C, 0x03, 0xC3, 0x83, 0x80, 0xF0, 0x70, 0xF0, 0x3C, 0x0F, 0xFC,
  0x07, 0x00, 0xFF, 0x03, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x03,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xC1, 0xF0, 0x1F, 0x07,
  0xC0, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x13, 0xEF,
  0x87, 0x8F, 0x1E, 0x3C, 0x3C, 0x7D, 0xF1, 0xF0, 0xFF, 0x87, 0xC3, 0xFC,
  0x1F, 0x07, 0xF0, 0x78, 0x1F, 0x81, 0xE0, 0x3E, 0x07, 0xC1, 0xF8, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xCF, 0x81, 0xFE, 0x1F, 0x00, 0x7D,
  0xF7, 0xDE, 0x7B, 0xEF, 0xBE, 0xF3, 0xCF, 0x00, 0x00, 0x03, 0x00, 0x0F,
  0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x20, 0x07, 0x00, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x02, 0x0F, 0x02, 0x78,
  0x71, 0xE7, 0xC6, 0x7E, 0xFF, 0x6F, 0xF7, 0xFF, 0xFE, 0x0F, 0xFE, 0x00,
  0x1E, 0x00, 0x03, 0xF0, 0x00, 0x73, 0x80, 0x1F, 0x3C, 0x01, 0xE3, 0xE0,
  0x3E, 0x3E, 0x07, 0xC1, 0xF0, 0x38, 0x1C, 0x01, 0x00, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0,
  0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x08, 0x3E, 0x7E, 0x7E, 0xFE, 0x7E, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x1F, 0x03, 0xE1, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0,
  0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xCE, 0x3E, 0x7D,
  0xF3, 0xC7, 0x9F, 0x3C, 0x79, 0xF3, 0xC7, 0x8E, 0x7C, 0x78, 0x07, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x80, 0xF8,
  0xF8, 0x1F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF,
  0x03, 0xE7, 0xC0, 0xF1, 0xE0, 0x30, 0x78, 0x18, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x81, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0x83, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xE0, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x78, 0x07, 0xC7, 0x80, 0x7C, 0x7C, 0x0F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC3, 0xE1, 0xF0,
  0x7C, 0x7C, 0x0F, 0x9F, 0x01, 0xE3, 0xC0, 0x3C, 0xF8, 0x0F, 0x9F, 0x01,
  0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC7, 0x80, 0xFB,
  0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7E, 0x1F, 0x8F, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xCF, 0x80,
  0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF,
  0x80, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x30, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8F, 0xC1, 0xF9, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xE0,
  0x0F, 0xBC, 0x01, 0xF7, 0x80, 0x3C, 0xF8, 0x0F, 0x9F, 0x03, 0xF3, 0xFF,
  0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0x3C,
  0x03, 0xE7, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01,
  0xE0, 0xF0, 0x3E, 0x0F, 0x87, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xFF, 0x81, 0xF8, 0xF8, 0x3E, 0x07, 0xC3, 0xC0, 0x3C, 0x7C,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0xC7,
  0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xE0, 0x7C, 0xF8, 0x07,
  0x9E, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x1F,
  0x7C, 0x07, 0xEF, 0xC1, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFE, 0xF8,
  0x07, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x03, 0xE1, 0xFC, 0x7F, 0x1F, 0x87, 0xE0, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x7E,
  0x1F, 0x8F, 0xE3, 0xF8, 0x7C, 0x00, 0x00, 0xE0, 0x0F, 0x80, 0xFE, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x03,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x3E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x08, 0x3F,
  0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xF8, 0x10, 0x00, 0x0F, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0E, 0x00,
  0x02, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x40,
  0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x03, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0x07, 0xE0, 0xF8, 0x03, 0xC1,
  0xE0, 0x07, 0x87, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1C, 0x00, 0x1C, 0x78,
  0x1F, 0x38, 0xF0, 0x7F, 0x71, 0xE1, 0xFF, 0xE3, 0xC7, 0xC7, 0xC7, 0x8F,
  0x07, 0x8E, 0x1E, 0x0F, 0x3C, 0x38, 0x3C, 0x78, 0xF0, 0x78, 0xF1, 0xE0,
  0xF1, 0xE3, 0xC1, 0xE3, 0xC7, 0x83, 0xC7, 0x0F, 0x07, 0x9E, 0x1E, 0x1E,
  0x3C, 0x3F, 0xFC, 0x78, 0x3F, 0xB8, 0xF0, 0x3C, 0xF1, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xF7, 0xC0, 0x3C, 0x78, 0x0F,
  0x8F, 0x01, 0xF1, 0xE0, 0x3C, 0x3C, 0x0F, 0x87, 0x81, 0xE0, 0xF0, 0x7C,
  0x1E, 0x0F, 0x83, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xF3, 0xE0,
  0x3E, 0x7C, 0x07, 0xCF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0xF0, 0x3F, 0x07, 0x80, 0xF8, 0x7C, 0x03, 0xC3, 0xE0,
  0x3E, 0x1F, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0x81, 0xF8, 0x3F, 0xFF, 0x81,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xC0, 0xF8, 0x3C, 0x03,
  0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E,
  0x03, 0xE1, 0xE0, 0x3F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF,
  0xFE, 0x1F, 0x83, 0xE1, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xE0, 0x1E, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xFC, 0x1F,
  0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xF0, 0x7F,
  0x07, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x1E, 0x1F, 0x01, 0xF0, 0xF8,
  0x0F, 0x87, 0x80, 0x7C, 0x3C, 0x03, 0xE3, 0xE0, 0x1E, 0x1F, 0x00, 0xF0,
  0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xE0, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x87,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xC0, 0xFF, 0xFE, 0x1F, 0x83, 0xE1, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xE0,
  0x1E, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC7, 0xFC, 0x7C, 0x7F, 0xC7, 0x87, 0xFC, 0x78, 0x7F, 0xC7,
  0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF8,
  0xFC, 0x1F, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xE0,
  0xF0, 0x0F, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01,
  0xF0, 0xF8, 0x0F, 0x87, 0x80, 0x78, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xC1, 0xE0, 0x1E,
  0x0F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0,
  0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE0,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x1E, 0x00, 0xF0, 0x78, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0x80, 0x7C, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x03,
  0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0x80,
  0x7C, 0x7C, 0x01, 0xE1, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0x7C,
  0x03, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x0F, 0x01, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1E, 0x03, 0xE0, 0x78, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80,
  0x7C, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x77, 0x07, 0xE0,
  0xEE, 0x1D, 0xC1, 0xDC, 0x3F, 0x83, 0xB8, 0xEF, 0x07, 0x71, 0xDE, 0x1E,
  0xE7, 0xB8, 0x3D, 0xCE, 0xF0, 0x79, 0xFD, 0xE0, 0xF3, 0xF3, 0xC1, 0xE7,
  0xE7, 0x83, 0xCF, 0x9F, 0x0F, 0x9F, 0x3E, 0x1F, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x87, 0xC0, 0x1F,
  0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x78, 0x7E, 0x03, 0xC3,
  0xF0, 0x1E, 0x1F, 0xC1, 0xF0, 0xFE, 0x0F, 0x8F, 0xF0, 0x78, 0x7F, 0x83,
  0xC3, 0xDC, 0x1E, 0x1E, 0xF0, 0xF0, 0xF7, 0x8F, 0x87, 0xBC, 0x7C, 0x7D,
  0xE3, 0xC3, 0xE7, 0x1E, 0x1E, 0x38, 0xF0, 0xF1, 0xE7, 0x87, 0x8F, 0x3C,
  0x3C, 0x7B, 0xE1, 0xE1, 0xDE, 0x1F, 0x0E, 0xF0, 0xF0, 0x7F, 0x87, 0x83,
  0xFC, 0x3C, 0x1F, 0xE1, 0xE0, 0xFF, 0x0F, 0x03, 0xF0, 0xF8, 0x1F, 0x87,
  0xC0, 0xFC, 0x3C, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x07, 0xFF, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F,
  0x3E, 0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0xBE, 0x01, 0xE7, 0xC0, 0x3C,
  0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0xCF, 0x00, 0xF3,
  0xE0, 0x1E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3F, 0x07, 0xC3,
  0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0x01, 0xF8,
  0x3C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x1E, 0x1F, 0x00, 0xF8, 0x7C,
  0x03, 0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x7C, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F,
  0x03, 0xE1, 0xE0, 0x3E, 0x3E, 0x01, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xE3,
  0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xC7, 0xC0, 0x3C,
  0x7C, 0x07, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07,
  0x8F, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xFC, 0x1F, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0xF0, 0x3F, 0x07, 0x80, 0xFC, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0x87, 0x80, 0x7C, 0x3C, 0x07, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3C, 0x3E, 0x01, 0xE1,
  0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81,
  0xF0, 0x3E, 0x0F, 0x01, 0xF0, 0x78, 0x0F, 0x87, 0xC0, 0x3C, 0x3E, 0x01,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xF8, 0x1F, 0x07, 0x80, 0xF8, 0x7C, 0x03, 0xC3, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC7, 0x80, 0x3C, 0x3C, 0x03, 0xE1, 0xF0,
  0x3F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01,
  0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xF3, 0xE0, 0x1E, 0x3E, 0x03, 0xE3, 0xE0,
  0x3E, 0x3E, 0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x7C,
  0x03, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x78, 0x07, 0xC7,
  0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8,
  0xFC, 0x1F, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xF8,
  0x07, 0xCF, 0x80, 0x78, 0x78, 0x0F, 0x87, 0x80, 0xF0, 0x78, 0x1F, 0x07,
  0x81, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0x7C, 0x3C, 0x07, 0xC3, 0xC0,
  0x7C, 0x7C, 0x07, 0xC7, 0x80, 0x7C, 0xF8, 0x03, 0xCF, 0x00, 0x3C, 0xF0,
  0x03, 0xDF, 0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x78, 0x3C, 0x3D,
  0xE1, 0xF0, 0xF7, 0x87, 0xC3, 0xDE, 0x1F, 0x1E, 0x78, 0xFC, 0x79, 0xE3,
  0xF1, 0xE7, 0x8D, 0x87, 0x9E, 0x36, 0x3C, 0x79, 0xD8, 0xF1, 0xC7, 0x63,
  0xC7, 0x19, 0x8E, 0x1C, 0x66, 0x78, 0x73, 0x99, 0xE3, 0xCE, 0x67, 0x8F,
  0x31, 0x9C, 0x3D, 0xC6, 0x70, 0xF7, 0x3B, 0xC3, 0xD8, 0xEF, 0x0F, 0x63,
  0xB8, 0x3F, 0x8E, 0xE0, 0xFE, 0x3F, 0x83, 0xF0, 0xFE, 0x0E, 0xC3, 0xF0,
  0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x00,
  0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0xF8, 0x01, 0xF1, 0xF8, 0x00, 0xF1, 0xF0, 0x00, 0xFB, 0xE0,
  0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xE7, 0x80, 0x03, 0xE7, 0xC0,
  0x07, 0xC7, 0xC0, 0x0F, 0x83, 0xC0, 0x0F, 0x83, 0xE0, 0x1F, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0xF0, 0x01, 0xFF,
  0x80, 0x3E, 0xF8, 0x03, 0xC7, 0x80, 0x7C, 0x7C, 0x0F, 0x87, 0xC0, 0xF8,
  0x7C, 0x1F, 0x03, 0xC1, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x1E, 0x78,
  0x01, 0xEF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0,
  0xFF, 0xE1, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00,
  0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x07, 0xFF, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x3D, 0xC0, 0x3C, 0xF0, 0x1E, 0x78, 0x1E, 0x3C, 0x1F, 0x1E,
  0x0F, 0x07, 0x8F, 0x83, 0xC7, 0x81, 0xE7, 0x80, 0xFF, 0xC0, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0x3E, 0x3E,
  0x1F, 0x01, 0xC0, 0x00, 0xFF, 0x7C, 0x3F, 0xEF, 0x8F, 0xFF, 0xF3, 0xF9,
  0xFC, 0x7C, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80,
  0xF9, 0xE0, 0x1E, 0x3C, 0x03, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03,
  0xE7, 0xC0, 0x7C, 0xFC, 0x1F, 0x1F, 0xFF, 0xE1, 0xFF, 0xBC, 0x3F, 0xEF,
  0x83, 0xF9, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x0E, 0x01, 0xF3, 0xF8, 0x1F,
  0xFF, 0xC1, 0xEF, 0xFE, 0x1F, 0xCF, 0xE1, 0xF0, 0x3E, 0x1E, 0x03, 0xE3,
  0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xC0, 0x3C,
  0x3C, 0x03, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7E, 0x0F,
  0x87, 0xFF, 0xF8, 0x7B, 0xFF, 0x0F, 0xBF, 0xE0, 0xF9, 0xFC, 0x00, 0x00,
  0x70, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xF8, 0xFC, 0x7C,
  0x0F, 0x9F, 0x00, 0xF3, 0xE0, 0x1E, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE7, 0xC0,
  0x7C, 0xFC, 0x1F, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x01, 0xC3, 0xE0, 0x7F, 0xBE, 0x0F, 0xFB, 0xE1,
  0xFF, 0xFE, 0x3F, 0x9F, 0xC3, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C,
  0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x78, 0x07, 0x87, 0x80, 0x78, 0xF8, 0x0F,
  0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xFC, 0x1F, 0x0F, 0xFF,
  0xF0, 0x7F, 0xEF, 0x07, 0xFD, 0xF0, 0x3F, 0x9F, 0x00, 0x00, 0x78, 0x00,
  0xFF, 0x80, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x0F, 0xCF, 0x81, 0xF7, 0xC0,
  0x3D, 0xF0, 0x0F, 0x78, 0x07, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x02, 0xF8, 0x1F, 0x1F,
  0x8F, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFF,
  0x7C, 0x3F, 0xEF, 0x8F, 0xFF, 0xF3, 0xF9, 0xFC, 0x7C, 0x0F, 0x9F, 0x01,
  0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x1E, 0x3C, 0x03,
  0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xE7, 0xF1, 0xFC, 0x7F, 0xFF,
  0x0F, 0xFD, 0xE0, 0xFF, 0x3C, 0x07, 0x8F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x03, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0x80, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC3, 0x80, 0xF9, 0xFC, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x7F, 0x3F, 0x8F, 0x81, 0xF1, 0xE0, 0x3E, 0x7C, 0x07,
  0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1F,
  0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x3C,
  0x78, 0x07, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xFF,
  0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8,
  0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x1F, 0x81, 0xE0, 0xF8, 0x1F, 0x0F, 0x80,
  0xF8, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x78, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F,
  0x81, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x3E, 0x3E, 0x01, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x30, 0x60, 0x7B,
  0xE7, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1E, 0x3C, 0x78, 0x78, 0xF1,
  0xE1, 0xE3, 0x87, 0x8F, 0x8E, 0x1E, 0x3C, 0x38, 0x78, 0xF0, 0xE3, 0xE3,
  0xC7, 0x8F, 0x0F, 0x1E, 0x3C, 0x3C, 0x78, 0xF1, 0xF1, 0xC3, 0xC7, 0x87,
  0x0F, 0x1E, 0x1C, 0x7C, 0x78, 0x71, 0xE1, 0xE3, 0xC7, 0x87, 0x8F, 0x1E,
  0x1E, 0x38, 0x78, 0xF0, 0xE1, 0xE0, 0x00, 0x0E, 0x03, 0xE7, 0xF0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFC, 0xFE, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0,
  0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x1E, 0x01, 0xE3, 0xC0,
  0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x00,
  0xF1, 0xE0, 0x1E, 0x7C, 0x07, 0xCF, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0x80, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x9F, 0xCF, 0x81, 0xF7, 0xC0, 0x7D,
  0xF0, 0x1F, 0x7C, 0x07, 0xDE, 0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x1E, 0xF8,
  0x07, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xFC, 0x1F, 0x1F, 0xFF,
  0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x7C,
  0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFE, 0x7F, 0x07, 0xC0, 0xF8,
  0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0,
  0x7C, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87,
  0xC0, 0x7C, 0x3F, 0x07, 0xC1, 0xFF, 0xFE, 0x0F, 0x7F, 0xE0, 0xFB, 0xFE,
  0x07, 0xCF, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0xFF, 0x7C, 0x3F, 0xEF, 0x8F, 0xFF, 0xE3, 0xF9, 0xFC, 0x7C, 0x0F,
  0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x00, 0xF9, 0xE0, 0x1E,
  0x3C, 0x03, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xFC,
  0xFC, 0x1F, 0x1F, 0xFF, 0xE1, 0xFF, 0xBC, 0x3F, 0xEF, 0x83, 0xF9, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x01, 0xE7, 0xF8, 0x1E, 0xFF,
  0xC1, 0xFF, 0xFE, 0x3F, 0x87, 0xE3, 0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0,
  0x3E, 0x3C, 0x03, 0xE3, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0x03, 0xE1, 0xE0,
  0x1E, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC7,
  0x80, 0x7C, 0x7C, 0x07, 0xC7, 0xE1, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00,
  0xFF, 0x80, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9E, 0x01, 0xE3,
  0xC0, 0x3C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF,
  0x00, 0xF1, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E,
  0x03, 0xC7, 0xE0, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x79, 0xE0, 0x1F, 0x3C, 0x03, 0xC7,
  0x80, 0xF8, 0xF8, 0x1E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3C, 0x3E, 0x07,
  0x87, 0xC0, 0xF1, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0x80, 0x7D, 0xF0, 0x07,
  0xBC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0xF0, 0x78, 0x7F, 0x87, 0xC3, 0xBC, 0x3E, 0x3D, 0xE1, 0xF1,
  0xEF, 0x1F, 0x0F, 0x78, 0xD8, 0x73, 0xC6, 0xC7, 0x9E, 0x76, 0x3C, 0xF3,
  0x31, 0xC7, 0x99, 0x9E, 0x3D, 0xCC, 0xF1, 0xEE, 0x67, 0x0F, 0x63, 0x78,
  0x7B, 0x1B, 0xC3, 0xF8, 0xDC, 0x1F, 0x86, 0xE0, 0xFC, 0x3F, 0x07, 0xE1,
  0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x00, 0x1F, 0x80, 0xFC, 0x3E, 0x07,
  0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0xBE, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0xF8, 0xF0,
  0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x3F,
  0x00, 0xF8, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF0, 0x0F, 0x1E, 0x01, 0xE7,
  0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0x8F,
  0x00, 0xF1, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF8, 0x3F, 0x3F,
  0xFF, 0xE3, 0xFF, 0x78, 0x7F, 0xEF, 0x07, 0xFB, 0xE0, 0x10, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x83, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0,
  0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x00, 0x07, 0xC0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x81, 0xE7,
  0xF8, 0x3D, 0xFF, 0x87, 0xFC, 0xF8, 0xFF, 0x0F, 0xBF, 0xE1, 0xFF, 0xBC,
  0x1F, 0xE7, 0x81, 0xF8,
};

const GFXglyph JetBrainsMono_BoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 9, 27, 22, 7, -27 },
  { 32, 14, 11, 22, 6, -27 },
  { 52, 23, 27, 22, 0, -27 },
  { 130, 21, 37, 22, 1, -32 },
  { 228, 27, 27, 22, -2, -27 },
  { 320, 22, 27, 22, 0, -27 },
  { 395, 6, 11, 22, 10, -27 },
  { 404, 16, 36, 22, 5, -31 },
  { 476, 16, 36, 22, 2, -31 },
  { 548, 20, 20, 22, 2, -23 },
  { 598, 19, 18, 22, 2, -21 },
  { 641, 11, 12, 22, 3, -6 },
  { 658, 13, 4, 22, 5, -14 },
  { 665, 8, 7, 22, 6, -7 },
  { 672, 23, 35, 22, 0, -31 },
  { 773, 20, 27, 22, 2, -27 },
  { 841, 18, 27, 22, 1, -27 },
  { 902, 20, 27, 22, 1, -27 },
  { 970, 20, 27, 22, 1, -27 },
  { 1038, 19, 27, 22, 2, -27 },
  { 1103, 19, 27, 22, 2, -27 },
  { 1168, 19, 27, 22, 1, -27 },
  { 1233, 19, 27, 22, 4, -27 },
  { 1298, 20, 27, 22, 1, -27 },
  { 1366, 19, 27, 22, 3, -27 },
  { 1431, 10, 21, 22, 6, -21 },
  { 1458, 13, 27, 22, 3, -21 },
  { 1502, 18, 20, 22, 3, -22 },
  { 1547, 19, 13, 22, 2, -19 },
  { 1578, 18, 20, 22, 2, -22 },
  { 1623, 16, 27, 22, 5, -27 },
  { 1677, 23, 34, 22, 0, -27 },
  { 1775, 19, 27, 22, 0, -27 },
  { 1840, 21, 27, 22, 1, -27 },
  { 1911, 20, 27, 22, 2, -27 },
  { 1979, 21, 27, 22, 1, -27 },
  { 2050, 20, 27, 22, 2, -27 },
  { 2118, 21, 27, 22, 1, -27 },
  { 2189, 20, 27, 22, 2, -27 },
  { 2257, 21, 27, 22, 1, -27 },
  { 2328, 20, 27, 22, 2, -27 },
  { 2396, 22, 27, 22, 0, -27 },
  { 2471, 22, 27, 22, 1, -27 },
  { 2546, 17, 27, 22, 2, -27 },
  { 2604, 23, 27, 22, 0, -27 },
  { 2682, 21, 27, 22, 1, -27 },
  { 2753, 19, 27, 22, 2, -27 },
  { 2818, 22, 27, 22, 1, -27 },
  { 2893, 20, 34, 22, 2, -27 },
  { 2978, 21, 27, 22, 1, -27 },
  { 3049, 21, 27, 22, 1, -27 },
  { 3120, 19, 27, 22, 4, -27 },
  { 3185, 20, 27, 22, 2, -27 },
  { 3253, 20, 27, 22, 4, -27 },
  { 3321, 22, 27, 22, 2, -27 },
  { 3396, 24, 27, 22, -1, -27 },
  { 3477, 20, 27, 22, 4, -27 },
  { 3545, 21, 27, 22, 1, -27 },
  { 3616, 15, 35, 22, 5, -31 },
  { 3682, 13, 35, 22, 5, -31 },
  { 3739, 16, 35, 22, 3, -31 },
  { 3809, 17, 14, 22, 3, -27 },
  { 3839, 18, 4, 22, 0, 1 },
  { 3848, 8, 5, 22, 9, -29 },
  { 3853, 19, 21, 22, 2, -21 },
  { 3903, 20, 27, 22, 1, -27 },
  { 3971, 19, 21, 22, 2, -21 },
  { 4021, 20, 27, 22, 2, -27 },
  { 4089, 18, 21, 22, 2, -21 },
  { 4137, 25, 34, 22, -2, -27 },
  { 4244, 19, 28, 22, 2, -21 },
  { 4311, 19, 27, 22, 1, -27 },
  { 4376, 19, 29, 22, 1, -29 },
  { 4445, 20, 36, 22, 0, -29 },
  { 4535, 21, 27, 22, 1, -27 },
  { 4606, 17, 27, 22, 3, -27 },
  { 4664, 22, 21, 22, 0, -21 },
  { 4722, 19, 21, 22, 1, -21 },
  { 4772, 18, 21, 22, 2, -21 },
  { 4820, 21, 28, 22, 0, -21 },
  { 4894, 19, 28, 22, 2, -21 },
  { 4961, 20, 21, 22, 2, -21 },
  { 5014, 20, 21, 22, 1, -21 },
  { 5067, 18, 26, 22, 3, -26 },
  { 5126, 19, 20, 22, 2, -20 },
  { 5174, 19, 20, 22, 3, -20 },
  { 5222, 21, 20, 22, 2, -20 },
  { 5275, 22, 20, 22, 0, -20 },
  { 5330, 19, 27, 22, 2, -20 },
  { 5395, 20, 20, 22, 1, -20 },
  { 5445, 20, 35, 22, 3, -31 },
  { 5533, 10, 35, 22, 7, -31 },
  { 5577, 19, 35, 22, 1, -31 },
  { 5661, 19, 8, 22, 2, -17 },
};

const GFXfont JetBrainsMono_BoldItalic37pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic37pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _JETBRAINSMONO_BOLDITALIC37PT7B_H_
