#ifndef _JETBRAINSMONO_BOLDITALIC72PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC,
  0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x07, 0xFE,
  0xFF, 0xC0, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0,
  0x7F, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x7F, 0xC7,
  0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0x07,
  0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F,
  0x80, 0x7F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xE7, 0xCF, 0xFE, 0x00, 0xFF, 0xC7, 0xC7, 0xFE, 0x01,
  0xFF, 0x87, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0x83, 0xFE, 0x03, 0xFF, 0x07,
  0x83, 0xFE, 0x03, 0xFE, 0x0F, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0x80, 0x00,
  0x03, 0xFE, 0x0F, 0x80, 0x00, 0x03, 0xFE, 0x0F, 0x80, 0x00, 0x03, 0xFE,
  0x0F, 0x00, 0x00, 0x03, 0xFF, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0x9F, 0x00,
  0x00, 0x03, 0xFF, 0xDF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x7C, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x7F, 0xF0, 0x00,
  0x00, 0x7C, 0x3F, 0xF0, 0x00, 0x00, 0x78, 0x1F, 0xF0, 0x00, 0x00, 0x78,
  0x1F, 0xF0, 0x00, 0x00, 0x78, 0x1F, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0xF0,
  0x7F, 0xC0, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0,
  0xF8, 0x3F, 0xE0, 0x7F, 0xE0, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xF0, 0x7F,
  0xE0, 0x7F, 0xF0, 0xF1, 0xFF, 0xC0, 0x3F, 0xFF, 0xF7, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x1F, 0xC0, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x7F, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE1,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0x3F,
  0xC7, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x8F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF1, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC3, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xE3, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0x8F, 0xF0, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFC, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x81, 0xFC,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0x01, 0xFC,
  0x01, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x07,
  0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xDF, 0xF0,
  0x1F, 0xF0, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8,
  0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC7, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE7, 0xFC, 0x0F, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xF8, 0x07, 0xFF,
  0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x01,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0x80,
  0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xFF, 0x9F,
  0xF0, 0x07, 0xFF, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE7,
  0xFC, 0xFF, 0x9F, 0xF7, 0xFE, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xFB,
  0xFF, 0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x10, 0x00, 0xFF, 0x00,
  0x08, 0x38, 0x01, 0xFC, 0x00, 0xF0, 0xFE, 0x03, 0xF8, 0x0F, 0xE1, 0xFF,
  0x03, 0xE0, 0x7F, 0xC7, 0xFF, 0x07, 0xC3, 0xFF, 0x8F, 0xFF, 0x0F, 0x0F,
  0xFF, 0xBF, 0xFF, 0x9E, 0x7F, 0xFF, 0xFF, 0xFF, 0xB9, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xC1,
  0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x1F, 0xE0, 0x7F, 0xE1,
  0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0xFF, 0xFC, 0xFF,
  0xF1, 0xFF, 0xE3, 0xFF, 0x83, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x1F, 0x03, 0xFE,
  0x0F, 0xF8, 0x7F, 0x07, 0xFC, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE3,
  0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF8, 0x7F,
  0x81, 0xFE, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x1F, 0xC3, 0xFE, 0x0F, 0xF8,
  0x1F, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03,
  0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFD, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x87, 0xFC,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xF0, 0x1F, 0xF0, 0x00, 0xF8, 0x03,
  0xFE, 0x00, 0x1E, 0x00, 0xFF, 0xC0, 0x03, 0x00, 0x1F, 0xF0, 0x00, 0xC0,
  0x03, 0xFE, 0x00, 0x10, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF8,
  0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00,
  0x7F, 0xC1, 0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xFF, 0x00, 0x07, 0xFC,
  0xFF, 0xFE, 0x00, 0x1F, 0xF7, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFE, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0x7F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xFE, 0x00,
  0x3F, 0xEF, 0xFF, 0xF0, 0x07, 0xFD, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE,
  0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF3,
  0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01,
  0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07,
  0xFC, 0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0,
  0x03, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xF8, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x81, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x07, 0xFD, 0xFF, 0x00,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF3,
  0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x03,
  0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFD, 0xFF,
  0x00, 0x1F, 0xFF, 0xDF, 0xF0, 0x00, 0x7F, 0xF9, 0xFF, 0x80, 0x00, 0x7C,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF0,
  0x07, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x07,
  0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF8,
  0x7F, 0x01, 0xFE, 0x00, 0x7F, 0xF9, 0xFC, 0x07, 0xF8, 0x03, 0xFF, 0xF7,
  0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0xDF, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0x7F,
  0x01, 0xFC, 0x03, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F,
  0x80, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0x81,
  0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x01, 0xFC,
  0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x01,
  0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0xBF, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0xFC,
  0x07, 0xF8, 0x03, 0xFF, 0xE7, 0xF0, 0x1F, 0xE0, 0x07, 0xFF, 0x1F, 0xC0,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x0F, 0xF9,
  0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0xC0,
  0x3F, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03,
  0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF,
  0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x01,
  0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0,
  0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFF,
  0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xC3, 0xFE,
  0x03, 0xFF, 0xFF, 0x0F, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF,
  0xE0, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xFF, 0xFE, 0x1F, 0xF0,
  0x1F, 0xFF, 0xF8, 0x7F, 0xC0, 0x7F, 0xFF, 0xE1, 0xFF, 0x00, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF0, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x1F,
  0xF8, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F,
  0x7E, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF8,
  0x07, 0xEF, 0xC0, 0x3F, 0x7F, 0x01, 0xFD, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F,
  0x9F, 0x01, 0xFB, 0xF8, 0x07, 0xF3, 0xF0, 0x3F, 0x7F, 0x00, 0xFE, 0x7E,
  0x0F, 0xCF, 0xE0, 0x1F, 0xCF, 0xC1, 0xF9, 0xFC, 0x03, 0xF9, 0xF8, 0x7E,
  0x7F, 0x80, 0xFF, 0x3F, 0x0F, 0xCF, 0xF0, 0x1F, 0xE7, 0xE3, 0xF1, 0xFC,
  0x03, 0xFC, 0x7C, 0x7E, 0x3F, 0x80, 0x7F, 0x8F, 0xDF, 0xCF, 0xF0, 0x0F,
  0xF1, 0xFB, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0x7E, 0x3F, 0xC0, 0x3F, 0x87,
  0xFF, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xFC,
  0x3F, 0xC0, 0x3F, 0xC3, 0xFF, 0x87, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0xFF,
  0x00, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x00,
  0x3F, 0xC0, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xF0,
  0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFF,
  0xC0, 0x03, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xC0,
  0x3F, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xE0, 0x1F, 0xEF,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF7, 0xF0, 0x07, 0xF8, 0x07, 0xFB, 0xF8, 0x03,
  0xFC, 0x03, 0xFD, 0xFC, 0x03, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x3F, 0x80, 0xFF, 0x00, 0xFF, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x8F,
  0xE0, 0x3F, 0xC0, 0x3F, 0xC7, 0xF0, 0x1F, 0xE0, 0x1F, 0xE3, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF1, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x07,
  0xFC, 0x3F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F,
  0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x81, 0xFC, 0x7F,
  0xC0, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0x1F, 0xE0, 0x1F,
  0xF0, 0x3F, 0x8F, 0xF0, 0x0F, 0xF0, 0x1F, 0xC7, 0xF8, 0x07, 0xF8, 0x07,
  0xF3, 0xFC, 0x03, 0xFC, 0x03, 0xF9, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0xFE,
  0x01, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0x80, 0x7F, 0x3F, 0x80, 0x7F,
  0x80, 0x3F, 0xDF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xE0, 0x07,
  0xFF, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0xF8,
  0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0x80, 0x07,
  0xFF, 0xC0, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0xE0,
  0x1F, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xF0, 0x00,
  0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x07, 0xFC,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFF, 0x00,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0x83, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0,
  0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x1F,
  0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x1F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x1F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3D,
  0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xDE, 0x03, 0xFC, 0x1F, 0xC0, 0x7D, 0xE0,
  0x3F, 0xC1, 0xFC, 0x07, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7B, 0xE0, 0x3F,
  0x81, 0xFC, 0x0F, 0xBE, 0x07, 0xF8, 0x1F, 0xC0, 0xFB, 0xE0, 0x7F, 0x03,
  0xFC, 0x0F, 0xBE, 0x07, 0xF0, 0x3F, 0xC1, 0xF3, 0xE0, 0x7F, 0x03, 0xFC,
  0x1F, 0x3E, 0x0F, 0xF0, 0x3F, 0xC1, 0xF3, 0xE0, 0xFE, 0x03, 0xFC, 0x1F,
  0x3E, 0x0F, 0xE0, 0x3F, 0x83, 0xE3, 0xE0, 0xFE, 0x03, 0xF8, 0x3E, 0x3E,
  0x1F, 0xE0, 0x3F, 0x83, 0xE3, 0xE1, 0xFC, 0x03, 0xF8, 0x3C, 0x3E, 0x1F,
  0xC0, 0x3F, 0x87, 0xC3, 0xE1, 0xFC, 0x03, 0xF8, 0x7C, 0x3C, 0x3F, 0xC0,
  0x3F, 0x87, 0xC3, 0xC3, 0xF8, 0x03, 0xF8, 0xF8, 0x3C, 0x3F, 0x80, 0x3F,
  0x8F, 0x87, 0xC3, 0xF8, 0x03, 0xF8, 0xF8, 0x7C, 0x7F, 0x00, 0x3F, 0x8F,
  0x87, 0xC7, 0xF0, 0x03, 0xF9, 0xF0, 0x7C, 0x7F, 0x00, 0x3F, 0x9F, 0x07,
  0xC7, 0xF0, 0x07, 0xF9, 0xF0, 0x7C, 0xFE, 0x00, 0x7F, 0x3E, 0x07, 0xCF,
  0xE0, 0x07, 0xF3, 0xE0, 0x7C, 0xFE, 0x00, 0x7F, 0x3E, 0x07, 0xCF, 0xE0,
  0x07, 0xF3, 0xE0, 0x7D, 0xFC, 0x00, 0x7F, 0x7C, 0x07, 0xDF, 0xC0, 0x07,
  0xF7, 0xC0, 0x7D, 0xFC, 0x00, 0x7F, 0x7C, 0x07, 0xDF, 0xC0, 0x07, 0xF7,
  0xC0, 0x7D, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xEF, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x9F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x0F,
  0xFC, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xF0, 0x01,
  0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF,
  0x3F, 0xE0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03,
  0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xFE, 0x1F, 0xF0, 0x03,
  0xFF, 0xFC, 0x7F, 0xC0, 0x1F, 0xFF, 0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0xEF,
  0xF8, 0x07, 0xFF, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFD, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFE, 0x00,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x80, 0xFF, 0xFF, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0xEF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xFD, 0xFF, 0x00, 0x3F, 0xFF, 0xE7,
  0xFC, 0x00, 0x7F, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x7F, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x3F,
  0xE1, 0xFF, 0xF8, 0x00, 0xFF, 0x8F, 0xFF, 0xF0, 0x03, 0xFE, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFB, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFB, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFD, 0xFF, 0xFF, 0xF0, 0x1F,
  0xF7, 0xFF, 0xFF, 0xC0, 0x7F, 0xDF, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0xFF,
  0xF0, 0x07, 0xFC, 0xFF, 0xFF, 0x80, 0x1F, 0xE1, 0xFF, 0xF8, 0x00, 0xFF,
  0x83, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF,
  0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x03, 0xFF,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xF8,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF8,
  0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0xFF, 0xC7, 0xFC, 0x00, 0x7F,
  0xFF, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0xEF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xF7, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F,
  0xFC, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0xFF, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0x00, 0x1F, 0xFF, 0xFD, 0xFF, 0x00,
  0x0F, 0xFF, 0xF9, 0xFF, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0x00, 0x03, 0xFF,
  0xC1, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFE, 0x3F,
  0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x3F,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE,
  0x07, 0xFF, 0xC7, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0xF8, 0x7F, 0xC0, 0x1F, 0xFF, 0xE3, 0xFE,
  0x01, 0xFF, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xFD, 0xFF, 0x01, 0xFF, 0xFF,
  0xEF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFD, 0xFF, 0xFE, 0x0F,
  0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xBF, 0xE0, 0x3F, 0xFF, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0xCF, 0xF8, 0x07,
  0xFF, 0xFC, 0x7F, 0x80, 0x1F, 0xFF, 0xC7, 0xFC, 0x00, 0x3F, 0xF8, 0x3F,
  0xE0, 0x00, 0x3E, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x3F,
  0xE1, 0xFF, 0xF8, 0x00, 0xFF, 0x8F, 0xFF, 0xF0, 0x03, 0xFE, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFB, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0x7F, 0xFF, 0xFC, 0x03, 0xFD, 0xFB, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x03, 0xF8,
  0x7E, 0x03, 0xF8, 0x01, 0xFC, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0xFF, 0xE3,
  0xFF, 0x80, 0xFF, 0x7F, 0xF3, 0xFF, 0xE0, 0x7F, 0xFF, 0xFD, 0xFF, 0xF0,
  0x3F, 0xBF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0xFF, 0xC7, 0xFC, 0x0F, 0xF0,
  0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xE0,
  0x7F, 0x83, 0xFC, 0x07, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xF0, 0x1F, 0xE0,
  0xFF, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xF8, 0x3F, 0xC0,
  0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0x01,
  0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x7F, 0x83,
  0xFC, 0x0F, 0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x03,
  0xF8, 0x1F, 0xE0, 0xFF, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFC, 0x07,
  0xF8, 0x3F, 0xC0, 0x7E, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x0F,
  0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F,
  0xE0, 0x7F, 0x83, 0xFC, 0x07, 0xE0, 0x3F, 0xC1, 0xFE, 0x03, 0xF0, 0x1F,
  0xE0, 0xFF, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xF8, 0x3F,
  0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0x3F,
  0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xC0, 0x7F,
  0x83, 0xFC, 0x0F, 0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x01,
  0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xFE, 0x00, 0x3F, 0xE3, 0xFF,
  0xFC, 0x00, 0xFF, 0x9F, 0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xDF, 0xFF, 0xFF, 0x00, 0xFF, 0x7E, 0xFF,
  0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF,
  0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x07, 0xFC,
  0x7F, 0xC0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFF, 0xE0,
  0x00, 0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0xFF, 0x9F, 0xFF, 0xF8, 0x00, 0xFF,
  0xBF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F,
  0xF7, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7, 0xFF,
  0xFF, 0x80, 0x1F, 0xF7, 0xFF, 0xFF, 0x00, 0x1F, 0xF3, 0xFF, 0xFE, 0x00,
  0x1F, 0xF1, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xF0, 0x00, 0x3F, 0xE0,
  0x1E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xFE, 0x1F,
  0xF0, 0x03, 0xFF, 0xFC, 0x7F, 0x80, 0x1F, 0xFF, 0xF3, 0xFE, 0x00, 0xFF,
  0xFF, 0xEF, 0xF8, 0x07, 0xFF, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xFE, 0xFF,
  0x81, 0xFF, 0xFD, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0xEF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xFD, 0xFF, 0x00, 0x3F,
  0xFF, 0xE7, 0xFC, 0x00, 0x7F, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xF0, 0x7F,
  0xC0, 0x00, 0x7C, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0xFE,
  0x00, 0x3F, 0xC7, 0xFF, 0xFC, 0x01, 0xFF, 0x3F, 0xFF, 0xF8, 0x07, 0xFD,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xBF, 0xFF, 0xFF,
  0x01, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0x80,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0,
  0x0F, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC3,
  0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFF,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00,
  0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0x3F, 0xE0,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x3F,
  0x80, 0x3F, 0xDF, 0xC0, 0x3F, 0xC0, 0x1F, 0xDF, 0xE0, 0x1F, 0xE0, 0x0F,
  0xEF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF7, 0xF8, 0x0F, 0xF8, 0x07, 0xF3, 0xFC,
  0x07, 0xFC, 0x03, 0xF9, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFF,
  0x01, 0xFC, 0x7F, 0x81, 0xFF, 0x80, 0xFE, 0x3F, 0xC0, 0xFF, 0xC0, 0x7F,
  0x1F, 0xE0, 0x7B, 0xE0, 0x7F, 0x0F, 0xF0, 0x7D, 0xF0, 0x3F, 0x87, 0xF8,
  0x3E, 0xF8, 0x1F, 0xC3, 0xFC, 0x1E, 0x7C, 0x1F, 0xC1, 0xFE, 0x1F, 0x3E,
  0x0F, 0xE0, 0xFE, 0x0F, 0x9F, 0x07, 0xF0, 0x7F, 0x07, 0x8F, 0x87, 0xF0,
  0x3F, 0x87, 0xC7, 0xC3, 0xF8, 0x1F, 0xC3, 0xE3, 0xE1, 0xFC, 0x0F, 0xE1,
  0xF1, 0xF0, 0xFE, 0x07, 0xF1, 0xF0, 0xF8, 0xFE, 0x03, 0xF8, 0xF8, 0x7C,
  0x7F, 0x01, 0xFC, 0x7C, 0x3E, 0x3F, 0x80, 0xFE, 0x3C, 0x1F, 0x3F, 0x80,
  0x7F, 0x3E, 0x0F, 0x9F, 0xC0, 0x3F, 0x9F, 0x07, 0xCF, 0xE0, 0x1F, 0xCF,
  0x03, 0xEF, 0xE0, 0x0F, 0xEF, 0x81, 0xF7, 0xF0, 0x07, 0xF7, 0xC0, 0xFB,
  0xF8, 0x03, 0xFB, 0xE0, 0x7D, 0xF8, 0x01, 0xFD, 0xE0, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x3F,
  0xF0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xE3, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xDF, 0xF8, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF,
  0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF7, 0xFC, 0x0F, 0xFF, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xF9, 0xFF,
  0x00, 0xFF, 0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0xF8, 0xFF, 0x80, 0x0F, 0xFF,
  0x87, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x04, 0x0F, 0xFF,
  0xC0, 0x07, 0xF0, 0x7F, 0xFF, 0xC0, 0x0F, 0xE0, 0xFF, 0xFF, 0x80, 0x3F,
  0xC3, 0xFF, 0xFF, 0x80, 0x7F, 0x8F, 0xFF, 0xFF, 0x80, 0xFF, 0x1F, 0xF3,
  0xFF, 0x01, 0xFE, 0x3F, 0xC1, 0xFF, 0x03, 0xF8, 0xFF, 0x03, 0xFF, 0x0F,
  0xF1, 0xFE, 0x03, 0xFF, 0xFF, 0xE3, 0xFC, 0x03, 0xFF, 0xFF, 0x87, 0xF0,
  0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x07, 0xFF, 0xFC, 0x3F, 0xC0, 0x07, 0xFF,
  0xF0, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
};

const GFXglyph JetBrainsMono_BoldItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 19, 53, 43, 13, -53 },
  { 127, 27, 22, 43, 12, -53 },
  { 202, 43, 53, 43, 1, -53 },
  { 487, 40, 73, 43, 2, -63 },
  { 852, 52, 53, 43, -3, -53 },
  { 1197, 41, 54, 43, 1, -53 },
  { 1474, 11, 22, 43, 20, -53 },
  { 1505, 31, 70, 43, 10, -61 },
  { 1777, 30, 70, 43, 4, -61 },
  { 2040, 39, 38, 43, 3, -44 },
  { 2226, 36, 34, 43, 4, -41 },
  { 2379, 21, 23, 43, 6, -11 },
  { 2440, 26, 8, 43, 9, -28 },
  { 2466, 15, 14, 43, 12, -13 },
  { 2493, 45, 68, 43, 0, -60 },
  { 2876, 39, 54, 43, 3, -53 },
  { 3140, 35, 53, 43, 3, -53 },
  { 3372, 38, 53, 43, 3, -53 },
  { 3624, 38, 54, 43, 3, -53 },
  { 3881, 37, 53, 43, 3, -53 },
  { 4127, 38, 54, 43, 3, -53 },
  { 4384, 36, 54, 43, 3, -53 },
  { 4627, 37, 53, 43, 7, -53 },
  { 4873, 38, 54, 43, 3, -53 },
  { 5130, 37, 53, 43, 6, -53 },
  { 5376, 19, 41, 43, 12, -40 },
  { 5474, 25, 52, 43, 6, -40 },
  { 5637, 36, 39, 43, 5, -43 },
  { 5813, 36, 26, 43, 4, -37 },
  { 5930, 36, 39, 43, 3, -43 },
  { 6106, 31, 53, 43, 9, -53 },
  { 6312, 46, 66, 43, -1, -53 },
  { 6692, 39, 53, 43, -1, -53 },
  { 6951, 40, 53, 43, 2, -53 },
  { 7216, 38, 54, 43, 4, -53 },
  { 7473, 40, 53, 43, 2, -53 },
  { 7738, 40, 53, 43, 3, -53 },
  { 8003, 41, 53, 43, 3, -53 },
  { 8275, 38, 54, 43, 4, -53 },
  { 8532, 41, 53, 43, 2, -53 },
  { 8804, 39, 53, 43, 3, -53 },
  { 9063, 42, 54, 43, 0, -53 },
  { 9347, 44, 53, 43, 2, -53 },
  { 9639, 33, 53, 43, 4, -53 },
  { 9858, 43, 53, 43, 1, -53 },
  { 10143, 41, 53, 43, 2, -53 },
  { 10415, 38, 54, 43, 4, -53 },
  { 10672, 42, 53, 43, 2, -53 },
  { 10951, 39, 66, 43, 3, -53 },
  { 11273, 41, 53, 43, 2, -53 },
  { 11545, 40, 54, 43, 2, -53 },
  { 11815, 38, 53, 43, 7, -53 },
  { 12067, 40, 54, 43, 3, -53 },
  { 12337, 38, 53, 43, 8, -53 },
  { 12589, 44, 53, 43, 3, -53 },
  { 12881, 47, 53, 43, -1, -53 },
  { 13193, 40, 53, 43, 7, -53 },
  { 13458, 39, 53, 43, 3, -53 },
  { 13717, 31, 68, 43, 9, -60 },
  { 13981, 23, 68, 43, 11, -60 },
  { 14177, 31, 68, 43, 5, -60 },
  { 14441, 33, 29, 43, 6, -53 },
  { 14561, 35, 8, 43, 0, 2 },
  { 14596, 15, 11, 43, 18, -57 },
  { 14617, 38, 41, 43, 3, -40 },
  { 14812, 38, 54, 43, 2, -53 },
  { 15069, 36, 41, 43, 4, -40 },
  { 15254, 40, 54, 43, 3, -53 },
  { 15524, 36, 41, 43, 4, -40 },
  { 15709, 49, 66, 43, -4, -53 },
  { 16114, 37, 53, 43, 4, -40 },
  { 16360, 38, 53, 43, 2, -53 },
  { 16612, 36, 57, 43, 2, -57 },
  { 16869, 38, 70, 43, 1, -57 },
  { 17202, 41, 53, 43, 3, -53 },
  { 17474, 32, 53, 43, 6, -53 },
  { 17686, 41, 40, 43, 1, -40 },
  { 17891, 38, 40, 43, 2, -40 },
  { 18081, 36, 41, 43, 4, -40 },
  { 18266, 40, 53, 43, 0, -40 },
  { 18531, 38, 53, 43, 3, -40 },
  { 18783, 38, 40, 43, 4, -40 },
  { 18973, 37, 41, 43, 3, -40 },
  { 19163, 36, 50, 43, 5, -50 },
  { 19388, 38, 41, 43, 3, -40 },
  { 19583, 37, 40, 43, 6, -40 },
  { 19768, 41, 40, 43, 4, -40 },
  { 19973, 43, 40, 43, 0, -40 },
  { 20188, 37, 53, 43, 4, -40 },
  { 20434, 38, 40, 43, 2, -40 },
  { 20624, 38, 68, 43, 6, -60 },
  { 20947, 19, 68, 43, 13, -60 },
  { 21109, 38, 68, 43, 1, -60 },
  { 21432, 39, 17, 43, 3, -34 },
};

const GFXfont JetBrainsMono_BoldItalic72pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic72pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic72pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _JETBRAINSMONO_BOLDITALIC72PT7B_H_
