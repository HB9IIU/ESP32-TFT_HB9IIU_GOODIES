#ifndef _JETBRAINSMONO_BOLDITALIC39PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0xFE, 0x3F, 0x8F, 0xC1, 0xF0,
  0x3E, 0x3E, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xF7, 0xC3, 0xCF, 0x8F, 0x9E,
  0x1F, 0x3C, 0x3E, 0x78, 0x7C, 0xF0, 0xF3, 0xE1, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C,
  0x00, 0x70, 0x38, 0x00, 0xF0, 0x78, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x01, 0xE0, 0xF0, 0x01, 0xC0, 0xE0, 0x03, 0xC1, 0xE0,
  0x03, 0xC1, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x83, 0xC0,
  0x07, 0x03, 0x80, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x7E, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0xFD, 0xCF, 0x83, 0xE7, 0x3E, 0x1F, 0x1C, 0xF8, 0x7C, 0x60, 0x01,
  0xF1, 0x80, 0x07, 0xE6, 0x00, 0x1F, 0xD8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x1C, 0xFC, 0x00, 0x71, 0xF0, 0x01, 0xC7, 0xC7, 0xC6, 0x1F, 0x1F,
  0x18, 0xF8, 0x7C, 0x63, 0xE1, 0xFB, 0x9F, 0x87, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0xE0, 0x0F, 0x03, 0xFE, 0x01, 0xE0, 0x79, 0xF0, 0x3C, 0x07,
  0x0F, 0x07, 0x80, 0xF0, 0xF0, 0xF0, 0x0F, 0x0F, 0x0E, 0x00, 0xF0, 0xF1,
  0xC0, 0x0E, 0x0E, 0x38, 0x00, 0xF1, 0xE7, 0x80, 0x0F, 0xFE, 0xF0, 0x00,
  0x7F, 0xDE, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xDF, 0xE0,
  0x00, 0x7B, 0xFF, 0x00, 0x0F, 0x3C, 0xF0, 0x01, 0xE7, 0x87, 0x00, 0x1C,
  0x78, 0x70, 0x03, 0x87, 0x07, 0x00, 0x78, 0x70, 0x70, 0x0F, 0x07, 0x0F,
  0x01, 0xE0, 0x70, 0xF0, 0x3C, 0x07, 0xFE, 0x07, 0x80, 0x7F, 0xC0, 0xF0,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x3F, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0xF0, 0x3E, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x1F, 0x3E, 0x7C, 0x7C, 0x7C, 0xF9, 0xF0, 0xF0, 0xFB, 0xC3, 0xE0, 0xFF,
  0x87, 0xC1, 0xFE, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0,
  0x7C, 0x1F, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xCF, 0x81,
  0xFE, 0x0F, 0x80, 0x7D, 0xFF, 0xBE, 0xFB, 0xEF, 0xBC, 0xF3, 0xCF, 0x00,
  0x00, 0x01, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x01, 0xE0, 0x00, 0x60, 0x02, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x10, 0x3C, 0x09, 0xE1, 0xC3, 0xCF, 0xCE, 0x7E, 0xFF, 0x77,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01,
  0xDE, 0x00, 0x3E, 0xF8, 0x03, 0xE3, 0xC0, 0x3F, 0x1F, 0x01, 0xF0, 0xFC,
  0x1F, 0x03, 0xC0, 0x30, 0x1C, 0x00, 0x80, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE1,
  0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x00, 0x7F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xFE, 0x7F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x1E, 0x3E, 0x00,
  0xF1, 0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0x78, 0x03, 0xE3, 0xC7, 0x1F, 0x3E,
  0x7C, 0xF1, 0xF3, 0xE7, 0x8F, 0x9F, 0x3C, 0x7C, 0xF3, 0xE3, 0xC0, 0x1F,
  0x1E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xE0,
  0x1F, 0x1F, 0x01, 0xF8, 0xFC, 0x1F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F,
  0xF0, 0x3F, 0xFC, 0x1F, 0xDF, 0x07, 0xC7, 0x81, 0xE3, 0xE0, 0x60, 0xF8,
  0x10, 0x3E, 0x08, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00,
  0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xE0,
  0xFC, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1,
  0xF0, 0x1F, 0x8F, 0xC1, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x83,
  0xE3, 0xF0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0x78, 0x07, 0xCF, 0x80,
  0x7C, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE1, 0xE0, 0x3E, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xF8,
  0xFE, 0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF,
  0xC1, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xC4, 0x00, 0xFB, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F,
  0x87, 0xF3, 0xF0, 0x3F, 0x7E, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7,
  0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xE0, 0xFC,
  0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x03, 0xEF, 0x80,
  0x7E, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7E, 0x3F, 0x87, 0xE0, 0x7C,
  0x3E, 0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0xC3, 0xE0,
  0x7C, 0x1F, 0x87, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0xF0, 0x0F, 0xCF, 0xC0, 0xF8, 0x3F, 0x0F, 0x80, 0xF8, 0x78, 0x07,
  0xC7, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7E,
  0x0F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F,
  0xCF, 0xE3, 0xE0, 0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xF7,
  0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xFC, 0x07, 0xE7, 0xE0, 0xFC,
  0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x3F, 0xEF, 0x80, 0xFD, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0x07, 0xE1, 0xFC, 0xFF, 0x3F, 0x87, 0xE0, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0xFF, 0x03, 0xF8, 0x07, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x07, 0x80, 0x03, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x02, 0x00,
  0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0E, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF,
  0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0,
  0x3F, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xE0, 0x3E, 0x07, 0x80, 0x1E, 0x0F, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x07,
  0xCF, 0x3C, 0x1F, 0xEE, 0x3C, 0x1F, 0xEE, 0x3C, 0x3E, 0x3E, 0x3C, 0x3C,
  0x1E, 0x3C, 0x78, 0x1E, 0x3C, 0x78, 0x3E, 0x78, 0x78, 0x3C, 0x78, 0x78,
  0x3C, 0x78, 0x78, 0x3C, 0x78, 0x78, 0x3C, 0x78, 0xF0, 0x3C, 0x78, 0xF8,
  0x7C, 0xF8, 0xF8, 0xF8, 0xF0, 0x7F, 0xB8, 0xF0, 0x7F, 0x38, 0xF0, 0x1E,
  0x40, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xBC, 0x00, 0xFB, 0xC0, 0x0F, 0xBC,
  0x00, 0xF3, 0xC0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3,
  0xE0, 0x3C, 0x3E, 0x07, 0xC1, 0xE0, 0x7C, 0x1E, 0x0F, 0x81, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xE0, 0x1F, 0x3E,
  0x01, 0xF7, 0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF0, 0x0F, 0x83, 0xC0, 0x3E,
  0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x3F, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0x81, 0xF8, 0x3E, 0x03,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0x7C, 0x7C, 0x01, 0xF1,
  0xF0, 0x0F, 0xC7, 0xC0, 0x3E, 0x1F, 0x03, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xC0, 0xF8, 0x7C,
  0x07, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xFC, 0x1F,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F,
  0x81, 0xF8, 0x3E, 0x03, 0xE0, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00,
  0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8,
  0xF8, 0x03, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0x7C, 0x7C, 0x03, 0xE1, 0xF0, 0x0F,
  0x87, 0xC0, 0x7C, 0x1F, 0x1F, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF1, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xE7, 0xC0,
  0x1F, 0x3E, 0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0xFF, 0xCF, 0x87, 0xFC, 0x7C, 0x7F,
  0xE3, 0xE3, 0xFF, 0x1F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xFC, 0x1F, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x78, 0x3E,
  0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03,
  0xE1, 0xF0, 0x0F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFF, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0,
  0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E,
  0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0x80, 0x7C, 0x3E,
  0x01, 0xF0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x02, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF8, 0x3F, 0x07,
  0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xC0, 0x3F, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07,
  0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x3C, 0x0F,
  0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xEE, 0x0F, 0xF1, 0xFE, 0x0F, 0xF1,
  0xDE, 0x0F, 0x71, 0xDE, 0x0F, 0x73, 0x9E, 0x1F, 0x73, 0xBC, 0x1E, 0x77,
  0xBC, 0x1E, 0x77, 0x3C, 0x1E, 0x7F, 0x3C, 0x1E, 0x7E, 0x7C, 0x1E, 0x3E,
  0x7C, 0x3E, 0x3C, 0x7C, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x3E, 0x00,
  0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF0, 0x7C, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0x0F, 0xE0, 0x3C, 0x3F, 0x80, 0xF0, 0xFE, 0x07,
  0xC3, 0xF8, 0x1F, 0x0F, 0xE0, 0x7C, 0x3F, 0xC1, 0xE1, 0xFF, 0x07, 0x87,
  0xFC, 0x1E, 0x1E, 0xF0, 0x78, 0x79, 0xC3, 0xE1, 0xE7, 0x8F, 0x87, 0x9E,
  0x3E, 0x1E, 0x78, 0xF0, 0xF9, 0xE3, 0xC3, 0xE7, 0x8F, 0x0F, 0x8F, 0x7C,
  0x3C, 0x3D, 0xF0, 0xF0, 0xF7, 0xC3, 0xC3, 0xDE, 0x1F, 0x0F, 0x78, 0x7C,
  0x1D, 0xE1, 0xF0, 0x7F, 0x87, 0x81, 0xFE, 0x1E, 0x07, 0xF8, 0x78, 0x1F,
  0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFE, 0xFF, 0x0F, 0xC0,
  0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F,
  0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1E, 0x1E, 0x01, 0xF1, 0xF0, 0x0F,
  0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0,
  0x07, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF0,
  0xFC, 0x1F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07,
  0xC1, 0xF0, 0x7F, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFE, 0x7F,
  0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0,
  0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xC0, 0x1F, 0x3E, 0x00, 0xF1,
  0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1E, 0x00,
  0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x01, 0xF8, 0xFC, 0x1F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0x80, 0xFC,
  0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C,
  0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xF8, 0x7C, 0x03,
  0xE1, 0xF0, 0x0F, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0x80, 0x7E,
  0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xC0,
  0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7E, 0x07, 0xE1,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80,
  0x78, 0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F,
  0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F,
  0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0,
  0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x83, 0xF0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x7C, 0xF0, 0x07, 0xC7, 0x80, 0x3E,
  0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0x83, 0xE0,
  0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x00,
  0xF0, 0xF8, 0x07, 0x87, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0xBE,
  0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x3E, 0x1F, 0x78, 0x3E, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x7C,
  0x3E, 0x78, 0x7C, 0x3C, 0x78, 0x6C, 0x3C, 0x78, 0xEC, 0x3C, 0x78, 0xEC,
  0x78, 0x78, 0xEC, 0x78, 0x78, 0xCC, 0x78, 0x79, 0xDC, 0x78, 0x79, 0xDC,
  0xF0, 0x79, 0xDC, 0xF0, 0x79, 0x9C, 0xF0, 0x73, 0x9C, 0xF0, 0x73, 0x9D,
  0xE0, 0xF3, 0x1D, 0xE0, 0xF7, 0x1D, 0xE0, 0xF7, 0x1D, 0xE0, 0xF7, 0x1F,
  0xC0, 0xF6, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1B, 0x80, 0xFE, 0x1B,
  0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xF8, 0x1F,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x07,
  0xC1, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x9F, 0x80,
  0x03, 0xE7, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0x9F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE0,
  0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xCF,
  0x80, 0x3E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xDE, 0x00,
  0xF7, 0xC0, 0x78, 0xF0, 0x3E, 0x3C, 0x0F, 0x0F, 0x07, 0xC3, 0xE1, 0xE0,
  0x78, 0xF8, 0x1E, 0x7C, 0x07, 0xDE, 0x01, 0xFF, 0x80, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E,
  0x3E, 0x1F, 0x01, 0xF0, 0x00, 0x7F, 0x9F, 0x0F, 0xFD, 0xF1, 0xFF, 0xDF,
  0x1F, 0xDF, 0xE3, 0xF0, 0x7E, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xCF, 0x80,
  0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0xC1, 0xF8, 0xFF,
  0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xEF, 0x81, 0xFC, 0xF8, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x3C, 0x01, 0xE7, 0xF8, 0x1F, 0x7F, 0xE0, 0xFF, 0xFF, 0x87,
  0xF9, 0xFC, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x07,
  0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x78, 0x7C,
  0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8,
  0x7F, 0xFF, 0xC3, 0xDF, 0xFC, 0x1E, 0xFF, 0xC1, 0xF3, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xCF, 0xE3,
  0xF0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0xC1, 0xF8, 0x7F, 0xFF, 0x87, 0xFF,
  0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x07, 0xC7,
  0xC0, 0xFF, 0x3E, 0x0F, 0xFD, 0xF0, 0xFF, 0xEF, 0x87, 0xF7, 0xFC, 0x7E,
  0x0F, 0xC3, 0xE0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C,
  0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80,
  0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x83, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x0F, 0xFB, 0xE0, 0x3F, 0x9F, 0x00, 0x00, 0x7C, 0x00, 0x7F,
  0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xF0, 0x7E, 0x7C, 0x07, 0xCF, 0x80,
  0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x07,
  0xDF, 0x81, 0xF1, 0xFD, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xDF,
  0x0F, 0xFD, 0xF1, 0xFF, 0xFF, 0x1F, 0xDF, 0xE3, 0xF0, 0x7E, 0x3E, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x3C, 0x7C, 0x07, 0xCF, 0x80, 0x7C, 0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0x7F,
  0x7F, 0xC7, 0xFF, 0x78, 0x3F, 0xFF, 0x83, 0xFE, 0xF8, 0x07, 0x8F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x3C, 0x01, 0xE7, 0xF8, 0x1F, 0x7F, 0xE0, 0xFF, 0xFF, 0x87, 0xF9,
  0xFC, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xC7,
  0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x7C, 0x07,
  0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x78, 0x7C,
  0x07, 0xC3, 0xE0, 0x3E, 0x1E, 0x01, 0xF1, 0xF0, 0x0F, 0x80, 0x00, 0x03,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x87, 0xC0, 0x7E, 0x1F, 0x01, 0xF8, 0x3E, 0x03,
  0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x3F, 0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF0,
  0x07, 0x87, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xF1, 0xF8, 0x03, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF0,
  0x1F, 0x87, 0xC0, 0x1F, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F,
  0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x38, 0x78, 0x1E,
  0xF9, 0xF8, 0x7B, 0xF7, 0xF0, 0xFF, 0xFF, 0xE1, 0xF1, 0xE3, 0xC3, 0xC3,
  0x87, 0x87, 0x87, 0x0F, 0x0F, 0x0E, 0x1E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78,
  0xF8, 0xF0, 0xF1, 0xF1, 0xE1, 0xC3, 0xC3, 0xC3, 0x87, 0x87, 0x87, 0x0F,
  0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0xF8, 0xF0, 0xE1, 0xE1,
  0xE1, 0xC3, 0xC3, 0xC3, 0x87, 0x87, 0x8F, 0x0F, 0x1F, 0x1E, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x79, 0xFE, 0x07, 0xDF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFE,
  0x7F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3E, 0x01, 0xF1,
  0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xC3, 0xE0, 0x3E, 0x1F, 0x01,
  0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1E, 0x1F,
  0x01, 0xF0, 0xF8, 0x0F, 0x87, 0x80, 0x7C, 0x7C, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFD, 0xFE, 0x7E, 0x07,
  0xCF, 0x80, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F,
  0xBE, 0x01, 0xF7, 0x80, 0x3D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E,
  0xF8, 0x0F, 0x9F, 0x83, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x7F, 0x80, 0xFB, 0xFF, 0x03,
  0xFF, 0xFE, 0x0F, 0xF3, 0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0,
  0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E,
  0x1F, 0x00, 0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3F,
  0x03, 0xF0, 0xFC, 0x1F, 0x83, 0xFF, 0xFE, 0x0F, 0x7F, 0xF0, 0x7D, 0xFF,
  0x81, 0xF3, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x7F, 0x9F, 0x0F, 0xFD, 0xF1, 0xFF, 0xDF, 0x3F, 0xDF, 0xE3,
  0xF0, 0x7E, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0x78, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07,
  0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0xC1, 0xF8, 0xFF, 0xFF, 0x87, 0xFF,
  0xF8, 0x3F, 0xEF, 0x81, 0xFC, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0xF9, 0xFE, 0x07, 0xFF, 0xF8, 0x3D, 0xFF, 0xE1, 0xFC,
  0x7F, 0x0F, 0x81, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1,
  0xF0, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xF8, 0x3F, 0x0F,
  0x80, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E,
  0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7,
  0xC0, 0x3E, 0x7C, 0x03, 0xC7, 0xC0, 0x7C, 0x78, 0x07, 0xCF, 0x80, 0x7C,
  0xF8, 0x07, 0xCF, 0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xFF, 0xF0, 0x7F, 0xFE,
  0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xF8, 0x01, 0xF7, 0x80, 0x3F, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0x83,
  0xC0, 0xF8, 0x3C, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0,
  0x3E, 0x7C, 0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xEF, 0x80, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF0,
  0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x0F, 0x87, 0xBC, 0x3E, 0x1E, 0xF0, 0xD8,
  0x7B, 0xC3, 0x61, 0xCF, 0x1D, 0x8F, 0x3C, 0x66, 0x3C, 0xF1, 0x98, 0xE3,
  0xCE, 0x67, 0x8F, 0x39, 0x9E, 0x3C, 0xC6, 0x78, 0xF7, 0x1B, 0xC3, 0xDC,
  0x6F, 0x0F, 0x61, 0xBC, 0x3F, 0x86, 0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xC0, 0xFC, 0x1F, 0x00, 0x0F, 0x80, 0x7E,
  0x0F, 0x81, 0xF8, 0x1F, 0x07, 0xE0, 0x1F, 0x1F, 0x80, 0x3E, 0x3E, 0x00,
  0x3E, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xE0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x1F, 0x87, 0xC0, 0x3E, 0x0F,
  0x80, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x01,
  0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xC0,
  0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0x7C,
  0x07, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0xC0, 0xFC, 0xFC, 0x1F, 0xC7,
  0xFF, 0x78, 0x7F, 0xF7, 0x83, 0xFE, 0xF8, 0x1F, 0xCF, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0xF9, 0xFF, 0x07, 0x9F, 0xFC, 0x3C, 0xFF, 0xE1, 0xEF, 0x8F, 0x9F,
  0x78, 0x7F, 0xF3, 0xC1, 0xFF, 0x9E, 0x07, 0xF8, 0x00, 0x0F, 0x00,
};

const GFXglyph JetBrainsMono_BoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 10, 28, 23, 7, -28 },
  { 36, 15, 11, 23, 6, -28 },
  { 57, 24, 28, 23, 0, -28 },
  { 141, 22, 39, 23, 1, -34 },
  { 249, 28, 29, 23, -2, -29 },
  { 351, 23, 29, 23, 0, -29 },
  { 435, 6, 11, 23, 11, -28 },
  { 444, 16, 38, 23, 6, -33 },
  { 520, 17, 38, 23, 2, -33 },
  { 601, 21, 21, 23, 2, -24 },
  { 657, 20, 18, 23, 2, -22 },
  { 702, 11, 12, 23, 3, -6 },
  { 719, 14, 4, 23, 5, -15 },
  { 726, 7, 7, 23, 7, -7 },
  { 733, 24, 36, 23, 0, -32 },
  { 841, 21, 29, 23, 2, -29 },
  { 918, 18, 28, 23, 2, -28 },
  { 981, 21, 29, 23, 1, -29 },
  { 1058, 21, 28, 23, 1, -28 },
  { 1132, 20, 28, 23, 2, -28 },
  { 1202, 20, 28, 23, 2, -28 },
  { 1272, 20, 28, 23, 1, -28 },
  { 1342, 20, 28, 23, 4, -28 },
  { 1412, 21, 29, 23, 1, -29 },
  { 1489, 20, 29, 23, 3, -29 },
  { 1562, 10, 22, 23, 7, -22 },
  { 1590, 14, 28, 23, 3, -22 },
  { 1639, 19, 22, 23, 3, -24 },
  { 1692, 20, 14, 23, 2, -20 },
  { 1727, 19, 22, 23, 2, -24 },
  { 1780, 17, 28, 23, 5, -28 },
  { 1840, 24, 36, 23, 0, -29 },
  { 1948, 20, 28, 23, 0, -28 },
  { 2018, 22, 28, 23, 1, -28 },
  { 2095, 21, 29, 23, 2, -29 },
  { 2172, 22, 28, 23, 1, -28 },
  { 2249, 21, 28, 23, 2, -28 },
  { 2323, 23, 28, 23, 1, -28 },
  { 2404, 21, 29, 23, 2, -29 },
  { 2481, 22, 28, 23, 1, -28 },
  { 2558, 21, 28, 23, 2, -28 },
  { 2632, 23, 28, 23, 0, -28 },
  { 2713, 24, 28, 23, 1, -28 },
  { 2797, 18, 28, 23, 2, -28 },
  { 2860, 24, 28, 23, 0, -28 },
  { 2944, 22, 28, 23, 1, -28 },
  { 3021, 21, 29, 23, 2, -29 },
  { 3098, 23, 28, 23, 1, -28 },
  { 3179, 21, 36, 23, 2, -29 },
  { 3274, 22, 28, 23, 1, -28 },
  { 3351, 22, 29, 23, 1, -29 },
  { 3431, 20, 28, 23, 4, -28 },
  { 3501, 21, 28, 23, 2, -28 },
  { 3575, 21, 28, 23, 4, -28 },
  { 3649, 24, 28, 23, 2, -28 },
  { 3733, 26, 28, 23, -1, -28 },
  { 3824, 21, 28, 23, 4, -28 },
  { 3898, 22, 28, 23, 1, -28 },
  { 3975, 17, 36, 23, 5, -32 },
  { 4052, 13, 36, 23, 6, -32 },
  { 4111, 17, 36, 23, 3, -32 },
  { 4188, 18, 15, 23, 3, -28 },
  { 4222, 19, 4, 23, 0, 1 },
  { 4232, 8, 6, 23, 10, -31 },
  { 4238, 20, 22, 23, 2, -22 },
  { 4293, 21, 28, 23, 1, -28 },
  { 4367, 20, 22, 23, 2, -22 },
  { 4422, 21, 28, 23, 2, -28 },
  { 4496, 19, 22, 23, 2, -22 },
  { 4549, 26, 35, 23, -2, -28 },
  { 4663, 20, 29, 23, 2, -22 },
  { 4736, 21, 28, 23, 1, -28 },
  { 4810, 20, 31, 23, 1, -31 },
  { 4888, 21, 38, 23, 0, -31 },
  { 4988, 23, 28, 23, 1, -28 },
  { 5069, 18, 28, 23, 3, -28 },
  { 5132, 23, 22, 23, 0, -22 },
  { 5196, 21, 22, 23, 1, -22 },
  { 5254, 19, 22, 23, 2, -22 },
  { 5307, 22, 29, 23, 0, -22 },
  { 5387, 20, 29, 23, 2, -22 },
  { 5460, 21, 22, 23, 2, -22 },
  { 5518, 21, 22, 23, 1, -22 },
  { 5576, 19, 27, 23, 3, -27 },
  { 5641, 20, 21, 23, 2, -21 },
  { 5694, 20, 21, 23, 3, -21 },
  { 5747, 22, 21, 23, 2, -21 },
  { 5805, 23, 21, 23, 0, -21 },
  { 5866, 20, 28, 23, 2, -21 },
  { 5936, 21, 21, 23, 1, -21 },
  { 5992, 21, 36, 23, 3, -32 },
  { 6087, 11, 36, 23, 7, -32 },
  { 6137, 20, 36, 23, 1, -32 },
  { 6227, 21, 9, 23, 2, -18 },
};

const GFXfont JetBrainsMono_BoldItalic39pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic39pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _JETBRAINSMONO_BOLDITALIC39PT7B_H_
