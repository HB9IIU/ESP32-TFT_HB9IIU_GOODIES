#ifndef _JETBRAINSMONO_BOLDITALIC15PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x76, 0x66, 0x66, 0x44, 0x0C, 0xC0, 0x6D, 0xB4, 0xD3, 0xC8, 0x0D,
  0x84, 0x86, 0x4F, 0xF1, 0x21, 0x90, 0x99, 0xFE, 0x64, 0x26, 0x32, 0x00,
  0x04, 0x02, 0x07, 0xC7, 0xE3, 0x59, 0xA0, 0xE0, 0x7C, 0x0F, 0x05, 0x9A,
  0xCF, 0xC3, 0xC0, 0x80, 0x40, 0x1C, 0x64, 0x98, 0x92, 0x12, 0x83, 0xA0,
  0x08, 0x03, 0xE0, 0xF6, 0x36, 0xC4, 0x93, 0x1E, 0x00, 0x1E, 0x1D, 0x8C,
  0xC6, 0x03, 0x03, 0xC5, 0xAC, 0x9C, 0xC6, 0x77, 0x1E, 0xC0, 0x7B, 0x6C,
  0x02, 0x18, 0x61, 0x86, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x03, 0x07, 0x07,
  0x04, 0x00, 0x20, 0xC1, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x73,
  0x88, 0x00, 0x18, 0x18, 0xD3, 0xFE, 0x18, 0x6C, 0xCC, 0x48, 0x18, 0x30,
  0x67, 0xFF, 0xE6, 0x0C, 0x18, 0x3B, 0x99, 0x80, 0xFF, 0xC0, 0x5B, 0x00,
  0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C,
  0x0C, 0x06, 0x06, 0x00, 0x3E, 0x7E, 0x63, 0x42, 0xD2, 0xDE, 0xD6, 0xC6,
  0xC6, 0xFC, 0x78, 0x1C, 0x79, 0xB4, 0x61, 0x83, 0x06, 0x0C, 0x19, 0xFF,
  0xF8, 0x3E, 0x7E, 0x63, 0x82, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFE, 0xFC,
  0x7F, 0x7E, 0x0C, 0x18, 0x1C, 0x3E, 0x06, 0x06, 0xC6, 0xCC, 0x78, 0x06,
  0x18, 0x61, 0x87, 0x0C, 0xF1, 0xFF, 0xFC, 0x18, 0x30, 0x7F, 0x7E, 0x60,
  0x60, 0x5C, 0xE6, 0x06, 0x06, 0xC6, 0xFC, 0x78, 0x0E, 0x30, 0x61, 0x86,
  0xDF, 0xF1, 0xE3, 0xC7, 0xD9, 0xE0, 0x7F, 0x7F, 0x43, 0x86, 0x0C, 0x0C,
  0x18, 0x18, 0x30, 0x30, 0x60, 0x3E, 0x76, 0x63, 0x66, 0x7E, 0x3C, 0x6E,
  0xC6, 0xC6, 0xEC, 0x78, 0x3E, 0x76, 0x63, 0xC3, 0xC6, 0x7E, 0x7C, 0x0C,
  0x18, 0x30, 0x60, 0x6C, 0x00, 0x36, 0x18, 0xC0, 0x00, 0x04, 0xCE, 0x66,
  0x00, 0x03, 0x0E, 0x3C, 0xE0, 0xE0, 0x78, 0x1E, 0x04, 0x7E, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x40, 0xE0, 0xF0, 0x70, 0xE7, 0xB8, 0x40, 0x79, 0xF0,
  0xC3, 0x1D, 0xE6, 0x10, 0x03, 0x0C, 0x00, 0x1F, 0x18, 0xD8, 0x2C, 0x14,
  0xEA, 0x4D, 0x67, 0xB2, 0xD9, 0x6F, 0xB0, 0x18, 0x07, 0x81, 0xC0, 0x0E,
  0x0E, 0x1E, 0x1E, 0x12, 0x32, 0x32, 0x7E, 0x63, 0xC3, 0xC3, 0x3F, 0x1F,
  0x8C, 0x64, 0x22, 0x73, 0xF1, 0x8C, 0xC6, 0x63, 0x3F, 0x3F, 0x00, 0x3E,
  0x7E, 0x63, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC6, 0xFC, 0x78, 0x3E, 0x1F,
  0x8C, 0x66, 0x36, 0x13, 0x19, 0x8C, 0xC6, 0x63, 0x3F, 0x3F, 0x00, 0x7F,
  0x7F, 0x60, 0x60, 0x60, 0x7E, 0xC0, 0xC0, 0xC0, 0xFC, 0xFC, 0x7F, 0x7F,
  0x60, 0x60, 0x40, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3E, 0x7E, 0x63,
  0x40, 0xC0, 0xDE, 0xDE, 0xC6, 0xC6, 0xFC, 0x78, 0x31, 0x98, 0xCC, 0x66,
  0x63, 0xF3, 0xF9, 0x8C, 0xC6, 0x63, 0x31, 0x31, 0x80, 0x7F, 0x7E, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0xFC, 0xFC, 0x0F, 0x87, 0xC0, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0xC6, 0x77, 0x1F, 0x00, 0x31, 0xCC, 0x63,
  0x30, 0xD8, 0x3E, 0x1F, 0x06, 0x61, 0x98, 0x66, 0x19, 0x8C, 0x30, 0x30,
  0xC1, 0x83, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0xFF, 0xF0, 0x31, 0x99, 0xCC,
  0xEF, 0xF6, 0xDB, 0x69, 0x8C, 0x86, 0x43, 0x61, 0xB0, 0xC0, 0x39, 0x9C,
  0xCE, 0x65, 0x26, 0x93, 0x59, 0xBC, 0xDE, 0x67, 0x23, 0xB1, 0x80, 0x3E,
  0x7E, 0x63, 0x42, 0xC6, 0xC6, 0xC6, 0xC6, 0xC6, 0xFC, 0x78, 0x3F, 0x1F,
  0xCC, 0x66, 0x32, 0x1B, 0xF9, 0xF0, 0xC0, 0x60, 0x30, 0x30, 0x00, 0x3E,
  0x7E, 0x63, 0x42, 0xC6, 0xC6, 0xC6, 0xC6, 0xC6, 0xFC, 0x78, 0x18, 0x08,
  0x0C, 0x3F, 0x1F, 0xCC, 0x66, 0x32, 0x33, 0xF9, 0xF0, 0xCC, 0x66, 0x33,
  0x30, 0xC0, 0x1F, 0x1F, 0xCC, 0x66, 0x03, 0x80, 0xF0, 0x1C, 0x06, 0x63,
  0x3F, 0x0F, 0x00, 0x7F, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30,
  0x30, 0x30, 0x63, 0x63, 0x63, 0x62, 0xC6, 0xC6, 0xC6, 0xC6, 0xC6, 0xFC,
  0x78, 0xC7, 0xC6, 0xC6, 0xCC, 0xCC, 0xC8, 0xD8, 0xD8, 0xF0, 0xF0, 0x60,
  0xC9, 0xEC, 0xB6, 0x5B, 0x6D, 0xB7, 0x52, 0xA9, 0x5C, 0xCE, 0x66, 0x33,
  0x00, 0x31, 0x99, 0x86, 0xC3, 0xC1, 0xC0, 0x60, 0x70, 0x6C, 0x76, 0x33,
  0x30, 0xC0, 0xC3, 0xB1, 0x99, 0x8C, 0xC3, 0xC1, 0xC0, 0xE0, 0x60, 0x30,
  0x18, 0x0C, 0x00, 0x7F, 0x7E, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC0,
  0xFC, 0xFC, 0x3C, 0xC2, 0x18, 0x61, 0x86, 0x18, 0x61, 0x0C, 0x30, 0xF3,
  0xC0, 0xC3, 0x18, 0xC6, 0x10, 0xC6, 0x31, 0x84, 0x31, 0x8C, 0x3E, 0x18,
  0x30, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x60, 0xCF, 0x1E, 0x00, 0x1C,
  0x38, 0xD1, 0x26, 0x78, 0xC0, 0xFF, 0xFC, 0xCC, 0x7B, 0x66, 0xC6, 0xC6,
  0xC6, 0xC6, 0xFC, 0xFC, 0x30, 0x30, 0x30, 0x3F, 0x33, 0x63, 0x63, 0x63,
  0x63, 0x7E, 0xDC, 0x3E, 0xCF, 0x1E, 0x0C, 0x18, 0xFF, 0x3C, 0x03, 0x03,
  0x03, 0x7A, 0x66, 0xC6, 0xC6, 0xC6, 0xC6, 0xFC, 0xFC, 0x3E, 0xCF, 0x1F,
  0xFC, 0x18, 0x73, 0x3C, 0x03, 0xC1, 0xF0, 0x60, 0x10, 0x3F, 0xC3, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0xF8, 0x38, 0x00, 0x7B, 0x66,
  0xC6, 0xC6, 0xC6, 0xCE, 0xF4, 0x2C, 0x0C, 0xFC, 0xF0, 0x30, 0x30, 0x30,
  0x3F, 0x33, 0x63, 0x63, 0x63, 0x63, 0x62, 0xC6, 0x06, 0x06, 0x00, 0x00,
  0x3C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x7F, 0xFF, 0x03, 0x03, 0x00, 0x01,
  0x3E, 0x06, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0xF8, 0xF0, 0x60,
  0x60, 0x60, 0x67, 0x46, 0xCC, 0xF8, 0xF8, 0xCC, 0xCC, 0x86, 0xF9, 0xF0,
  0x60, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7C, 0xF8, 0x7F, 0xB6, 0xDA, 0x49,
  0x24, 0xB2, 0x5B, 0x6D, 0xB6, 0x3F, 0x33, 0x63, 0x63, 0x63, 0x63, 0x62,
  0xC6, 0x7E, 0xCF, 0x1E, 0x3C, 0x78, 0xFF, 0x3C, 0x3F, 0x33, 0x63, 0x63,
  0x63, 0x63, 0x7E, 0x5C, 0xC0, 0xC0, 0xC0, 0x7A, 0xCF, 0x1E, 0x3C, 0x78,
  0xFF, 0x7E, 0x0C, 0x18, 0x30, 0x7E, 0x67, 0x63, 0xC4, 0xC0, 0xC0, 0xC0,
  0xC0, 0x7E, 0xCF, 0x03, 0xE1, 0xE0, 0xF3, 0x7E, 0x18, 0x18, 0x10, 0xFF,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x3C, 0x3C, 0x63, 0xC6, 0xC6, 0xC6, 0xC6,
  0xC6, 0xFC, 0x78, 0xC3, 0x46, 0x66, 0x6C, 0x6C, 0x78, 0x78, 0x30, 0x99,
  0x9B, 0x9A, 0xAA, 0xAE, 0xAE, 0xCC, 0xCC, 0x73, 0x9B, 0x07, 0x83, 0x81,
  0xC1, 0xA1, 0x99, 0x8E, 0x67, 0x8F, 0x1E, 0x3C, 0x79, 0xFD, 0x06, 0x0D,
  0xFB, 0xC0, 0x7E, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0x7E, 0x07, 0x0C, 0x0C,
  0x0C, 0x0C, 0x18, 0xF0, 0x38, 0x18, 0x18, 0x18, 0x38, 0x1C, 0x0C, 0x32,
  0x66, 0x66, 0x64, 0xCC, 0xCC, 0xCC, 0x3C, 0x0C, 0x0C, 0x0C, 0x18, 0x1C,
  0x0F, 0x1C, 0x18, 0x18, 0x10, 0x30, 0xF0, 0xC0, 0x73, 0xFA, 0x9E,
};

const GFXglyph JetBrainsMono_BoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 11, 9, 3, -11 },
  { 7, 6, 5, 9, 2, -11 },
  { 11, 9, 11, 9, 0, -11 },
  { 24, 9, 15, 9, 0, -13 },
  { 41, 11, 11, 9, -1, -11 },
  { 57, 9, 11, 9, 0, -11 },
  { 70, 3, 5, 9, 4, -11 },
  { 72, 7, 15, 9, 2, -13 },
  { 86, 6, 15, 9, 1, -13 },
  { 98, 8, 8, 9, 1, -9 },
  { 106, 7, 8, 9, 1, -9 },
  { 113, 5, 4, 9, 1, -2 },
  { 116, 5, 2, 9, 2, -6 },
  { 118, 3, 3, 9, 3, -3 },
  { 120, 9, 14, 9, 0, -12 },
  { 136, 8, 11, 9, 1, -11 },
  { 147, 7, 11, 9, 1, -11 },
  { 157, 8, 11, 9, 1, -11 },
  { 168, 8, 11, 9, 1, -11 },
  { 179, 7, 11, 9, 1, -11 },
  { 189, 8, 11, 9, 1, -11 },
  { 200, 7, 11, 9, 1, -11 },
  { 210, 8, 11, 9, 1, -11 },
  { 221, 8, 11, 9, 1, -11 },
  { 232, 8, 11, 9, 1, -11 },
  { 243, 3, 8, 9, 3, -8 },
  { 246, 5, 10, 9, 1, -8 },
  { 253, 8, 8, 9, 1, -9 },
  { 261, 7, 6, 9, 1, -8 },
  { 267, 7, 8, 9, 1, -9 },
  { 274, 6, 11, 9, 2, -11 },
  { 283, 9, 14, 9, 0, -11 },
  { 299, 8, 11, 9, 0, -11 },
  { 310, 9, 11, 9, 0, -11 },
  { 323, 8, 11, 9, 1, -11 },
  { 334, 9, 11, 9, 0, -11 },
  { 347, 8, 11, 9, 1, -11 },
  { 358, 8, 11, 9, 1, -11 },
  { 369, 8, 11, 9, 1, -11 },
  { 380, 9, 11, 9, 0, -11 },
  { 393, 8, 11, 9, 1, -11 },
  { 404, 9, 11, 9, 0, -11 },
  { 417, 10, 11, 9, 0, -11 },
  { 431, 7, 11, 9, 1, -11 },
  { 441, 9, 11, 9, 0, -11 },
  { 454, 9, 11, 9, 0, -11 },
  { 467, 8, 11, 9, 1, -11 },
  { 478, 9, 11, 9, 0, -11 },
  { 491, 8, 14, 9, 1, -11 },
  { 505, 9, 11, 9, 0, -11 },
  { 518, 9, 11, 9, 0, -11 },
  { 531, 8, 11, 9, 1, -11 },
  { 542, 8, 11, 9, 1, -11 },
  { 553, 8, 11, 9, 2, -11 },
  { 564, 9, 11, 9, 1, -11 },
  { 577, 9, 11, 9, 0, -11 },
  { 590, 9, 11, 9, 1, -11 },
  { 603, 8, 11, 9, 1, -11 },
  { 614, 6, 14, 9, 2, -12 },
  { 625, 5, 14, 9, 2, -12 },
  { 634, 7, 14, 9, 1, -12 },
  { 647, 7, 6, 9, 1, -11 },
  { 653, 7, 2, 9, 0, 0 },
  { 655, 3, 2, 9, 4, -12 },
  { 656, 8, 8, 9, 1, -8 },
  { 664, 8, 11, 9, 0, -11 },
  { 675, 7, 8, 9, 1, -8 },
  { 682, 8, 11, 9, 1, -11 },
  { 693, 7, 8, 9, 1, -8 },
  { 700, 10, 14, 9, -1, -11 },
  { 718, 8, 11, 9, 1, -8 },
  { 729, 8, 11, 9, 0, -11 },
  { 740, 8, 12, 9, 0, -12 },
  { 752, 8, 15, 9, 0, -12 },
  { 767, 8, 11, 9, 1, -11 },
  { 778, 7, 11, 9, 1, -11 },
  { 788, 9, 8, 9, 0, -8 },
  { 797, 8, 8, 9, 0, -8 },
  { 805, 7, 8, 9, 1, -8 },
  { 812, 8, 11, 9, 0, -8 },
  { 823, 7, 11, 9, 1, -8 },
  { 833, 8, 8, 9, 1, -8 },
  { 841, 7, 8, 9, 1, -8 },
  { 848, 8, 11, 9, 1, -11 },
  { 859, 8, 8, 9, 1, -8 },
  { 867, 8, 8, 9, 1, -8 },
  { 875, 8, 8, 9, 1, -8 },
  { 883, 9, 8, 9, 0, -8 },
  { 892, 7, 11, 9, 1, -8 },
  { 902, 7, 8, 9, 1, -8 },
  { 909, 8, 14, 9, 1, -12 },
  { 923, 4, 14, 9, 3, -12 },
  { 930, 8, 14, 9, 0, -12 },
  { 944, 8, 3, 9, 1, -7 },
};

const GFXfont JetBrainsMono_BoldItalic15pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic15pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _JETBRAINSMONO_BOLDITALIC15PT7B_H_
