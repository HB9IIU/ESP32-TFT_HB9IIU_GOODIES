#ifndef _JETBRAINSMONO_BOLDITALIC31PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF0,
  0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x9E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E,
  0xF1, 0xCE, 0x1C, 0x00, 0x60, 0xE0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0xE0,
  0xC0, 0x1C, 0x38, 0x03, 0x87, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE0, 0xE0, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0xE0, 0xC0, 0x1C, 0x38,
  0x03, 0x87, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x03, 0x87, 0x00, 0xE0, 0xC0,
  0x1C, 0x38, 0x03, 0x87, 0x00, 0xE0, 0xC0, 0x1C, 0x38, 0x00, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x3F,
  0xFC, 0x1F, 0xFF, 0x1E, 0x67, 0x8F, 0x33, 0xCF, 0x18, 0x07, 0x98, 0x03,
  0xEC, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0x00, 0x67, 0x80, 0x33, 0xE0, 0x18, 0xE7, 0x8C, 0xF3, 0xE6, 0x79, 0xF2,
  0x78, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xF8, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x1C, 0x3F, 0x80, 0xE0, 0xFF, 0x07,
  0x07, 0x1C, 0x38, 0x1C, 0x71, 0xC0, 0x71, 0xC7, 0x01, 0x87, 0x38, 0x06,
  0x39, 0xC0, 0x1F, 0xEE, 0x00, 0x7F, 0x70, 0x00, 0x23, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xBF, 0x00, 0x1D, 0xFC, 0x00, 0xEF, 0x38,
  0x07, 0x38, 0xE0, 0x38, 0xC3, 0x81, 0xC3, 0x0E, 0x06, 0x1C, 0x30, 0x38,
  0x7B, 0xC1, 0xC0, 0xFE, 0x0E, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x7F,
  0x80, 0x3F, 0xF0, 0x1E, 0x3C, 0x07, 0x07, 0x03, 0xC1, 0xC0, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3D,
  0xE3, 0xCE, 0x79, 0xE7, 0x8F, 0xF1, 0xE3, 0xFC, 0x78, 0x7E, 0x1E, 0x1F,
  0x07, 0x03, 0xC1, 0xE1, 0xF0, 0x7F, 0xFE, 0x1F, 0xFB, 0xC3, 0xF8, 0xF0,
  0x7B, 0xDE, 0xF7, 0xBD, 0xCE, 0xF7, 0x80, 0x00, 0x0C, 0x01, 0xF0, 0x0F,
  0x80, 0x7E, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xE0, 0x03, 0x80, 0x02, 0x00,
  0x0C, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF8, 0x3F, 0x01, 0xF0, 0x0E, 0x00, 0x40,
  0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x02, 0x0E, 0x1B,
  0xC6, 0x3D, 0xFB, 0x7F, 0xFF, 0xFF, 0x0F, 0xF8, 0x00, 0xE0, 0x01, 0xD8,
  0x01, 0xCE, 0x01, 0xE7, 0x81, 0xE3, 0xE1, 0xF0, 0xF0, 0x30, 0x60, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x1F, 0x1F, 0x1E, 0x3E, 0x3C, 0x78, 0x78, 0x70,
  0xF0, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7D, 0xFF, 0xFF, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x01,
  0xFF, 0x03, 0xFF, 0xC1, 0xF3, 0xE1, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x1E,
  0x78, 0x0F, 0x3C, 0x07, 0x1E, 0x03, 0x8E, 0x73, 0xC7, 0x3D, 0xE7, 0x9E,
  0xF3, 0xC6, 0x79, 0xE0, 0x38, 0xF0, 0x1C, 0x70, 0x1E, 0x38, 0x0F, 0x1E,
  0x07, 0x8F, 0x8F, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xF7, 0x83, 0xCF, 0x06, 0x1E, 0x08,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xE1, 0xE0, 0xF9, 0xE0, 0x3C, 0xF0, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xFF,
  0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x8F,
  0x0F, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x1F, 0x0F, 0x3E, 0x0E, 0x3C, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0xFF, 0xFC, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xE1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0xF8, 0x0E, 0xFE, 0x0F, 0xFF, 0x87, 0xE7, 0xC3, 0xC1, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0x8F,
  0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x78, 0x1F, 0xFC, 0x3F, 0xFE, 0x7E, 0x3F, 0x78, 0x1F, 0x78,
  0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF8, 0x1E, 0x78, 0x3C, 0x7F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xF3, 0xE1,
  0xE0, 0xF8, 0xF0, 0x3C, 0x70, 0x1C, 0x3C, 0x1E, 0x1E, 0x1F, 0x0F, 0x9F,
  0x03, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xC1, 0xF1, 0xF0, 0xF0, 0x78, 0xF0,
  0x3C, 0x70, 0x1E, 0x78, 0x0F, 0x3E, 0x07, 0x8F, 0x07, 0x87, 0xFF, 0xC1,
  0xFF, 0xC0, 0x7F, 0x80, 0x01, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0x3F,
  0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1F,
  0x78, 0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x1F, 0x1F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x7C, 0xFC, 0xFC, 0x78, 0x07, 0xC1, 0xF0, 0xFC, 0x3F,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x87,
  0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x38, 0x00, 0x00,
  0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7E, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x08, 0x3F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x10, 0x00, 0x18, 0x00, 0x1E, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x3E, 0x00, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0x7E, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0x3E, 0x01, 0xFF, 0x0F, 0xFC, 0xFF, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x87, 0xF8, 0x7F, 0xC3,
  0xF8, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F,
  0xFF, 0x07, 0xC1, 0xE0, 0xE0, 0x1E, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xC0,
  0x07, 0x38, 0x3C, 0xE7, 0x0F, 0xD8, 0xE3, 0xCF, 0x3C, 0x70, 0xE7, 0x9E,
  0x1C, 0xE3, 0x83, 0x9C, 0x70, 0xF3, 0x8E, 0x1E, 0x71, 0xC3, 0x8E, 0x38,
  0x73, 0xC7, 0x1E, 0x70, 0xFF, 0xCE, 0x0F, 0xB9, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xDE, 0x03, 0xDE, 0x03, 0xDE, 0x03, 0x9E, 0x07, 0x9E, 0x07,
  0x9E, 0x0F, 0x0E, 0x0F, 0x0E, 0x0E, 0x0E, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F,
  0xFF, 0x3F, 0xFF, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0x0F, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF1, 0xE0, 0xF8,
  0xF0, 0x3C, 0x70, 0x1E, 0x78, 0x0E, 0x3C, 0x0F, 0x1E, 0x1F, 0x0F, 0xFF,
  0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xC0, 0xF1, 0xE0, 0x3C, 0xF0, 0x1E, 0x78,
  0x0F, 0x3C, 0x0F, 0x1E, 0x07, 0x8E, 0x0F, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3,
  0xFF, 0x80, 0x01, 0xF8, 0x07, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x3C, 0x0F,
  0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xE0, 0xF8, 0xF0,
  0x3C, 0x70, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0x8F, 0x03, 0xC7,
  0x81, 0xE3, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1C, 0x78, 0x1E,
  0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFF,
  0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7F, 0xFC,
  0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0x87, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x07,
  0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x79, 0xFE, 0xF1, 0xFE, 0xF1,
  0xFE, 0xF0, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8,
  0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0, 0x0F, 0x03, 0x8F, 0x03, 0xC7,
  0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1C, 0x78, 0x1E,
  0x3C, 0x0F, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xC0,
  0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8E,
  0x03, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF0, 0x0F, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xE3, 0xFF, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x07, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF0, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x78, 0x0E, 0x1C,
  0x07, 0x87, 0x81, 0xE1, 0xF1, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE,
  0x00, 0x0E, 0x03, 0xE3, 0xC0, 0x78, 0x78, 0x1E, 0x0F, 0x07, 0xC1, 0xE0,
  0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x3C, 0x7C, 0x07, 0x8F,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xF1, 0xE0, 0x1E, 0x1E,
  0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x38, 0x1E,
  0x0F, 0x03, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0x03, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x8F, 0xC3, 0xF1, 0xD8,
  0x7C, 0x3B, 0x1F, 0x87, 0x63, 0x70, 0xEE, 0xEE, 0x1D, 0xDB, 0xC3, 0xBF,
  0x78, 0xF7, 0xEF, 0x1E, 0x79, 0xC3, 0xCF, 0x38, 0x70, 0x0F, 0x0E, 0x01,
  0xE1, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xE1, 0xE0, 0x1C, 0x3C, 0x07,
  0x87, 0x00, 0xF0, 0xE0, 0x1E, 0x3C, 0x03, 0xC0, 0x1F, 0x03, 0xC7, 0xC0,
  0xE1, 0xF8, 0x38, 0x7E, 0x0E, 0x1F, 0x87, 0x87, 0xE1, 0xE3, 0xF8, 0x78,
  0xFE, 0x1C, 0x3D, 0xC7, 0x0F, 0x71, 0xC3, 0x9C, 0xF0, 0xE7, 0x3C, 0x39,
  0xCF, 0x1E, 0x3B, 0xC7, 0x8E, 0xE1, 0xE3, 0xB8, 0x70, 0xEE, 0x1C, 0x3B,
  0x87, 0x0F, 0xE3, 0xC1, 0xF8, 0xF0, 0x7C, 0x3C, 0x1F, 0x0E, 0x07, 0xC0,
  0x01, 0xF0, 0x07, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x3C, 0x1F, 0x3C, 0x0F,
  0x78, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x7C, 0xF8, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x1E, 0x07, 0x87, 0x81, 0xF1,
  0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC1, 0xF0, 0xFF,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xE0,
  0xF8, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x1E, 0x07, 0x8F,
  0x03, 0xC7, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x38, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0x8F, 0x87, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x0F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF,
  0xF1, 0xE0, 0xF8, 0xF0, 0x3C, 0x70, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E,
  0x07, 0x8F, 0x0F, 0xC7, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0x81, 0xE3, 0xC0,
  0xF1, 0xE0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0E, 0x07, 0x8F, 0x03,
  0xC7, 0x81, 0xE3, 0xC0, 0x78, 0x00, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0xC1,
  0xFF, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0E, 0x78, 0x0F, 0x3C, 0x07, 0x9F, 0x07, 0xC7,
  0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x03, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0x78,
  0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1C, 0x3C, 0x0F,
  0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x38, 0x0F, 0x1E, 0x03, 0xC7,
  0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x83, 0xE1, 0xF1,
  0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0xF0, 0x07, 0xF8, 0x07,
  0x9C, 0x03, 0xCE, 0x01, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0,
  0x78, 0x78, 0x38, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x1E, 0x07, 0x8F, 0x01,
  0xC7, 0x00, 0xE7, 0x80, 0x73, 0xC0, 0x39, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x38, 0x70, 0xE7,
  0x0E, 0x1C, 0xE3, 0xC7, 0x9C, 0x78, 0xF7, 0x8F, 0x1C, 0xF3, 0xE3, 0x9E,
  0x6C, 0x73, 0x8D, 0x9C, 0x71, 0xB3, 0x8E, 0x66, 0x71, 0xCC, 0xCE, 0x39,
  0x9B, 0x87, 0x73, 0x70, 0xEC, 0xEE, 0x1D, 0x9D, 0xC3, 0xB3, 0x70, 0x7E,
  0x6E, 0x0F, 0x8D, 0xC1, 0xF1, 0xB8, 0x3E, 0x3E, 0x07, 0x87, 0xC0, 0xF0,
  0xF8, 0x3E, 0x1E, 0x00, 0x0F, 0x80, 0xF8, 0x3C, 0x0F, 0x81, 0xE0, 0x78,
  0x07, 0x87, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x07, 0xBC, 0x00, 0x3D,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7B, 0xC0, 0x07, 0x9E,
  0x00, 0x7C, 0xF0, 0x03, 0xC3, 0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0xF0, 0x1E,
  0x03, 0xC3, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0xF8, 0x07, 0x9E, 0x03, 0xCF,
  0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0xF0,
  0x0E, 0x70, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xE3, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x00, 0xE0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0x07, 0xFC, 0x1F, 0xE0,
  0x7F, 0x83, 0xFE, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x80, 0x00,
  0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x80, 0xE7, 0x03, 0xCE,
  0x0F, 0x1C, 0x1C, 0x3C, 0x78, 0x38, 0xE0, 0x77, 0xC0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0x8F, 0x07, 0xE7, 0x87, 0xFF, 0x87,
  0xFF, 0xC7, 0xC3, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE3, 0xE3,
  0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0xFC, 0x3D, 0xFE,
  0x3F, 0xFF, 0x3E, 0x1F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x7C, 0x7C,
  0xFF, 0xFC, 0xF7, 0xF8, 0xF3, 0xE0, 0x07, 0xF8, 0x3F, 0xF8, 0xFF, 0xF9,
  0xE1, 0xF7, 0x81, 0xEF, 0x03, 0xDC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x81, 0xEF, 0x03, 0xDF, 0x1F, 0x3F, 0xFE, 0x3F, 0xF8,
  0x3F, 0xC0, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x1F, 0x9E, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0x0F, 0x8F,
  0x03, 0xC7, 0x81, 0xE3, 0x80, 0xF3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0x8F, 0x87, 0xFF, 0xC1, 0xFF,
  0xE0, 0x7C, 0xF0, 0x07, 0xF0, 0x3F, 0xF8, 0xFF, 0xF1, 0xE1, 0xF7, 0x81,
  0xEE, 0x03, 0xDC, 0x07, 0xFF, 0xFF, 0xFF, 0xFD, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x03, 0xDE, 0x0F, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0xCF, 0x1F, 0xFE, 0x3F, 0xFE, 0x7C, 0x3E,
  0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x7C, 0xFC, 0xFC, 0xFF, 0xB8, 0x7F, 0xF8, 0x3E, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0,
  0xFC, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0xFC, 0x3D, 0xFE, 0x3F, 0xFF, 0x3E, 0x1F, 0x3C, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0x00, 0x78, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xE0,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x7C, 0x70, 0x3E, 0x3C, 0x1F, 0x0F, 0x07, 0x83,
  0xC3, 0xC0, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x78, 0xF0, 0x1E, 0x3E, 0x07, 0x87, 0x81, 0xE1, 0xF0, 0xF0, 0x3C,
  0x3C, 0x0F, 0x0F, 0x01, 0xE0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3F, 0xF1, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x1D, 0xE7, 0x87, 0xFB, 0xF1,
  0xEF, 0xFC, 0xF1, 0xCF, 0x3C, 0x63, 0xCF, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x9E, 0x39, 0xE7, 0x8C, 0x79, 0xE7, 0x1E, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xC7, 0x3C, 0xF1, 0x8F, 0x00, 0x1E, 0xFC,
  0x3D, 0xFE, 0x3F, 0xFF, 0x3E, 0x1F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F,
  0x38, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x70, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0x07, 0xF0, 0x3F, 0xF8,
  0xFF, 0xF1, 0xE1, 0xF7, 0x81, 0xEF, 0x03, 0xDC, 0x07, 0xF8, 0x0F, 0xF0,
  0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x07, 0xDF, 0x1F, 0x3F, 0xFC,
  0x3F, 0xF0, 0x3F, 0xC0, 0x0F, 0x7E, 0x0F, 0x7F, 0x87, 0xFF, 0xE3, 0xE1,
  0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x38, 0x0F, 0x3C, 0x0F, 0x1E,
  0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xF1, 0xF1, 0xF1, 0xFF, 0xF8,
  0xF7, 0xF8, 0x79, 0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0x07, 0xE7, 0x87, 0xFF, 0x87, 0xFF, 0xC7,
  0xC3, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x3C, 0x78, 0x1E,
  0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE3, 0xE3, 0xE1, 0xFF,
  0xF0, 0x7F, 0xF8, 0x1F, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x3D, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE,
  0x3E, 0x1F, 0x3C, 0x1F, 0x78, 0x0F, 0x78, 0x1F, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x3C, 0x0F,
  0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x03, 0xFE,
  0x00, 0x1E, 0x00, 0x1E, 0xF0, 0x1E, 0xF8, 0x3E, 0x7F, 0xFC, 0x7F, 0xF8,
  0x3F, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x1E, 0x07,
  0x9E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0,
  0x3C, 0xF0, 0x1C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7,
  0x83, 0xC3, 0xE3, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0xF0,
  0x1F, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0x70, 0x78, 0x70,
  0x78, 0x78, 0xF0, 0x78, 0xF0, 0x79, 0xE0, 0x79, 0xE0, 0x3B, 0xC0, 0x3B,
  0xC0, 0x3B, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0xE1, 0xC3, 0xF0,
  0xE1, 0xF8, 0xF1, 0xFC, 0x78, 0xEE, 0x3C, 0x77, 0x36, 0x3B, 0x9B, 0x39,
  0xCD, 0x9C, 0xEC, 0xCE, 0x76, 0x6E, 0x3B, 0x37, 0x1F, 0x9B, 0x8F, 0x8F,
  0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0x00, 0x1E, 0x07,
  0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x1E, 0x7C, 0x07, 0xBE, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x1F, 0x3C, 0x07, 0x8F, 0x03, 0xC1, 0xE1, 0xE0, 0x78, 0xF8, 0x0F,
  0x00, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEF, 0x03,
  0xFC, 0x07, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x83, 0xEF,
  0xFF, 0xDF, 0xF7, 0x1F, 0xDE, 0x0E, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC3, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x20, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0xFF, 0x00, 0xFE, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F,
  0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xF8, 0x00,
  0x04, 0x00, 0x0F, 0xC1, 0xCF, 0xF1, 0xEF, 0xF8, 0xE7, 0x1F, 0xF3, 0x87,
  0xFB, 0xC3, 0xF8, 0x00, 0x70,
};

const GFXglyph JetBrainsMono_BoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 8, 23, 19, 6, -23 },
  { 24, 12, 10, 19, 5, -23 },
  { 39, 19, 23, 19, 0, -23 },
  { 94, 17, 31, 19, 1, -27 },
  { 160, 22, 23, 19, -1, -23 },
  { 224, 18, 23, 19, 0, -23 },
  { 276, 5, 10, 19, 8, -23 },
  { 283, 14, 30, 19, 4, -26 },
  { 336, 13, 30, 19, 2, -26 },
  { 385, 17, 16, 19, 1, -19 },
  { 419, 15, 15, 19, 2, -18 },
  { 448, 8, 10, 19, 3, -5 },
  { 458, 11, 4, 19, 4, -12 },
  { 464, 6, 5, 19, 5, -5 },
  { 468, 19, 29, 19, 0, -26 },
  { 537, 17, 23, 19, 1, -23 },
  { 586, 15, 23, 19, 1, -23 },
  { 630, 17, 23, 19, 1, -23 },
  { 679, 17, 23, 19, 1, -23 },
  { 728, 16, 23, 19, 1, -23 },
  { 774, 17, 23, 19, 1, -23 },
  { 823, 16, 23, 19, 1, -23 },
  { 869, 16, 23, 19, 3, -23 },
  { 915, 17, 23, 19, 1, -23 },
  { 964, 16, 23, 19, 2, -23 },
  { 1010, 8, 17, 19, 5, -17 },
  { 1027, 10, 22, 19, 3, -17 },
  { 1055, 16, 17, 19, 2, -19 },
  { 1089, 15, 11, 19, 2, -16 },
  { 1110, 16, 17, 19, 1, -19 },
  { 1144, 13, 23, 19, 4, -23 },
  { 1182, 19, 29, 19, 0, -23 },
  { 1251, 16, 23, 19, 0, -23 },
  { 1297, 17, 23, 19, 1, -23 },
  { 1346, 16, 23, 19, 2, -23 },
  { 1392, 17, 23, 19, 1, -23 },
  { 1441, 18, 23, 19, 1, -23 },
  { 1493, 18, 23, 19, 1, -23 },
  { 1545, 16, 23, 19, 2, -23 },
  { 1591, 17, 23, 19, 1, -23 },
  { 1640, 17, 23, 19, 1, -23 },
  { 1689, 18, 23, 19, 0, -23 },
  { 1741, 19, 23, 19, 1, -23 },
  { 1796, 14, 23, 19, 2, -23 },
  { 1837, 19, 23, 19, 0, -23 },
  { 1892, 18, 23, 19, 1, -23 },
  { 1944, 16, 23, 19, 2, -23 },
  { 1990, 18, 23, 19, 1, -23 },
  { 2042, 17, 29, 19, 1, -23 },
  { 2104, 17, 23, 19, 1, -23 },
  { 2153, 17, 23, 19, 1, -23 },
  { 2202, 16, 23, 19, 3, -23 },
  { 2248, 18, 23, 19, 1, -23 },
  { 2300, 17, 23, 19, 3, -23 },
  { 2349, 19, 23, 19, 1, -23 },
  { 2404, 21, 23, 19, -1, -23 },
  { 2465, 17, 23, 19, 3, -23 },
  { 2514, 17, 23, 19, 1, -23 },
  { 2563, 13, 29, 19, 4, -26 },
  { 2611, 10, 29, 19, 5, -26 },
  { 2648, 14, 29, 19, 2, -26 },
  { 2699, 15, 12, 19, 2, -23 },
  { 2722, 15, 3, 19, 0, 1 },
  { 2728, 6, 4, 19, 8, -24 },
  { 2731, 17, 17, 19, 1, -17 },
  { 2768, 16, 23, 19, 1, -23 },
  { 2814, 15, 17, 19, 2, -17 },
  { 2846, 17, 23, 19, 1, -23 },
  { 2895, 15, 17, 19, 2, -17 },
  { 2927, 21, 29, 19, -2, -23 },
  { 3004, 16, 23, 19, 2, -17 },
  { 3050, 16, 23, 19, 1, -23 },
  { 3096, 15, 24, 19, 1, -24 },
  { 3141, 17, 30, 19, 0, -24 },
  { 3205, 18, 23, 19, 1, -23 },
  { 3257, 13, 23, 19, 3, -23 },
  { 3295, 18, 17, 19, 0, -17 },
  { 3334, 16, 17, 19, 1, -17 },
  { 3368, 15, 17, 19, 2, -17 },
  { 3400, 17, 23, 19, 0, -17 },
  { 3449, 17, 23, 19, 1, -17 },
  { 3498, 16, 17, 19, 2, -17 },
  { 3532, 16, 17, 19, 1, -17 },
  { 3566, 16, 22, 19, 2, -22 },
  { 3610, 17, 17, 19, 1, -17 },
  { 3647, 16, 17, 19, 3, -17 },
  { 3681, 17, 17, 19, 2, -17 },
  { 3718, 18, 17, 19, 0, -17 },
  { 3757, 15, 23, 19, 2, -17 },
  { 3801, 16, 17, 19, 1, -17 },
  { 3835, 16, 29, 19, 3, -26 },
  { 3893, 9, 29, 19, 5, -26 },
  { 3926, 16, 29, 19, 1, -26 },
  { 3984, 17, 8, 19, 1, -15 },
};

const GFXfont JetBrainsMono_BoldItalic31pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic31pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _JETBRAINSMONO_BOLDITALIC31PT7B_H_
