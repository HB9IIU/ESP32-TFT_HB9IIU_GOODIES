#ifndef _JETBRAINSMONO_BOLDITALIC47PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xDF,
  0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0xBF, 0x07, 0xEF, 0xC1,
  0xF3, 0xF0, 0x7C, 0xFC, 0x3F, 0x3E, 0x0F, 0xCF, 0x83, 0xF3, 0xE0, 0xF8,
  0xF8, 0x3E, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xF0, 0x3C,
  0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x00,
  0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07,
  0xC0, 0x03, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0xF8, 0x00,
  0x7C, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x3C, 0x00,
  0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0,
  0x78, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x0F, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x39, 0xFC,
  0x0F, 0xC7, 0x1F, 0x81, 0xF0, 0xE3, 0xF0, 0x7E, 0x1C, 0x7E, 0x0F, 0xC7,
  0x00, 0x01, 0xF8, 0xE0, 0x00, 0x3F, 0x9C, 0x00, 0x07, 0xFB, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0x7F, 0x80, 0x00, 0xC7, 0xF0, 0x00, 0x38, 0x7E, 0x00, 0x07, 0x0F,
  0xC0, 0x00, 0xE1, 0xF8, 0x7E, 0x1C, 0x3F, 0x0F, 0xC3, 0x8F, 0xC1, 0xF8,
  0x71, 0xF8, 0x3F, 0xDC, 0x7F, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x1F, 0xE0, 0x01, 0xE0, 0x1F, 0xFC, 0x00, 0xF0, 0x0F,
  0xFF, 0x00, 0x78, 0x03, 0xE3, 0xE0, 0x3C, 0x01, 0xF0, 0xF8, 0x1F, 0x00,
  0x78, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x87, 0xC0, 0x07, 0x83, 0xC1, 0xE0,
  0x01, 0xE0, 0xF0, 0xF0, 0x00, 0xF8, 0x3C, 0x78, 0x00, 0x3E, 0x1F, 0x3C,
  0x00, 0x07, 0xDF, 0x9F, 0x00, 0x01, 0xFF, 0xEF, 0x80, 0x00, 0x3F, 0xF7,
  0xC0, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x04, 0x00, 0x00,
  0x0F, 0x9F, 0xE0, 0x00, 0x07, 0xCF, 0xFC, 0x00, 0x01, 0xE7, 0xFF, 0x80,
  0x00, 0xF3, 0xE3, 0xE0, 0x00, 0x78, 0xF0, 0x78, 0x00, 0x3C, 0x7C, 0x1E,
  0x00, 0x1F, 0x1E, 0x07, 0x80, 0x0F, 0x87, 0x81, 0xE0, 0x07, 0xC1, 0xE0,
  0xF8, 0x01, 0xE0, 0x78, 0x3C, 0x00, 0xF0, 0x1E, 0x0F, 0x00, 0x78, 0x07,
  0xEF, 0xC0, 0x3C, 0x01, 0xFF, 0xE0, 0x1F, 0x00, 0x3F, 0xF0, 0x0F, 0x80,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFE, 0x1F, 0xC0, 0x3F,
  0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0xFC, 0xFD, 0xF8, 0x3E, 0x7E, 0x3F, 0x1F, 0x9F,
  0x87, 0xCF, 0xC7, 0xE1, 0xFB, 0xE1, 0xF0, 0x3F, 0xF8, 0x7C, 0x0F, 0xFC,
  0x3F, 0x01, 0xFE, 0x0F, 0xC0, 0x7F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x07,
  0xF0, 0x3F, 0x03, 0xFE, 0x0F, 0xF3, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0x7E, 0x0F, 0xFF, 0x1F, 0x81, 0xFF, 0x03, 0xF0, 0x7E, 0xFD, 0xFB,
  0xF7, 0xFF, 0xBF, 0x7E, 0xFD, 0xFB, 0xE7, 0xCF, 0x9F, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0x78, 0x00, 0x01, 0x80, 0x01, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x02, 0x01, 0xF0, 0x08, 0xF0,
  0x7C, 0x1E, 0x3F, 0x1E, 0x1F, 0x9F, 0xE3, 0x9F, 0xE7, 0xFC, 0xCF, 0xFB,
  0xFF, 0xBF, 0xFF, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x7C,
  0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0xFE, 0x03,
  0xF0, 0x1F, 0x00, 0x38, 0x07, 0x00, 0x04, 0x00, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0,
  0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x3F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC7,
  0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7E, 0x7C, 0x7E, 0x3F, 0x3F, 0x3F, 0x1F,
  0x1F, 0x9F, 0x8F, 0x8F, 0xCF, 0xC7, 0xC7, 0xC7, 0xC7, 0xE1, 0xC3, 0xE3,
  0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0x7E,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x1F,
  0xC3, 0xF8, 0x1F, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0x07, 0xE0, 0x1C, 0x0F,
  0xC0, 0x20, 0x1F, 0x00, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x7F, 0x1F,
  0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x3F, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x7E, 0x1F,
  0xC0, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x20, 0x01, 0xF9, 0xFF, 0x00, 0xFD, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xE3, 0xFE, 0x0F, 0xC0,
  0x7F, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x3F, 0x83,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x0F, 0xDF,
  0xF8, 0x1F, 0xBF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xF7, 0xFE, 0x3F, 0x80,
  0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xC3, 0xF8, 0x3F,
  0x80, 0xFE, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0xC7,
  0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x7F, 0x07, 0xF0,
  0x1F, 0xC7, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xF0,
  0x1F, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xE3, 0xFE,
  0x3F, 0x80, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFF, 0x03, 0xFC, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xF7, 0xF0, 0x07, 0xC7, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFE,
  0x0F, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0x8F, 0xF8,
  0xFF, 0x8F, 0xF8, 0xFF, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xF8,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x30, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFB,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x3E,
  0x00, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x0F, 0x81, 0xFE, 0x78, 0x7C, 0x1F,
  0xFB, 0xC3, 0xC1, 0xFF, 0xFE, 0x3E, 0x0F, 0x83, 0xF1, 0xF0, 0x7C, 0x1F,
  0x8F, 0x87, 0xC0, 0xF8, 0x7C, 0x3E, 0x07, 0xC3, 0xE1, 0xF0, 0x3E, 0x1E,
  0x0F, 0x81, 0xF1, 0xF0, 0x7C, 0x0F, 0x8F, 0x87, 0xC0, 0x7C, 0x7C, 0x3E,
  0x03, 0xC3, 0xE1, 0xF0, 0x3E, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x7C, 0x0F,
  0x87, 0x83, 0xF1, 0xFC, 0x7C, 0x1F, 0xFF, 0xE3, 0xE0, 0x7F, 0xDF, 0x1F,
  0x01, 0xFC, 0xF0, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xFC,
  0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x7E, 0x03, 0xF0,
  0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xF8,
  0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x7F, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0xFC, 0x03, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F,
  0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x87, 0xC0, 0x0F, 0xE1, 0xF0, 0x03, 0xF0, 0xFC, 0x03, 0xFC, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x3F, 0xE0,
  0xFE, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E,
  0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x81, 0xF8, 0x0F, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x3F,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0,
  0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0x7E, 0x0F, 0xFC, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0x3F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC,
  0x3E, 0x0F, 0xFE, 0x1F, 0x87, 0xFF, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01,
  0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x1F,
  0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00,
  0x7E, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x01,
  0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x7E,
  0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x3F,
  0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F,
  0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0,
  0x0F, 0xC0, 0x7E, 0x00, 0x7C, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80,
  0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0xFF,
  0x01, 0xFE, 0x0F, 0x78, 0x1F, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x3F,
  0xE0, 0xF7, 0x87, 0xBE, 0x0F, 0x78, 0x7B, 0xE1, 0xF7, 0x8F, 0x3C, 0x1F,
  0x38, 0xF7, 0xC1, 0xF3, 0xDF, 0x7C, 0x1F, 0x3D, 0xE7, 0xC1, 0xF3, 0xDE,
  0x7C, 0x1F, 0x3F, 0xCF, 0xC3, 0xF3, 0xFC, 0xF8, 0x3F, 0x3F, 0x8F, 0x83,
  0xF1, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0x83, 0xE0, 0x01, 0xF8, 0x3E, 0x00,
  0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF0,
  0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x03, 0xE0, 0xFF, 0x00, 0x7C, 0x1F, 0xE0, 0x1F, 0x83, 0xFE, 0x03,
  0xF0, 0x7F, 0xC0, 0x7C, 0x0F, 0xF8, 0x0F, 0x81, 0xEF, 0x01, 0xF0, 0x3D,
  0xE0, 0x3E, 0x0F, 0xBE, 0x0F, 0xC1, 0xF7, 0xC1, 0xF8, 0x3E, 0xF8, 0x3F,
  0x07, 0xDF, 0x07, 0xC0, 0xF9, 0xE0, 0xF8, 0x1F, 0x3C, 0x1F, 0x07, 0xE7,
  0xC7, 0xE0, 0xFC, 0xF8, 0xFC, 0x1F, 0x1F, 0x1F, 0x83, 0xE1, 0xE3, 0xE0,
  0x7C, 0x3C, 0x7C, 0x0F, 0x87, 0xCF, 0x83, 0xF0, 0xF9, 0xF0, 0x7E, 0x1F,
  0x3E, 0x0F, 0xC1, 0xEF, 0xC1, 0xF0, 0x3D, 0xF0, 0x3E, 0x07, 0xFE, 0x07,
  0xC0, 0xFF, 0xC1, 0xF8, 0x1F, 0xF8, 0x3F, 0x03, 0xFF, 0x07, 0xE0, 0x3F,
  0xE0, 0xF8, 0x07, 0xF8, 0x1F, 0x00, 0xFF, 0x03, 0xE0, 0x1F, 0xE0, 0x7C,
  0x03, 0xFC, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xEF,
  0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xE3,
  0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7C,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F,
  0x83, 0xF8, 0x1F, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x1F, 0x80, 0x7F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x0F,
  0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xE1, 0xF8,
  0x1F, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xE7, 0xF8, 0x3F, 0x80,
  0xFE, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F,
  0xC0, 0x0F, 0xC7, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x1F, 0x00, 0x3F, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF8, 0x1F,
  0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xC0, 0x3F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7F, 0x07, 0xC0, 0x07,
  0xE1, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01,
  0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x1F,
  0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFC, 0xFF, 0x81, 0xFC, 0x07,
  0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x07,
  0xE0, 0x07, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x83, 0xF0,
  0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87,
  0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF0,
  0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xE3, 0xE0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0x80, 0x3E,
  0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x03,
  0xF1, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7C, 0x00,
  0x3F, 0x7E, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0xF9,
  0xF0, 0x7E, 0x0F, 0x8F, 0x83, 0xF0, 0x7C, 0x7C, 0x1F, 0x83, 0xE3, 0xE0,
  0xFC, 0x1F, 0x1F, 0x0E, 0xE1, 0xF0, 0xF8, 0x77, 0x0F, 0x87, 0xC3, 0xB8,
  0x7C, 0x3C, 0x3F, 0xC3, 0xC1, 0xE1, 0xDE, 0x3E, 0x0F, 0x0E, 0xE1, 0xF0,
  0xF8, 0x77, 0x0F, 0x87, 0xC7, 0xB8, 0x78, 0x3E, 0x39, 0xC7, 0xC1, 0xF1,
  0xCE, 0x3E, 0x0F, 0x8E, 0x71, 0xF0, 0x7C, 0xF3, 0x8F, 0x03, 0xE7, 0x1C,
  0xF8, 0x1F, 0x38, 0xE7, 0xC0, 0xFB, 0xC7, 0x3E, 0x07, 0xDC, 0x39, 0xE0,
  0x3C, 0xE1, 0xDF, 0x01, 0xE7, 0x0E, 0xF8, 0x0F, 0x78, 0x77, 0x80, 0x7B,
  0x83, 0xBC, 0x03, 0xDC, 0x1F, 0xE0, 0x1E, 0xE0, 0xFF, 0x00, 0xFF, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0,
  0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0x9F, 0x80, 0x01,
  0xFB, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x7C, 0x7C,
  0x07, 0xE3, 0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x03, 0xE1, 0xF0,
  0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x1F, 0x7C, 0x00, 0xFF,
  0xE0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F,
  0x07, 0xE0, 0xFC, 0x00, 0xFF, 0x1F, 0x81, 0xFF, 0xCF, 0x81, 0xFF, 0xEF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xF8, 0x7E, 0x01,
  0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8,
  0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x3F, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFB, 0xF0, 0x1F, 0xF9, 0xF8, 0x07, 0xF8, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x87, 0xF0, 0x1F, 0x9F, 0xF8, 0x1F, 0xBF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0x80, 0x7F, 0x3F, 0x80,
  0x7F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01,
  0xFC, 0xFF, 0x03, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFD, 0xFF,
  0xE0, 0xFD, 0xFF, 0xC0, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0,
  0xFF, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0xFF, 0x1F, 0x80, 0xFF, 0xE7, 0xC0, 0x7F, 0xFB,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xF0, 0x3F, 0xC1, 0xF8,
  0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83,
  0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F,
  0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xF7, 0xE0, 0x1F, 0xF9, 0xF8,
  0x03, 0xFC, 0x7E, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xF1, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0x80,
  0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7F, 0x87, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x1F, 0x81, 0xFF, 0xCF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFE, 0x07, 0xF8, 0x7E, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F,
  0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7,
  0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xEF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xF7, 0xE0, 0x1F, 0xE3,
  0xF0, 0x01, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x87, 0xF0,
  0x1F, 0x9F, 0xF8, 0x1F, 0xBF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0xE0, 0xFE, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E,
  0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x1F, 0xC3, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x01, 0xFC,
  0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x0F,
  0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xC3, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01,
  0xF8, 0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0x7E,
  0x01, 0xF8, 0x1F, 0xC0, 0x7C, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x3F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0x9F, 0x0F, 0x81, 0xF7, 0xF3,
  0xF8, 0x3F, 0xFE, 0xFF, 0x87, 0xFF, 0xDF, 0xF0, 0xFC, 0x7C, 0x7E, 0x1F,
  0x0F, 0x87, 0xC7, 0xE1, 0xE0, 0xF8, 0xF8, 0x3C, 0x3F, 0x1F, 0x07, 0x87,
  0xE3, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xE3, 0xF0,
  0xF0, 0x7C, 0x7E, 0x1E, 0x0F, 0x8F, 0x83, 0xC3, 0xF1, 0xF0, 0x78, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3E, 0x3F, 0x0F,
  0x07, 0xC7, 0xC1, 0xE1, 0xF8, 0xF8, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1F, 0x1F, 0x87, 0x83, 0xE0, 0x0F, 0x87,
  0xF0, 0x1F, 0x9F, 0xF8, 0x1F, 0xBF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0xFC, 0x00,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0x80,
  0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7E, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x03, 0xE1,
  0xFC, 0x01, 0xF9, 0xFF, 0x80, 0x7E, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00,
  0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7E,
  0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0,
  0x7E, 0x01, 0xFC, 0x3F, 0xC0, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC0, 0xFD, 0xFF, 0xE0, 0x3F, 0x7F, 0xF0, 0x0F, 0x8F, 0xF0, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x1F, 0x81, 0xFF, 0xCF, 0x81, 0xFF, 0xEF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xF8, 0x7E, 0x01, 0xFC, 0x7F,
  0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87,
  0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x7F,
  0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x3F, 0x83, 0xFF, 0xF7, 0xC1, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFB, 0xF0, 0x3F, 0xF9, 0xF8, 0x07, 0xF8, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC7, 0xF8, 0x07, 0xE7, 0xFF, 0x03, 0xF7, 0xFF, 0xC1, 0xF7, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80,
  0x7F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF1,
  0xFF, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFC, 0x01,
  0xFC, 0xFF, 0x07, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x1F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xE0, 0x07, 0xE3,
  0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x3F,
  0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x3E,
  0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F,
  0xBE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xF8,
  0x1E, 0x07, 0xFE, 0x0F, 0x81, 0xFF, 0x83, 0xE0, 0x7F, 0xE0, 0xF8, 0x1E,
  0xF8, 0x7E, 0x0F, 0xBE, 0x1F, 0x83, 0xEF, 0x87, 0xE0, 0xF3, 0xE3, 0xB8,
  0x7C, 0xF8, 0xEE, 0x1F, 0x3E, 0x3B, 0x87, 0x8F, 0x9E, 0xE3, 0xE3, 0xC7,
  0x38, 0xF8, 0xF1, 0xCE, 0x3C, 0x3C, 0x73, 0x8F, 0x0F, 0x38, 0xE7, 0xC3,
  0xCE, 0x39, 0xE0, 0xF3, 0x8E, 0x78, 0x3D, 0xC3, 0xBE, 0x0F, 0x70, 0xEF,
  0x83, 0xDC, 0x3B, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0,
  0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x3F,
  0x03, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC, 0xFE,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xBF, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE1,
  0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x07, 0xE0,
  0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x1F, 0x80,
  0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00,
  0x3F, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01,
  0xFC, 0x7F, 0x87, 0xFC, 0x7F, 0xFE, 0xF8, 0x3F, 0xFE, 0xF8, 0x3F, 0xFD,
  0xF8, 0x1F, 0xF9, 0xF8, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC,
  0x07, 0xCF, 0xFF, 0x03, 0xE7, 0xFF, 0x81, 0xF7, 0xFF, 0xE0, 0xFB, 0xE1,
  0xF8, 0xF9, 0xF0, 0xFF, 0xFC, 0xF8, 0x3F, 0xFC, 0xF8, 0x0F, 0xFE, 0x7C,
  0x07, 0xFE, 0x00, 0x00, 0xFC, 0x00,
};

const GFXglyph JetBrainsMono_BoldItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 13, 34, 28, 8, -34 },
  { 57, 18, 14, 28, 8, -34 },
  { 89, 28, 34, 28, 1, -34 },
  { 208, 27, 48, 28, 1, -41 },
  { 370, 34, 35, 28, -2, -35 },
  { 519, 26, 35, 28, 1, -35 },
  { 633, 7, 14, 28, 13, -34 },
  { 646, 20, 46, 28, 7, -40 },
  { 761, 20, 46, 28, 2, -40 },
  { 876, 26, 25, 28, 2, -29 },
  { 958, 23, 23, 28, 3, -27 },
  { 1025, 13, 15, 28, 4, -7 },
  { 1050, 17, 5, 28, 6, -18 },
  { 1061, 9, 8, 28, 8, -8 },
  { 1070, 29, 44, 28, 0, -39 },
  { 1230, 25, 35, 28, 2, -35 },
  { 1340, 23, 34, 28, 2, -34 },
  { 1438, 25, 35, 28, 2, -35 },
  { 1548, 25, 34, 28, 2, -34 },
  { 1655, 24, 34, 28, 2, -34 },
  { 1757, 25, 34, 28, 2, -34 },
  { 1864, 24, 34, 28, 2, -34 },
  { 1966, 24, 34, 28, 5, -34 },
  { 2068, 25, 35, 28, 2, -35 },
  { 2178, 24, 35, 28, 4, -35 },
  { 2283, 12, 26, 28, 8, -26 },
  { 2322, 16, 34, 28, 4, -26 },
  { 2390, 24, 25, 28, 3, -28 },
  { 2465, 23, 17, 28, 3, -24 },
  { 2514, 23, 25, 28, 2, -28 },
  { 2586, 20, 34, 28, 6, -34 },
  { 2671, 29, 43, 28, 0, -35 },
  { 2827, 24, 34, 28, 0, -34 },
  { 2929, 26, 34, 28, 2, -34 },
  { 3040, 26, 35, 28, 2, -35 },
  { 3154, 26, 34, 28, 1, -34 },
  { 3265, 26, 34, 28, 2, -34 },
  { 3376, 26, 34, 28, 2, -34 },
  { 3487, 26, 35, 28, 2, -35 },
  { 3601, 26, 34, 28, 2, -34 },
  { 3712, 25, 34, 28, 2, -34 },
  { 3819, 27, 35, 28, 0, -34 },
  { 3938, 29, 34, 28, 1, -34 },
  { 4062, 21, 34, 28, 3, -34 },
  { 4152, 28, 34, 28, 1, -34 },
  { 4271, 27, 34, 28, 1, -34 },
  { 4386, 25, 35, 28, 2, -35 },
  { 4496, 27, 34, 28, 2, -34 },
  { 4611, 25, 43, 28, 2, -35 },
  { 4746, 27, 34, 28, 1, -34 },
  { 4861, 27, 35, 28, 1, -35 },
  { 4980, 24, 34, 28, 5, -34 },
  { 5082, 26, 34, 28, 2, -34 },
  { 5193, 25, 34, 28, 5, -34 },
  { 5300, 29, 34, 28, 2, -34 },
  { 5424, 31, 34, 28, -1, -34 },
  { 5556, 27, 34, 28, 4, -34 },
  { 5671, 25, 34, 28, 2, -34 },
  { 5778, 20, 44, 28, 6, -39 },
  { 5888, 15, 44, 28, 7, -39 },
  { 5971, 21, 44, 28, 3, -39 },
  { 6087, 21, 18, 28, 4, -34 },
  { 6135, 23, 5, 28, 0, 1 },
  { 6150, 10, 7, 28, 12, -37 },
  { 6159, 25, 26, 28, 2, -26 },
  { 6241, 24, 34, 28, 2, -34 },
  { 6343, 24, 26, 28, 2, -26 },
  { 6421, 26, 34, 28, 2, -34 },
  { 6532, 24, 26, 28, 2, -26 },
  { 6610, 32, 42, 28, -3, -34 },
  { 6778, 25, 34, 28, 2, -26 },
  { 6885, 24, 34, 28, 2, -34 },
  { 6987, 24, 37, 28, 1, -37 },
  { 7098, 26, 45, 28, 0, -37 },
  { 7245, 26, 34, 28, 2, -34 },
  { 7356, 21, 34, 28, 4, -34 },
  { 7446, 27, 26, 28, 0, -26 },
  { 7534, 24, 26, 28, 2, -26 },
  { 7612, 24, 26, 28, 2, -26 },
  { 7690, 26, 34, 28, 0, -26 },
  { 7801, 25, 34, 28, 2, -26 },
  { 7908, 25, 26, 28, 2, -26 },
  { 7990, 24, 26, 28, 2, -26 },
  { 8068, 24, 33, 28, 3, -33 },
  { 8167, 25, 26, 28, 2, -26 },
  { 8249, 24, 26, 28, 4, -26 },
  { 8327, 26, 26, 28, 3, -26 },
  { 8412, 28, 26, 28, 0, -26 },
  { 8503, 24, 34, 28, 2, -26 },
  { 8605, 24, 26, 28, 2, -26 },
  { 8683, 25, 44, 28, 4, -39 },
  { 8821, 13, 44, 28, 8, -39 },
  { 8893, 25, 44, 28, 1, -39 },
  { 9031, 25, 11, 28, 2, -22 },
};

const GFXfont JetBrainsMono_BoldItalic47pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic47pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _JETBRAINSMONO_BOLDITALIC47PT7B_H_
