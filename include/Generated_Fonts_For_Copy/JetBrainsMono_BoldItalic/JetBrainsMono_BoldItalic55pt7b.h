#ifndef _JETBRAINSMONO_BOLDITALIC55PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0x3F,
  0x83, 0xF9, 0xFC, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F,
  0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7E, 0x07, 0xF3, 0xF0,
  0x3F, 0x3F, 0x81, 0xF9, 0xFC, 0x1F, 0xCF, 0xC0, 0xFE, 0x7E, 0x07, 0xE3,
  0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x03, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x01, 0xF0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0x8E, 0x3F, 0xC1, 0xFC,
  0x78, 0xFF, 0x07, 0xF1, 0xE1, 0xFC, 0x3F, 0x87, 0x87, 0xF0, 0xFE, 0x1E,
  0x00, 0x03, 0xF8, 0x70, 0x00, 0x0F, 0xE1, 0xC0, 0x00, 0x3F, 0xC7, 0x00,
  0x00, 0xFF, 0x3C, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0x3F, 0xE0, 0x00, 0x1C, 0x7F, 0x80, 0x00, 0xF0,
  0xFE, 0x00, 0x03, 0xC3, 0xF8, 0x00, 0x0F, 0x0F, 0xE3, 0xF8, 0x38, 0x3F,
  0x8F, 0xE0, 0xE0, 0xFE, 0x3F, 0x83, 0x87, 0xF8, 0xFF, 0x0E, 0x1F, 0xC1,
  0xFE, 0x79, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x7F, 0xFC, 0x00, 0x7C, 0x00,
  0xFF, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x3E,
  0x03, 0xE0, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x3C, 0x0F, 0xC0,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0x03, 0xE0,
  0x7C, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0xF8,
  0x00, 0x03, 0xF1, 0xF9, 0xF0, 0x00, 0x03, 0xFF, 0xF3, 0xF0, 0x00, 0x01,
  0xFF, 0xE3, 0xE0, 0x00, 0x00, 0xFF, 0xC7, 0xC0, 0x00, 0x00, 0x3F, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0xFE, 0x00, 0x00, 0x01, 0xF3, 0xFF, 0x80, 0x00, 0x03, 0xE7, 0xFF,
  0xC0, 0x00, 0x07, 0xCF, 0xFF, 0xC0, 0x00, 0x0F, 0x9F, 0x87, 0xE0, 0x00,
  0x1F, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x1E,
  0x03, 0xE0, 0x00, 0x7C, 0x3E, 0x03, 0xC0, 0x00, 0xF8, 0x3E, 0x07, 0xC0,
  0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x07, 0xC0,
  0x3E, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0xFF,
  0x80, 0x1F, 0x00, 0x1F, 0xFF, 0x00, 0x3E, 0x00, 0x0F, 0xFE, 0x00, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xCF, 0xF7, 0xF0, 0x7F, 0x1F, 0xC7, 0xF0,
  0xFC, 0x3F, 0x0F, 0xE3, 0xF8, 0xFE, 0x0F, 0xEF, 0xE1, 0xFC, 0x1F, 0xDF,
  0x83, 0xF8, 0x1F, 0xFF, 0x07, 0xE0, 0x3F, 0xFC, 0x0F, 0xC0, 0x3F, 0xF0,
  0x1F, 0x80, 0x7F, 0xE0, 0x7F, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7E, 0x01,
  0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x3F, 0xFC, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF3, 0xF8, 0x0F,
  0xFF, 0x87, 0xF0, 0x0F, 0xFE, 0x07, 0xF0, 0x00, 0x80, 0x00, 0x00, 0x3F,
  0x9F, 0xDF, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0xFE, 0x7F, 0x3F, 0x9F,
  0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x02, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x38, 0x07,
  0xC0, 0x71, 0xF0, 0x3C, 0x1F, 0x9F, 0xE1, 0xE1, 0xFF, 0xFF, 0x8E, 0x3F,
  0xFF, 0xFF, 0x77, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E,
  0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xC1, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x40,
  0x06, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x07,
  0x03, 0xF8, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFE, 0x7F, 0xC7,
  0xF0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0xFF, 0xC1, 0xFE, 0x01,
  0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE,
  0x3F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x78,
  0x3F, 0x8F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x8F, 0xC3, 0xF1, 0xFC, 0x7E,
  0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xE1, 0xF1, 0xFC, 0x7E,
  0x02, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF1, 0xFC, 0x00,
  0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7E,
  0x1F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC0, 0xFF, 0xCF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0x40, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xBF, 0x80, 0x3F, 0xE7, 0xF0, 0x07, 0xF0, 0xFE, 0x00,
  0xFC, 0x3F, 0x80, 0x1E, 0x07, 0xF0, 0x03, 0x80, 0xFE, 0x00, 0xC0, 0x1F,
  0xC0, 0x10, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFB, 0xFF, 0x81, 0xFE,
  0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xE0,
  0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xF8, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xC1,
  0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0,
  0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x1F, 0xF0, 0x03, 0xFB, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xE1, 0xFF,
  0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x07,
  0xF8, 0x07, 0xF8, 0x3F, 0xFB, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x87,
  0x00, 0x07, 0xFB, 0xFF, 0x00, 0xFF, 0x7F, 0xF8, 0x0F, 0xEF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE3, 0xFE, 0x01, 0xFE, 0x3F, 0xC0,
  0x0F, 0xF3, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F,
  0x7F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F,
  0xC7, 0xF8, 0x07, 0xF8, 0x7F, 0xE3, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFE, 0x01, 0xFE,
  0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x7F,
  0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xFB,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0x3F, 0xE0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFE, 0x0F,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xFC, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x01,
  0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC,
  0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0xFF, 0x1F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xEF, 0xE0, 0x07,
  0xFC, 0xFE, 0x00, 0x06, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x04,
  0x00, 0x00, 0x0F, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF0,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x7E, 0x01, 0xFF, 0x3E,
  0x1F, 0x80, 0xFF, 0xEF, 0x87, 0xE0, 0x7F, 0xFB, 0xE1, 0xF8, 0x3F, 0x87,
  0xF8, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x3F, 0x0F, 0xC1, 0xF8,
  0x0F, 0xC3, 0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x07,
  0xC0, 0x3F, 0x0F, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0xFC, 0x03, 0xE0, 0xF8,
  0x3F, 0x01, 0xF8, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x83, 0xF0, 0x1F, 0x87,
  0xE0, 0xFC, 0x07, 0xE1, 0xF8, 0x3F, 0x03, 0xF8, 0x7C, 0x0F, 0xC0, 0xFC,
  0x1F, 0x03, 0xF8, 0xFF, 0x0F, 0xC0, 0xFF, 0xF7, 0xC3, 0xF0, 0x1F, 0xF9,
  0xF0, 0xFC, 0x03, 0xFE, 0x7C, 0x3F, 0x00, 0x7E, 0x20, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x08, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xFC,
  0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x1F,
  0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x03, 0xF0,
  0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFE, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF8,
  0xFE, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0xFF, 0x07, 0xE0, 0x03, 0xFC, 0x1F, 0x80, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xF8, 0x03,
  0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x7F,
  0x00, 0x3F, 0xC1, 0xFC, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0,
  0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07,
  0xF1, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07,
  0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xC0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0x01, 0xFF, 0x81, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFC,
  0x1F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x3F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x0F,
  0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF1, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0xFE, 0x1F, 0x83,
  0xFF, 0xF1, 0xFC, 0x1F, 0xFF, 0x8F, 0xE0, 0xFF, 0xFC, 0x7F, 0x07, 0xFF,
  0xE3, 0xF8, 0x3F, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x8F,
  0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x3F,
  0xC0, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x02,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x0F,
  0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x01,
  0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0,
  0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F,
  0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x1F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xFB, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x03, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x0F, 0xF0, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF8,
  0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x1F, 0x78, 0x0F, 0x7C, 0x0F, 0xBC, 0x0F, 0xFE, 0x07, 0xDE,
  0x07, 0xBF, 0x07, 0xEF, 0x07, 0xDF, 0x03, 0xF7, 0xC3, 0xCF, 0x81, 0xFB,
  0xE3, 0xEF, 0xC0, 0xFD, 0xF1, 0xF7, 0xE0, 0x7E, 0xF9, 0xF3, 0xF0, 0x3F,
  0x3C, 0xF9, 0xF8, 0x1F, 0x1E, 0x79, 0xF8, 0x1F, 0x8F, 0x7C, 0xFC, 0x0F,
  0xC7, 0xBC, 0x7E, 0x07, 0xE3, 0xFE, 0x3F, 0x03, 0xF1, 0xFE, 0x1F, 0x81,
  0xF8, 0xFF, 0x1F, 0xC0, 0xFC, 0x3F, 0x8F, 0xC0, 0xFE, 0x1F, 0x87, 0xE0,
  0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x7E, 0x07, 0xFC, 0x01, 0xFC, 0x1F, 0xF8, 0x03, 0xF8, 0x3F, 0xF0,
  0x07, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0xFF, 0xC0, 0x1F, 0x81, 0xFF, 0x80,
  0x3F, 0x03, 0xFF, 0x80, 0x7E, 0x07, 0xFF, 0x01, 0xFC, 0x1F, 0xBE, 0x03,
  0xF0, 0x3F, 0x7C, 0x07, 0xE0, 0x7E, 0xF8, 0x0F, 0xC0, 0xFD, 0xF8, 0x1F,
  0x81, 0xFB, 0xF0, 0x3F, 0x03, 0xF3, 0xE0, 0xFE, 0x0F, 0xE7, 0xC1, 0xFC,
  0x1F, 0x8F, 0x83, 0xF0, 0x3F, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x0F, 0xC0,
  0xFC, 0x7E, 0x1F, 0x81, 0xF8, 0x7C, 0x7F, 0x07, 0xF0, 0xF8, 0xFE, 0x0F,
  0xE1, 0xF1, 0xF8, 0x1F, 0x83, 0xF3, 0xF0, 0x3F, 0x07, 0xE7, 0xE0, 0x7E,
  0x07, 0xCF, 0xC0, 0xFC, 0x0F, 0x9F, 0x81, 0xF8, 0x1F, 0x3F, 0x07, 0xF0,
  0x3F, 0x7C, 0x0F, 0xE0, 0x7E, 0xF8, 0x1F, 0x80, 0x7F, 0xF0, 0x3F, 0x00,
  0xFF, 0xE0, 0x7E, 0x01, 0xFF, 0xC0, 0xFC, 0x03, 0xFF, 0x83, 0xF8, 0x07,
  0xFF, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xC0, 0x0F, 0xF8, 0x1F, 0x80, 0x1F,
  0xF0, 0x3F, 0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF,
  0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x01,
  0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8,
  0x7F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0xFE, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xF8,
  0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x03, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x07, 0xFE, 0x07, 0xF0,
  0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xC0,
  0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0xFF, 0xC1,
  0xFF, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0xFE, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF8, 0x7E, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1,
  0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01,
  0xFC, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF1,
  0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x03,
  0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x01, 0xFC, 0x01, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x3F,
  0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01,
  0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xF1, 0xFF, 0x81, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xFC,
  0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80,
  0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x07,
  0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F,
  0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0,
  0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x68, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x80,
  0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07,
  0xF1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x83,
  0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0,
  0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x00,
  0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xFE,
  0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xF9, 0xF8, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0x0F,
  0xCF, 0x80, 0xFC, 0x07, 0xC7, 0xC0, 0xFE, 0x07, 0xE3, 0xE0, 0x7F, 0x03,
  0xF1, 0xF0, 0x3B, 0x81, 0xF9, 0xF8, 0x1D, 0xC0, 0xF8, 0xFC, 0x1F, 0xE0,
  0xFC, 0x7E, 0x0F, 0xF0, 0x7E, 0x3F, 0x07, 0xF8, 0x3F, 0x1F, 0x83, 0xBC,
  0x1F, 0x0F, 0xC3, 0xDE, 0x1F, 0x87, 0xE1, 0xEF, 0x0F, 0xC3, 0xF0, 0xF7,
  0x87, 0xC1, 0xF8, 0xF3, 0xC3, 0xE0, 0xF8, 0x79, 0xE3, 0xF0, 0x7C, 0x3C,
  0xF1, 0xF8, 0x3E, 0x1C, 0x78, 0xF8, 0x1F, 0x1E, 0x3C, 0x7C, 0x0F, 0x8F,
  0x1C, 0x7E, 0x07, 0xC7, 0x8E, 0x3F, 0x03, 0xE7, 0x87, 0x1F, 0x01, 0xF3,
  0xC3, 0x8F, 0x81, 0xF9, 0xE1, 0xCF, 0xC0, 0xFC, 0xE0, 0xE7, 0xE0, 0x7E,
  0xF0, 0xF3, 0xE0, 0x3F, 0x78, 0x79, 0xF0, 0x1F, 0xBC, 0x3D, 0xF8, 0x0F,
  0xDC, 0x1E, 0xF8, 0x07, 0xDE, 0x0F, 0x7C, 0x03, 0xEF, 0x07, 0xBE, 0x01,
  0xF7, 0x83, 0xFF, 0x00, 0xFB, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7F,
  0xBF, 0x80, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC,
  0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00,
  0xFC, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x00,
  0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF9, 0xFC,
  0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1,
  0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x1F,
  0xC0, 0x3F, 0xFC, 0xFE, 0x03, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xBF, 0x83,
  0xFF, 0xFD, 0xF8, 0x3F, 0xF0, 0xEF, 0xC1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0,
  0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F,
  0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87,
  0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F,
  0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x83,
  0xFF, 0xBE, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x7F, 0x01, 0xFF,
  0xFB, 0xF8, 0x07, 0xFF, 0x9F, 0xC0, 0x1F, 0xF0, 0xFC, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x03,
  0xE0, 0x03, 0xF8, 0xFF, 0xC0, 0x1F, 0xCF, 0xFF, 0x80, 0xFE, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x0F,
  0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFC, 0x3F, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x1F,
  0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x3F,
  0x83, 0xFE, 0x03, 0xFC, 0x1F, 0xBC, 0xFF, 0xE0, 0xFD, 0xFF, 0xFE, 0x0F,
  0xEF, 0xFF, 0xE0, 0x7F, 0x7F, 0xFE, 0x03, 0xF9, 0xFF, 0xE0, 0x1F, 0xC7,
  0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x7F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x4F, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x07, 0xFF, 0x7F,
  0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x05, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x07,
  0xF0, 0x01, 0xFF, 0x8F, 0xE0, 0x07, 0xFF, 0x9F, 0xC0, 0x1F, 0xFF, 0xBF,
  0x80, 0x7F, 0xFF, 0x7F, 0x01, 0xFF, 0xFE, 0xFC, 0x07, 0xFE, 0x1D, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xDF,
  0x7E, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFB, 0xF8, 0x03, 0xFF, 0xF7,
  0xF0, 0x03, 0xFF, 0xCF, 0xE0, 0x03, 0xFE, 0x1F, 0x80, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xF8, 0x07,
  0xF0, 0xFE, 0x00, 0xFF, 0x1F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFC,
  0x00, 0x3F, 0x9F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0xFF, 0x00,
  0x7F, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFC, 0x7F,
  0x01, 0xFF, 0xE7, 0xF0, 0x3F, 0xFF, 0x7F, 0x07, 0xFF, 0xF7, 0xF0, 0xFF,
  0xFF, 0x7E, 0x1F, 0xF8, 0x77, 0xE1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x1F,
  0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0x7F,
  0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01,
  0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x8F,
  0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0x7F, 0x81,
  0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xBF, 0x03, 0xFF, 0xFB, 0xF0,
  0x3F, 0xFF, 0x7F, 0x01, 0xFF, 0xE7, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x07, 0xC0, 0x0F, 0xE3, 0xFF, 0x00, 0xFE, 0x7F, 0xFC, 0x0F,
  0xEF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFD, 0xC3,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF1,
  0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x1F, 0x80,
  0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE,
  0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xF0,
  0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F,
  0xC7, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x7F,
  0x81, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8,
  0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xC0,
  0x70, 0x07, 0xE7, 0xE1, 0xFC, 0x07, 0xEF, 0xF3, 0xFE, 0x07, 0xDF, 0xF7,
  0xFE, 0x07, 0xDF, 0xF7, 0xFE, 0x0F, 0xF1, 0xFC, 0x7F, 0x0F, 0xE1, 0xF8,
  0x7F, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x81, 0xF0,
  0x7E, 0x1F, 0x83, 0xE0, 0xFE, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x83, 0xE0,
  0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x3F, 0x03, 0xE0,
  0xFC, 0x3F, 0x07, 0xC0, 0xFC, 0x3F, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC1,
  0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x7F, 0x07, 0xC1,
  0xF8, 0x7E, 0x0F, 0x81, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x83,
  0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0xFE, 0x0F, 0x83,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x3F, 0xF0, 0x0F, 0xE7, 0xFF, 0xC0,
  0xFE, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xDC,
  0x3F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF1, 0xFC, 0x00, 0x7F,
  0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F,
  0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01,
  0xFC, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x8F,
  0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFE,
  0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xE7, 0xF0, 0x01, 0xFC,
  0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00,
  0x1F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF,
  0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x03,
  0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF8, 0x03, 0xF8, 0xFF,
  0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xF1, 0xFF, 0x80, 0x0F, 0xE7,
  0xFF, 0xC0, 0x1F, 0xDF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x03,
  0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F,
  0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0,
  0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x1F,
  0xF0, 0x1F, 0xE0, 0x3F, 0x79, 0xFF, 0xC0, 0xFE, 0xFF, 0xFF, 0x01, 0xFD,
  0xFF, 0xFC, 0x03, 0xFB, 0xFF, 0xF0, 0x07, 0xF3, 0xFF, 0xC0, 0x0F, 0xE3,
  0xFE, 0x00, 0x1F, 0xC0, 0x40, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x1F,
  0xC0, 0x3F, 0xFC, 0xFE, 0x07, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xBF, 0x83,
  0xFF, 0xFD, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFE, 0x03, 0xFE, 0x1F, 0xE0,
  0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F,
  0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87,
  0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F,
  0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x83,
  0xFF, 0xBE, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x7F, 0x01, 0xFF,
  0xFB, 0xF8, 0x0F, 0xFF, 0x9F, 0xC0, 0x1F, 0xF0, 0xFC, 0x00, 0x0C, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x7F, 0x1F, 0xFC, 0x03, 0xF9, 0xFF, 0xF0, 0x1F, 0xDF, 0xFF,
  0xC0, 0xFD, 0xFF, 0xFE, 0x07, 0xEF, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xC3,
  0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0,
  0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03,
  0xF8, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x03,
  0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00,
  0x7F, 0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3,
  0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80,
  0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC,
  0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x68, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F,
  0x87, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x03, 0xF8, 0x1F,
  0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x01,
  0xF8, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xDF,
  0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0xF8, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x81, 0xF7, 0xE0, 0x7F, 0x03,
  0xEF, 0xC0, 0xFE, 0x0F, 0xDF, 0x83, 0xFC, 0x1F, 0x3F, 0x07, 0xF8, 0x3E,
  0x7E, 0x0E, 0xF0, 0xFC, 0xFC, 0x3D, 0xE1, 0xF9, 0xF8, 0x7B, 0xC3, 0xE3,
  0xF0, 0xE7, 0x8F, 0xC7, 0xE3, 0xCF, 0x1F, 0x8F, 0xC7, 0x9E, 0x3E, 0x1F,
  0x8E, 0x3C, 0x7C, 0x3F, 0x3C, 0x71, 0xF8, 0x7E, 0x78, 0xE3, 0xE0, 0xFC,
  0xF1, 0xC7, 0xC1, 0xF9, 0xC3, 0x9F, 0x83, 0xF7, 0x87, 0x3E, 0x07, 0xEF,
  0x0E, 0x7C, 0x0F, 0xDC, 0x1D, 0xF8, 0x1F, 0xF8, 0x3B, 0xE0, 0x3F, 0xF0,
  0x77, 0xC0, 0x7D, 0xC0, 0xEF, 0x80, 0xFF, 0x81, 0xFE, 0x01, 0xFF, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x0F,
  0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0xFE,
  0x1F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F,
  0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x03,
  0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x87,
  0xFC, 0x3F, 0xF8, 0x7F, 0xFF, 0xBF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0x7F, 0x01, 0xFF, 0xE7, 0xF0, 0x0F, 0xFC, 0x7F, 0x00, 0x3E, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xC7,
  0xFF, 0x80, 0x7E, 0x7F, 0xFE, 0x03, 0xE7, 0xFF, 0xF0, 0x3F, 0x3F, 0xFF,
  0xC1, 0xFB, 0xF8, 0xFF, 0x0F, 0xDF, 0x83, 0xFC, 0xFE, 0xFC, 0x0F, 0xFF,
  0xE7, 0xE0, 0x7F, 0xFE, 0x3F, 0x01, 0xFF, 0xF1, 0xF0, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00,
};

const GFXglyph JetBrainsMono_BoldItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 14, 40, 33, 10, -40 },
  { 71, 21, 16, 33, 9, -40 },
  { 113, 33, 40, 33, 1, -40 },
  { 278, 30, 56, 33, 2, -48 },
  { 488, 40, 40, 33, -3, -40 },
  { 688, 31, 42, 33, 1, -41 },
  { 851, 9, 16, 33, 15, -40 },
  { 869, 24, 53, 33, 8, -46 },
  { 1028, 23, 53, 33, 3, -46 },
  { 1181, 29, 29, 33, 3, -34 },
  { 1287, 28, 26, 33, 3, -31 },
  { 1378, 16, 17, 33, 4, -8 },
  { 1412, 20, 6, 33, 7, -21 },
  { 1427, 11, 11, 33, 9, -10 },
  { 1443, 34, 52, 33, 0, -46 },
  { 1664, 29, 42, 33, 3, -41 },
  { 1817, 27, 40, 33, 2, -40 },
  { 1952, 30, 41, 33, 2, -41 },
  { 2106, 29, 41, 33, 2, -40 },
  { 2255, 29, 40, 33, 2, -40 },
  { 2400, 29, 41, 33, 3, -40 },
  { 2549, 28, 41, 33, 2, -40 },
  { 2693, 29, 40, 33, 5, -40 },
  { 2838, 30, 42, 33, 2, -41 },
  { 2996, 29, 41, 33, 4, -41 },
  { 3145, 15, 32, 33, 9, -31 },
  { 3205, 19, 40, 33, 5, -31 },
  { 3300, 28, 30, 33, 4, -33 },
  { 3405, 28, 20, 33, 3, -28 },
  { 3475, 28, 30, 33, 2, -33 },
  { 3580, 24, 40, 33, 7, -40 },
  { 3700, 34, 51, 33, 0, -41 },
  { 3917, 30, 40, 33, -1, -40 },
  { 4067, 30, 40, 33, 2, -40 },
  { 4217, 29, 42, 33, 3, -41 },
  { 4370, 30, 40, 33, 2, -40 },
  { 4520, 31, 40, 33, 2, -40 },
  { 4675, 31, 40, 33, 2, -40 },
  { 4830, 29, 42, 33, 3, -41 },
  { 4983, 31, 40, 33, 2, -40 },
  { 5138, 29, 40, 33, 3, -40 },
  { 5283, 32, 41, 33, 0, -40 },
  { 5447, 33, 40, 33, 2, -40 },
  { 5612, 25, 40, 33, 3, -40 },
  { 5737, 33, 40, 33, 1, -40 },
  { 5902, 31, 40, 33, 2, -40 },
  { 6057, 29, 42, 33, 3, -41 },
  { 6210, 32, 40, 33, 2, -40 },
  { 6370, 29, 51, 33, 3, -41 },
  { 6555, 31, 40, 33, 2, -40 },
  { 6710, 30, 42, 33, 2, -41 },
  { 6868, 29, 40, 33, 5, -40 },
  { 7013, 30, 41, 33, 3, -40 },
  { 7167, 29, 40, 33, 6, -40 },
  { 7312, 33, 40, 33, 3, -40 },
  { 7477, 36, 40, 33, -1, -40 },
  { 7657, 31, 40, 33, 5, -40 },
  { 7812, 30, 40, 33, 2, -40 },
  { 7962, 23, 52, 33, 7, -46 },
  { 8112, 18, 52, 33, 8, -46 },
  { 8229, 24, 52, 33, 4, -46 },
  { 8385, 26, 21, 33, 4, -40 },
  { 8454, 27, 7, 33, 0, 1 },
  { 8478, 11, 8, 33, 14, -43 },
  { 8489, 29, 32, 33, 2, -31 },
  { 8605, 29, 41, 33, 2, -40 },
  { 8754, 28, 32, 33, 3, -31 },
  { 8866, 31, 41, 33, 2, -40 },
  { 9025, 27, 32, 33, 3, -31 },
  { 9133, 37, 50, 33, -3, -40 },
  { 9365, 28, 41, 33, 3, -31 },
  { 9509, 28, 40, 33, 2, -40 },
  { 9649, 27, 43, 33, 2, -43 },
  { 9795, 30, 53, 33, 0, -43 },
  { 9994, 31, 40, 33, 2, -40 },
  { 10149, 24, 40, 33, 5, -40 },
  { 10269, 32, 31, 33, 0, -31 },
  { 10393, 28, 31, 33, 2, -31 },
  { 10502, 27, 32, 33, 3, -31 },
  { 10610, 31, 41, 33, 0, -31 },
  { 10769, 29, 41, 33, 2, -31 },
  { 10918, 29, 31, 33, 3, -31 },
  { 11031, 29, 32, 33, 2, -31 },
  { 11147, 27, 39, 33, 4, -39 },
  { 11279, 28, 31, 33, 3, -30 },
  { 11388, 28, 30, 33, 5, -30 },
  { 11493, 31, 30, 33, 3, -30 },
  { 11610, 33, 30, 33, 0, -30 },
  { 11734, 28, 40, 33, 3, -30 },
  { 11874, 28, 30, 33, 2, -30 },
  { 11979, 28, 52, 33, 5, -46 },
  { 12161, 15, 52, 33, 10, -46 },
  { 12259, 29, 52, 33, 1, -46 },
  { 12448, 29, 13, 33, 3, -26 },
};

const GFXfont JetBrainsMono_BoldItalic55pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic55pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _JETBRAINSMONO_BOLDITALIC55PT7B_H_
