#ifndef _JETBRAINSMONO_BOLDITALIC41PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC1, 0xF8, 0x7F, 0x0F, 0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0,
  0xFB, 0xE1, 0xFF, 0xC7, 0xFF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D,
  0xF0, 0xFB, 0xC1, 0xE7, 0x83, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x07,
  0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xC0,
  0xF0, 0x01, 0xE0, 0x70, 0x00, 0xF0, 0x78, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x00, 0x0F,
  0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x03,
  0xC0, 0xF0, 0x01, 0xE0, 0x70, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x00,
  0x0F, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xC0, 0x03, 0xC1, 0xE0,
  0x03, 0xC0, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFB, 0xF0,
  0x7E, 0x73, 0xF0, 0xF8, 0xE7, 0xE1, 0xF1, 0x8F, 0xC3, 0xE3, 0x00, 0x0F,
  0xCE, 0x00, 0x0F, 0x9C, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3B, 0xF8, 0x00, 0x63, 0xF0, 0x00, 0xC3, 0xE0, 0x01, 0x87,
  0xC7, 0xC7, 0x1F, 0x8F, 0x8E, 0x3E, 0x1F, 0x1C, 0xFC, 0x3F, 0xB3, 0xF0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x7C, 0x07, 0xFC, 0x01,
  0xC0, 0x3F, 0xF0, 0x0F, 0x01, 0xE3, 0xE0, 0x78, 0x07, 0x07, 0x83, 0xC0,
  0x1C, 0x1E, 0x1E, 0x00, 0xF0, 0x70, 0xF0, 0x03, 0xC1, 0xC7, 0x80, 0x0F,
  0x0F, 0x1C, 0x00, 0x3C, 0x3C, 0xF0, 0x00, 0xFF, 0xE7, 0x80, 0x01, 0xFF,
  0x3C, 0x00, 0x03, 0xF9, 0xE0, 0x00, 0x01, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x08, 0x00, 0x00, 0x79, 0xFC,
  0x00, 0x03, 0xDF, 0xF8, 0x00, 0x1E, 0x7F, 0xE0, 0x00, 0xF3, 0xC3, 0xC0,
  0x07, 0x8E, 0x0F, 0x00, 0x1C, 0x38, 0x3C, 0x00, 0xF1, 0xE0, 0xE0, 0x07,
  0x87, 0x83, 0x80, 0x3C, 0x1E, 0x1E, 0x01, 0xE0, 0x78, 0xF8, 0x0F, 0x01,
  0xFF, 0xC0, 0x78, 0x03, 0xFE, 0x03, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xF0,
  0xFC, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x1F, 0x3F, 0x7C,
  0x3E, 0x3E, 0x3E, 0x7C, 0x3E, 0x3E, 0x7C, 0x3E, 0x1F, 0xF8, 0x7C, 0x1F,
  0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0F, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F,
  0xE0, 0x7E, 0x1F, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFC,
  0xF8, 0x0F, 0xF0, 0xFC, 0x7E, 0xFD, 0xF3, 0xE7, 0xCF, 0x9F, 0x7E, 0xF9,
  0xF3, 0xE7, 0xC0, 0x00, 0x00, 0x40, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0x80, 0x02, 0x00, 0x00,
  0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0x80,
  0x03, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x80, 0xF0, 0x27, 0x83, 0x83, 0x9F, 0x8E,
  0x3F, 0xFF, 0x33, 0xFF, 0xFE, 0xFF, 0xF3, 0xFF, 0xFE, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x79, 0xE0, 0x03, 0xE7, 0xC0, 0x1F,
  0x1F, 0x80, 0xFC, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0x03, 0xE0, 0x18, 0x06,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0x81, 0xF8,
  0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x00, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xC0, 0x3E, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC1,
  0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0xC7, 0x80, 0x1F, 0x3E, 0x00, 0x78,
  0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x70, 0xF8, 0xF3,
  0xE3, 0xE7, 0xCF, 0xCF, 0x1F, 0x3E, 0x7C, 0x7C, 0x79, 0xF1, 0xF0, 0xC7,
  0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xFC, 0x07, 0xC1, 0xF8, 0x7F, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x81, 0xFD,
  0xF0, 0x1F, 0x9F, 0x01, 0xE1, 0xF0, 0x1C, 0x1F, 0x01, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x7F, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xC7, 0xE0, 0xFE,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0xF8,
  0x7E, 0x07, 0xC7, 0xE0, 0x7E, 0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF0, 0x07, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0xE0,
  0x07, 0xDF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F,
  0xC0, 0xFC, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0xF8,
  0xFC, 0x07, 0xC3, 0xF8, 0x7F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFD, 0xFC, 0x07, 0xDF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F,
  0x01, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0x7D, 0xF0, 0x07, 0xEF, 0x80, 0x3E, 0x7E, 0x03, 0xF3, 0xF8,
  0x3F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBE, 0x00, 0xFB, 0xF0, 0x0F, 0xDF, 0x00, 0x7C, 0xF8, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F,
  0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF8,
  0x3E, 0x03, 0xE0, 0x7E, 0x0F, 0x80, 0x7F, 0x7E, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0x8F, 0xE0, 0x7C,
  0x0F, 0xC1, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x8F, 0x80, 0x3F, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0xFE, 0x0F, 0xC1, 0xFF, 0xFF,
  0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xF8, 0x3F, 0x1F,
  0x80, 0xFD, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07,
  0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0x3F, 0x03, 0xF9, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xF7, 0xC0, 0xFF, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x81, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x1F,
  0x00, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0x80,
  0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x78, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x10, 0x00, 0x01,
  0xC0, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xF8,
  0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x03,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0x8F, 0xE0, 0x7E, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x81,
  0xF9, 0xE7, 0xC1, 0xFE, 0xF3, 0xE1, 0xFF, 0x71, 0xE0, 0xF0, 0xF8, 0xF0,
  0xF8, 0x7C, 0x78, 0x78, 0x1E, 0x3C, 0x3C, 0x1F, 0x1E, 0x3E, 0x0F, 0x9F,
  0x1F, 0x07, 0x8F, 0x0F, 0x03, 0xC7, 0x87, 0x81, 0xE3, 0xC3, 0xC0, 0xF1,
  0xE1, 0xE0, 0xF8, 0xF0, 0xF0, 0x7C, 0xF8, 0x7E, 0xFE, 0x7C, 0x3F, 0xEE,
  0x3C, 0x0F, 0xEF, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x1E, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0xF9, 0xE0, 0x07,
  0xCF, 0x00, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8,
  0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0,
  0x7C, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7,
  0xE0, 0x1F, 0x3E, 0x00, 0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7C, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xF8, 0x1F, 0xC1, 0xF0, 0x0F, 0xC3,
  0xE0, 0x1F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x7C,
  0x03, 0xF0, 0xF8, 0x0F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x03,
  0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E,
  0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x1F, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE1, 0xF8, 0x7E,
  0x03, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3E,
  0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x7F, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xF0,
  0x1F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x0F, 0x80, 0x7E, 0x1F, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F,
  0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x3E, 0x1F,
  0x80, 0x7C, 0x3E, 0x01, 0xF8, 0x7C, 0x07, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE1, 0xF8, 0x7E, 0x03,
  0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE3,
  0xFF, 0x9F, 0x8F, 0xFC, 0x7C, 0x3F, 0xF1, 0xF0, 0xFF, 0xC7, 0xC3, 0xFF,
  0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3E, 0x3F,
  0x00, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF0, 0x0F,
  0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8,
  0x7E, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7C, 0x03, 0xF0, 0xF8,
  0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F,
  0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7E, 0x03, 0xE0,
  0x7F, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x1F, 0x81, 0xF0, 0x0F,
  0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x07,
  0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xE1,
  0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0x0F, 0xC0, 0x0F,
  0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x3E, 0x01,
  0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F,
  0xC0, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE,
  0x0F, 0xF0, 0x77, 0x07, 0x78, 0x7B, 0x83, 0xF8, 0x3D, 0xC3, 0xFC, 0x1E,
  0xE1, 0xDE, 0x0F, 0x71, 0xEF, 0x07, 0xBC, 0xEF, 0x83, 0xDE, 0xF7, 0xC3,
  0xEF, 0x73, 0xC1, 0xF3, 0xB9, 0xE0, 0xF9, 0xFC, 0xF0, 0x7C, 0xFC, 0xF8,
  0x3C, 0x7E, 0x7C, 0x1E, 0x3E, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF0, 0x01,
  0xF0, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x1F, 0x07, 0xE0, 0x1E, 0x07, 0xF0, 0x1E, 0x0F, 0xF0, 0x3E, 0x0F,
  0xF0, 0x3E, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x3C, 0x0F,
  0x78, 0x3C, 0x1F, 0x78, 0x7C, 0x1F, 0x78, 0x7C, 0x1F, 0x78, 0x7C, 0x1F,
  0x78, 0x7C, 0x1E, 0x3C, 0x78, 0x1E, 0x3C, 0x78, 0x3E, 0x3C, 0xF8, 0x3E,
  0x3C, 0xF8, 0x3E, 0x3C, 0xF8, 0x3E, 0x1E, 0xF8, 0x3E, 0x1E, 0xF8, 0x3C,
  0x1E, 0xF0, 0x7C, 0x1E, 0xF0, 0x7C, 0x1E, 0xF0, 0x7C, 0x1F, 0xF0, 0x7C,
  0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x78, 0x0F, 0xE0, 0x78, 0x0F, 0xE0, 0xF8,
  0x0F, 0xE0, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE3, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F,
  0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x80,
  0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0xFC,
  0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0xFC,
  0x07, 0xC1, 0xF8, 0x7F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x80, 0x7E, 0x0F, 0x80,
  0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x1F, 0x80,
  0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x01, 0xFC, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE1, 0xF8,
  0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07,
  0xE7, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0xFC, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3E, 0x00, 0xF8, 0xFC, 0x07, 0xC1, 0xF8, 0x7F, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F,
  0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x01, 0xF8,
  0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0xFF, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0xFC, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x83, 0xF0, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F,
  0x07, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F,
  0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x00,
  0x7E, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xFE, 0x0F, 0xC1, 0xFF, 0xFF,
  0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x7E,
  0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF0, 0x07, 0xC3,
  0xE0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x7E,
  0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xC0,
  0x3E, 0x0F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03,
  0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0x7C,
  0x3F, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xC0, 0xFC, 0x3F, 0x81,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0x9F, 0x00, 0x7E, 0x7C,
  0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03,
  0xE1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80,
  0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xE0,
  0x03, 0xEF, 0x80, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x3C,
  0x1E, 0x0F, 0x9E, 0x0F, 0x07, 0xDF, 0x0F, 0x83, 0xCF, 0x87, 0xC1, 0xE7,
  0xC3, 0x61, 0xF3, 0xE1, 0xB0, 0xF1, 0xE1, 0xF8, 0x78, 0xF0, 0xFC, 0x3C,
  0x78, 0x7E, 0x3E, 0x3C, 0x77, 0x1E, 0x1E, 0x3B, 0x8F, 0x0F, 0x1D, 0xC7,
  0x87, 0x8C, 0xE7, 0xC3, 0xCE, 0x73, 0xC1, 0xE7, 0x39, 0xE0, 0xF3, 0x9C,
  0xF0, 0x7B, 0x8E, 0xF8, 0x3D, 0xC7, 0x78, 0x1E, 0xE3, 0xBC, 0x0F, 0x71,
  0xDE, 0x0F, 0x70, 0xCE, 0x07, 0xB8, 0x6F, 0x03, 0xDC, 0x37, 0x81, 0xEC,
  0x1B, 0xC0, 0xFE, 0x0D, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F,
  0x83, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0x07,
  0xE0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0xF8, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x07, 0xC1, 0xF8,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xE3,
  0xE0, 0x0F, 0x87, 0xC0, 0x3F, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF8, 0x1F,
  0x03, 0xE0, 0x3F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xF9,
  0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x1E, 0xF0, 0x03, 0xDE, 0x00, 0xFB, 0xE0, 0x3E, 0x7C, 0x07, 0x87, 0x81,
  0xF0, 0xF0, 0x3C, 0x1F, 0x0F, 0x83, 0xE3, 0xE0, 0x3C, 0x7C, 0x07, 0xDF,
  0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x3F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C,
  0x01, 0xF8, 0xF8, 0x1F, 0xE7, 0xC3, 0xFF, 0xBE, 0x3F, 0xFD, 0xF1, 0xFE,
  0xEF, 0x9F, 0x81, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x01, 0xF3,
  0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xE7, 0xC0, 0x3E, 0x3E, 0x01,
  0xF3, 0xF0, 0x0F, 0x9F, 0x80, 0x7C, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F,
  0x87, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0x7C, 0x1F, 0xFB, 0xE0, 0x7F, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x0F,
  0x9F, 0xE0, 0x3E, 0xFF, 0xC1, 0xF7, 0xFF, 0x87, 0xFD, 0xFE, 0x1F, 0xC1,
  0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3F, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xE1, 0xFC, 0x3F,
  0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7D, 0xFF, 0x83, 0xE3, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x1F, 0x81, 0xF8, 0xF8, 0x07, 0xE7, 0xC0, 0x3F, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7C, 0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0x1F,
  0x83, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x7E, 0x3E, 0x03,
  0xFC, 0xF8, 0x3F, 0xFB, 0xE1, 0xFF, 0xEF, 0x87, 0xFB, 0xBE, 0x3F, 0x03,
  0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xF1,
  0xF0, 0x0F, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xF0,
  0x0F, 0x8F, 0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF8, 0x7F,
  0x07, 0xFF, 0xFC, 0x1F, 0xFD, 0xF0, 0x3F, 0xF7, 0xC0, 0x7F, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xF8,
  0x3F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x01, 0xF3,
  0xE0, 0x0F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x1F,
  0x03, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0xF8, 0x1F, 0xE7, 0xC3, 0xFF, 0xBE, 0x3F, 0xFD, 0xF1, 0xFE, 0xEF,
  0x9F, 0x81, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x01, 0xF3, 0xE0,
  0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1,
  0xF0, 0x0F, 0x8F, 0x80, 0xFC, 0x7E, 0x0F, 0xE3, 0xFF, 0xDF, 0x1F, 0xFF,
  0xF0, 0x7F, 0xEF, 0x81, 0xFE, 0x7C, 0x03, 0x83, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE3, 0xF0, 0x0F, 0x9F, 0xE0, 0x3F, 0xFF, 0xC1, 0xF7, 0xFF,
  0x87, 0xFD, 0xFE, 0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x87,
  0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80,
  0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0x7C,
  0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C,
  0x03, 0xE3, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0xFC, 0x0F,
  0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x1F, 0x07, 0xE0, 0x1F,
  0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x1F, 0x80, 0x3E,
  0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F,
  0x3C, 0x3C, 0x0F, 0x7E, 0x7E, 0x0F, 0xFE, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x3E, 0x3E, 0x1E, 0x3E, 0x3E, 0x1C, 0x3E, 0x3E, 0x3C, 0x3E, 0x3E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x3C, 0x7C, 0x7C,
  0x38, 0x7C, 0x7C, 0x38, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0xF8, 0xF8, 0x70, 0xF8, 0x0F, 0x8F, 0xC0, 0x3E,
  0x7F, 0x80, 0xFF, 0xFF, 0x07, 0xDF, 0xFE, 0x1F, 0xF7, 0xF8, 0x7E, 0x07,
  0xE1, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x1F, 0x0F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E,
  0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x1F, 0x81, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x01, 0xF3,
  0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0x3E, 0x01,
  0xF3, 0xF0, 0x0F, 0x9F, 0x80, 0x7C, 0xFC, 0x07, 0xE7, 0xE0, 0x3E, 0x1F,
  0x87, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xC7, 0xE0, 0x0F, 0x9F, 0xE0, 0x1F, 0x7F, 0xE0, 0x7D, 0xFF,
  0xE0, 0xFF, 0xBF, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3E,
  0x0F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1,
  0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x3F,
  0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xFE, 0x1F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xDF, 0xF8, 0x1F, 0x9F, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0xF8, 0x3F, 0xE7, 0xC3, 0xFF, 0xBE,
  0x3F, 0xFD, 0xF1, 0xFE, 0xEF, 0x9F, 0x81, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xC7,
  0xC0, 0x3E, 0x3E, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x80, 0x7C, 0xFC, 0x07,
  0xE7, 0xE0, 0x3F, 0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0x7C, 0x1F,
  0xFB, 0xE0, 0x7F, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x0F,
  0x0F, 0xC0, 0x7C, 0xFF, 0x81, 0xF7, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xE7,
  0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x3F, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03,
  0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x7E, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xE0, 0x3F, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xFC,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x00,
  0x7C, 0xF8, 0x07, 0xE7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x9F,
  0x80, 0x7C, 0xFC, 0x07, 0xE3, 0xE0, 0x3E, 0x1F, 0x87, 0xF0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0xFD,
  0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x9F, 0x00, 0x7C, 0x7C, 0x03, 0xF1, 0xF0,
  0x0F, 0x87, 0xE0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E,
  0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0xF8, 0x01,
  0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xE0, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x00, 0x78, 0x3C, 0x1F, 0x78, 0x3C, 0x1E, 0x78, 0x7C, 0x1E, 0x78, 0x7C,
  0x1E, 0x78, 0x7C, 0x3C, 0x78, 0xFC, 0x3C, 0x78, 0xFC, 0x3C, 0x78, 0xDC,
  0x78, 0x79, 0xDC, 0x78, 0x79, 0xDC, 0x78, 0x79, 0xDC, 0xF0, 0xF9, 0x9C,
  0xF0, 0xF3, 0x9C, 0xF0, 0xF3, 0x9D, 0xE0, 0xF3, 0x1D, 0xE0, 0xF7, 0x1D,
  0xE0, 0xF7, 0x1D, 0xE0, 0xF6, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0xFC, 0x03, 0xE1,
  0xF8, 0x03, 0xF3, 0xF0, 0x01, 0xF3, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xE7,
  0xC0, 0x0F, 0xC7, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0x03, 0xE0, 0x3F, 0x03,
  0xF0, 0x7E, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0xCF, 0xC0, 0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xFC,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x9F, 0x80,
  0xFC, 0x7E, 0x1F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xEF, 0x81,
  0xFC, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F,
  0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x7F, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x81,
  0xF3, 0xFF, 0x07, 0x9F, 0xFE, 0x1E, 0x78, 0xF8, 0xFB, 0xE1, 0xFF, 0xEF,
  0x87, 0xFF, 0x3C, 0x0F, 0xF8, 0xF0, 0x1F, 0xC0,
};

const GFXglyph JetBrainsMono_BoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 11, 30, 25, 7, -30 },
  { 43, 15, 12, 25, 7, -30 },
  { 66, 25, 30, 25, 0, -30 },
  { 160, 23, 42, 25, 1, -36 },
  { 281, 30, 30, 25, -2, -30 },
  { 394, 24, 30, 25, 0, -30 },
  { 484, 7, 12, 25, 11, -30 },
  { 495, 18, 40, 25, 6, -35 },
  { 585, 18, 40, 25, 2, -35 },
  { 675, 22, 21, 25, 2, -25 },
  { 733, 21, 19, 25, 2, -23 },
  { 783, 12, 13, 25, 3, -6 },
  { 803, 15, 5, 25, 5, -16 },
  { 813, 8, 7, 25, 7, -7 },
  { 820, 26, 39, 25, 0, -34 },
  { 947, 22, 30, 25, 2, -30 },
  { 1030, 20, 30, 25, 2, -30 },
  { 1105, 23, 30, 25, 1, -30 },
  { 1192, 21, 30, 25, 2, -30 },
  { 1271, 21, 30, 25, 2, -30 },
  { 1350, 22, 30, 25, 2, -30 },
  { 1433, 21, 30, 25, 1, -30 },
  { 1512, 21, 30, 25, 4, -30 },
  { 1591, 23, 30, 25, 1, -30 },
  { 1678, 21, 30, 25, 3, -30 },
  { 1757, 11, 23, 25, 7, -23 },
  { 1789, 14, 30, 25, 4, -23 },
  { 1842, 21, 23, 25, 3, -25 },
  { 1903, 20, 15, 25, 3, -21 },
  { 1941, 20, 23, 25, 2, -25 },
  { 1999, 18, 30, 25, 5, -30 },
  { 2067, 25, 37, 25, 0, -30 },
  { 2183, 21, 30, 25, 0, -30 },
  { 2262, 23, 30, 25, 1, -30 },
  { 2349, 22, 30, 25, 2, -30 },
  { 2432, 23, 30, 25, 1, -30 },
  { 2519, 23, 30, 25, 2, -30 },
  { 2606, 24, 30, 25, 1, -30 },
  { 2696, 22, 30, 25, 2, -30 },
  { 2779, 23, 30, 25, 1, -30 },
  { 2866, 22, 30, 25, 2, -30 },
  { 2949, 24, 30, 25, 0, -30 },
  { 3039, 25, 30, 25, 1, -30 },
  { 3133, 19, 30, 25, 2, -30 },
  { 3205, 25, 30, 25, 0, -30 },
  { 3299, 24, 30, 25, 1, -30 },
  { 3389, 22, 30, 25, 2, -30 },
  { 3472, 24, 30, 25, 1, -30 },
  { 3562, 22, 37, 25, 2, -30 },
  { 3664, 23, 30, 25, 1, -30 },
  { 3751, 23, 30, 25, 1, -30 },
  { 3838, 22, 30, 25, 4, -30 },
  { 3921, 23, 30, 25, 2, -30 },
  { 4008, 22, 30, 25, 4, -30 },
  { 4091, 25, 30, 25, 2, -30 },
  { 4185, 27, 30, 25, -1, -30 },
  { 4287, 23, 30, 25, 4, -30 },
  { 4374, 23, 30, 25, 1, -30 },
  { 4461, 18, 39, 25, 5, -34 },
  { 4549, 14, 39, 25, 6, -34 },
  { 4618, 18, 39, 25, 3, -34 },
  { 4706, 19, 16, 25, 3, -30 },
  { 4744, 20, 5, 25, 0, 1 },
  { 4757, 9, 6, 25, 10, -32 },
  { 4764, 21, 23, 25, 2, -23 },
  { 4825, 22, 30, 25, 1, -30 },
  { 4908, 21, 23, 25, 2, -23 },
  { 4969, 22, 30, 25, 2, -30 },
  { 5052, 21, 23, 25, 2, -23 },
  { 5113, 28, 37, 25, -2, -30 },
  { 5243, 21, 30, 25, 2, -23 },
  { 5322, 22, 30, 25, 1, -30 },
  { 5405, 21, 32, 25, 1, -32 },
  { 5489, 22, 39, 25, 0, -32 },
  { 5597, 24, 30, 25, 1, -30 },
  { 5687, 19, 30, 25, 3, -30 },
  { 5759, 24, 23, 25, 0, -23 },
  { 5828, 22, 23, 25, 1, -23 },
  { 5892, 21, 23, 25, 2, -23 },
  { 5953, 23, 30, 25, 0, -23 },
  { 6040, 21, 30, 25, 2, -23 },
  { 6119, 22, 23, 25, 2, -23 },
  { 6183, 22, 23, 25, 1, -23 },
  { 6247, 20, 29, 25, 3, -29 },
  { 6320, 21, 23, 25, 2, -23 },
  { 6381, 22, 23, 25, 3, -23 },
  { 6445, 24, 23, 25, 2, -23 },
  { 6514, 24, 23, 25, 0, -23 },
  { 6583, 21, 30, 25, 2, -23 },
  { 6662, 22, 23, 25, 1, -23 },
  { 6726, 22, 39, 25, 3, -34 },
  { 6834, 11, 39, 25, 7, -34 },
  { 6888, 21, 39, 25, 1, -34 },
  { 6991, 22, 9, 25, 2, -19 },
};

const GFXfont JetBrainsMono_BoldItalic41pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic41pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _JETBRAINSMONO_BOLDITALIC41PT7B_H_
