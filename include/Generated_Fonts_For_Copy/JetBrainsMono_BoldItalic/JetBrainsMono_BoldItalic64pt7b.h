#ifndef _JETBRAINSMONO_BOLDITALIC64PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xCF,
  0xF0, 0x3F, 0xE7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8,
  0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0xC1, 0xFF, 0x3F, 0xC0, 0xFF,
  0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xF8, 0x0F,
  0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00,
  0xFE, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0x9E, 0x7F, 0xE0, 0x3F, 0xE3, 0xE3, 0xFE, 0x03, 0xFC,
  0x3C, 0x3F, 0xE0, 0x3F, 0xC3, 0xC1, 0xFE, 0x07, 0xF8, 0x3C, 0x1F, 0xE0,
  0x7F, 0x83, 0xC1, 0xFE, 0x07, 0xF8, 0x3C, 0x00, 0x00, 0x7F, 0x83, 0xC0,
  0x00, 0x07, 0xFC, 0x78, 0x00, 0x00, 0x7F, 0xC7, 0x80, 0x00, 0x07, 0xFE,
  0x78, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x1E, 0x7F, 0xF0, 0x00, 0x01, 0xE3, 0xFF, 0x00, 0x00, 0x1E, 0x1F,
  0xF0, 0x00, 0x01, 0xE0, 0xFF, 0x00, 0x00, 0x1E, 0x0F, 0xF0, 0x00, 0x03,
  0xE0, 0xFF, 0x07, 0xF8, 0x3C, 0x0F, 0xF0, 0x7F, 0x83, 0xC0, 0xFF, 0x07,
  0xF8, 0x3C, 0x1F, 0xE0, 0x7F, 0x83, 0xC1, 0xFE, 0x07, 0xFC, 0x3C, 0x3F,
  0xE0, 0x7F, 0xE3, 0xC7, 0xFC, 0x07, 0xFF, 0xFB, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x00, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x03,
  0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xC7,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xF9, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xC7, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0xE1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x1F, 0xC0, 0x00, 0x0F,
  0xE3, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x07,
  0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x7C,
  0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0,
  0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xF0,
  0x01, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xF8, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xF1, 0xFF, 0x7F, 0x81, 0xFE, 0x3F, 0xE3,
  0xFC, 0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC1, 0xFE, 0x7F, 0x83,
  0xF8, 0x1F, 0xE7, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0x07, 0xF8, 0x0F, 0xFF,
  0xE0, 0x7F, 0x80, 0x7F, 0xFC, 0x07, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0x80,
  0x3F, 0xF8, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xF8, 0x07, 0xFF,
  0x80, 0x7F, 0xC1, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xDF, 0xE0, 0x1F, 0xFF, 0xF0, 0xFF, 0x00,
  0xFF, 0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0x00, 0x00,
  0x00, 0x1F, 0xE7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF3, 0xFE,
  0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x10, 0x01,
  0xF8, 0x00, 0x83, 0xC0, 0x3F, 0x00, 0xF0, 0xFE, 0x07, 0xE0, 0x7F, 0x1F,
  0xF0, 0xF8, 0x3F, 0xE7, 0xFF, 0x1F, 0x1F, 0xFC, 0xFF, 0xF1, 0xCF, 0xFF,
  0xBF, 0xFF, 0xBB, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFD, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x1F,
  0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x03, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x0F,
  0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE,
  0xFF, 0xE3, 0xFE, 0x0F, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x07, 0x81, 0xFE, 0x1F, 0xC3, 0xF0, 0x7F,
  0x07, 0xF1, 0xFE, 0x1F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE3,
  0xFC, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x3F,
  0x0F, 0xE0, 0xFE, 0x07, 0x83, 0xF8, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0x3F, 0xC0, 0x0F, 0xFC, 0x7F, 0x80, 0x1F, 0xE1,
  0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7C, 0x07, 0xF8, 0x00, 0xF0, 0x0F,
  0xF0, 0x01, 0x80, 0x1F, 0xE0, 0x06, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xF0,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x74, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x01,
  0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x0E, 0x00, 0x01, 0xFC, 0x7F, 0xF8,
  0x00, 0xFF, 0x3F, 0xFF, 0x00, 0x3F, 0xDF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xF9,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC3, 0xC0, 0x00, 0x7F, 0xCF, 0xFE, 0x00, 0x3F, 0xDF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x1F,
  0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x8F,
  0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFD, 0xFF, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFE,
  0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x3F,
  0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03,
  0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F,
  0xF8, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFE, 0x7F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x1F,
  0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF7, 0xF8, 0x03, 0xFF, 0xF7,
  0xFC, 0x00, 0xFF, 0xF7, 0xFC, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x07,
  0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x07, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x04, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0xFE, 0x0F, 0xE0, 0x1F, 0xFC, 0xFC, 0x0F,
  0xC0, 0x3F, 0xFE, 0xFC, 0x0F, 0xC0, 0x3F, 0xFE, 0xFC, 0x1F, 0xC0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0xFE, 0x03, 0xFC,
  0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0xC1, 0xFC, 0x01, 0xF8, 0x1F, 0x81,
  0xFC, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x03,
  0xF8, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x3F,
  0x83, 0xF8, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x03, 0xF8,
  0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x07, 0xF0,
  0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7E, 0x03,
  0xF8, 0x1F, 0xE0, 0x7E, 0x03, 0xFF, 0x7F, 0xE0, 0x7E, 0x03, 0xFF, 0xF7,
  0xE0, 0xFE, 0x01, 0xFF, 0xE7, 0xE0, 0xFE, 0x01, 0xFF, 0xE7, 0xE0, 0xFE,
  0x00, 0x7F, 0x8F, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8,
  0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xFE, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xC0, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF8,
  0x07, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01,
  0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xFE, 0x07, 0xF8,
  0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xE0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x87,
  0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC,
  0x1F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0xE0, 0x7F, 0xFD, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x03,
  0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xC0, 0xFF, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xC3, 0xFC, 0x0F, 0xFF, 0xF0,
  0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xC1, 0xFF, 0xFE, 0x0F, 0xF0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xFC, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x80,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7D, 0xF8, 0x0F, 0xDF, 0x01, 0xF7, 0xE0, 0x3F, 0x7C, 0x0F, 0xDF,
  0x81, 0xFD, 0xF0, 0x3E, 0xFE, 0x07, 0xF7, 0xC1, 0xFB, 0xF0, 0x1F, 0xDF,
  0x07, 0xCF, 0xC0, 0x7E, 0x7E, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0xF9, 0xFC,
  0x07, 0xE3, 0xE7, 0xE7, 0xF0, 0x3F, 0x8F, 0x9F, 0x1F, 0xC0, 0xFE, 0x3E,
  0x7C, 0x7F, 0x03, 0xF8, 0xFB, 0xF3, 0xF8, 0x0F, 0xE3, 0xEF, 0x8F, 0xE0,
  0x3F, 0x8F, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0xF0, 0xFE, 0x07, 0xF8, 0x7F,
  0xC3, 0xF8, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x7F, 0x01,
  0xFC, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x1F, 0xF8, 0x00,
  0x7F, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0x01, 0xFF,
  0xC0, 0x0F, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xE0,
  0x3F, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x3F, 0xFE, 0x00,
  0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0x7E, 0x01, 0xFE, 0x07, 0xF7,
  0xE0, 0x1F, 0xC0, 0x7F, 0x7E, 0x01, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xC0,
  0x7F, 0x7F, 0x01, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0xC0, 0xFF, 0x3F, 0x03,
  0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0xC0, 0xFE, 0x3F, 0x03, 0xF8, 0x0F, 0xE3,
  0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0x83, 0xF8, 0x0F, 0xE1, 0xF8, 0x3F, 0x80,
  0xFE, 0x1F, 0x87, 0xF8, 0x1F, 0xE1, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xC7,
  0xF0, 0x1F, 0xC1, 0xFC, 0x7F, 0x01, 0xFC, 0x0F, 0xC7, 0xF0, 0x1F, 0xC0,
  0xFC, 0x7F, 0x01, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0xC0, 0xFE, 0x7F, 0x03,
  0xFC, 0x0F, 0xE7, 0xE0, 0x3F, 0x80, 0x7E, 0xFE, 0x03, 0xF8, 0x07, 0xEF,
  0xE0, 0x3F, 0x80, 0x7E, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0x80,
  0x7F, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0x00, 0x3F, 0xFC, 0x07,
  0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xF0, 0x03, 0xFF,
  0xC0, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0x00,
  0x1F, 0xF8, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFC,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x3F,
  0xE0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07,
  0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x7F, 0xC0, 0x7F, 0xFD, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F,
  0xFC, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07,
  0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0xFF,
  0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xFD, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xBF,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x3F,
  0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x03,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xF9, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F,
  0xCF, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x1F,
  0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01,
  0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x1F, 0xEF, 0xE0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0xFE,
  0x3F, 0x00, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0x03, 0xF1, 0xFC, 0x07,
  0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xF0, 0x1F, 0xC7, 0xF0, 0x1F, 0xE0, 0x3F,
  0x8F, 0xE0, 0x3F, 0xC0, 0x7E, 0x1F, 0xC0, 0xF7, 0x81, 0xFC, 0x3F, 0x81,
  0xEF, 0x03, 0xF8, 0x7F, 0x03, 0xDE, 0x07, 0xF0, 0xFE, 0x07, 0xBC, 0x0F,
  0xC1, 0xFC, 0x1F, 0x78, 0x3F, 0x83, 0xF0, 0x3D, 0xF0, 0x7F, 0x07, 0xE0,
  0x7B, 0xE0, 0xFC, 0x0F, 0xC1, 0xF7, 0xC1, 0xF8, 0x1F, 0x83, 0xEF, 0x87,
  0xF0, 0x3F, 0x07, 0x9E, 0x0F, 0xE0, 0x7E, 0x0F, 0x3C, 0x1F, 0x80, 0xFC,
  0x3E, 0x78, 0x3F, 0x01, 0xF8, 0x78, 0xF0, 0xFE, 0x07, 0xF0, 0xF1, 0xE1,
  0xFC, 0x0F, 0xE3, 0xE3, 0xC3, 0xF0, 0x1F, 0xC7, 0xC7, 0x87, 0xE0, 0x3F,
  0x8F, 0x0F, 0x1F, 0xC0, 0x7F, 0x1E, 0x1E, 0x3F, 0x80, 0xFE, 0x7C, 0x3C,
  0x7E, 0x01, 0xF8, 0xF8, 0x78, 0xFC, 0x03, 0xF1, 0xE0, 0xF3, 0xF8, 0x07,
  0xE3, 0xC1, 0xE7, 0xE0, 0x0F, 0xCF, 0x83, 0xCF, 0xC0, 0x1F, 0x9E, 0x07,
  0x9F, 0x80, 0x3F, 0x3C, 0x1F, 0x7F, 0x00, 0x7E, 0xF8, 0x3E, 0xFC, 0x00,
  0xFD, 0xF0, 0x7D, 0xF8, 0x01, 0xFB, 0xC0, 0xFB, 0xF0, 0x03, 0xF7, 0x81,
  0xF7, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xBF, 0x00,
  0x3F, 0xF8, 0x0F, 0x7E, 0x00, 0x7E, 0xF0, 0x1E, 0xFC, 0x00, 0xFF, 0xE0,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x8F, 0xF8, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x0F, 0xF7,
  0xFC, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x00, 0x3F,
  0xE3, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xC0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0xBF,
  0x80, 0x01, 0xFE, 0x7E, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE,
  0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFF, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x03,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xC0, 0x1F, 0xFF, 0x9F, 0xE0, 0x3F, 0xFF,
  0xCF, 0xF0, 0x3F, 0xFF, 0xF7, 0xF8, 0x1F, 0xFF, 0xFB, 0xFC, 0x1F, 0xFF,
  0xFD, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0x0F, 0xF8,
  0x00, 0xFF, 0x87, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x3F, 0xE1, 0xFE,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFE,
  0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0xC7, 0xFF,
  0xC1, 0xFF, 0xFF, 0xDF, 0xE0, 0x7F, 0xFF, 0xEF, 0xE0, 0x3F, 0xFF, 0xEF,
  0xF0, 0x0F, 0xFF, 0xE7, 0xF8, 0x03, 0xFF, 0xE3, 0xFC, 0x00, 0xFF, 0xE1,
  0xFE, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x03, 0xFC, 0x7F,
  0xF8, 0x01, 0xFE, 0x3F, 0xFF, 0x00, 0x7F, 0x9F, 0xFF, 0xE0, 0x1F, 0xEF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0x78, 0x3F, 0xF8, 0x3F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07,
  0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xFC, 0x7F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0xFF,
  0x80, 0xFF, 0x3F, 0xFF, 0xC0, 0x3F, 0xC7, 0xFF, 0xE0, 0x0F, 0xF0, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x01,
  0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0xE7, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x3F, 0xC0, 0x03, 0xFF, 0x87, 0xF8,
  0x00, 0xFF, 0xFC, 0xFF, 0x00, 0x7F, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF, 0xFB,
  0xFC, 0x03, 0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0xEF, 0xE0, 0x3F, 0xF8,
  0x3F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F,
  0xF0, 0x1F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0xDF, 0xC0, 0x1F,
  0xFF, 0xF7, 0xF8, 0x01, 0xFF, 0xFC, 0xFF, 0x00, 0x1F, 0xFF, 0x1F, 0xE0,
  0x01, 0xFF, 0xC3, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x8F,
  0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xC0, 0x1F,
  0xFF, 0x9F, 0xE0, 0x3F, 0xFF, 0xCF, 0xF0, 0x3F, 0xFF, 0xF7, 0xF8, 0x1F,
  0xFF, 0xFB, 0xFC, 0x1F, 0xFF, 0xFD, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F,
  0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xBF, 0xC0, 0x7F, 0xFF, 0x9F, 0xE0, 0x1F, 0xFF,
  0x8F, 0xE0, 0x07, 0xFF, 0x8F, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0x3F, 0xC7,
  0xFF, 0x80, 0x3F, 0xC7, 0xFF, 0xE0, 0x1F, 0xE7, 0xFF, 0xF8, 0x0F, 0xF7,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFD,
  0xC0, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F,
  0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0x0F,
  0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01,
  0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x10, 0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x1F,
  0xE0, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0xE0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x7F, 0x3F, 0x83, 0xFC, 0x07, 0xE7, 0xFC, 0x7F,
  0xE0, 0x7E, 0xFF, 0xCF, 0xFE, 0x0F, 0xEF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0xFF, 0x0F,
  0xE0, 0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xC0, 0xFF, 0x0F, 0xE0, 0x7C, 0x0F,
  0xE1, 0xFC, 0x0F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F,
  0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xC1, 0xFE, 0x1F,
  0xC0, 0xF8, 0x1F, 0xC3, 0xFC, 0x1F, 0x81, 0xFC, 0x3F, 0x81, 0xF8, 0x1F,
  0xC3, 0xF8, 0x1F, 0x81, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F,
  0x81, 0xFC, 0x3F, 0x81, 0xF0, 0x3F, 0x87, 0xF8, 0x3F, 0x03, 0xF8, 0x7F,
  0x03, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x3F,
  0x87, 0xF0, 0x3F, 0x03, 0xF8, 0x7F, 0x03, 0xE0, 0x7F, 0x87, 0xF0, 0x3E,
  0x07, 0xF0, 0xFE, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0xFE,
  0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0x7F,
  0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x3F,
  0xFC, 0x01, 0xFE, 0x3F, 0xFF, 0x00, 0xFF, 0x3F, 0xFF, 0xC0, 0x7F, 0xBF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xEE,
  0x07, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0x7F,
  0x80, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE,
  0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF0,
  0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0,
  0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0,
  0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80,
  0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80,
  0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80,
  0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xF9, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE1, 0xFF, 0xE0, 0x01,
  0xFE, 0x3F, 0xFF, 0x00, 0x1F, 0xE7, 0xFF, 0xF8, 0x01, 0xFE, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xDE,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF8, 0x0F,
  0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xEF, 0xFF, 0xF8, 0x03, 0xFC, 0xFF, 0xFF, 0x00, 0x3F,
  0xC7, 0xFF, 0xC0, 0x03, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xC0, 0x70, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xC0, 0x1F,
  0xFF, 0x1F, 0xE0, 0x3F, 0xFF, 0xCF, 0xF0, 0x3F, 0xFF, 0xF7, 0xF8, 0x1F,
  0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x03,
  0xFF, 0x83, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xFF, 0xDF, 0xE0, 0x7F, 0xFF,
  0xEF, 0xE0, 0x3F, 0xFF, 0xEF, 0xF0, 0x0F, 0xFF, 0xE7, 0xF8, 0x03, 0xFF,
  0xE3, 0xFC, 0x00, 0xFF, 0xC1, 0xFE, 0x00, 0x07, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0x8F, 0xFF, 0xC0, 0x1F, 0xE7, 0xFF,
  0xF8, 0x07, 0xFB, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xF8, 0x03, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xFC,
  0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x9F, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xE0,
  0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xFC, 0x7F,
  0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x80,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFE,
  0x01, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x7E, 0xFC, 0x03, 0xF8, 0x07,
  0xEF, 0xC0, 0x3F, 0x80, 0xFE, 0xFC, 0x07, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F,
  0x80, 0xFC, 0xFC, 0x07, 0xF8, 0x1F, 0xCF, 0xC0, 0xF7, 0x81, 0xF8, 0xFC,
  0x0F, 0x78, 0x1F, 0x8F, 0xC0, 0xF7, 0x81, 0xF8, 0xFC, 0x1F, 0x78, 0x3F,
  0x8F, 0xC1, 0xE7, 0x83, 0xF0, 0xFC, 0x1E, 0x78, 0x3F, 0x0F, 0xC3, 0xE7,
  0x87, 0xF0, 0xFC, 0x3C, 0x78, 0x7E, 0x0F, 0xC3, 0xC7, 0x87, 0xE0, 0xFC,
  0x7C, 0x78, 0xFE, 0x0F, 0xC7, 0x87, 0x8F, 0xC0, 0xFC, 0x78, 0x78, 0xFC,
  0x0F, 0xC7, 0x87, 0x9F, 0xC0, 0xFC, 0xF8, 0x79, 0xF8, 0x0F, 0xCF, 0x07,
  0x9F, 0x80, 0xFC, 0xF0, 0x79, 0xF8, 0x0F, 0xDF, 0x07, 0xBF, 0x00, 0xFD,
  0xE0, 0x7B, 0xF0, 0x0F, 0xDE, 0x07, 0xBF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xE0,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFE, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0xFF, 0x03, 0xFF, 0xFE, 0x7F, 0x80,
  0xFF, 0xFE, 0x3F, 0x80, 0x3F, 0xFE, 0x3F, 0xC0, 0x07, 0xFE, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x40,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x02, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0xFF, 0xFC, 0x01,
  0xFC, 0x7F, 0xFF, 0x80, 0x7F, 0x3F, 0xFF, 0xE0, 0x1F, 0x8F, 0xFF, 0xFC,
  0x0F, 0xE7, 0xF8, 0xFF, 0x03, 0xF9, 0xFC, 0x1F, 0xE0, 0xFE, 0x7F, 0x03,
  0xFE, 0xFF, 0x9F, 0x80, 0xFF, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0xE3, 0xF8,
  0x07, 0xFF, 0xF8, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0x80, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00,
};

const GFXglyph JetBrainsMono_BoldItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 17, 47, 38, 11, -47 },
  { 101, 25, 19, 38, 10, -47 },
  { 161, 38, 47, 38, 1, -47 },
  { 385, 36, 65, 38, 2, -56 },
  { 678, 46, 47, 38, -3, -47 },
  { 949, 36, 48, 38, 1, -47 },
  { 1165, 11, 19, 38, 17, -47 },
  { 1192, 28, 62, 38, 9, -54 },
  { 1409, 27, 62, 38, 3, -54 },
  { 1619, 35, 33, 38, 3, -39 },
  { 1764, 32, 30, 38, 4, -36 },
  { 1884, 19, 20, 38, 5, -10 },
  { 1932, 23, 8, 38, 8, -25 },
  { 1955, 13, 12, 38, 11, -11 },
  { 1975, 40, 60, 38, 0, -53 },
  { 2275, 34, 48, 38, 3, -47 },
  { 2479, 31, 47, 38, 3, -47 },
  { 2662, 35, 47, 38, 2, -47 },
  { 2868, 35, 48, 38, 2, -47 },
  { 3078, 33, 47, 38, 3, -47 },
  { 3272, 34, 48, 38, 3, -47 },
  { 3476, 33, 48, 38, 2, -47 },
  { 3674, 33, 47, 38, 6, -47 },
  { 3868, 35, 48, 38, 2, -47 },
  { 4078, 33, 47, 38, 5, -47 },
  { 4272, 17, 37, 38, 11, -36 },
  { 4351, 23, 46, 38, 5, -36 },
  { 4484, 32, 35, 38, 5, -39 },
  { 4624, 32, 23, 38, 4, -33 },
  { 4716, 32, 35, 38, 3, -39 },
  { 4856, 28, 47, 38, 8, -47 },
  { 5021, 40, 58, 38, 0, -47 },
  { 5311, 34, 47, 38, -1, -47 },
  { 5511, 36, 47, 38, 2, -47 },
  { 5723, 34, 48, 38, 3, -47 },
  { 5927, 35, 47, 38, 2, -47 },
  { 6133, 35, 47, 38, 3, -47 },
  { 6339, 37, 47, 38, 2, -47 },
  { 6557, 34, 48, 38, 3, -47 },
  { 6761, 36, 47, 38, 2, -47 },
  { 6973, 34, 47, 38, 3, -47 },
  { 7173, 37, 48, 38, 0, -47 },
  { 7395, 39, 47, 38, 2, -47 },
  { 7625, 29, 47, 38, 4, -47 },
  { 7796, 38, 47, 38, 1, -47 },
  { 8020, 36, 47, 38, 2, -47 },
  { 8232, 34, 48, 38, 3, -47 },
  { 8436, 37, 47, 38, 2, -47 },
  { 8654, 34, 59, 38, 3, -47 },
  { 8905, 36, 47, 38, 2, -47 },
  { 9117, 36, 48, 38, 2, -47 },
  { 9333, 34, 47, 38, 6, -47 },
  { 9533, 35, 48, 38, 3, -47 },
  { 9743, 34, 47, 38, 7, -47 },
  { 9943, 39, 47, 38, 3, -47 },
  { 10173, 41, 47, 38, -1, -47 },
  { 10414, 36, 47, 38, 6, -47 },
  { 10626, 35, 47, 38, 2, -47 },
  { 10832, 27, 60, 38, 8, -53 },
  { 11035, 22, 60, 38, 9, -53 },
  { 11200, 27, 60, 38, 5, -53 },
  { 11403, 30, 25, 38, 5, -47 },
  { 11497, 31, 7, 38, 0, 2 },
  { 11525, 14, 9, 38, 16, -50 },
  { 11541, 33, 37, 38, 3, -36 },
  { 11694, 34, 48, 38, 2, -47 },
  { 11898, 33, 37, 38, 3, -36 },
  { 12051, 35, 48, 38, 3, -47 },
  { 12261, 32, 37, 38, 3, -36 },
  { 12409, 44, 59, 38, -4, -47 },
  { 12734, 33, 48, 38, 3, -36 },
  { 12932, 33, 47, 38, 2, -47 },
  { 13126, 32, 50, 38, 2, -50 },
  { 13326, 34, 62, 38, 1, -50 },
  { 13590, 37, 47, 38, 2, -47 },
  { 13808, 29, 47, 38, 5, -47 },
  { 13979, 36, 36, 38, 1, -36 },
  { 14141, 33, 36, 38, 2, -36 },
  { 14290, 32, 37, 38, 3, -36 },
  { 14438, 36, 48, 38, 0, -36 },
  { 14654, 33, 48, 38, 3, -36 },
  { 14852, 34, 36, 38, 3, -36 },
  { 15005, 34, 37, 38, 2, -36 },
  { 15163, 33, 45, 38, 4, -45 },
  { 15349, 33, 36, 38, 3, -35 },
  { 15498, 34, 35, 38, 5, -35 },
  { 15647, 36, 35, 38, 4, -35 },
  { 15805, 38, 35, 38, 0, -35 },
  { 15972, 33, 47, 38, 3, -35 },
  { 16166, 33, 35, 38, 2, -35 },
  { 16311, 34, 60, 38, 5, -53 },
  { 16566, 18, 60, 38, 11, -53 },
  { 16701, 34, 60, 38, 1, -53 },
  { 16956, 34, 15, 38, 3, -30 },
};

const GFXfont JetBrainsMono_BoldItalic64pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic64pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic64pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _JETBRAINSMONO_BOLDITALIC64PT7B_H_
