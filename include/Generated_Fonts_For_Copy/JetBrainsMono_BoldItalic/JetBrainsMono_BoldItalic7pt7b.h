#ifndef _JETBRAINSMONO_BOLDITALIC7PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC7PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x54, 0x80, 0xB4, 0x37, 0x6F, 0xA0, 0x27, 0x66, 0x3E, 0x40, 0xFF,
  0x08, 0xEB, 0x00, 0x74, 0x5A, 0xF0, 0xC0, 0x2A, 0x49, 0x10, 0x44, 0x92,
  0xA0, 0x2F, 0x60, 0x2F, 0x60, 0xE0, 0xC0, 0xC0, 0x11, 0x22, 0x44, 0x80,
  0x75, 0xB9, 0x60, 0x6A, 0x22, 0xF0, 0x71, 0x24, 0xF0, 0x72, 0x31, 0xE0,
  0x32, 0x5F, 0x20, 0x74, 0x71, 0xE0, 0x34, 0x79, 0x60, 0xE5, 0x28, 0x75,
  0x69, 0xE0, 0xF7, 0xA8, 0x43, 0x43, 0x80, 0x73, 0x10, 0x70, 0xF0, 0x43,
  0x68, 0xE7, 0x08, 0x79, 0xBD, 0xBC, 0x26, 0x66, 0x90, 0x75, 0x69, 0xE0,
  0x74, 0x49, 0x60, 0x75, 0x59, 0xE0, 0x74, 0x78, 0xF0, 0x74, 0x78, 0x80,
  0x74, 0x79, 0x60, 0x55, 0x79, 0xA0, 0x72, 0x22, 0xE0, 0x31, 0x19, 0xE0,
  0x56, 0x6A, 0x90, 0x44, 0x44, 0xF0, 0x5D, 0xB9, 0x90, 0x55, 0xBB, 0xA0,
  0x75, 0x59, 0x60, 0x75, 0x78, 0x80, 0x75, 0x99, 0x62, 0x75, 0x7A, 0xB0,
  0x74, 0x61, 0xE0, 0xE9, 0x28, 0x55, 0x59, 0x60, 0xB7, 0x6C, 0xAD, 0xBD,
  0xEA, 0x00, 0x56, 0x26, 0x90, 0xBA, 0xC4, 0x80, 0x72, 0x24, 0xE0, 0x6A,
  0x49, 0x30, 0xA9, 0x54, 0xE9, 0x24, 0xB0, 0x56, 0x80, 0xE0, 0x80, 0x75,
  0x9E, 0x47, 0x59, 0xE0, 0x74, 0x96, 0x17, 0x59, 0xE0, 0x75, 0xA7, 0x33,
  0xC4, 0x4C, 0x75, 0x97, 0x60, 0x47, 0x59, 0xA0, 0x22, 0x62, 0x2F, 0x11,
  0x62, 0x22, 0xE0, 0x45, 0x6A, 0xB0, 0xCA, 0x4E, 0x7B, 0xBD, 0x75, 0x9A,
  0x75, 0x96, 0x75, 0x9E, 0x80, 0x75, 0x9F, 0x20, 0x75, 0x48, 0x74, 0x3E,
  0x2F, 0x44, 0x60, 0x55, 0x96, 0xB7, 0x60, 0xBB, 0xFA, 0x56, 0x6B, 0x55,
  0x96, 0x60, 0x72, 0x4E, 0x29, 0x44, 0x90, 0x55, 0x68, 0x62, 0x23, 0x44,
  0xC0, 0xF0,
};

const GFXglyph JetBrainsMono_BoldItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 3, 2, 4, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 7, 4, 0, -6 },
  { 11, 5, 5, 4, 0, -5 },
  { 15, 4, 5, 4, 0, -5 },
  { 18, 1, 2, 4, 2, -5 },
  { 19, 3, 7, 4, 1, -6 },
  { 22, 3, 7, 4, 0, -6 },
  { 25, 4, 3, 4, 0, -4 },
  { 27, 4, 3, 4, 0, -4 },
  { 29, 2, 2, 4, 1, -1 },
  { 30, 2, 1, 4, 1, -3 },
  { 31, 2, 1, 4, 1, -1 },
  { 32, 4, 7, 4, 0, -6 },
  { 36, 4, 5, 4, 0, -5 },
  { 39, 4, 5, 4, 0, -5 },
  { 42, 4, 5, 4, 0, -5 },
  { 45, 4, 5, 4, 0, -5 },
  { 48, 4, 5, 4, 0, -5 },
  { 51, 4, 5, 4, 0, -5 },
  { 54, 4, 5, 4, 0, -5 },
  { 57, 3, 5, 4, 1, -5 },
  { 59, 4, 5, 4, 0, -5 },
  { 62, 3, 5, 4, 1, -5 },
  { 64, 2, 4, 4, 1, -4 },
  { 65, 2, 5, 4, 1, -4 },
  { 67, 3, 4, 4, 1, -4 },
  { 69, 4, 3, 4, 0, -4 },
  { 71, 4, 4, 4, 0, -4 },
  { 73, 3, 5, 4, 1, -5 },
  { 75, 4, 6, 4, 0, -5 },
  { 78, 4, 5, 4, 0, -5 },
  { 81, 4, 5, 4, 0, -5 },
  { 84, 4, 5, 4, 0, -5 },
  { 87, 4, 5, 4, 0, -5 },
  { 90, 4, 5, 4, 0, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 4, 5, 4, 0, -5 },
  { 99, 4, 5, 4, 0, -5 },
  { 102, 4, 5, 4, 0, -5 },
  { 105, 4, 5, 4, 0, -5 },
  { 108, 4, 5, 4, 0, -5 },
  { 111, 4, 5, 4, 0, -5 },
  { 114, 4, 5, 4, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 4, 6, 4, 0, -5 },
  { 129, 4, 5, 4, 0, -5 },
  { 132, 4, 5, 4, 0, -5 },
  { 135, 3, 5, 4, 1, -5 },
  { 137, 4, 5, 4, 0, -5 },
  { 140, 3, 5, 4, 1, -5 },
  { 142, 5, 5, 4, 0, -5 },
  { 146, 4, 5, 4, 0, -5 },
  { 149, 4, 5, 4, 1, -5 },
  { 152, 4, 5, 4, 0, -5 },
  { 155, 3, 7, 4, 1, -6 },
  { 158, 2, 7, 4, 1, -6 },
  { 160, 3, 7, 4, 1, -6 },
  { 163, 3, 3, 4, 1, -5 },
  { 165, 3, 1, 4, 0, 0 },
  { 166, 1, 1, 4, 2, -6 },
  { 167, 4, 4, 4, 0, -4 },
  { 169, 4, 5, 4, 0, -5 },
  { 172, 4, 4, 4, 0, -4 },
  { 174, 4, 5, 4, 0, -5 },
  { 177, 4, 4, 4, 0, -4 },
  { 179, 4, 6, 4, 0, -5 },
  { 182, 4, 5, 4, 0, -4 },
  { 185, 4, 5, 4, 0, -5 },
  { 188, 4, 6, 4, 0, -6 },
  { 191, 4, 7, 4, 0, -6 },
  { 195, 4, 5, 4, 0, -5 },
  { 198, 3, 5, 4, 1, -5 },
  { 200, 4, 4, 4, 0, -4 },
  { 202, 4, 4, 4, 0, -4 },
  { 204, 4, 4, 4, 0, -4 },
  { 206, 4, 5, 4, 0, -4 },
  { 209, 4, 5, 4, 0, -4 },
  { 212, 4, 4, 4, 0, -4 },
  { 214, 4, 4, 4, 0, -4 },
  { 216, 4, 5, 4, 0, -5 },
  { 219, 4, 4, 4, 0, -4 },
  { 221, 3, 4, 4, 1, -4 },
  { 223, 4, 4, 4, 0, -4 },
  { 225, 4, 4, 4, 0, -4 },
  { 227, 4, 5, 4, 0, -4 },
  { 230, 4, 4, 4, 0, -4 },
  { 232, 3, 7, 4, 1, -6 },
  { 235, 2, 7, 4, 1, -6 },
  { 237, 4, 7, 4, 0, -6 },
  { 241, 4, 1, 4, 0, -3 },
};

const GFXfont JetBrainsMono_BoldItalic7pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic7pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _JETBRAINSMONO_BOLDITALIC7PT7B_H_
