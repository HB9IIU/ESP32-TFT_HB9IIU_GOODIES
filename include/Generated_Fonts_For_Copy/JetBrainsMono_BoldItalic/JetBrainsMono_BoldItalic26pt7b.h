#ifndef _JETBRAINSMONO_BOLDITALIC26PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x73, 0xCF, 0x3C, 0xE3, 0x8E, 0x38, 0xE3, 0x0C, 0x70, 0x00,
  0x00, 0xF3, 0xCF, 0x00, 0x71, 0xDC, 0x77, 0x3D, 0xCF, 0x73, 0xB8, 0xEE,
  0x3B, 0x8E, 0x01, 0xC7, 0x01, 0x86, 0x03, 0x8E, 0x03, 0x0C, 0x03, 0x0C,
  0x3F, 0xFF, 0x3F, 0xFF, 0x06, 0x18, 0x0E, 0x38, 0x0C, 0x30, 0x0C, 0x30,
  0x1C, 0x70, 0x7F, 0xFC, 0xFF, 0xFC, 0x38, 0xE0, 0x30, 0xC0, 0x30, 0xC0,
  0x71, 0xC0, 0x61, 0x80, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x07,
  0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x6F, 0x39, 0x9C, 0xE6, 0x03, 0x90, 0x0F,
  0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0x78, 0x08, 0xEE,
  0x27, 0xBD, 0x9C, 0xFF, 0xF1, 0xFF, 0x83, 0xF8, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x07, 0x80, 0xE3, 0xF8, 0x30, 0x63, 0x0C, 0x0C,
  0x63, 0x83, 0x8C, 0xE0, 0x71, 0xB8, 0x0F, 0xE6, 0x00, 0xFD, 0x80, 0x04,
  0x60, 0x00, 0x18, 0x00, 0x07, 0x20, 0x01, 0xDF, 0x00, 0x77, 0x70, 0x0D,
  0xC6, 0x03, 0x38, 0xC0, 0xC6, 0x38, 0x30, 0xC6, 0x0E, 0x1F, 0xC3, 0x81,
  0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0x70, 0xE0, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xEE, 0x7B, 0x9E,
  0xE7, 0x1F, 0x8E, 0x3E, 0x1C, 0x3C, 0x38, 0x78, 0x7B, 0xF0, 0xFF, 0x70,
  0xFC, 0xF0, 0x77, 0x7F, 0xFE, 0xEE, 0x00, 0x60, 0x3C, 0x0F, 0x83, 0xE0,
  0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xF0, 0x06, 0x00, 0x0C, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x7C, 0x1F,
  0x03, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x10, 0xE1, 0x73,
  0x9D, 0xE5, 0xFF, 0xFF, 0xC0, 0xC0, 0x07, 0x80, 0x77, 0x03, 0xDE, 0x1E,
  0x38, 0x30, 0xF0, 0x41, 0x00, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0xFF, 0xFB, 0xFF, 0xDF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x00, 0x1F, 0x1E, 0x3C, 0x3C, 0x38, 0x78, 0x70, 0xE0, 0x7F,
  0xDF, 0xEF, 0xF8, 0x11, 0xE7, 0xBE, 0x78, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x3F,
  0xE1, 0xFF, 0xCF, 0x0F, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xDE, 0x0E, 0x73,
  0xB9, 0xDE, 0xE7, 0x3B, 0x9C, 0x0E, 0x70, 0x3B, 0xC1, 0xEF, 0x07, 0x3C,
  0x3C, 0x7F, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0x3F, 0x03, 0xF8,
  0x7F, 0xC3, 0x9E, 0x18, 0xE0, 0x87, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFC, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x8F, 0x0F, 0x38, 0x3D, 0xE0,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x00,
  0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x41,
  0xCE, 0x07, 0x3C, 0x3C, 0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x7C,
  0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x1C, 0x38, 0xE1, 0xE7, 0x87, 0x9C, 0x1C, 0x7F, 0xF3, 0xFF, 0xCF, 0xFF,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x1F, 0xFC, 0x7F, 0xF1,
  0xFF, 0xC7, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0xFC, 0x3F, 0xF0,
  0xF1, 0xE4, 0x07, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xEF, 0x07, 0x3C, 0x3C,
  0x7F, 0xE1, 0xFF, 0x83, 0xF8, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0x98, 0x3B, 0xF3, 0xFF, 0xDE, 0x1E,
  0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xFE, 0x0E, 0x7F, 0xF3, 0xFF, 0x0F,
  0xE0, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDC, 0x0E, 0x70, 0x7B, 0xC1, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x07,
  0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x0F, 0x38, 0x1C, 0xE0, 0xF3, 0xC3, 0x87,
  0x3C, 0x1F, 0xE0, 0x3F, 0x03, 0xFF, 0x1E, 0x1C, 0x70, 0x7B, 0xC1, 0xEE,
  0x07, 0xBC, 0x1C, 0xFF, 0xF1, 0xFF, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFF,
  0x8F, 0xFE, 0xF0, 0xF7, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xF0, 0xF3,
  0xFF, 0x9F, 0xF8, 0x33, 0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x00, 0x08, 0x3C, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC7, 0x9F, 0x1E, 0x00, 0x03, 0x03, 0xC3, 0xE1, 0xF0, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xE0, 0xE0, 0xF0, 0x70,
  0x78, 0x38, 0x38, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xE1, 0xFC,
  0x3F, 0x83, 0xE0, 0x1C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1E, 0x00, 0x30, 0x00, 0x80, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x20, 0x01, 0xC0, 0x0F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0x01, 0xF8, 0x3F, 0x87,
  0xE0, 0xFC, 0x0F, 0x80, 0x60, 0x02, 0x00, 0x00, 0x3F, 0x03, 0xFC, 0x3F,
  0xE4, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x3F, 0xC3, 0xF8, 0x3E,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x70,
  0x00, 0x03, 0xF8, 0x07, 0xFE, 0x0F, 0x0E, 0x1C, 0x07, 0x38, 0x07, 0x38,
  0x07, 0x30, 0x77, 0x31, 0xFF, 0x71, 0xCE, 0x73, 0x8E, 0x73, 0x8E, 0x73,
  0x8E, 0x63, 0x8E, 0x63, 0x0E, 0xE3, 0x0C, 0xE3, 0xBC, 0xE3, 0xEC, 0xE0,
  0x80, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x07,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1D, 0xC0,
  0x77, 0x03, 0xCC, 0x0E, 0x38, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x3F, 0xF8,
  0xFF, 0xE3, 0x83, 0x9E, 0x0E, 0x70, 0x3B, 0xC0, 0xEE, 0x03, 0xC0, 0x1F,
  0xF0, 0x7F, 0xE3, 0xFF, 0xCE, 0x0F, 0x38, 0x1C, 0xE0, 0x73, 0x83, 0x8E,
  0x1E, 0x3F, 0xE1, 0xFF, 0x87, 0x1F, 0x1C, 0x1E, 0x70, 0x39, 0xC0, 0xE7,
  0x07, 0xBC, 0x1C, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xF0, 0x3F,
  0xE1, 0xFF, 0xCF, 0x0F, 0x38, 0x1C, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x2F, 0x07, 0x1C,
  0x3C, 0x7F, 0xE1, 0xFF, 0x83, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xE3, 0xFF,
  0x8F, 0x0F, 0x38, 0x3C, 0xE0, 0x73, 0x83, 0xCE, 0x0F, 0x78, 0x39, 0xE0,
  0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC1, 0xE7, 0x07, 0x3C, 0x3C, 0xFF,
  0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0xF0, 0x7F, 0xE1,
  0xFF, 0xC3, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F,
  0xF1, 0xFF, 0xE3, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF1, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0xFF, 0xF1,
  0xFF, 0xC3, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x0F,
  0x38, 0x1C, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC7, 0xE7, 0x1F,
  0x9C, 0xFE, 0x70, 0x39, 0xC1, 0xEF, 0x07, 0x1C, 0x3C, 0x7F, 0xE1, 0xFF,
  0x83, 0xF8, 0x00, 0x1C, 0x1C, 0x70, 0x73, 0xC1, 0xCF, 0x07, 0x38, 0x3C,
  0xE0, 0xF3, 0x83, 0x8E, 0x0E, 0x3F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9C, 0x1E,
  0x70, 0x79, 0xC1, 0xC7, 0x07, 0x3C, 0x1C, 0xF0, 0x73, 0x83, 0xCE, 0x0F,
  0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x7F, 0xF3, 0xFF, 0x8F, 0xFE, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x8E,
  0x07, 0x3C, 0x1E, 0x78, 0x38, 0x7F, 0xF0, 0xFF, 0xC0, 0xFE, 0x00, 0x1C,
  0x0E, 0x38, 0x3C, 0xF0, 0xF1, 0xE1, 0xC3, 0x87, 0x87, 0x1E, 0x0E, 0x38,
  0x1C, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0x8E, 0x07, 0x1E, 0x0E,
  0x1C, 0x1C, 0x38, 0x78, 0x78, 0xE0, 0xF1, 0xC0, 0xE3, 0x81, 0xC0, 0x3C,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1E, 0x0F, 0x1E, 0x1F, 0x1E, 0x1F, 0x1B, 0x1E, 0x1B, 0x36,
  0x3B, 0x3E, 0x3B, 0x6E, 0x3B, 0x6E, 0x3B, 0xEE, 0x3B, 0xCE, 0x3B, 0xDC,
  0x78, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x38,
  0x70, 0x38, 0xE0, 0x38, 0x1E, 0x0E, 0x7C, 0x38, 0xF8, 0x71, 0xF0, 0xE3,
  0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x19, 0x9C, 0x73, 0x38, 0xE6, 0x71, 0xCE,
  0xE3, 0x9D, 0xC7, 0x3B, 0x8E, 0x36, 0x38, 0x6C, 0x70, 0xF8, 0xE1, 0xF1,
  0xC3, 0xE3, 0x83, 0xC0, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x0F, 0x38,
  0x1C, 0xE0, 0xF3, 0x83, 0xCE, 0x0E, 0x78, 0x39, 0xC0, 0xE7, 0x03, 0x9C,
  0x0E, 0x70, 0x79, 0xC1, 0xCF, 0x07, 0x1C, 0x3C, 0x7F, 0xE1, 0xFF, 0x03,
  0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xE1, 0xE3, 0x81, 0xE7,
  0x03, 0xCE, 0x07, 0x1C, 0x0E, 0x38, 0x7C, 0xFF, 0xF1, 0xFF, 0xC3, 0xFC,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF, 0x0F, 0x38, 0x1C, 0xE0,
  0x73, 0x83, 0xDE, 0x0E, 0x78, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70,
  0x7B, 0xC1, 0xEF, 0x07, 0x3C, 0x3C, 0x7F, 0xE1, 0xFF, 0x83, 0xF8, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x1F, 0xF0, 0x7F, 0xE3,
  0xFF, 0xCF, 0x0F, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCE, 0x0F, 0x78, 0xF9,
  0xFF, 0xC7, 0xFE, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x87, 0x0E, 0x3C, 0x38,
  0xE0, 0xF3, 0x83, 0xCE, 0x07, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF,
  0x0F, 0x38, 0x1C, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0xC0, 0x7F, 0x80,
  0x7F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xEE, 0x07, 0xBC, 0x1C, 0xFF, 0xF1,
  0xFF, 0x83, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x1C,
  0x1E, 0x38, 0x38, 0xF0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x07, 0x8E, 0x0F,
  0x1C, 0x1C, 0x78, 0x38, 0xF0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x07, 0x8E,
  0x0E, 0x3C, 0x1C, 0x38, 0x78, 0x7F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xE0,
  0x3F, 0x80, 0xEE, 0x07, 0xB8, 0x1C, 0xE0, 0xF3, 0x83, 0x8F, 0x0E, 0x3C,
  0x78, 0x71, 0xC1, 0xC7, 0x07, 0x38, 0x1C, 0xE0, 0x77, 0x01, 0xDC, 0x07,
  0x70, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x71, 0xC7, 0x71,
  0xC7, 0x71, 0xC6, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0xCE, 0x76, 0xCC, 0x66,
  0xDC, 0x66, 0xDC, 0x64, 0xDC, 0x6C, 0xD8, 0x6C, 0xF8, 0x6C, 0xB8, 0x68,
  0xB0, 0xF8, 0xB0, 0xF8, 0xB0, 0xF8, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0x1E,
  0x0F, 0x1E, 0x0E, 0x0E, 0x1E, 0x0F, 0x3C, 0x07, 0x38, 0x07, 0x78, 0x07,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F,
  0xE0, 0x1E, 0xF0, 0x1C, 0x70, 0x3C, 0x70, 0x78, 0x78, 0x70, 0x38, 0xF0,
  0x3C, 0xF0, 0x1E, 0xE0, 0x39, 0xE0, 0xE1, 0xC3, 0xC3, 0x87, 0x07, 0x1C,
  0x0F, 0x38, 0x0E, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x1C, 0x00, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x00, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xC7, 0xF8, 0xFF, 0x00, 0xE0, 0xE0,
  0xF0, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x1C,
  0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x07, 0x07, 0x07, 0x0F,
  0xE1, 0xFC, 0x7F, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x1E, 0x3F, 0xC7, 0xF0, 0xFE, 0x00, 0x03, 0x80,
  0x7C, 0x07, 0xC0, 0xEC, 0x1C, 0xE1, 0xCE, 0x38, 0xE3, 0x8E, 0x70, 0x7F,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xE3, 0xC0, 0x02, 0x00, 0x3E,
  0xF1, 0xFF, 0x8F, 0x1E, 0x78, 0x39, 0xE0, 0xE7, 0x03, 0x9C, 0x1E, 0x70,
  0x79, 0xC1, 0xCF, 0x07, 0x3C, 0x3C, 0x7F, 0xF1, 0xFD, 0xC3, 0xEF, 0x00,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x84, 0x1D, 0xF8, 0xFF, 0xE7,
  0x8F, 0x38, 0x3B, 0xC1, 0xDC, 0x0E, 0xE0, 0x77, 0x07, 0xB8, 0x39, 0xC1,
  0xDE, 0x1E, 0xEF, 0xE7, 0x7F, 0x3B, 0xF0, 0x01, 0x00, 0x3F, 0xC1, 0xFF,
  0x8F, 0x1E, 0x38, 0x39, 0xE0, 0xE7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x07, 0x9C, 0x1C, 0x7F, 0xF1, 0xFF, 0x83, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x21, 0xC1, 0xF7, 0x87, 0xFE, 0x1E,
  0x3C, 0x78, 0x38, 0xF0, 0x71, 0xC0, 0xE3, 0x83, 0xC7, 0x07, 0x8E, 0x0E,
  0x3C, 0x1C, 0x78, 0x78, 0x7F, 0xF0, 0xFE, 0xE0, 0xFB, 0xC0, 0x01, 0x80,
  0x7F, 0x87, 0xFC, 0x78, 0xF3, 0x83, 0xB8, 0x1D, 0xC0, 0xEF, 0xFF, 0x7F,
  0xFB, 0x80, 0x3C, 0x00, 0xE0, 0xE7, 0x9E, 0x3F, 0xF0, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xE0, 0x00, 0x02, 0x00, 0x3E, 0xF1, 0xFF, 0x8F, 0x1E, 0x38, 0x39, 0xE0,
  0xE7, 0x03, 0x9C, 0x1E, 0x70, 0x79, 0xC1, 0xC7, 0x0F, 0x1F, 0xFC, 0x7F,
  0x70, 0xFB, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE1, 0xFF, 0x07, 0xF8, 0x1F,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x84, 0x1D, 0xF8, 0xFF,
  0xE7, 0x8F, 0x38, 0x3B, 0xC1, 0xDC, 0x0E, 0xE0, 0xF7, 0x07, 0xB8, 0x39,
  0xC1, 0xDE, 0x0E, 0xF0, 0x77, 0x07, 0xB8, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x3F, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x07, 0xF8, 0x3F, 0xC0, 0xFC,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x27, 0x07,
  0x8E, 0x0E, 0x1C, 0x3C, 0x38, 0xF0, 0xF3, 0xC1, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0E, 0x38, 0x1C, 0x78, 0x78, 0xF0, 0xF0, 0xE1, 0xC1, 0xE3, 0x81,
  0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1F, 0xF1, 0xFF, 0x07, 0xE0, 0x01, 0x08, 0x77, 0x7C, 0xFF, 0xF9,
  0xCE, 0x73, 0x9C, 0xE7, 0x31, 0xCC, 0x63, 0x38, 0xCE, 0x71, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x98, 0xE6, 0x31, 0xDC, 0x67, 0x39, 0xCE, 0x00, 0x00,
  0x41, 0xDF, 0x8F, 0xFE, 0x78, 0xF3, 0x83, 0xBC, 0x1D, 0xC0, 0xEE, 0x0F,
  0x70, 0x7B, 0x83, 0x9C, 0x1D, 0xE0, 0xEF, 0x07, 0x70, 0x7B, 0x83, 0xC0,
  0x01, 0x80, 0x7F, 0x87, 0xFC, 0x78, 0xF3, 0x83, 0xBC, 0x1D, 0xC0, 0xEE,
  0x07, 0x70, 0x7B, 0x83, 0xBC, 0x1C, 0xE1, 0xE7, 0xFE, 0x3F, 0xE0, 0xFE,
  0x00, 0x00, 0x20, 0x77, 0xE1, 0xFF, 0xC7, 0x8F, 0x1C, 0x1C, 0xF0, 0x73,
  0x81, 0xCE, 0x07, 0x38, 0x3C, 0xE0, 0xE3, 0x83, 0x9E, 0x1E, 0x77, 0xF1,
  0xDF, 0xC7, 0x7E, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0x02, 0x00, 0x3E, 0xF1, 0xFF, 0x8F, 0x1E, 0x78, 0x39, 0xE0, 0xE7, 0x03,
  0x9C, 0x1E, 0x70, 0x71, 0xC1, 0xCF, 0x07, 0x3C, 0x3C, 0x7F, 0xF1, 0xFF,
  0xC3, 0xEF, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x00,
  0x60, 0xFF, 0xE3, 0xBF, 0x8F, 0x9F, 0x3C, 0x3C, 0xE0, 0xF3, 0x83, 0xDE,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0xFF, 0x8F, 0xFE, 0x70, 0x73, 0x80, 0x3C, 0x00,
  0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xC0, 0x1D, 0xC0, 0xEF, 0x9F, 0x3F,
  0xF0, 0xFF, 0x00, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC1, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x7E, 0x00, 0x38, 0x3C, 0xE0,
  0xE3, 0x83, 0x9E, 0x0E, 0x78, 0x39, 0xC0, 0xE7, 0x07, 0x9C, 0x1E, 0x70,
  0x71, 0xC1, 0xC7, 0x0F, 0x1F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0xF0, 0x3F,
  0xC1, 0xE7, 0x07, 0x1C, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x1C, 0x1E, 0x70,
  0x3B, 0x80, 0xEE, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0xC7,
  0x1F, 0x1C, 0x7C, 0x71, 0xB3, 0xCE, 0xCF, 0x3B, 0x3C, 0xCD, 0xB3, 0x36,
  0xDC, 0xDB, 0x63, 0x4D, 0x8F, 0x3E, 0x3C, 0xF8, 0xE3, 0xC3, 0x8F, 0x00,
  0x3C, 0x1E, 0x3C, 0x78, 0x39, 0xE0, 0x7B, 0x80, 0x7F, 0x00, 0xFC, 0x00,
  0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x1D, 0xC0, 0x73, 0xC1, 0xE3, 0x87, 0x87,
  0x9E, 0x07, 0x00, 0x38, 0x3C, 0xE0, 0xE3, 0x83, 0x9E, 0x0E, 0x70, 0x39,
  0xC1, 0xE7, 0x07, 0x9C, 0x1C, 0x70, 0x71, 0xC3, 0xC7, 0xFF, 0x1F, 0xDC,
  0x3E, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x7F, 0xC1, 0xFE, 0x07, 0xE0,
  0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8,
  0x00, 0x1C, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x1F, 0xC0, 0xFE, 0x03, 0xFC,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x1E, 0x3C, 0x70, 0xE1,
  0xC3, 0x8F, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0x1E, 0x38, 0x70, 0xE1,
  0xC7, 0x8F, 0x1C, 0x38, 0x70, 0xE0, 0x0E, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xFF, 0x00, 0xFC, 0x0F, 0xF0, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x07, 0xE0, 0x1F, 0x00,
  0xF8, 0x00, 0x3E, 0x1D, 0xFC, 0x77, 0x79, 0xF8, 0xFE, 0xE3, 0xF8, 0x03,
  0x80,
};

const GFXglyph JetBrainsMono_BoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 19, 16, 5, -19 },
  { 16, 10, 8, 16, 4, -19 },
  { 26, 16, 19, 16, 0, -19 },
  { 64, 14, 27, 16, 1, -23 },
  { 112, 19, 19, 16, -1, -19 },
  { 158, 15, 19, 16, 0, -19 },
  { 194, 4, 8, 16, 7, -19 },
  { 198, 11, 25, 16, 4, -22 },
  { 233, 11, 25, 16, 1, -22 },
  { 268, 14, 14, 16, 1, -16 },
  { 293, 13, 13, 16, 2, -15 },
  { 315, 8, 8, 16, 2, -4 },
  { 323, 10, 3, 16, 3, -10 },
  { 327, 6, 5, 16, 4, -5 },
  { 331, 16, 25, 16, 0, -22 },
  { 381, 14, 19, 16, 1, -19 },
  { 415, 13, 19, 16, 1, -19 },
  { 446, 14, 19, 16, 1, -19 },
  { 480, 14, 19, 16, 1, -19 },
  { 514, 14, 19, 16, 1, -19 },
  { 548, 14, 19, 16, 1, -19 },
  { 582, 13, 19, 16, 1, -19 },
  { 613, 14, 19, 16, 2, -19 },
  { 647, 14, 19, 16, 1, -19 },
  { 681, 13, 19, 16, 2, -19 },
  { 712, 7, 15, 16, 4, -15 },
  { 726, 9, 19, 16, 2, -15 },
  { 748, 13, 15, 16, 2, -16 },
  { 773, 12, 9, 16, 2, -13 },
  { 787, 13, 15, 16, 1, -16 },
  { 812, 12, 19, 16, 3, -19 },
  { 841, 16, 24, 16, 0, -19 },
  { 889, 14, 19, 16, 0, -19 },
  { 923, 14, 19, 16, 1, -19 },
  { 957, 14, 19, 16, 1, -19 },
  { 991, 14, 19, 16, 1, -19 },
  { 1025, 15, 19, 16, 1, -19 },
  { 1061, 15, 19, 16, 1, -19 },
  { 1097, 14, 19, 16, 1, -19 },
  { 1131, 14, 19, 16, 1, -19 },
  { 1165, 14, 19, 16, 1, -19 },
  { 1199, 15, 19, 16, 0, -19 },
  { 1235, 15, 19, 16, 1, -19 },
  { 1271, 11, 19, 16, 2, -19 },
  { 1298, 16, 19, 16, 0, -19 },
  { 1336, 15, 19, 16, 1, -19 },
  { 1372, 14, 19, 16, 1, -19 },
  { 1406, 15, 19, 16, 1, -19 },
  { 1442, 14, 24, 16, 1, -19 },
  { 1484, 14, 19, 16, 1, -19 },
  { 1518, 14, 19, 16, 1, -19 },
  { 1552, 13, 19, 16, 3, -19 },
  { 1583, 15, 19, 16, 1, -19 },
  { 1619, 14, 19, 16, 3, -19 },
  { 1653, 16, 19, 16, 1, -19 },
  { 1691, 16, 19, 16, 0, -19 },
  { 1729, 15, 19, 16, 2, -19 },
  { 1765, 14, 19, 16, 1, -19 },
  { 1799, 11, 25, 16, 3, -22 },
  { 1834, 8, 25, 16, 4, -22 },
  { 1859, 11, 25, 16, 2, -22 },
  { 1894, 12, 10, 16, 2, -19 },
  { 1909, 13, 3, 16, 0, 1 },
  { 1914, 6, 3, 16, 6, -20 },
  { 1917, 14, 15, 16, 1, -15 },
  { 1944, 13, 19, 16, 1, -19 },
  { 1975, 14, 15, 16, 1, -15 },
  { 2002, 15, 19, 16, 1, -19 },
  { 2038, 13, 15, 16, 1, -15 },
  { 2063, 17, 24, 16, -1, -19 },
  { 2114, 14, 20, 16, 1, -15 },
  { 2149, 13, 19, 16, 1, -19 },
  { 2180, 13, 20, 16, 1, -20 },
  { 2213, 14, 25, 16, 0, -20 },
  { 2257, 15, 19, 16, 1, -19 },
  { 2293, 12, 19, 16, 2, -19 },
  { 2322, 15, 15, 16, 0, -15 },
  { 2351, 13, 15, 16, 1, -15 },
  { 2376, 13, 15, 16, 1, -15 },
  { 2401, 14, 20, 16, 0, -15 },
  { 2436, 14, 20, 16, 1, -15 },
  { 2471, 14, 15, 16, 1, -15 },
  { 2498, 13, 15, 16, 1, -15 },
  { 2523, 13, 18, 16, 2, -18 },
  { 2553, 14, 14, 16, 1, -14 },
  { 2578, 14, 14, 16, 2, -14 },
  { 2603, 14, 14, 16, 2, -14 },
  { 2628, 15, 14, 16, 0, -14 },
  { 2655, 14, 19, 16, 1, -14 },
  { 2689, 13, 14, 16, 1, -14 },
  { 2712, 14, 25, 16, 2, -22 },
  { 2756, 7, 25, 16, 5, -22 },
  { 2778, 14, 25, 16, 0, -22 },
  { 2822, 14, 6, 16, 1, -12 },
};

const GFXfont JetBrainsMono_BoldItalic26pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic26pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _JETBRAINSMONO_BOLDITALIC26PT7B_H_
