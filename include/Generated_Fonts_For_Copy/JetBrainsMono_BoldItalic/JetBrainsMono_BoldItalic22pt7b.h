#ifndef _JETBRAINSMONO_BOLDITALIC22PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xE3, 0x8E, 0x38, 0xE3, 0x0C, 0x30, 0xC7, 0x00, 0x01, 0x8F,
  0x38, 0xE7, 0xE7, 0xE7, 0xE6, 0xC6, 0xC6, 0xCE, 0x03, 0x18, 0x0C, 0x60,
  0x63, 0x01, 0x8C, 0x3F, 0xFC, 0xFF, 0xE0, 0xC6, 0x03, 0x18, 0x18, 0xC0,
  0x63, 0x0F, 0xFF, 0x3F, 0xFC, 0x31, 0x80, 0xC6, 0x06, 0x30, 0x18, 0xC0,
  0x01, 0x00, 0x10, 0x01, 0x00, 0xFC, 0x1F, 0xE3, 0xAF, 0x32, 0x77, 0x20,
  0x7A, 0x03, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x4E, 0x04, 0xEE, 0xCC,
  0xFD, 0xC7, 0xF8, 0x3F, 0x00, 0x80, 0x08, 0x01, 0x80, 0x0F, 0x07, 0x1F,
  0x8E, 0x31, 0x8C, 0x31, 0x98, 0x31, 0xB0, 0x3F, 0x60, 0x1E, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x78, 0x06, 0xDC, 0x0D, 0x8C, 0x19, 0x8C, 0x31,
  0x98, 0x61, 0xF8, 0xC0, 0xF0, 0x07, 0xE0, 0x7F, 0x07, 0x1C, 0x38, 0xE1,
  0xC0, 0x0E, 0x00, 0x30, 0x07, 0xC0, 0x7F, 0x3B, 0xBB, 0x98, 0xF8, 0xC7,
  0x86, 0x1C, 0x39, 0xE1, 0xFF, 0x87, 0xCE, 0x7E, 0xEE, 0xEC, 0xC0, 0x00,
  0x40, 0x60, 0x78, 0x3C, 0x1C, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x18, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xF8,
  0x1C, 0x01, 0x00, 0x10, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x0E, 0x0F, 0x0F,
  0x1F, 0x0E, 0x04, 0x00, 0x07, 0x00, 0x70, 0x46, 0x17, 0x67, 0xFF, 0xF3,
  0xF8, 0x0E, 0x01, 0xB0, 0x3B, 0x87, 0x1C, 0x21, 0x00, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x07, 0xFE, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x30,
  0x00, 0x3C, 0xE7, 0x9C, 0x63, 0x8C, 0x00, 0xFF, 0xFF, 0xFE, 0x6F, 0xFE,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x0F,
  0xC1, 0xFE, 0x38, 0xF3, 0x07, 0x70, 0x77, 0x06, 0x74, 0x66, 0xEE, 0x66,
  0xE6, 0x0E, 0xE0, 0xEE, 0x0C, 0xE1, 0xCF, 0x3C, 0x7F, 0x83, 0xF0, 0x07,
  0x81, 0xF0, 0xFE, 0x1D, 0xC2, 0x38, 0x86, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x7F, 0xF7, 0xFE, 0x0F, 0xC1, 0xFE,
  0x38, 0xE7, 0x07, 0x70, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xFF, 0xCF, 0xFC, 0x1F, 0xF3, 0xFE,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x0C, 0xE1, 0xCE, 0x3C, 0x7F, 0x83, 0xF0, 0x00, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC7, 0x70, 0xEC, 0x1B, 0xFF,
  0x7F, 0xEF, 0xFC, 0x03, 0x80, 0x70, 0x0C, 0x1F, 0xF3, 0xFE, 0x38, 0x03,
  0x80, 0x30, 0x03, 0x10, 0x7F, 0xC7, 0xFE, 0x70, 0xE0, 0x0E, 0x00, 0xE0,
  0x0C, 0xE1, 0xCF, 0x3C, 0x7F, 0x83, 0xF0, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xE0, 0x38, 0x0E, 0xE3, 0xFE, 0x79, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0D, 0xE3, 0x9F, 0xE1, 0xF8, 0x7F, 0xF7, 0xFE, 0xE0, 0xEE, 0x0E, 0xE1,
  0xC0, 0x18, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x70, 0x0F, 0x00, 0x0F, 0xC1, 0xFE, 0x38, 0xE3, 0x07, 0x30,
  0x63, 0x8E, 0x3D, 0xC1, 0xF8, 0x3F, 0x87, 0x1C, 0xE0, 0xEE, 0x0E, 0xE0,
  0xCF, 0x1C, 0x7F, 0x83, 0xF0, 0x1F, 0x87, 0xF9, 0xC7, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x77, 0x9E, 0x7D, 0x87, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x38,
  0x0E, 0x03, 0x80, 0x3B, 0xDE, 0x00, 0x00, 0x00, 0x07, 0xBD, 0xC0, 0x0E,
  0x3C, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xE1, 0xC7, 0x0C, 0x38,
  0x60, 0x00, 0x60, 0x38, 0x3F, 0x1F, 0x8F, 0x81, 0xC0, 0x3C, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x0E, 0x00, 0x40, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x9F, 0xF7, 0xFE, 0x20, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xC0, 0xF8, 0x7E, 0x3E, 0x1F, 0x03, 0x80, 0x40, 0x00, 0x7E, 0x3F,
  0x9F, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x7E, 0x7C, 0x38, 0x1C, 0x00, 0x00,
  0x03, 0x03, 0xC1, 0xC0, 0x07, 0xF0, 0x3F, 0xE1, 0xC3, 0x8E, 0x06, 0x30,
  0x19, 0xC7, 0x67, 0x3F, 0x98, 0xCE, 0x67, 0x19, 0x98, 0xE6, 0x63, 0x39,
  0x8C, 0xE6, 0x33, 0x1F, 0xCC, 0x3B, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0xE0, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0x60, 0x6C, 0x1D, 0x83,
  0x38, 0xE7, 0x1C, 0xE7, 0x1C, 0xFF, 0x9F, 0xF7, 0x0E, 0xE0, 0xF8, 0x1F,
  0x03, 0x3F, 0xC3, 0xFE, 0x38, 0xF3, 0x07, 0x30, 0x77, 0x0E, 0x71, 0xC7,
  0xF0, 0x7F, 0xC6, 0x0E, 0x60, 0xEE, 0x0E, 0xE0, 0xEE, 0x3C, 0xFF, 0x8F,
  0xF0, 0x0F, 0xC1, 0xFE, 0x38, 0xF3, 0x07, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x0E, 0xE1, 0xCF, 0x3C, 0x7F, 0x83,
  0xF0, 0x3F, 0xC3, 0xFE, 0x39, 0xE3, 0x07, 0x30, 0x77, 0x06, 0x70, 0x67,
  0x0E, 0x70, 0xE6, 0x0E, 0x60, 0xEE, 0x0E, 0xE1, 0xCF, 0xFC, 0xFF, 0x8F,
  0xE0, 0x3F, 0xF3, 0xFF, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07,
  0xFC, 0x7F, 0xC7, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xFF, 0xCF,
  0xFC, 0x3F, 0xF3, 0xFF, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07,
  0xFE, 0x7F, 0xC7, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x0F, 0xC1, 0xFE, 0x38, 0xF3, 0x07, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x3E, 0x73, 0xE6, 0x7E, 0xE0, 0xEE, 0x0E, 0xE1, 0xCF, 0x3C, 0x7F, 0x83,
  0xF0, 0x38, 0x73, 0x87, 0x38, 0x73, 0x07, 0x30, 0x67, 0x0E, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0x0E, 0x60, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE,
  0x1C, 0x3F, 0xF3, 0xFF, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC4, 0xFF, 0x8F,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x39, 0xC1, 0xCE, 0x0E, 0x38, 0xE1,
  0xFE, 0x07, 0xE0, 0x38, 0x39, 0xC3, 0x8E, 0x38, 0x61, 0xC3, 0x1C, 0x39,
  0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0x1C, 0x18, 0xE1, 0xC7, 0x0E, 0x18,
  0x70, 0xE3, 0x87, 0x1C, 0x3C, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0xF7, 0xFF,
  0xFF, 0x1C, 0x3C, 0x70, 0xE3, 0x47, 0x8D, 0x96, 0x36, 0xD8, 0xDB, 0xE3,
  0x7B, 0x8D, 0xEC, 0x77, 0x31, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x60, 0x71,
  0x81, 0x86, 0x06, 0x38, 0x38, 0x3C, 0x33, 0xC7, 0x3C, 0x73, 0xC7, 0x7C,
  0x67, 0xE6, 0x76, 0x66, 0x6E, 0x66, 0xE6, 0x6E, 0xE6, 0xEE, 0x7C, 0xE3,
  0xCE, 0x3C, 0xC3, 0xCC, 0x3C, 0x0F, 0xC1, 0xFE, 0x38, 0xE3, 0x07, 0x70,
  0x67, 0x06, 0x70, 0xE7, 0x0E, 0x70, 0xE6, 0x0E, 0xE0, 0xEE, 0x0C, 0xE1,
  0xCF, 0x3C, 0x7F, 0x83, 0xF0, 0x3F, 0xC3, 0xFE, 0x38, 0xF3, 0x07, 0x30,
  0x77, 0x07, 0x70, 0x77, 0xFE, 0x7F, 0xC7, 0xF0, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0xC1, 0xFE, 0x38, 0xE3, 0x07, 0x70,
  0x77, 0x06, 0x70, 0xE7, 0x0E, 0x60, 0xE6, 0x0E, 0xE0, 0xEE, 0x0C, 0xE1,
  0xCF, 0x3C, 0x7F, 0x83, 0xF0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x3F,
  0xC3, 0xFE, 0x38, 0xF3, 0x07, 0x30, 0x77, 0x07, 0x70, 0xE7, 0xFE, 0x7F,
  0xC7, 0xF0, 0x63, 0x0E, 0x38, 0xE3, 0x8E, 0x18, 0xE1, 0xCE, 0x1C, 0x0F,
  0xC1, 0xFE, 0x38, 0xF3, 0x07, 0x70, 0x07, 0x00, 0x3C, 0x03, 0xF8, 0x0F,
  0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0xE0, 0xCF, 0x1C, 0xFF, 0x83, 0xF0, 0x7F,
  0xFF, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x73, 0x87, 0x38, 0x73, 0x07, 0x70, 0x67, 0x06, 0x70, 0xE7, 0x0E, 0x70,
  0xE6, 0x0E, 0x60, 0xEE, 0x0C, 0xE1, 0xCF, 0x3C, 0x7F, 0x83, 0xF0, 0xE0,
  0x76, 0x06, 0x60, 0xE6, 0x0E, 0x61, 0xC7, 0x1C, 0x71, 0x87, 0x38, 0x73,
  0x07, 0x70, 0x77, 0x07, 0x60, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x63,
  0x1B, 0x18, 0xD9, 0xCE, 0xCA, 0x66, 0x53, 0x36, 0x99, 0xB5, 0xCD, 0x2C,
  0xEB, 0x67, 0xDB, 0x36, 0xF9, 0xA7, 0x8D, 0x3C, 0x79, 0xE3, 0xCF, 0x1C,
  0x70, 0x3C, 0x3C, 0x70, 0xE1, 0xC7, 0x03, 0xB8, 0x0E, 0xE0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x01, 0xDC, 0x07, 0x70, 0x39, 0xC1,
  0xC3, 0x87, 0x0E, 0x38, 0x3C, 0xE0, 0x76, 0x0E, 0x70, 0xE7, 0x1C, 0x71,
  0x83, 0xB8, 0x3F, 0x03, 0xF0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x3F, 0xF3, 0xFF, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x0F, 0xFC, 0xFF, 0xCF, 0xFC, 0x1F, 0x8F, 0xC6, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0,
  0x70, 0x3F, 0x1F, 0x80, 0xE0, 0x60, 0x70, 0x70, 0x70, 0x70, 0x30, 0x38,
  0x38, 0x38, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x0E, 0x07,
  0x1F, 0x8F, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x3F, 0x1F, 0x80, 0x07,
  0x03, 0xC1, 0xF0, 0x6E, 0x3B, 0x8C, 0x66, 0x1B, 0x87, 0xC1, 0xC0, 0xFF,
  0xFF, 0xFC, 0xF1, 0x8E, 0x1F, 0x67, 0xED, 0xE3, 0xB8, 0x77, 0x0E, 0xC1,
  0xF8, 0x37, 0x06, 0xE1, 0xDE, 0x79, 0xFF, 0x3E, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x18, 0x03, 0x7C, 0xFF, 0xDE, 0x3B, 0x87, 0x70, 0xEC, 0x1D, 0x83,
  0xF0, 0x6E, 0x1D, 0xE7, 0xBF, 0xE6, 0x78, 0x1F, 0xC7, 0xFD, 0xE3, 0xB8,
  0x77, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xDE, 0x79, 0xFE, 0x1F, 0x80,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x1F, 0x63, 0xF6, 0x78, 0xE7, 0x0E,
  0x70, 0xE6, 0x0E, 0xE0, 0xCE, 0x0C, 0xE1, 0xCF, 0x3C, 0x7F, 0xC7, 0xDC,
  0x1F, 0xC7, 0xF9, 0xC3, 0xB8, 0x76, 0x0E, 0xFF, 0xFF, 0xFF, 0x00, 0xE0,
  0x1C, 0x39, 0xFE, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xFC, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x03, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x3C, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x67, 0xED, 0xE3, 0xB8,
  0x77, 0x0E, 0xC1, 0xF8, 0x37, 0x0E, 0xF1, 0xCF, 0xF9, 0xF7, 0x00, 0xE0,
  0x18, 0x07, 0x1F, 0xC3, 0xF0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x7C,
  0xFF, 0xDE, 0x3B, 0x87, 0x70, 0xEC, 0x1D, 0x83, 0x70, 0x6E, 0x1D, 0xC3,
  0xB8, 0x77, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x3F, 0xFF,
  0xFE, 0xFF, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x7F, 0x0F, 0xF0, 0xFC, 0x00, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x77, 0x0E, 0x71, 0xC7, 0x3C, 0x73,
  0x87, 0xF0, 0x7F, 0x06, 0x70, 0xE3, 0x8E, 0x38, 0xE1, 0xCE, 0x1C, 0xFE,
  0x3F, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0x03, 0xFC, 0x7E, 0x37, 0x71, 0xFF, 0xCC, 0xCE,
  0x66, 0x67, 0x33, 0x39, 0x99, 0x8C, 0xCC, 0xCE, 0x66, 0x73, 0x33, 0xB9,
  0x99, 0xCC, 0xC0, 0x37, 0xCF, 0xFD, 0xE3, 0xB8, 0x77, 0x0E, 0xC1, 0xD8,
  0x37, 0x06, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xE0, 0x1F, 0xC7, 0xF9, 0xE3,
  0xB8, 0x77, 0x0E, 0xC1, 0xF8, 0x3F, 0x06, 0xE1, 0xDE, 0x79, 0xFE, 0x1F,
  0x80, 0x1B, 0xE3, 0xFF, 0x3C, 0x73, 0x87, 0x38, 0x73, 0x07, 0x30, 0x77,
  0x06, 0x70, 0xE7, 0x9E, 0x7F, 0xC7, 0x78, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x1F, 0x67, 0xED, 0xE3, 0xB8, 0x77, 0x0E, 0xC1, 0xF8, 0x37, 0x06,
  0xE1, 0xDE, 0x79, 0xFF, 0x3E, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x3F,
  0xE3, 0x7E, 0x38, 0xF7, 0x07, 0x70, 0xE7, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x1F, 0xC7, 0xFD, 0xC3, 0xB8, 0x07, 0x80,
  0x7F, 0x07, 0xF0, 0x0E, 0x00, 0xDC, 0x3B, 0xFF, 0x3F, 0x80, 0x0C, 0x03,
  0x80, 0x70, 0x7F, 0xFF, 0xFC, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x7F, 0x07, 0xE0, 0x70, 0x77, 0x0E, 0x70, 0xE7,
  0x0E, 0x70, 0xE6, 0x0E, 0x60, 0xCE, 0x0C, 0xE1, 0xCF, 0x3C, 0x7F, 0x83,
  0xF0, 0xE0, 0xFC, 0x1B, 0x87, 0x70, 0xE6, 0x38, 0xC7, 0x1D, 0xC3, 0xB8,
  0x7E, 0x0F, 0xC0, 0xF0, 0x1E, 0x00, 0xE7, 0x3F, 0x39, 0xB9, 0xCD, 0xDE,
  0xEE, 0xB6, 0x65, 0xB3, 0x6D, 0x9B, 0x78, 0xD3, 0xC7, 0x9E, 0x3C, 0xE1,
  0xC7, 0x00, 0x38, 0x78, 0xE3, 0x87, 0x38, 0x1F, 0x80, 0xF8, 0x03, 0x80,
  0x3E, 0x01, 0xF0, 0x1D, 0xC1, 0xCE, 0x1C, 0x39, 0xC1, 0xC0, 0x70, 0x6E,
  0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xC1, 0xF8, 0x37, 0x0E, 0xF3, 0xCF, 0xF8,
  0xF7, 0x00, 0xE0, 0x18, 0x07, 0x1F, 0xC3, 0xF0, 0x3F, 0xE7, 0xFD, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x03, 0xFF, 0x7F,
  0xE0, 0x01, 0xE0, 0x7C, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x0E, 0x1F, 0x83, 0xF0, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C,
  0x03, 0x90, 0x7C, 0x07, 0x80, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x8E, 0x38,
  0xC7, 0x1C, 0x71, 0xC7, 0x18, 0xE3, 0x8E, 0x38, 0x0F, 0x01, 0xF0, 0x07,
  0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x3F, 0x03,
  0xF0, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x7C,
  0x0F, 0x80, 0x7C, 0x77, 0xE6, 0xE7, 0x6C, 0x7E, 0x03, 0x80,
};

const GFXglyph JetBrainsMono_BoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 6, 16, 13, 4, -16 },
  { 13, 8, 7, 13, 4, -16 },
  { 20, 14, 16, 13, 0, -16 },
  { 48, 12, 22, 13, 1, -19 },
  { 81, 16, 16, 13, -1, -16 },
  { 113, 13, 16, 13, 0, -16 },
  { 139, 4, 7, 13, 6, -16 },
  { 143, 10, 22, 13, 3, -19 },
  { 171, 9, 22, 13, 1, -19 },
  { 196, 12, 11, 13, 1, -13 },
  { 213, 11, 11, 13, 1, -13 },
  { 229, 6, 7, 13, 2, -3 },
  { 235, 8, 3, 13, 3, -9 },
  { 238, 4, 4, 13, 4, -4 },
  { 240, 14, 20, 13, 0, -18 },
  { 275, 12, 16, 13, 1, -16 },
  { 299, 11, 16, 13, 1, -16 },
  { 321, 12, 16, 13, 1, -16 },
  { 345, 12, 16, 13, 1, -16 },
  { 369, 11, 16, 13, 1, -16 },
  { 391, 12, 16, 13, 1, -16 },
  { 415, 11, 16, 13, 1, -16 },
  { 437, 12, 16, 13, 2, -16 },
  { 461, 12, 16, 13, 1, -16 },
  { 485, 11, 16, 13, 2, -16 },
  { 507, 5, 12, 13, 4, -12 },
  { 515, 7, 16, 13, 2, -12 },
  { 529, 11, 12, 13, 2, -13 },
  { 546, 11, 8, 13, 1, -11 },
  { 557, 11, 12, 13, 1, -13 },
  { 574, 9, 16, 13, 3, -16 },
  { 592, 14, 20, 13, 0, -16 },
  { 627, 11, 16, 13, 0, -16 },
  { 649, 12, 16, 13, 1, -16 },
  { 673, 12, 16, 13, 1, -16 },
  { 697, 12, 16, 13, 1, -16 },
  { 721, 12, 16, 13, 1, -16 },
  { 745, 12, 16, 13, 1, -16 },
  { 769, 12, 16, 13, 1, -16 },
  { 793, 12, 16, 13, 1, -16 },
  { 817, 12, 16, 13, 1, -16 },
  { 841, 13, 16, 13, 0, -16 },
  { 867, 13, 16, 13, 1, -16 },
  { 893, 10, 16, 13, 1, -16 },
  { 913, 14, 16, 13, 0, -16 },
  { 941, 12, 16, 13, 1, -16 },
  { 965, 12, 16, 13, 1, -16 },
  { 989, 12, 16, 13, 1, -16 },
  { 1013, 12, 20, 13, 1, -16 },
  { 1043, 12, 16, 13, 1, -16 },
  { 1067, 12, 16, 13, 1, -16 },
  { 1091, 12, 16, 13, 2, -16 },
  { 1115, 12, 16, 13, 1, -16 },
  { 1139, 12, 16, 13, 2, -16 },
  { 1163, 13, 16, 13, 1, -16 },
  { 1189, 14, 16, 13, 0, -16 },
  { 1217, 12, 16, 13, 2, -16 },
  { 1241, 12, 16, 13, 1, -16 },
  { 1265, 9, 20, 13, 3, -18 },
  { 1288, 8, 20, 13, 3, -18 },
  { 1308, 9, 20, 13, 2, -18 },
  { 1331, 10, 9, 13, 2, -16 },
  { 1343, 11, 2, 13, 0, 1 },
  { 1346, 5, 3, 13, 5, -17 },
  { 1348, 11, 12, 13, 1, -12 },
  { 1365, 11, 16, 13, 1, -16 },
  { 1387, 11, 12, 13, 1, -12 },
  { 1404, 12, 16, 13, 1, -16 },
  { 1428, 11, 12, 13, 1, -12 },
  { 1445, 15, 20, 13, -1, -16 },
  { 1483, 11, 16, 13, 1, -12 },
  { 1505, 11, 16, 13, 1, -16 },
  { 1527, 11, 17, 13, 1, -17 },
  { 1551, 12, 21, 13, 0, -17 },
  { 1583, 12, 16, 13, 1, -16 },
  { 1607, 10, 16, 13, 2, -16 },
  { 1627, 13, 12, 13, 0, -12 },
  { 1647, 11, 12, 13, 1, -12 },
  { 1664, 11, 12, 13, 1, -12 },
  { 1681, 12, 16, 13, 0, -12 },
  { 1705, 11, 16, 13, 1, -12 },
  { 1727, 12, 12, 13, 1, -12 },
  { 1745, 11, 12, 13, 1, -12 },
  { 1762, 11, 15, 13, 2, -15 },
  { 1783, 12, 12, 13, 1, -12 },
  { 1801, 11, 12, 13, 2, -12 },
  { 1818, 13, 12, 13, 1, -12 },
  { 1838, 13, 12, 13, 0, -12 },
  { 1858, 11, 16, 13, 1, -12 },
  { 1880, 11, 12, 13, 1, -12 },
  { 1897, 11, 20, 13, 2, -18 },
  { 1925, 6, 20, 13, 4, -18 },
  { 1940, 12, 20, 13, 0, -18 },
  { 1970, 12, 5, 13, 1, -10 },
};

const GFXfont JetBrainsMono_BoldItalic22pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic22pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _JETBRAINSMONO_BOLDITALIC22PT7B_H_
