#ifndef _JETBRAINSMONO_BOLDITALIC67PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x7F, 0xCF, 0xF8, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFE, 0x3F,
  0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF, 0x03, 0xFC,
  0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x1F, 0xF1, 0xFE, 0x07,
  0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC,
  0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xCF, 0x3F, 0xF0, 0x0F, 0xF8, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xC3, 0xFE,
  0x07, 0xFC, 0x3C, 0x1F, 0xF0, 0x3F, 0xC1, 0xE0, 0xFF, 0x81, 0xFE, 0x0F,
  0x07, 0xF8, 0x1F, 0xF0, 0x78, 0x00, 0x00, 0xFF, 0x87, 0xC0, 0x00, 0x07,
  0xFC, 0x3E, 0x00, 0x00, 0x3F, 0xE1, 0xE0, 0x00, 0x01, 0xFF, 0x8F, 0x00,
  0x00, 0x07, 0xFE, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xDF, 0xFE, 0x00, 0x00, 0x1E, 0x3F,
  0xF8, 0x00, 0x00, 0xF0, 0xFF, 0xC0, 0x00, 0x07, 0x83, 0xFE, 0x00, 0x00,
  0x7C, 0x1F, 0xF0, 0x00, 0x03, 0xE0, 0xFF, 0x80, 0x00, 0x1E, 0x07, 0xFC,
  0x3F, 0xC0, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0x81, 0xFE, 0x0F, 0xF8, 0x3C,
  0x1F, 0xF0, 0x7F, 0xC1, 0xE0, 0xFF, 0x03, 0xFF, 0x1F, 0x0F, 0xF8, 0x1F,
  0xFC, 0xF1, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xE0,
  0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x7E, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC1, 0xFC, 0x00,
  0x03, 0xF0, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0x00,
  0x03, 0xF8, 0x1F, 0x87, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x8F, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x3F, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7E, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xF8, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF1, 0xFC, 0x3F, 0x80,
  0x00, 0x07, 0xF1, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE3, 0xF0, 0x0F, 0xC0,
  0x00, 0x1F, 0xC3, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x1F, 0x80,
  0x00, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x00,
  0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFC,
  0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xC7, 0xFC, 0xFF, 0x01,
  0xFE, 0x1F, 0xE3, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x7F, 0xC3, 0xFC,
  0x1F, 0xF1, 0xFE, 0x0F, 0xF0, 0x3F, 0xCF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xE0,
  0x0F, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0xC0,
  0x1F, 0xFC, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xEF, 0xF8, 0x07, 0xFF, 0xFE, 0x1F, 0xE0,
  0x0F, 0xFF, 0xF0, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x9F,
  0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xC7,
  0xF8, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xC0, 0x0F, 0xC0, 0x06, 0x1F, 0x00, 0xFC, 0x03,
  0xE3, 0xFC, 0x0F, 0xC1, 0xFE, 0x3F, 0xF0, 0xF8, 0x3F, 0xF7, 0xFF, 0x8F,
  0x8F, 0xFF, 0x7F, 0xFC, 0x73, 0xFF, 0xFF, 0xFF, 0xF7, 0x7F, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x3F, 0xC3, 0xFF, 0x8F,
  0xFE, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xFF, 0xC7,
  0xFE, 0x0F, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE,
  0x0F, 0x03, 0xFC, 0x1F, 0xE3, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFC,
  0x1F, 0xE3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC,
  0x7F, 0x83, 0xFC, 0x3F, 0xC7, 0xF8, 0x3F, 0xC1, 0xF8, 0x7F, 0x83, 0xFC,
  0x0F, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xDF, 0xE0, 0x03, 0xFF, 0x1F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xF8,
  0x3F, 0xE0, 0x07, 0xF0, 0x3F, 0xE0, 0x07, 0xC0, 0x3F, 0xC0, 0x07, 0x00,
  0x3F, 0xC0, 0x06, 0x00, 0x3F, 0xC0, 0x04, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x03, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03,
  0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xC3, 0xFF, 0x00,
  0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF9, 0xFF,
  0xF8, 0x00, 0x7F, 0xBF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC7, 0xF0,
  0x00, 0x1F, 0xF7, 0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0xFC, 0x01, 0xFF, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xE7, 0xF8,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0xFF, 0xF9, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x03, 0xFE,
  0x3F, 0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0,
  0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0xFF,
  0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE3,
  0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x0F, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xFC,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xC3,
  0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0x9F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x0F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8,
  0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF0, 0x06,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFD,
  0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFC, 0x1F, 0x83, 0xF8,
  0x01, 0xFF, 0x8F, 0xC1, 0xFC, 0x01, 0xFF, 0xE7, 0xE0, 0xFE, 0x01, 0xFF,
  0xF3, 0xF0, 0x7F, 0x01, 0xFF, 0xFD, 0xF8, 0x3F, 0x80, 0xFF, 0x8F, 0xFC,
  0x3F, 0x80, 0xFF, 0x03, 0xFE, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0,
  0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x07, 0xF0,
  0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x81,
  0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x7F, 0x00,
  0x7F, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x3F, 0x80, 0x3F, 0x83,
  0xF8, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0x80, 0xFF, 0xFF,
  0xFC, 0x3F, 0x80, 0x7F, 0xFE, 0x7E, 0x1F, 0xC0, 0x1F, 0xFE, 0x7E, 0x0F,
  0xE0, 0x0F, 0xFE, 0x3F, 0x07, 0xF0, 0x01, 0xFE, 0x1F, 0x83, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x01, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F,
  0xE1, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0,
  0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03,
  0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xC0, 0x03, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F,
  0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0x81,
  0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0x07, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x7F, 0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF,
  0xC3, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xE0, 0x7F, 0xFF, 0x83, 0xFC, 0x0F,
  0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF8, 0x3F,
  0xC0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F,
  0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F,
  0xC0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x40, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x1F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0,
  0x3F, 0xFE, 0x03, 0xF7, 0xE0, 0x7E, 0xFE, 0x03, 0xF7, 0xE0, 0x7E, 0xFC,
  0x03, 0xF3, 0xE0, 0x7C, 0xFC, 0x07, 0xF3, 0xE0, 0xFD, 0xFC, 0x07, 0xF3,
  0xE0, 0xF9, 0xFC, 0x07, 0xF3, 0xF1, 0xF9, 0xFC, 0x07, 0xF3, 0xF1, 0xF1,
  0xFC, 0x07, 0xF3, 0xF3, 0xF3, 0xFC, 0x07, 0xF3, 0xF3, 0xF3, 0xF8, 0x0F,
  0xF1, 0xF7, 0xE3, 0xF8, 0x0F, 0xF1, 0xF7, 0xE3, 0xF8, 0x0F, 0xF1, 0xF7,
  0xC7, 0xF8, 0x0F, 0xE1, 0xFF, 0xC7, 0xF8, 0x0F, 0xE1, 0xFF, 0x87, 0xF8,
  0x0F, 0xE1, 0xFF, 0x87, 0xF0, 0x0F, 0xE1, 0xFF, 0x07, 0xF0, 0x1F, 0xE0,
  0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x07, 0xFF,
  0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xF0, 0x00, 0xFF,
  0x01, 0xFF, 0xE0, 0x03, 0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xE0, 0x1F, 0xFE,
  0x00, 0x3F, 0x80, 0xFF, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xF8,
  0x0F, 0xFF, 0xC0, 0x1F, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xFC,
  0x01, 0xFC, 0x03, 0xFB, 0xF0, 0x07, 0xF0, 0x1F, 0xEF, 0xC0, 0x3F, 0xC0,
  0x7F, 0xBF, 0x00, 0xFF, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0x07, 0xF3, 0xF8,
  0x0F, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0xFE, 0x01,
  0xFC, 0x7E, 0x07, 0xF8, 0x0F, 0xF1, 0xFC, 0x1F, 0xE0, 0x3F, 0xC7, 0xF0,
  0x7F, 0x80, 0xFF, 0x1F, 0xC1, 0xFE, 0x03, 0xFC, 0x3F, 0x07, 0xF0, 0x0F,
  0xE0, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x7F, 0x01, 0xFE, 0x0F, 0xE3,
  0xFC, 0x07, 0xF8, 0x3F, 0x8F, 0xF0, 0x1F, 0xE0, 0xFE, 0x3F, 0xC0, 0x7F,
  0x81, 0xF8, 0xFF, 0x01, 0xFC, 0x07, 0xE3, 0xF8, 0x07, 0xF0, 0x1F, 0xCF,
  0xE0, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0xFE, 0x03, 0xFC,
  0x03, 0xF3, 0xF8, 0x0F, 0xF0, 0x0F, 0xCF, 0xE0, 0x3F, 0xC0, 0x3F, 0xFF,
  0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xE0,
  0x07, 0xFF, 0xC0, 0x7F, 0x80, 0x1F, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xFC,
  0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0x00,
  0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0xE0,
  0x3F, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x03,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xE0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F,
  0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x03,
  0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xFC, 0x1F,
  0xE0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF8, 0x7F,
  0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07, 0xF8,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xC0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFC,
  0x7F, 0x80, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x0F, 0xE7, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC7, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF8, 0x07,
  0xF0, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x7E, 0x01, 0xFE, 0x03, 0xF8, 0x7F,
  0x01, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0xF7, 0x80, 0xFE, 0x1F, 0xC0, 0x7B,
  0xC0, 0xFE, 0x0F, 0xE0, 0x7D, 0xE0, 0x7F, 0x07, 0xF0, 0x3E, 0xF0, 0x3F,
  0x83, 0xF8, 0x1E, 0x78, 0x1F, 0xC1, 0xFC, 0x0F, 0x7C, 0x1F, 0xC0, 0xFE,
  0x0F, 0xBE, 0x0F, 0xE0, 0x7F, 0x07, 0xDF, 0x07, 0xF0, 0x3F, 0x83, 0xCF,
  0x83, 0xF8, 0x1F, 0xC3, 0xE7, 0xC3, 0xF8, 0x0F, 0xE1, 0xF3, 0xE1, 0xFC,
  0x07, 0xF0, 0xF9, 0xF0, 0xFE, 0x03, 0xF0, 0x78, 0xF8, 0x7F, 0x01, 0xF8,
  0x7C, 0x7C, 0x3F, 0x00, 0xFC, 0x3E, 0x3C, 0x3F, 0x80, 0x7E, 0x1E, 0x1E,
  0x1F, 0xC0, 0x3F, 0x0F, 0x0F, 0x0F, 0xC0, 0x3F, 0x8F, 0x87, 0x87, 0xE0,
  0x1F, 0xC7, 0xC3, 0xC7, 0xF0, 0x0F, 0xE3, 0xC1, 0xE3, 0xF8, 0x07, 0xF3,
  0xE0, 0xF1, 0xF8, 0x03, 0xF9, 0xF0, 0x78, 0xFC, 0x01, 0xFC, 0xF8, 0x3C,
  0xFE, 0x00, 0xFE, 0x78, 0x1E, 0x7F, 0x00, 0x7F, 0x7C, 0x1F, 0x3F, 0x00,
  0x3F, 0xBE, 0x0F, 0x9F, 0x80, 0x1F, 0x9E, 0x07, 0xDF, 0xC0, 0x0F, 0xDF,
  0x03, 0xEF, 0xE0, 0x07, 0xEF, 0x81, 0xF7, 0xE0, 0x03, 0xF7, 0xC0, 0xFB,
  0xF0, 0x01, 0xFB, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x03,
  0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFE, 0x3F, 0x80,
  0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFE,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x7F, 0x1F, 0xE0,
  0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0x80,
  0x7F, 0xFF, 0x9F, 0xF0, 0x1F, 0xFF, 0xFB, 0xFC, 0x07, 0xFF, 0xFF, 0x7F,
  0x80, 0xFF, 0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x03,
  0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xF8,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xF8, 0x07,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFB, 0xFC, 0x07, 0xFF,
  0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0xDF, 0xF0, 0x0F, 0xFF, 0xF3, 0xFE, 0x00,
  0xFF, 0xFC, 0x7F, 0x80, 0x07, 0xFE, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x40, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x07, 0xF8,
  0xFF, 0xFC, 0x00, 0xFF, 0x3F, 0xFF, 0xC0, 0x1F, 0xEF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF,
  0x87, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F,
  0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x03, 0xFE,
  0x0F, 0xFF, 0x01, 0xFF, 0xC1, 0xFE, 0xFF, 0xFF, 0xF0, 0x3F, 0xDF, 0xFF,
  0xFE, 0x07, 0xFB, 0xFF, 0xFF, 0x80, 0xFF, 0x7F, 0xFF, 0xE0, 0x1F, 0xE7,
  0xFF, 0xF8, 0x07, 0xFC, 0x7F, 0xFE, 0x00, 0xFF, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0xFF,
  0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xC7,
  0xF8, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x87,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x80, 0x3F, 0xC0, 0x00, 0xFF,
  0xC1, 0xFE, 0x00, 0x1F, 0xFF, 0x1F, 0xF0, 0x03, 0xFF, 0xFC, 0xFF, 0x80,
  0x3F, 0xFF, 0xF7, 0xFC, 0x03, 0xFF, 0xFF, 0xBF, 0xC0, 0x1F, 0xFF, 0xFD,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xC0, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF7,
  0xF8, 0x03, 0xFF, 0xFF, 0xBF, 0xC0, 0x1F, 0xFF, 0xFB, 0xFE, 0x00, 0x7F,
  0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0xF8, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x01, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC7, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0x80, 0x7F, 0xFF, 0x9F,
  0xF0, 0x1F, 0xFF, 0xFB, 0xFC, 0x07, 0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xFF,
  0xEF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF,
  0x80, 0x3F, 0xF8, 0x3F, 0xE0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F,
  0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xEF,
  0xDF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0xFF, 0x00, 0xFF,
  0xFF, 0xDF, 0xE0, 0x1F, 0xFF, 0xF3, 0xFC, 0x01, 0xFF, 0xFC, 0x7F, 0x80,
  0x0F, 0xFE, 0x1F, 0xF0, 0x00, 0x7E, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x40, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0xFC, 0x00,
  0xFF, 0x3F, 0xFF, 0xC0, 0x1F, 0xEF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x07,
  0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x81,
  0xFF, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x20, 0x01, 0x00, 0x1F, 0xC7, 0xF0, 0x3F,
  0x80, 0x7F, 0x3F, 0xE3, 0xFF, 0x01, 0xFD, 0xFF, 0x9F, 0xFE, 0x07, 0xFF,
  0xFF, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xCF, 0xFE, 0xFF,
  0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x80,
  0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x80, 0xFE,
  0x0F, 0xE0, 0x7E, 0x07, 0xF8, 0x7F, 0x81, 0xF8, 0x1F, 0xE1, 0xFE, 0x07,
  0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0x7E, 0x07, 0xF0,
  0x7F, 0x03, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0x7F, 0x0F, 0xF0, 0x3F,
  0x03, 0xFC, 0x3F, 0xC0, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xF0, 0x3F, 0x83,
  0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xF8,
  0x0F, 0xE1, 0xFE, 0x07, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0x81, 0xFE, 0x1F,
  0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0,
  0x7F, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xF0, 0xFF,
  0x03, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F, 0x03,
  0xF8, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x3F, 0x83, 0xF8,
  0x1F, 0x81, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x7F, 0x83, 0xFF,
  0x00, 0x0F, 0xF1, 0xFF, 0xF8, 0x01, 0xFE, 0x7F, 0xFF, 0x80, 0x3F, 0xDF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F,
  0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x01, 0xFE, 0x3F,
  0xE0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x3F,
  0xC7, 0xFC, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x01,
  0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x07, 0xF8, 0x3F, 0xF0, 0x00, 0x3F,
  0xC7, 0xFF, 0xE0, 0x01, 0xFE, 0x7F, 0xFF, 0x80, 0x0F, 0xF7, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFB, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x81,
  0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFD, 0xFF, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xFF, 0x00, 0xFF, 0x7F,
  0xFF, 0xF0, 0x07, 0xFB, 0xFF, 0xFF, 0x00, 0x3F, 0xCF, 0xFF, 0xF0, 0x03,
  0xFE, 0x3F, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x83, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0x80, 0x7F, 0xFF, 0x9F, 0xF0, 0x1F,
  0xFF, 0xFB, 0xFC, 0x07, 0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0xEF, 0xF0,
  0x3F, 0xFF, 0xFD, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0x80, 0x3F,
  0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F,
  0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFB, 0xFC, 0x07, 0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xFF,
  0xDF, 0xF0, 0x0F, 0xFF, 0xF3, 0xFC, 0x00, 0xFF, 0xFC, 0x7F, 0x80, 0x07,
  0xFE, 0x0F, 0xF0, 0x00, 0x1E, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x3F, 0xC1, 0xFF, 0xC0, 0x03, 0xFC, 0x7F, 0xFE, 0x00, 0x3F, 0xCF,
  0xFF, 0xF8, 0x03, 0xFD, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0xFC, 0x07,
  0xFB, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC7, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xF0,
  0x00, 0x7F, 0xC3, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07,
  0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F,
  0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xC0,
  0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF3, 0xFE,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xF8, 0x07,
  0xF0, 0x07, 0xEF, 0xE0, 0x1F, 0xC0, 0x3F, 0xBF, 0x80, 0x7F, 0x00, 0xFE,
  0xFE, 0x03, 0xFC, 0x03, 0xF3, 0xF8, 0x0F, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F,
  0xC0, 0x7F, 0x3F, 0x81, 0xFF, 0x01, 0xF8, 0xFE, 0x07, 0xBC, 0x07, 0xE3,
  0xF8, 0x1E, 0xF0, 0x3F, 0x8F, 0xE0, 0xFB, 0xC0, 0xFC, 0x3F, 0x83, 0xCF,
  0x03, 0xF0, 0xFE, 0x0F, 0x3C, 0x1F, 0xC3, 0xF8, 0x7C, 0xF0, 0x7F, 0x0F,
  0xE1, 0xF3, 0xC1, 0xF8, 0x3F, 0x87, 0x8F, 0x0F, 0xE0, 0xFE, 0x3E, 0x3C,
  0x3F, 0x83, 0xF8, 0xF8, 0xF0, 0xFC, 0x0F, 0xE3, 0xC3, 0xC7, 0xF0, 0x3F,
  0x8F, 0x0F, 0x1F, 0xC0, 0xFE, 0x7C, 0x3C, 0x7E, 0x03, 0xF9, 0xE0, 0xF1,
  0xF8, 0x0F, 0xE7, 0x83, 0xCF, 0xE0, 0x3F, 0x3E, 0x0F, 0x3F, 0x00, 0xFC,
  0xF0, 0x3C, 0xFC, 0x03, 0xF3, 0xC0, 0xF7, 0xF0, 0x0F, 0xDF, 0x03, 0xDF,
  0x80, 0x3F, 0x7C, 0x0F, 0x7E, 0x00, 0xFD, 0xE0, 0x3D, 0xF8, 0x03, 0xF7,
  0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0xE0,
  0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x1F,
  0xF1, 0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00,
  0xFF, 0xC7, 0xF8, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC1,
  0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xBF,
  0xC0, 0x7F, 0xFF, 0xF7, 0xF8, 0x07, 0xFF, 0xFC, 0xFF, 0x00, 0x7F, 0xFF,
  0x1F, 0xE0, 0x07, 0xFF, 0xC7, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x0F, 0xFF, 0xE0, 0x0F, 0xE1, 0xFF,
  0xFF, 0x00, 0xFE, 0x3F, 0xFF, 0xF0, 0x0F, 0xE3, 0xFF, 0xFF, 0x80, 0xFE,
  0x7F, 0xCF, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0xC1, 0xFC, 0x7F, 0x03, 0xFF,
  0x3F, 0xC7, 0xF0, 0x1F, 0xFF, 0xFC, 0x7F, 0x01, 0xFF, 0xFF, 0x8F, 0xF0,
  0x0F, 0xFF, 0xF0, 0xFE, 0x00, 0x7F, 0xFE, 0x0F, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00,
};

const GFXglyph JetBrainsMono_BoldItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 17, 49, 40, 12, -49 },
  { 106, 26, 20, 40, 11, -49 },
  { 171, 40, 49, 40, 1, -49 },
  { 416, 37, 67, 40, 2, -58 },
  { 726, 48, 49, 40, -3, -49 },
  { 1020, 38, 51, 40, 1, -50 },
  { 1263, 11, 20, 40, 18, -49 },
  { 1291, 29, 65, 40, 10, -57 },
  { 1527, 29, 65, 40, 3, -57 },
  { 1763, 36, 35, 40, 3, -41 },
  { 1921, 33, 32, 40, 4, -38 },
  { 2053, 20, 21, 40, 5, -10 },
  { 2106, 24, 8, 40, 9, -26 },
  { 2130, 14, 13, 40, 11, -12 },
  { 2153, 42, 63, 40, 0, -56 },
  { 2484, 36, 51, 40, 3, -50 },
  { 2714, 32, 49, 40, 3, -49 },
  { 2910, 37, 50, 40, 2, -50 },
  { 3142, 36, 50, 40, 2, -49 },
  { 3367, 34, 49, 40, 3, -49 },
  { 3576, 36, 50, 40, 3, -49 },
  { 3801, 35, 50, 40, 2, -49 },
  { 4020, 35, 49, 40, 6, -49 },
  { 4235, 37, 51, 40, 2, -50 },
  { 4471, 35, 50, 40, 5, -50 },
  { 4690, 18, 39, 40, 11, -38 },
  { 4778, 23, 49, 40, 6, -38 },
  { 4919, 34, 36, 40, 5, -40 },
  { 5072, 33, 24, 40, 4, -34 },
  { 5171, 33, 36, 40, 3, -40 },
  { 5320, 29, 49, 40, 8, -49 },
  { 5498, 41, 62, 40, 0, -50 },
  { 5816, 36, 49, 40, -1, -49 },
  { 6037, 37, 49, 40, 2, -49 },
  { 6264, 36, 51, 40, 3, -50 },
  { 6494, 37, 49, 40, 2, -49 },
  { 6721, 37, 49, 40, 3, -49 },
  { 6948, 39, 49, 40, 2, -49 },
  { 7187, 36, 51, 40, 3, -50 },
  { 7417, 38, 49, 40, 2, -49 },
  { 7650, 36, 49, 40, 3, -49 },
  { 7871, 39, 50, 40, 0, -49 },
  { 8115, 40, 49, 40, 2, -49 },
  { 8360, 30, 49, 40, 4, -49 },
  { 8544, 40, 49, 40, 1, -49 },
  { 8789, 38, 49, 40, 2, -49 },
  { 9022, 36, 51, 40, 3, -50 },
  { 9252, 39, 49, 40, 2, -49 },
  { 9491, 36, 62, 40, 3, -50 },
  { 9770, 38, 49, 40, 2, -49 },
  { 10003, 37, 51, 40, 2, -50 },
  { 10239, 35, 49, 40, 7, -49 },
  { 10454, 37, 50, 40, 3, -49 },
  { 10686, 36, 49, 40, 7, -49 },
  { 10907, 41, 49, 40, 3, -49 },
  { 11159, 43, 49, 40, -1, -49 },
  { 11423, 37, 49, 40, 6, -49 },
  { 11650, 37, 49, 40, 2, -49 },
  { 11877, 29, 63, 40, 8, -56 },
  { 12106, 22, 63, 40, 10, -56 },
  { 12280, 29, 63, 40, 5, -56 },
  { 12509, 31, 26, 40, 5, -49 },
  { 12610, 33, 7, 40, 0, 2 },
  { 12639, 15, 10, 40, 16, -53 },
  { 12658, 35, 39, 40, 3, -38 },
  { 12829, 35, 50, 40, 2, -49 },
  { 13048, 34, 39, 40, 3, -38 },
  { 13214, 37, 50, 40, 3, -49 },
  { 13446, 34, 39, 40, 3, -38 },
  { 13612, 46, 61, 40, -4, -49 },
  { 13963, 35, 50, 40, 3, -38 },
  { 14182, 35, 49, 40, 2, -49 },
  { 14397, 34, 53, 40, 2, -53 },
  { 14623, 36, 65, 40, 1, -53 },
  { 14916, 39, 49, 40, 2, -49 },
  { 15155, 30, 49, 40, 6, -49 },
  { 15339, 38, 38, 40, 1, -38 },
  { 15520, 35, 38, 40, 2, -38 },
  { 15687, 34, 39, 40, 3, -38 },
  { 15853, 37, 50, 40, 0, -38 },
  { 16085, 35, 50, 40, 3, -38 },
  { 16304, 36, 38, 40, 3, -38 },
  { 16475, 35, 39, 40, 2, -38 },
  { 16646, 33, 47, 40, 5, -47 },
  { 16840, 35, 38, 40, 3, -37 },
  { 17007, 34, 37, 40, 6, -37 },
  { 17165, 38, 37, 40, 4, -37 },
  { 17341, 40, 37, 40, 0, -37 },
  { 17526, 35, 49, 40, 3, -37 },
  { 17741, 35, 37, 40, 2, -37 },
  { 17903, 35, 63, 40, 6, -56 },
  { 18179, 18, 63, 40, 12, -56 },
  { 18321, 35, 63, 40, 1, -56 },
  { 18597, 36, 15, 40, 3, -31 },
};

const GFXfont JetBrainsMono_BoldItalic67pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic67pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic67pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _JETBRAINSMONO_BOLDITALIC67PT7B_H_
