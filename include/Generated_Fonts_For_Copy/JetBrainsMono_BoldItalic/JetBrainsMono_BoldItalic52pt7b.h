#ifndef _JETBRAINSMONO_BOLDITALIC52PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x3F, 0x81, 0xFE,
  0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0x07, 0xEF, 0xE0,
  0xFD, 0xFC, 0x3F, 0xBF, 0x07, 0xF7, 0xE0, 0xFF, 0xFC, 0x1F, 0xBF, 0x83,
  0xF7, 0xF0, 0x7E, 0xFC, 0x0F, 0xDF, 0x83, 0xFB, 0xF0, 0x7E, 0x7E, 0x0F,
  0xCF, 0xC1, 0xF9, 0xF0, 0x3F, 0x3E, 0x07, 0xE7, 0xC0, 0xF8, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F,
  0x80, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFD, 0xDF, 0xF0,
  0x7F, 0x1C, 0xFF, 0x07, 0xE3, 0xC7, 0xF0, 0xFE, 0x3C, 0x7F, 0x0F, 0xC3,
  0x87, 0xF0, 0xFC, 0x38, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0xFE, 0x38, 0x00,
  0x0F, 0xE3, 0x80, 0x00, 0xFF, 0x78, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x0E, 0x7F, 0xC0, 0x00, 0xE3, 0xFC, 0x00, 0x0E, 0x1F, 0xC0, 0x01, 0xE1,
  0xFC, 0x00, 0x1E, 0x1F, 0xCF, 0xE1, 0xC1, 0xF8, 0xFE, 0x1C, 0x1F, 0x8F,
  0xE1, 0xC3, 0xF8, 0xFF, 0x1C, 0x7F, 0x07, 0xFD, 0xDF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x07, 0xFF, 0x00,
  0x0F, 0x80, 0x7F, 0xFC, 0x00, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0xF8, 0x01, 0xE0, 0x7C, 0x07, 0x80, 0x1F, 0x03, 0xC0, 0x7C,
  0x00, 0xF8, 0x1E, 0x07, 0xC0, 0x07, 0xC0, 0xF0, 0x7C, 0x00, 0x3E, 0x0F,
  0x87, 0xC0, 0x01, 0xE0, 0x7C, 0x7C, 0x00, 0x0F, 0x03, 0xE7, 0xC0, 0x00,
  0x7C, 0x3E, 0x3C, 0x00, 0x03, 0xFF, 0xF3, 0xE0, 0x00, 0x1F, 0xFF, 0x3E,
  0x00, 0x00, 0x7F, 0xF3, 0xE0, 0x00, 0x00, 0xFE, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0x00, 0x1F,
  0x3F, 0xF0, 0x00, 0x01, 0xF3, 0xFF, 0xC0, 0x00, 0x1F, 0x3F, 0xFF, 0x00,
  0x01, 0xF3, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0xF0,
  0x3E, 0x00, 0x0F, 0x87, 0x81, 0xF0, 0x00, 0xF8, 0x7C, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x03, 0xC0, 0x0F, 0x80, 0xF8, 0x3E,
  0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0x00, 0x7C, 0x00,
  0xFF, 0xF0, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0,
  0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x03,
  0xF3, 0xFB, 0xF8, 0x3F, 0x1F, 0x8F, 0xC3, 0xF9, 0xFC, 0x7F, 0x1F, 0x8F,
  0xC1, 0xFD, 0xF8, 0x7E, 0x07, 0xFF, 0xC3, 0xF0, 0x3F, 0xFC, 0x1F, 0x80,
  0xFF, 0xC0, 0xFC, 0x07, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFF, 0x07, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x3F, 0x03, 0xFF,
  0xF1, 0xFC, 0x07, 0xFE, 0x07, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x9F,
  0x8F, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x9F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x01, 0x80, 0x7C, 0x02, 0x3E, 0x07, 0x81, 0xF3,
  0xF8, 0x78, 0x7F, 0x7F, 0xC7, 0x1F, 0xF7, 0xFF, 0x73, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x06,
  0x00, 0x60, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x07,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE,
  0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x0F, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0xFE, 0x00,
  0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1,
  0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xE1, 0xF8, 0x20, 0x7E, 0x1F, 0x8F, 0x87, 0xE3, 0xF9, 0xF8, 0xFE,
  0x3F, 0x1F, 0xCF, 0xC3, 0xF1, 0xFC, 0xFC, 0x3F, 0x1F, 0x8F, 0xC3, 0xF0,
  0xF8, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F,
  0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x0F,
  0xF0, 0x7F, 0xC1, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xF7, 0xE0,
  0x0F, 0xF3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xE1, 0xFC, 0x03, 0xC0, 0xFE,
  0x01, 0xC0, 0x7F, 0x00, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x0F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F,
  0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0xFE,
  0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x0F,
  0xF0, 0x0F, 0xC3, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F,
  0xE3, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xCF, 0xFE, 0x00, 0xFD, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xF9, 0xFF, 0x81, 0xFE,
  0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x03,
  0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x9F, 0xE0, 0x0F, 0xEF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x7F, 0x00, 0x3F, 0x9F,
  0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01,
  0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xF9, 0xFC,
  0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x81, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0xFC,
  0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x3F,
  0xCF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x1F,
  0xE0, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x8F,
  0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xF0, 0x07, 0xF1, 0xFC,
  0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0xBF, 0x80,
  0x07, 0xF3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x8F, 0xF0, 0x1F, 0xF1,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFD,
  0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0xC3,
  0xFE, 0x1F, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xC1, 0xFC, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xFE, 0x0F, 0xF8, 0xFF,
  0xC7, 0xFE, 0x3F, 0xE1, 0xFF, 0x07, 0xF0, 0x0C, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x30, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F,
  0xC0, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0x83, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80,
  0x08, 0x3E, 0x1F, 0x80, 0x7F, 0x3E, 0x1F, 0x81, 0xFF, 0xBE, 0x1F, 0x03,
  0xFF, 0xBE, 0x1F, 0x03, 0xFF, 0xFE, 0x1F, 0x07, 0xE0, 0xFE, 0x3F, 0x07,
  0xC0, 0x7E, 0x3F, 0x07, 0xC0, 0x7C, 0x3F, 0x0F, 0xC0, 0x7C, 0x3E, 0x0F,
  0xC0, 0x7C, 0x3E, 0x0F, 0x80, 0xFC, 0x3E, 0x0F, 0x80, 0xFC, 0x3E, 0x0F,
  0x80, 0xFC, 0x7E, 0x0F, 0x80, 0xF8, 0x7E, 0x1F, 0x80, 0xF8, 0x7C, 0x1F,
  0x80, 0xF8, 0x7C, 0x1F, 0x81, 0xF8, 0x7C, 0x1F, 0x81, 0xF8, 0x7C, 0x1F,
  0x83, 0xF8, 0xFC, 0x1F, 0xFF, 0xF0, 0xFC, 0x0F, 0xFC, 0xF0, 0xFC, 0x07,
  0xFD, 0xF0, 0xFC, 0x03, 0xF1, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xDF,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0xCF, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0x80, 0x1F, 0x87,
  0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x01,
  0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xF0, 0x3F,
  0xF8, 0x1F, 0x80, 0x3F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0,
  0x7F, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFC,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x1F,
  0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFC,
  0x00, 0xFF, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC,
  0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E,
  0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xF8, 0xFF, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x00, 0x7F,
  0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC,
  0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x87, 0xFC,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xE0, 0x1F, 0xE0, 0xFE, 0x00,
  0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0,
  0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0,
  0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0xFE,
  0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC3, 0xF8,
  0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x1F,
  0xC3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7F,
  0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF8, 0x7E, 0x00, 0xFF, 0x07, 0xE0, 0x1F,
  0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xF8, 0xFF, 0xC3,
  0xFC, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01,
  0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xFF, 0x3F, 0x87, 0xFF, 0xC7, 0xF0,
  0xFF, 0xF8, 0xFE, 0x1F, 0xFF, 0x1F, 0x83, 0xFF, 0xE3, 0xF0, 0x01, 0xFC,
  0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFC, 0x7F, 0x00,
  0x1F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x87,
  0xF8, 0x07, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC1, 0xFC,
  0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x01,
  0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0,
  0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC,
  0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE,
  0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x01,
  0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF0,
  0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0x7E,
  0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x00,
  0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0xC1,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x03, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xFE,
  0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE,
  0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF8,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x03,
  0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7B, 0xC0, 0xF7, 0x80, 0xFF, 0x81, 0xEF,
  0x03, 0xFF, 0x07, 0xDE, 0x07, 0xBE, 0x0F, 0xBC, 0x1F, 0x7C, 0x1F, 0x7C,
  0x3D, 0xF8, 0x3E, 0xF8, 0xFB, 0xE0, 0x7C, 0xF1, 0xE7, 0xC0, 0xF9, 0xE3,
  0xCF, 0x81, 0xF3, 0xCF, 0xBF, 0x07, 0xE7, 0x9E, 0x7E, 0x0F, 0xCF, 0x7C,
  0xFC, 0x1F, 0x9E, 0xF1, 0xF0, 0x3F, 0x3D, 0xE7, 0xE0, 0x7E, 0x3F, 0x8F,
  0xC0, 0xF8, 0x7F, 0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7E,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x0F, 0xF8, 0x03, 0xF0, 0x3F,
  0xE0, 0x0F, 0xC0, 0xFF, 0x80, 0x3F, 0x03, 0xFE, 0x00, 0xFC, 0x0F, 0xF8,
  0x07, 0xE0, 0x7F, 0xF0, 0x1F, 0x81, 0xFF, 0xC0, 0x7E, 0x07, 0xFF, 0x01,
  0xF8, 0x1F, 0x7C, 0x07, 0xE0, 0x7D, 0xF0, 0x1F, 0x81, 0xF7, 0xE0, 0xFC,
  0x0F, 0xCF, 0x83, 0xF0, 0x3F, 0x3E, 0x0F, 0xC0, 0xFC, 0xF8, 0x3F, 0x03,
  0xF3, 0xE0, 0xFC, 0x0F, 0xCF, 0x83, 0xF0, 0x3F, 0x3F, 0x1F, 0x80, 0xF8,
  0x7C, 0x7E, 0x07, 0xE1, 0xF1, 0xF8, 0x1F, 0x87, 0xC7, 0xE0, 0x7E, 0x1F,
  0x1F, 0x81, 0xF8, 0x7E, 0x7E, 0x07, 0xE0, 0xF9, 0xF0, 0x1F, 0x83, 0xE7,
  0xC0, 0xFC, 0x0F, 0x9F, 0x03, 0xF0, 0x3E, 0xFC, 0x0F, 0xC0, 0xFB, 0xF0,
  0x3F, 0x01, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0x03, 0xF0, 0x1F, 0xF8, 0x1F,
  0x80, 0x7F, 0xE0, 0x7E, 0x01, 0xFF, 0x81, 0xF8, 0x07, 0xFE, 0x07, 0xE0,
  0x0F, 0xF8, 0x1F, 0x80, 0x3F, 0xE0, 0x7E, 0x00, 0xFF, 0x03, 0xF0, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xF8, 0xFF, 0x83, 0xF8,
  0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC,
  0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7F, 0x00,
  0x1F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC7,
  0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x03,
  0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x3F,
  0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0,
  0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7E, 0x00, 0xFF, 0x81, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0x7E, 0x03, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xC3, 0xFE, 0x07, 0xF0,
  0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x7F,
  0x0F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE1, 0xFC,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x0F,
  0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F,
  0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF0, 0x01,
  0xFC, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF0, 0x7F, 0x00,
  0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x3F, 0xC1,
  0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0xFE,
  0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00,
  0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0,
  0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFE,
  0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x01,
  0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC,
  0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x01,
  0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0,
  0x7F, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFC,
  0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01,
  0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0,
  0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFC,
  0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8,
  0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F,
  0xC3, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x7E,
  0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F,
  0xC7, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF8,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0xFE, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x1F,
  0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03,
  0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0x03,
  0xF0, 0x3F, 0x3F, 0x03, 0xF0, 0x3F, 0x3F, 0x03, 0xF0, 0x3E, 0x3F, 0x03,
  0xF0, 0x3E, 0x3F, 0x07, 0xF0, 0x7E, 0x3F, 0x07, 0x70, 0x7E, 0x3F, 0x07,
  0xF0, 0x7C, 0x3F, 0x0F, 0xF0, 0x7C, 0x3E, 0x0F, 0xF0, 0xFC, 0x3E, 0x0E,
  0xF0, 0xFC, 0x3E, 0x0E, 0xF0, 0xF8, 0x3E, 0x1E, 0xF0, 0xF8, 0x3E, 0x1E,
  0xF1, 0xF8, 0x3E, 0x1C, 0xF1, 0xF8, 0x3E, 0x1C, 0xE1, 0xF0, 0x3E, 0x3C,
  0xE1, 0xF0, 0x3E, 0x3C, 0xE3, 0xF0, 0x3E, 0x38, 0xE3, 0xE0, 0x3E, 0x78,
  0xE3, 0xE0, 0x7E, 0x78, 0xE3, 0xE0, 0x7E, 0x70, 0xE3, 0xE0, 0x7C, 0x70,
  0xE7, 0xC0, 0x7C, 0xF0, 0xE7, 0xC0, 0x7C, 0xF0, 0xE7, 0xC0, 0x7C, 0xE1,
  0xE7, 0xC0, 0x7D, 0xE1, 0xEF, 0x80, 0x7D, 0xE1, 0xEF, 0x80, 0x7D, 0xE1,
  0xEF, 0x80, 0x7D, 0xC1, 0xEF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x07, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0,
  0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xF8, 0xFE,
  0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x07, 0xF0,
  0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x07,
  0xE1, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xFD,
  0xF0, 0x00, 0xFD, 0xF8, 0x01, 0xF9, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0,
  0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0,
  0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x7E, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0,
  0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF8, 0x00, 0x3F,
  0x87, 0xE0, 0x1F, 0xF8, 0xFC, 0x07, 0xFF, 0x9F, 0x81, 0xFF, 0xFB, 0xF0,
  0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xF8, 0x0F, 0xF8, 0xFE, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F,
  0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xE1, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC,
  0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xEF, 0xE0, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0x3F, 0x00, 0xFF, 0x87, 0xE0,
  0x01, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0x1F, 0xFC, 0x07, 0xE7, 0xFF, 0xC0, 0xFD, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0x81, 0xFE, 0x1F, 0xE0,
  0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3,
  0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F,
  0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x1F,
  0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF0, 0x7E, 0x7F, 0xFC, 0x0F, 0xCF, 0xFF, 0x01, 0xF8, 0x7F, 0x80,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1,
  0xFE, 0x03, 0xF8, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xCF, 0xC0, 0x07,
  0xF7, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F,
  0x3F, 0x80, 0x3F, 0x8F, 0xF0, 0x0F, 0xE3, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0xF1, 0xF8, 0x03, 0xFF,
  0xCF, 0xC0, 0x3F, 0xFF, 0x7E, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFC, 0x07, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F,
  0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07,
  0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x1F, 0xE0, 0x7F, 0xC3, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xDF,
  0xC0, 0x7F, 0xFE, 0xFC, 0x01, 0xFF, 0xE7, 0xE0, 0x03, 0xFC, 0x3F, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xE1,
  0xFC, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xE7, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x0F, 0xE3, 0xFC, 0x07, 0xF0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x7F, 0xF3, 0xF0, 0x3F, 0xFC, 0xFC,
  0x1F, 0xFF, 0xBF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFC, 0x07,
  0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xC0, 0x0F, 0xE7, 0xF0,
  0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xC7,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F,
  0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xF1,
  0xFF, 0x87, 0xFF, 0xF7, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0xFE, 0x07,
  0xFF, 0x3F, 0x80, 0xFF, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x9F, 0xFC, 0x07, 0xE7, 0xFF, 0xC0, 0xFD,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0x81, 0xFE,
  0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xE1,
  0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x00,
  0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x0F,
  0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F,
  0xC0, 0x1F, 0xE0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00,
  0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x07, 0xF0,
  0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x07, 0xF8, 0x01, 0xF8, 0x7F, 0x80, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xE0,
  0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x80,
  0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x1F,
  0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xC7, 0xC1, 0xF0, 0x1F,
  0x3F, 0x9F, 0xE0, 0x7D, 0xFE, 0xFF, 0x83, 0xFF, 0xFB, 0xFF, 0x0F, 0xF7,
  0xFF, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0xC3, 0xF0, 0xF8,
  0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x0F, 0x83, 0xE1, 0xF8, 0x3E, 0x1F,
  0x87, 0xE0, 0xF0, 0x7E, 0x1F, 0x83, 0xC1, 0xF8, 0x7E, 0x1F, 0x07, 0xE1,
  0xF0, 0x7C, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F, 0x07, 0xC3, 0xF0, 0xFC,
  0x1F, 0x0F, 0xC3, 0xF0, 0x78, 0x3F, 0x0F, 0xC3, 0xE0, 0xFC, 0x3F, 0x0F,
  0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0xF8, 0x3E, 0x1F, 0x83, 0xE1,
  0xF8, 0x7E, 0x0F, 0x07, 0xE1, 0xF8, 0x3C, 0x1F, 0x87, 0xE1, 0xF0, 0x7E,
  0x1F, 0x07, 0xC1, 0xF8, 0xFC, 0x1F, 0x07, 0xC0, 0x0F, 0xE1, 0xFC, 0x01,
  0xF8, 0xFF, 0xE0, 0x3F, 0x3F, 0xFE, 0x07, 0xEF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFC, 0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x1F,
  0xC0, 0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x0F,
  0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xF8,
  0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE,
  0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFE, 0x07, 0xF8, 0xFE, 0x00, 0xFE,
  0x3F, 0x80, 0x3F, 0x8F, 0xC0, 0x07, 0xE7, 0xF0, 0x01, 0xF9, 0xFC, 0x00,
  0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xE7, 0xE0, 0x03, 0xF9, 0xF8,
  0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x07, 0xF3,
  0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F,
  0xE3, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x8F, 0xFE, 0x00, 0xFC, 0xFF, 0xF8, 0x07,
  0xEF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0,
  0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F,
  0xC1, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x03,
  0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xEF,
  0xFF, 0x80, 0x7E, 0x7F, 0xF8, 0x03, 0xF0, 0xFF, 0x00, 0x1F, 0x80, 0x80,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x1F, 0xF8,
  0xFC, 0x0F, 0xFF, 0x9F, 0x83, 0xFF, 0xFB, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F,
  0xC3, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8,
  0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3,
  0xFE, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xEF, 0xC0, 0xFF, 0xFD,
  0xF8, 0x0F, 0xFF, 0x3F, 0x00, 0xFF, 0x87, 0xE0, 0x01, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0xFF, 0xE0, 0x3F, 0x7F,
  0xFE, 0x07, 0xEF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0x79, 0xFF, 0x87,
  0xF8, 0x07, 0xF8, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xE3, 0xF0, 0x01,
  0xFC, 0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xE3, 0xF8, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0,
  0x7F, 0x83, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xC7, 0xF8,
  0x07, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0xC0,
  0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC3, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F,
  0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x07, 0xF0, 0x07,
  0xF0, 0x7F, 0x80, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFD,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xF8, 0xFE, 0x00,
  0x7F, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x07,
  0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F,
  0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x87, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xE7, 0xE0,
  0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0xFF, 0xE0,
  0x7C, 0x07, 0xFF, 0x03, 0xE0, 0x3F, 0xF0, 0x3F, 0x03, 0xEF, 0x81, 0xF8,
  0x1F, 0x7C, 0x0F, 0xC0, 0xFB, 0xE0, 0xFE, 0x0F, 0x9F, 0x07, 0x70, 0x7C,
  0xF8, 0x3B, 0x83, 0xE7, 0xC3, 0xDC, 0x3F, 0x3E, 0x1C, 0xE1, 0xF1, 0xF0,
  0xE7, 0x0F, 0x8F, 0x8F, 0x38, 0x7C, 0x7C, 0x79, 0xC7, 0xC3, 0xE3, 0x8E,
  0x3E, 0x1F, 0x3C, 0x71, 0xF0, 0xF9, 0xE3, 0x9F, 0x07, 0xCE, 0x1C, 0xF8,
  0x3E, 0x70, 0xE7, 0xC1, 0xF7, 0x87, 0x7C, 0x0F, 0xB8, 0x3B, 0xE0, 0x7D,
  0xC1, 0xDF, 0x03, 0xFE, 0x0E, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x03,
  0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x07,
  0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0xFF,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF8,
  0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x80,
  0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F,
  0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00,
  0xFE, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x0F, 0xE3,
  0xF8, 0x03, 0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xFF, 0xDF, 0x87, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFB, 0xF8, 0x3F, 0xFC, 0xFE, 0x07, 0xFE, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x3F, 0x1F, 0xFF, 0x03, 0xF3, 0xFF, 0xF0, 0x3F, 0x3F, 0xFF,
  0x83, 0xE7, 0xE1, 0xF8, 0x3E, 0x7E, 0x1F, 0xEF, 0xE7, 0xC0, 0xFF, 0xFC,
  0x7C, 0x07, 0xFF, 0xC7, 0xC0, 0x7F, 0xF8, 0xFC, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0x80,
};

const GFXglyph JetBrainsMono_BoldItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 14, 38, 31, 9, -38 },
  { 68, 19, 16, 31, 9, -38 },
  { 106, 31, 38, 31, 1, -38 },
  { 254, 28, 52, 31, 2, -45 },
  { 436, 37, 38, 31, -2, -38 },
  { 612, 29, 39, 31, 1, -38 },
  { 754, 9, 16, 31, 14, -38 },
  { 772, 23, 51, 31, 7, -44 },
  { 919, 22, 51, 31, 3, -44 },
  { 1060, 28, 27, 31, 2, -32 },
  { 1155, 26, 25, 31, 3, -30 },
  { 1237, 15, 16, 31, 4, -8 },
  { 1267, 18, 6, 31, 7, -20 },
  { 1281, 10, 10, 31, 9, -9 },
  { 1294, 33, 49, 31, 0, -43 },
  { 1497, 28, 39, 31, 2, -38 },
  { 1634, 25, 38, 31, 2, -38 },
  { 1753, 28, 38, 31, 2, -38 },
  { 1886, 28, 39, 31, 2, -38 },
  { 2023, 27, 38, 31, 2, -38 },
  { 2152, 28, 39, 31, 2, -38 },
  { 2289, 27, 39, 31, 2, -38 },
  { 2421, 27, 38, 31, 5, -38 },
  { 2550, 28, 39, 31, 2, -38 },
  { 2687, 27, 38, 31, 4, -38 },
  { 2816, 13, 30, 31, 9, -29 },
  { 2865, 18, 37, 31, 4, -29 },
  { 2949, 26, 28, 31, 4, -31 },
  { 3040, 26, 19, 31, 3, -27 },
  { 3102, 26, 28, 31, 2, -31 },
  { 3193, 22, 38, 31, 7, -38 },
  { 3298, 32, 47, 31, 0, -38 },
  { 3486, 27, 38, 31, 0, -38 },
  { 3615, 29, 38, 31, 2, -38 },
  { 3753, 27, 39, 31, 3, -38 },
  { 3885, 28, 38, 31, 2, -38 },
  { 4018, 29, 38, 31, 2, -38 },
  { 4156, 30, 38, 31, 2, -38 },
  { 4299, 27, 39, 31, 3, -38 },
  { 4431, 29, 38, 31, 2, -38 },
  { 4569, 28, 38, 31, 2, -38 },
  { 4702, 30, 39, 31, 0, -38 },
  { 4849, 31, 38, 31, 2, -38 },
  { 4997, 24, 38, 31, 3, -38 },
  { 5111, 31, 38, 31, 1, -38 },
  { 5259, 30, 38, 31, 1, -38 },
  { 5402, 27, 39, 31, 3, -38 },
  { 5534, 30, 38, 31, 2, -38 },
  { 5677, 28, 47, 31, 2, -38 },
  { 5842, 29, 38, 31, 2, -38 },
  { 5980, 29, 39, 31, 2, -38 },
  { 6122, 28, 38, 31, 5, -38 },
  { 6255, 29, 39, 31, 2, -38 },
  { 6397, 27, 38, 31, 6, -38 },
  { 6526, 32, 38, 31, 2, -38 },
  { 6678, 34, 38, 31, -1, -38 },
  { 6840, 29, 38, 31, 5, -38 },
  { 6978, 28, 38, 31, 2, -38 },
  { 7111, 23, 49, 31, 6, -43 },
  { 7252, 17, 49, 31, 8, -43 },
  { 7357, 22, 49, 31, 4, -43 },
  { 7492, 24, 20, 31, 4, -38 },
  { 7552, 26, 6, 31, 0, 1 },
  { 7572, 11, 7, 31, 13, -41 },
  { 7582, 27, 30, 31, 2, -29 },
  { 7684, 27, 39, 31, 2, -38 },
  { 7816, 26, 30, 31, 3, -29 },
  { 7914, 29, 39, 31, 2, -38 },
  { 8056, 26, 30, 31, 3, -29 },
  { 8154, 36, 47, 31, -3, -38 },
  { 8366, 26, 38, 31, 3, -29 },
  { 8490, 27, 38, 31, 2, -38 },
  { 8619, 26, 41, 31, 2, -41 },
  { 8753, 29, 50, 31, 0, -41 },
  { 8935, 29, 38, 31, 2, -38 },
  { 9073, 24, 38, 31, 4, -38 },
  { 9187, 30, 29, 31, 0, -29 },
  { 9296, 27, 29, 31, 2, -29 },
  { 9394, 26, 30, 31, 3, -29 },
  { 9492, 29, 38, 31, 0, -29 },
  { 9630, 27, 38, 31, 2, -29 },
  { 9759, 27, 29, 31, 3, -29 },
  { 9857, 27, 30, 31, 2, -29 },
  { 9959, 26, 36, 31, 4, -36 },
  { 10076, 28, 30, 31, 2, -29 },
  { 10181, 27, 29, 31, 4, -29 },
  { 10279, 29, 29, 31, 3, -29 },
  { 10385, 31, 29, 31, 0, -29 },
  { 10498, 26, 38, 31, 3, -29 },
  { 10622, 27, 29, 31, 2, -29 },
  { 10720, 28, 49, 31, 4, -43 },
  { 10892, 14, 49, 31, 9, -43 },
  { 10978, 27, 49, 31, 1, -43 },
  { 11144, 28, 12, 31, 2, -24 },
};

const GFXfont JetBrainsMono_BoldItalic52pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic52pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _JETBRAINSMONO_BOLDITALIC52PT7B_H_
