#ifndef _JETBRAINSMONO_BOLDITALIC28PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x87, 0x1E, 0x3C, 0x70, 0xE1, 0xC3,
  0x80, 0x00, 0x00, 0x31, 0xF3, 0xE7, 0x80, 0xF1, 0xFC, 0xFF, 0x3F, 0x8F,
  0xE3, 0xB8, 0xEE, 0x3B, 0x8E, 0x01, 0xC3, 0x80, 0xE3, 0x80, 0x61, 0xC0,
  0x70, 0xC0, 0x38, 0xE0, 0xFF, 0xFC, 0xFF, 0xFE, 0x0E, 0x38, 0x06, 0x1C,
  0x07, 0x0C, 0x03, 0x8E, 0x01, 0x87, 0x07, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF,
  0xF8, 0x70, 0xC0, 0x38, 0xE0, 0x18, 0x70, 0x1C, 0x30, 0x0E, 0x38, 0x00,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x07, 0x80, 0x7F, 0xC1, 0xFF, 0x87,
  0xFF, 0x8E, 0x6F, 0x3C, 0xCE, 0x79, 0x00, 0xF6, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0x3C, 0x06, 0x78, 0x0C, 0xF7,
  0x99, 0xEF, 0x37, 0x8F, 0xFF, 0x1F, 0xFC, 0x0F, 0xE0, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x01, 0x00, 0x10, 0xFC, 0x0E, 0x1F, 0xE0,
  0xC1, 0x8E, 0x18, 0x18, 0xE3, 0x81, 0x8E, 0x70, 0x38, 0xEE, 0x03, 0xDD,
  0xC0, 0x1F, 0xB8, 0x00, 0xE3, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01,
  0xDF, 0x00, 0x3B, 0xF8, 0x07, 0x71, 0x80, 0xE6, 0x18, 0x0C, 0x63, 0x81,
  0x86, 0x38, 0x30, 0x63, 0x87, 0x07, 0xF0, 0xE0, 0x3E, 0x00, 0x00, 0xF0,
  0x03, 0xFC, 0x07, 0xFC, 0x0F, 0x1E, 0x0E, 0x0E, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x3F, 0x80, 0x3F, 0xC7, 0x79, 0xCE,
  0x79, 0xFE, 0x70, 0xFC, 0x70, 0xF8, 0x70, 0x78, 0x70, 0xF8, 0x7F, 0xF8,
  0x7F, 0xDC, 0x3F, 0x1E, 0xFF, 0xFF, 0xEE, 0xEE, 0x00, 0x10, 0x07, 0x01,
  0xF0, 0x3F, 0x07, 0xC0, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x00, 0x10, 0x08, 0x00, 0x70, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F,
  0x83, 0xF0, 0x7E, 0x07, 0x80, 0x60, 0x08, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x07, 0x18, 0xEF, 0xB7, 0xFF, 0xDF, 0x8F, 0xF8, 0x03,
  0x80, 0x1D, 0x80, 0x7B, 0x81, 0xE7, 0x87, 0x87, 0x86, 0x0C, 0x04, 0x10,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFE, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xFF, 0xFF, 0xEF, 0xF8,
  0x77, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF9, 0xF1, 0xC1,
  0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x0F, 0x38, 0x1E, 0xF7, 0x39, 0xEF, 0x73,
  0xDC, 0xE7, 0x11, 0xCE, 0x03, 0x9C, 0x0F, 0x38, 0x1E, 0xF0, 0x38, 0xF0,
  0xF1, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0xC1, 0xFF,
  0x07, 0xBC, 0x18, 0xE0, 0xC3, 0x82, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC1, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0,
  0xFB, 0xF3, 0xC1, 0xE7, 0x83, 0xCE, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x80, 0x1F, 0xFE,
  0x3F, 0xFC, 0x7F, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0xBC, 0x0E, 0x78, 0x1C, 0xF0, 0x78, 0xFF, 0xE1, 0xFF, 0x81, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x1C, 0x78, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x03,
  0x8F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1F, 0xFC, 0x3B, 0xF8, 0x7F, 0xF8, 0xE0, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x78, 0x1C, 0x78, 0x78, 0xFF, 0xE1,
  0xFF, 0x80, 0xFE, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x1C, 0x00, 0xF0, 0x07, 0x98, 0x3F, 0xF8, 0xFF, 0xE7, 0xC7, 0xDE,
  0x0F, 0x70, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x79, 0xFF, 0xC3,
  0xFE, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0xE0, 0x7B,
  0x81, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF9, 0xF1, 0xC1, 0xE7,
  0x83, 0xCF, 0x07, 0x9E, 0x0E, 0x1E, 0x78, 0x1F, 0xE0, 0x1F, 0x80, 0xFF,
  0x83, 0xC7, 0x8F, 0x07, 0x9C, 0x0F, 0x78, 0x1E, 0xF0, 0x39, 0xE0, 0xF1,
  0xFF, 0xC3, 0xFF, 0x83, 0xFC, 0x00, 0x03, 0xC0, 0x1F, 0xE0, 0x7F, 0xE1,
  0xF3, 0xE7, 0x83, 0xCE, 0x03, 0x9C, 0x07, 0x78, 0x0E, 0xF0, 0x3C, 0xF0,
  0xF9, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x0C, 0x7C,
  0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9F, 0x3E, 0x78,
  0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x83,
  0xC0, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0xFF, 0x0F, 0xE0, 0xFE, 0x07,
  0xE0, 0x3C, 0x00, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0,
  0x03, 0xC0, 0x03, 0x00, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x20, 0x00,
  0xE0, 0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07,
  0x00, 0x7C, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0x7E, 0x03, 0xE0, 0x0C, 0x00,
  0x00, 0x7F, 0x87, 0xFC, 0x7F, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1E, 0x3F, 0xC3, 0xF8, 0x3F, 0x07, 0x80, 0x70, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xFF, 0x01,
  0xFF, 0xC1, 0xE0, 0xF1, 0xC0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x67,
  0x38, 0xFB, 0x98, 0xF7, 0xDC, 0x71, 0xCE, 0x38, 0xE7, 0x38, 0x73, 0x9C,
  0x39, 0xCE, 0x1C, 0xC7, 0x0E, 0xE3, 0x8F, 0x71, 0xFF, 0x38, 0x7D, 0x9C,
  0x01, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3B,
  0x80, 0x77, 0x01, 0xEE, 0x03, 0x9C, 0x0F, 0x3C, 0x1C, 0x78, 0x38, 0xF0,
  0xF0, 0xE1, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1C, 0x0E, 0x78, 0x1C, 0xE0,
  0x3B, 0xC0, 0x77, 0x80, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x71, 0xF8, 0xE0,
  0xF3, 0xC1, 0xE7, 0x83, 0xCE, 0x07, 0x9C, 0x1E, 0x3F, 0xF8, 0x7F, 0xC1,
  0xFF, 0xE3, 0xC1, 0xE7, 0x83, 0xCE, 0x03, 0x9C, 0x0F, 0x38, 0x1E, 0xF0,
  0x79, 0xFF, 0xF3, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0xF0, 0x0F, 0xF8, 0x3F,
  0xF0, 0xF9, 0xF1, 0xC1, 0xE7, 0x81, 0xCF, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x1E, 0x70, 0x38, 0xF0, 0xF1, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x1F,
  0xF8, 0x3F, 0xF8, 0x7F, 0xF9, 0xE0, 0xF3, 0xC1, 0xE7, 0x81, 0xCF, 0x07,
  0x9C, 0x0F, 0x38, 0x1E, 0x70, 0x39, 0xE0, 0x73, 0xC0, 0xE7, 0x83, 0xCE,
  0x07, 0x9C, 0x0F, 0x38, 0x3C, 0xF0, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xFC,
  0x00, 0x1F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x7F, 0xF8, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F,
  0xF8, 0x3F, 0xF0, 0xF9, 0xF1, 0xC1, 0xE7, 0x81, 0xCF, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE7, 0xF3, 0xCF, 0xE7, 0x9F, 0xCE, 0x07, 0x9C,
  0x0F, 0x38, 0x1E, 0x70, 0x38, 0xF0, 0xF1, 0xFF, 0xC1, 0xFF, 0x01, 0xFC,
  0x00, 0x1E, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x38, 0x1C, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0x78,
  0x3C, 0x78, 0x3C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0x70, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x70,
  0x3C, 0xF0, 0x3C, 0x78, 0x78, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x1E,
  0x0F, 0x8E, 0x07, 0x87, 0x07, 0x87, 0x87, 0x83, 0xC3, 0xC1, 0xE3, 0xC0,
  0xF1, 0xC0, 0x71, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0x3C,
  0x07, 0x8E, 0x03, 0x87, 0x81, 0xC3, 0xC0, 0xE0, 0xE0, 0xF0, 0x78, 0x78,
  0x3C, 0x3C, 0x1E, 0x1C, 0x07, 0x80, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0x07, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xF1, 0xF1, 0xB0, 0xDD,
  0xF8, 0xEE, 0xDC, 0x77, 0xEE, 0x39, 0xE7, 0x1C, 0xF3, 0x8E, 0x7B, 0xC7,
  0x01, 0xC3, 0x80, 0xE3, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x3C, 0x70, 0x1E,
  0x38, 0x0E, 0x1C, 0x07, 0x1E, 0x03, 0x80, 0x1E, 0x0F, 0x1F, 0x0E, 0x1F,
  0x0E, 0x3F, 0x0E, 0x3F, 0x0E, 0x3B, 0x0E, 0x3B, 0x9E, 0x3B, 0x9E, 0x3B,
  0x9C, 0x7B, 0x9C, 0x79, 0x9C, 0x71, 0xDC, 0x71, 0xDC, 0x71, 0xDC, 0x71,
  0xF8, 0xF1, 0xF8, 0xF0, 0xF8, 0xE0, 0xF8, 0xE0, 0xF8, 0xE0, 0xF8, 0x01,
  0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF9, 0xF1, 0xC1, 0xE7, 0x83, 0xCF, 0x07,
  0x9C, 0x0F, 0x38, 0x1E, 0x70, 0x39, 0xE0, 0x73, 0xC0, 0xE7, 0x83, 0xCE,
  0x07, 0x9C, 0x0F, 0x38, 0x1C, 0x70, 0x38, 0xF0, 0xF1, 0xFF, 0xC1, 0xFF,
  0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0E, 0x38, 0x3E, 0x3F, 0xFC, 0x7F,
  0xF8, 0x7F, 0xE0, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3F,
  0xF0, 0xF9, 0xF1, 0xC1, 0xE7, 0x83, 0xCE, 0x07, 0x9C, 0x0F, 0x38, 0x1E,
  0xF0, 0x39, 0xE0, 0x73, 0xC0, 0xE7, 0x83, 0xCE, 0x07, 0x9C, 0x0F, 0x38,
  0x1E, 0xF0, 0x38, 0xF0, 0xF1, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xFE, 0x3C, 0x1E, 0x3C, 0x0E, 0x3C, 0x0E, 0x3C, 0x0E, 0x38, 0x1E,
  0x38, 0x3C, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xE0, 0x79, 0xE0, 0x70, 0xE0,
  0x70, 0xF0, 0x70, 0xF0, 0xF0, 0x70, 0xF0, 0x78, 0xF0, 0x78, 0xE0, 0x78,
  0x01, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0xF9, 0xF1, 0xC1, 0xE7, 0x81, 0xCF,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0xF0, 0x3D, 0xE0, 0xF1, 0xFF, 0xE3,
  0xFF, 0x81, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x1E, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E,
  0x3C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x38, 0x1E, 0x38, 0x1C,
  0x78, 0x1C, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x3C, 0x70, 0x38,
  0x70, 0x38, 0x78, 0x78, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0xF0, 0x1F,
  0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xCF, 0x07, 0x8E, 0x0E, 0x1C, 0x1C, 0x38,
  0x78, 0x70, 0xE0, 0xE3, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x3C, 0x0F, 0x70,
  0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x70, 0xE3, 0xB8, 0xF1, 0xDC, 0x78, 0xEE, 0x3C, 0xE7, 0x16, 0x73, 0x9B,
  0x39, 0xCD, 0x9C, 0xE6, 0xDC, 0x76, 0x6E, 0x3B, 0x27, 0x1D, 0x93, 0x0E,
  0xDB, 0x86, 0xCD, 0xC3, 0x66, 0xE1, 0xB3, 0x60, 0xF1, 0xF0, 0xF8, 0xF8,
  0x7C, 0x7C, 0x3E, 0x3C, 0x1E, 0x1E, 0x00, 0x1E, 0x07, 0xC3, 0xC3, 0xC0,
  0xF0, 0xF0, 0x1C, 0x78, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xDC, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3C, 0x38, 0x1E, 0x0F, 0x07,
  0x83, 0xC3, 0xC0, 0x78, 0xF0, 0x1F, 0xE0, 0x79, 0xC0, 0xE3, 0x83, 0xC7,
  0x8F, 0x0F, 0x1E, 0x0E, 0x78, 0x1C, 0xE0, 0x3F, 0xC0, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xF8, 0x7F, 0x8F, 0xF0, 0xF0,
  0x78, 0x1C, 0x0E, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x03,
  0x81, 0xC0, 0xF0, 0x78, 0x1C, 0x0E, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x38,
  0x1E, 0x0F, 0x03, 0x81, 0xC0, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x03, 0xC0, 0x1F, 0x01,
  0xF8, 0x1D, 0xC0, 0xE7, 0x0E, 0x38, 0x71, 0xC7, 0x0E, 0x78, 0x3F, 0x81,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF1, 0xC3, 0x8F, 0x03, 0x80,
  0x1F, 0xBC, 0x7F, 0xF9, 0xF3, 0xE3, 0xC3, 0xCF, 0x03, 0x9E, 0x0F, 0x3C,
  0x1E, 0x78, 0x3C, 0xE0, 0x71, 0xC0, 0xE3, 0x83, 0xC7, 0x87, 0x8F, 0xFF,
  0x1F, 0xFE, 0x1F, 0xBC, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC6, 0x07, 0xBF, 0x0E, 0xFF, 0x1F, 0x3E, 0x3C, 0x3C, 0x70, 0x39, 0xE0,
  0x73, 0xC1, 0xE7, 0x83, 0xCE, 0x07, 0x9C, 0x0E, 0x38, 0x1C, 0xF8, 0x79,
  0xFF, 0xE3, 0xFF, 0xC7, 0x3E, 0x00, 0x01, 0xC0, 0x1F, 0xF0, 0x7F, 0xF1,
  0xF3, 0xE3, 0xC1, 0xCF, 0x03, 0x9E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x13, 0x81, 0xC7, 0x87, 0x8F, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x03, 0x9E, 0x0F, 0xDE,
  0x1F, 0xFE, 0x3E, 0x7C, 0x3C, 0x3C, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x3C,
  0x78, 0x3C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x78, 0x78, 0x78, 0x7F, 0xF8,
  0x7F, 0xF8, 0x3F, 0x78, 0x01, 0xC0, 0x3F, 0xE1, 0xFF, 0x8F, 0x0F, 0x38,
  0x1D, 0xE0, 0x77, 0x81, 0xDF, 0xFF, 0x7F, 0xFD, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x79, 0xFF, 0xC3, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0x80, 0x1F, 0xBC, 0x7F, 0xF9, 0xF3, 0xE3, 0xC3, 0xCF, 0x03, 0x9E, 0x0F,
  0x3C, 0x1E, 0x78, 0x3C, 0xE0, 0x71, 0xC0, 0xE3, 0xC3, 0xC7, 0xFB, 0x87,
  0xFF, 0x07, 0xDE, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0xFF, 0x83, 0xFF,
  0x07, 0xF8, 0x00, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x60,
  0xF7, 0xE3, 0xFF, 0xCF, 0x9F, 0x3C, 0x3C, 0xE0, 0x77, 0x83, 0xDE, 0x0F,
  0x78, 0x3D, 0xC0, 0xF7, 0x03, 0x9C, 0x0E, 0xF0, 0x3B, 0xC1, 0xEF, 0x07,
  0xBC, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x01, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x01, 0x3C, 0x1E, 0x3C, 0x3C, 0x38, 0x3C,
  0x38, 0x78, 0x38, 0xF0, 0x39, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xE0,
  0x71, 0xE0, 0x70, 0xF0, 0x70, 0xF0, 0xF0, 0x70, 0xF0, 0x78, 0xF0, 0x7C,
  0x7F, 0x83, 0xFC, 0x3F, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x05, 0x8C, 0x3B,
  0xDF, 0x3F, 0xDF, 0x38, 0xE7, 0x38, 0xC7, 0x38, 0xC7, 0x39, 0xC7, 0x39,
  0xCE, 0x79, 0xCE, 0x71, 0x8E, 0x71, 0x8E, 0x71, 0x8E, 0x73, 0x8E, 0x73,
  0x9E, 0xF3, 0x9C, 0xE3, 0x9C, 0x00, 0x60, 0xF7, 0xE3, 0xBF, 0xCF, 0x9F,
  0x3C, 0x3C, 0xE0, 0x77, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xC0, 0xF7, 0x03,
  0x9C, 0x0E, 0xF0, 0x3B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0x01, 0xE0, 0x3F,
  0xE1, 0xFF, 0x8F, 0x9F, 0x3C, 0x3D, 0xE0, 0x77, 0x81, 0xDE, 0x0F, 0x70,
  0x3D, 0xC0, 0xF7, 0x03, 0x9C, 0x0E, 0x78, 0x79, 0xFF, 0xC3, 0xFE, 0x07,
  0xF0, 0x00, 0x30, 0x1E, 0xFC, 0x1D, 0xFE, 0x1F, 0x3E, 0x1E, 0x1E, 0x1C,
  0x0E, 0x3C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x38,
  0x1C, 0x7C, 0x3C, 0x7F, 0xF8, 0x7F, 0xF8, 0x73, 0xE0, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x1F, 0xBC, 0x7F,
  0xF9, 0xF3, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x70, 0x3C,
  0xE0, 0x71, 0xC0, 0xE3, 0x83, 0xC7, 0x87, 0x8F, 0xFF, 0x1F, 0xFE, 0x1F,
  0xB8, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x70, 0x3B, 0xF8, 0x7F, 0xF9, 0xF1, 0xF3, 0xC1, 0xE7, 0x83, 0xCE, 0x07,
  0x9C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xE1,
  0xE3, 0x81, 0xC7, 0x00, 0x0F, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x03, 0xF0,
  0x00, 0xF0, 0x01, 0xCF, 0x03, 0x9F, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x00, 0x1E, 0x00, 0x7F, 0xC1, 0xFF, 0x03, 0xF8, 0x3C, 0x1E,
  0x78, 0x3C, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xCF, 0x07, 0x9E, 0x0F, 0x3C,
  0x1E, 0x70, 0x3C, 0xE0, 0x71, 0xC1, 0xE3, 0xC3, 0xC7, 0xFF, 0x07, 0xFC,
  0x07, 0xF0, 0x00, 0xF0, 0x1E, 0xE0, 0x79, 0xC0, 0xE3, 0x83, 0xC7, 0x87,
  0x8F, 0x0E, 0x0E, 0x3C, 0x1C, 0x70, 0x39, 0xE0, 0x73, 0x80, 0xEF, 0x01,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xE3, 0x8F, 0xC7, 0x1F,
  0x9E, 0x3F, 0x3C, 0xEE, 0x59, 0xD9, 0xB3, 0xB3, 0x66, 0x66, 0xDC, 0xD9,
  0xB9, 0xB3, 0x63, 0x67, 0xC6, 0x8F, 0x8F, 0x1E, 0x1E, 0x3C, 0x38, 0x78,
  0x00, 0x1E, 0x0F, 0x87, 0x0F, 0x03, 0xCF, 0x00, 0xE7, 0x00, 0x7F, 0x80,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x07, 0x9C,
  0x03, 0xCF, 0x03, 0xC7, 0x83, 0xC1, 0xE3, 0xC0, 0xF8, 0x3C, 0x1E, 0x70,
  0x38, 0xE0, 0x71, 0xC0, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x38, 0x1E,
  0x70, 0x38, 0xE0, 0xF1, 0xE3, 0xE3, 0xFF, 0xC3, 0xF7, 0x83, 0xCF, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x00, 0x3F,
  0xFE, 0x7F, 0xF8, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0x9F,
  0xFF, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x78,
  0x78, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0x07, 0x80, 0x1F, 0x80, 0x3F,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x83,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xF0, 0x00, 0x1F, 0x0E, 0x7F, 0x1D,
  0xFE, 0x3B, 0x9E, 0xFE, 0x1F, 0xDC, 0x1F, 0x00,
};

const GFXglyph JetBrainsMono_BoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 7, 20, 17, 5, -20 },
  { 19, 10, 8, 17, 5, -20 },
  { 29, 17, 20, 17, 0, -20 },
  { 72, 15, 28, 17, 1, -24 },
  { 125, 20, 21, 17, -1, -21 },
  { 178, 16, 21, 17, 0, -21 },
  { 220, 4, 8, 17, 8, -20 },
  { 224, 12, 28, 17, 4, -24 },
  { 266, 12, 28, 17, 1, -24 },
  { 308, 15, 15, 17, 1, -17 },
  { 337, 14, 13, 17, 2, -16 },
  { 360, 8, 8, 17, 2, -4 },
  { 368, 10, 3, 17, 4, -11 },
  { 372, 5, 5, 17, 5, -5 },
  { 376, 18, 26, 17, 0, -23 },
  { 435, 15, 21, 17, 1, -21 },
  { 475, 14, 20, 17, 1, -20 },
  { 510, 15, 21, 17, 1, -21 },
  { 550, 15, 20, 17, 1, -20 },
  { 588, 15, 20, 17, 1, -20 },
  { 626, 15, 20, 17, 1, -20 },
  { 664, 14, 20, 17, 1, -20 },
  { 699, 14, 20, 17, 3, -20 },
  { 734, 15, 21, 17, 1, -21 },
  { 774, 15, 21, 17, 2, -21 },
  { 814, 7, 16, 17, 5, -16 },
  { 828, 10, 20, 17, 2, -16 },
  { 853, 14, 15, 17, 2, -17 },
  { 880, 14, 10, 17, 2, -14 },
  { 898, 14, 15, 17, 1, -17 },
  { 925, 12, 20, 17, 4, -20 },
  { 955, 17, 26, 17, 0, -21 },
  { 1011, 15, 20, 17, 0, -20 },
  { 1049, 15, 20, 17, 1, -20 },
  { 1087, 15, 21, 17, 1, -21 },
  { 1127, 15, 20, 17, 1, -20 },
  { 1165, 16, 20, 17, 1, -20 },
  { 1205, 16, 20, 17, 1, -20 },
  { 1245, 15, 21, 17, 1, -21 },
  { 1285, 16, 20, 17, 1, -20 },
  { 1325, 15, 20, 17, 1, -20 },
  { 1363, 16, 20, 17, 0, -20 },
  { 1403, 17, 20, 17, 1, -20 },
  { 1446, 12, 20, 17, 2, -20 },
  { 1476, 17, 20, 17, 0, -20 },
  { 1519, 16, 20, 17, 1, -20 },
  { 1559, 15, 21, 17, 1, -21 },
  { 1599, 16, 20, 17, 1, -20 },
  { 1639, 15, 26, 17, 1, -21 },
  { 1688, 16, 20, 17, 1, -20 },
  { 1728, 15, 21, 17, 1, -21 },
  { 1768, 15, 20, 17, 3, -20 },
  { 1806, 16, 20, 17, 1, -20 },
  { 1846, 15, 20, 17, 3, -20 },
  { 1884, 17, 20, 17, 1, -20 },
  { 1927, 18, 20, 17, 0, -20 },
  { 1972, 15, 20, 17, 3, -20 },
  { 2010, 15, 20, 17, 1, -20 },
  { 2048, 12, 26, 17, 3, -23 },
  { 2087, 9, 26, 17, 4, -23 },
  { 2117, 12, 26, 17, 2, -23 },
  { 2156, 13, 10, 17, 2, -20 },
  { 2173, 14, 3, 17, 0, 1 },
  { 2179, 6, 4, 17, 7, -22 },
  { 2182, 15, 16, 17, 1, -16 },
  { 2212, 15, 20, 17, 1, -20 },
  { 2250, 15, 16, 17, 1, -16 },
  { 2280, 16, 20, 17, 1, -20 },
  { 2320, 14, 16, 17, 1, -16 },
  { 2348, 20, 25, 17, -2, -20 },
  { 2411, 15, 21, 17, 1, -16 },
  { 2451, 14, 20, 17, 1, -20 },
  { 2486, 14, 22, 17, 1, -22 },
  { 2525, 15, 27, 17, 0, -22 },
  { 2576, 16, 20, 17, 1, -20 },
  { 2616, 13, 20, 17, 2, -20 },
  { 2649, 16, 16, 17, 0, -16 },
  { 2681, 14, 16, 17, 1, -16 },
  { 2709, 14, 16, 17, 1, -16 },
  { 2737, 16, 21, 17, 0, -16 },
  { 2779, 15, 21, 17, 1, -16 },
  { 2819, 15, 16, 17, 1, -16 },
  { 2849, 15, 16, 17, 1, -16 },
  { 2879, 14, 20, 17, 2, -20 },
  { 2914, 15, 15, 17, 1, -15 },
  { 2943, 15, 15, 17, 2, -15 },
  { 2972, 15, 15, 17, 2, -15 },
  { 3001, 17, 15, 17, 0, -15 },
  { 3033, 15, 20, 17, 1, -15 },
  { 3071, 15, 15, 17, 1, -15 },
  { 3100, 15, 26, 17, 2, -23 },
  { 3149, 8, 26, 17, 5, -23 },
  { 3175, 15, 26, 17, 0, -23 },
  { 3224, 15, 6, 17, 1, -13 },
};

const GFXfont JetBrainsMono_BoldItalic28pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic28pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _JETBRAINSMONO_BOLDITALIC28PT7B_H_
