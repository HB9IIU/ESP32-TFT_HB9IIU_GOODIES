#ifndef _JETBRAINSMONO_BOLDITALIC30PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x38, 0x7C, 0xF8, 0x78, 0x79,
  0xEF, 0x3D, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xBC, 0x77, 0x0E, 0xE1, 0xC0,
  0x00, 0xE1, 0xC0, 0x1C, 0x30, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x30,
  0x07, 0x0E, 0x47, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0x0E, 0x00, 0xE1, 0xC0,
  0x1C, 0x30, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x30, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x30, 0x07,
  0x0E, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x3F, 0xFC, 0x3E, 0xFE, 0x1E, 0xCF,
  0x1E, 0x67, 0x8F, 0x30, 0x07, 0x98, 0x03, 0xEC, 0x00, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0xDF, 0x00, 0x67, 0x80, 0x33, 0xCF,
  0x19, 0xE7, 0x98, 0xF3, 0xEC, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xF0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x38,
  0x7F, 0x03, 0x87, 0xBC, 0x38, 0x38, 0xE1, 0x81, 0x87, 0x18, 0x0C, 0x31,
  0xC0, 0x61, 0x9C, 0x03, 0xBD, 0xC0, 0x1F, 0xDC, 0x00, 0x7D, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0xE0, 0x0E, 0xFF,
  0x00, 0xE6, 0x18, 0x0E, 0x70, 0xC0, 0xE3, 0x8E, 0x06, 0x1C, 0x70, 0x70,
  0xE7, 0x87, 0x03, 0xF8, 0x70, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x73, 0x9E, 0x7B, 0xCF,
  0x79, 0xE3, 0xF8, 0xF0, 0xFC, 0x70, 0x7C, 0x38, 0x3C, 0x1E, 0x3F, 0x0F,
  0xFF, 0xC7, 0xFD, 0xE1, 0xFC, 0x78, 0x7B, 0xDE, 0xEF, 0x7B, 0xDE, 0xE0,
  0x00, 0x18, 0x03, 0xC0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x3C, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x81, 0xF0,
  0x3E, 0x0F, 0xC0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x03, 0x0C, 0x73, 0xE6, 0xFB, 0xFA, 0xFE, 0x7F,
  0xF8, 0x01, 0xC0, 0x03, 0xF0, 0x03, 0xBC, 0x03, 0xCE, 0x03, 0xC7, 0x83,
  0xC3, 0xC0, 0x60, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x0F, 0x87, 0xC7, 0xC3, 0xC1,
  0xE1, 0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F,
  0xE0, 0x79, 0xFF, 0xFF, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0x1F, 0x1E, 0x0F, 0x3C, 0x07,
  0x3C, 0x07, 0x3C, 0x0F, 0x38, 0x0F, 0x39, 0xCF, 0x3B, 0xCE, 0x7B, 0xCE,
  0x79, 0xCE, 0x78, 0x1E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0x3C,
  0x78, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0xF8, 0x03, 0xF0,
  0x1F, 0xE0, 0xFF, 0xC1, 0xE7, 0x03, 0x8E, 0x04, 0x3C, 0x10, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0x80, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0x1F, 0x3E, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFF, 0x10, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF8, 0x7C,
  0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x1F, 0x1E, 0x1E, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x7F, 0xFC,
  0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3D, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE,
  0x3C, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x70, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3F, 0xF0, 0xFF, 0xF1, 0xFB, 0xF7, 0x81, 0xEF, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x79, 0xE1, 0xF3, 0xFF, 0xC3,
  0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xDE, 0x07, 0xBC, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x01, 0xFC,
  0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F,
  0x1C, 0x1E, 0x1E, 0x3E, 0x0F, 0xFC, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0x7C,
  0x3C, 0x3C, 0x78, 0x1E, 0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF8, 0x7C,
  0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE,
  0x3E, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1E,
  0x78, 0x3E, 0x7C, 0x7C, 0x7F, 0xFC, 0x3F, 0xF8, 0x0C, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x0E, 0x1F, 0x3F, 0x3E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x7C, 0xFC, 0xFC, 0x78, 0x03, 0x81, 0xF0, 0xFC, 0x3F,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x07,
  0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x00, 0x00,
  0x02, 0x00, 0x1C, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x1F, 0xC0,
  0x3C, 0x00, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1E, 0x00, 0x0C, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3,
  0xFF, 0xE0, 0x10, 0x00, 0x38, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x1E, 0x01, 0xFC, 0x0F, 0xE0, 0x7F,
  0x07, 0xF8, 0x0F, 0xC0, 0x3C, 0x00, 0x60, 0x00, 0x3F, 0x81, 0xFF, 0x1F,
  0xFC, 0xFF, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x01, 0xF1, 0xFF,
  0x0F, 0xF0, 0x7F, 0x03, 0xE0, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xF0, 0x1F, 0xFE, 0x07, 0x81, 0xE1, 0xE0, 0x1C, 0x38, 0x03, 0x8E, 0x00,
  0x71, 0xC0, 0xCE, 0x38, 0x7D, 0xC7, 0x1F, 0xF9, 0xE7, 0x8F, 0x38, 0xE1,
  0xE7, 0x1C, 0x38, 0xE3, 0x87, 0x1C, 0x70, 0xE3, 0x8E, 0x1C, 0x73, 0xC7,
  0x9C, 0x78, 0xF3, 0x87, 0xEC, 0x70, 0xFB, 0x8E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xDC, 0x03,
  0xDC, 0x03, 0xDC, 0x03, 0x9C, 0x07, 0x9C, 0x07, 0x1C, 0x0F, 0x1E, 0x0F,
  0x1E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x38,
  0x0E, 0x78, 0x0E, 0x78, 0x0E, 0xF0, 0x0E, 0xF0, 0x0F, 0x1F, 0xF8, 0x0F,
  0xFF, 0x07, 0xFF, 0xC3, 0xC3, 0xE1, 0xC0, 0xF0, 0xE0, 0x78, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x1E, 0x1F, 0xFE, 0x0F, 0xF8, 0x07, 0xFF, 0x87, 0x83,
  0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x38, 0x0F, 0x1C,
  0x1F, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xE3, 0xE1, 0xE0, 0xF1, 0xE0, 0x38, 0xF0, 0x20, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x1E, 0x3C, 0x1E, 0x1E, 0x1F,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFE, 0x1F, 0xFF, 0x1C, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x3C, 0xF1, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xC0, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC7,
  0xFF, 0xE0, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC3, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE3, 0xE1, 0xE0, 0xF1,
  0xE0, 0x38, 0xF0, 0x20, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x3F,
  0xCF, 0x1F, 0xC7, 0x8F, 0xE3, 0xC7, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78,
  0x1E, 0x3C, 0x1E, 0x1E, 0x1F, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00,
  0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC3, 0xC0, 0xE1, 0xE0, 0xF0, 0xE0,
  0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1F, 0xFF, 0x0F, 0xFF, 0x87,
  0xFF, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x38, 0x78, 0x3C,
  0x38, 0x1E, 0x1C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC0, 0x0F,
  0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3C, 0xF0, 0x1E, 0x3C, 0x1E, 0x1E, 0x1F, 0x0F,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x1E, 0x03, 0xC7, 0x81, 0xE1, 0xE0,
  0xF8, 0x78, 0x3C, 0x1E, 0x1E, 0x07, 0x0F, 0x83, 0xC3, 0xC0, 0xF1, 0xE0,
  0x3C, 0x78, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x78, 0xF0, 0x1E,
  0x3C, 0x07, 0x87, 0x01, 0xE1, 0xE0, 0x78, 0x78, 0x1C, 0x1E, 0x0F, 0x03,
  0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC3, 0xC1,
  0xF1, 0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x67, 0x71, 0xD9, 0xF8,
  0x76, 0x6E, 0x3D, 0xBB, 0x8F, 0x6C, 0xE3, 0xDF, 0x78, 0xE7, 0x9E, 0x39,
  0xE7, 0x8E, 0x01, 0xC3, 0x80, 0x71, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03,
  0xC7, 0x00, 0xF1, 0xC0, 0x38, 0x70, 0x0E, 0x3C, 0x07, 0x80, 0x1F, 0x07,
  0x8F, 0x83, 0xC7, 0xC1, 0xE3, 0xE0, 0xE1, 0xF8, 0x71, 0xFC, 0x38, 0xFE,
  0x1C, 0x77, 0x1E, 0x3B, 0x8F, 0x1C, 0xE7, 0x8E, 0x73, 0x8F, 0x39, 0xC7,
  0x9C, 0xE3, 0xCE, 0x71, 0xC3, 0xF8, 0xE1, 0xFC, 0x70, 0xFC, 0x38, 0x7E,
  0x3C, 0x3F, 0x1E, 0x0F, 0x8F, 0x07, 0xC7, 0x03, 0xE0, 0x01, 0xFC, 0x07,
  0xFE, 0x0F, 0xFF, 0x1F, 0x1F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1C, 0x78, 0x3C, 0x78, 0x7C, 0x7F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0xC3,
  0xC7, 0xF1, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07,
  0x1E, 0x07, 0x8F, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0x83, 0xFE, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0x1F,
  0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F,
  0x38, 0x0E, 0x78, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x70, 0x1C, 0x78, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x1F, 0xF8,
  0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xC7, 0xE1, 0xC0, 0xF8, 0xE0, 0x3C, 0xF0,
  0x1E, 0x78, 0x0E, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0xFF, 0x87, 0xFF, 0x87,
  0xFF, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0x78, 0x38, 0x3C,
  0x3C, 0x1E, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE0, 0x01, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xE1, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3E,
  0x1F, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0,
  0xE1, 0xC0, 0x71, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E,
  0x07, 0x8E, 0x03, 0x87, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78,
  0xF0, 0x3C, 0x78, 0x1C, 0x3C, 0x1E, 0x1E, 0x1F, 0x0F, 0xFF, 0x03, 0xFF,
  0x00, 0xFE, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x70, 0x1E, 0x70,
  0x1C, 0x70, 0x3C, 0x70, 0x38, 0x78, 0x78, 0x78, 0x78, 0x78, 0x70, 0x78,
  0xF0, 0x78, 0xE0, 0x79, 0xE0, 0x79, 0xE0, 0x39, 0xC0, 0x3B, 0xC0, 0x3B,
  0x80, 0x3B, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x38,
  0xF1, 0xE7, 0x1E, 0x39, 0xE3, 0xC7, 0x3C, 0x78, 0xE7, 0x1B, 0x3C, 0xE3,
  0x67, 0x1C, 0x78, 0xE3, 0x9F, 0x1C, 0x73, 0x67, 0x0E, 0x6C, 0xE1, 0xCD,
  0x9C, 0x3B, 0x33, 0x87, 0x66, 0xE0, 0xEC, 0xDC, 0x1D, 0x9B, 0x83, 0xE3,
  0x70, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xB1, 0xF0, 0x3C, 0x3E, 0x0F, 0x87,
  0x81, 0xF0, 0xF0, 0x00, 0x1F, 0x03, 0xE1, 0xE0, 0x78, 0x3C, 0x1E, 0x03,
  0xC7, 0xC0, 0x78, 0xF0, 0x0F, 0x3C, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF0,
  0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE1, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0xF0,
  0x0F, 0x70, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x78, 0x3C, 0x78, 0x3C,
  0xF0, 0x3D, 0xE0, 0x1D, 0xE0, 0x1D, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFF, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF,
  0xF8, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFC, 0x3F, 0xC1, 0xFE, 0x00, 0xF0,
  0x1C, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01,
  0xC0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x1C,
  0x07, 0x81, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x83, 0xFC, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x3F, 0x01, 0xFC, 0x07, 0x70, 0x3D, 0xE0, 0xE3, 0x87, 0x0E, 0x3C, 0x38,
  0xE0, 0xF7, 0x81, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0xF0,
  0xF0, 0xF1, 0xE1, 0xE0, 0x03, 0xCF, 0x0F, 0xEF, 0x1F, 0xFF, 0x3F, 0x7F,
  0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x7F, 0xFC, 0x7F, 0xBC,
  0x3F, 0x3C, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x70, 0x3D, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x3C, 0x1E, 0x3C, 0x1E,
  0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C,
  0x78, 0x3C, 0x78, 0x7C, 0xFF, 0xF8, 0xF7, 0xF0, 0xF7, 0xE0, 0x01, 0xF0,
  0x07, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x3C, 0x1E, 0x3C, 0x0E, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x1E, 0x78, 0x3C,
  0x78, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x1E, 0x78, 0x3F, 0xBC, 0x3F,
  0xFE, 0x3F, 0x7F, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3,
  0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x38, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1F,
  0x0F, 0xFF, 0x87, 0xFB, 0xC1, 0xF9, 0xE0, 0x01, 0xF0, 0x07, 0xFC, 0x0F,
  0xFC, 0x1E, 0x1E, 0x3C, 0x1E, 0x38, 0x0E, 0x78, 0x0E, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x3C, 0x7F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x7C, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0x9E, 0x3F, 0xBC, 0xFF, 0xFB, 0xF7, 0xF7,
  0x83, 0xCF, 0x07, 0x9C, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0,
  0xE7, 0x83, 0xCF, 0x8F, 0x9F, 0xFF, 0x1F, 0xDE, 0x1F, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x70, 0x3D, 0xFC,
  0x3F, 0xFE, 0x3F, 0x7E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x70, 0x3C, 0x70, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0x00, 0x30, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFE, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x80, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x3C, 0x70, 0x3C, 0x78, 0x3E, 0x3C, 0x1E, 0x1E, 0x1E, 0x0F, 0x1E,
  0x07, 0x9F, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xF1, 0xE0, 0x78,
  0xF0, 0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x0F, 0x8F, 0x03, 0xC7, 0x81, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x80, 0x3F, 0xF1, 0xFF, 0x83, 0xFC,
  0x1C, 0xC7, 0x0F, 0xF7, 0xC7, 0xFF, 0xE7, 0x9C, 0x73, 0xCE, 0x39, 0xC7,
  0x1C, 0xE3, 0x9E, 0x71, 0xCF, 0x38, 0xC7, 0x3C, 0x63, 0x9E, 0x71, 0xCE,
  0x38, 0xE7, 0x1C, 0x73, 0x8E, 0x79, 0xC6, 0x3D, 0xE3, 0x1C, 0xF3, 0x8E,
  0x00, 0x1C, 0x70, 0x3D, 0xFC, 0x3F, 0xFE, 0x3F, 0x7E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x78,
  0x1C, 0x70, 0x3C, 0x70, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0x01,
  0xF0, 0x07, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x3C, 0x1E, 0x3C, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1C, 0x78,
  0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x0E, 0x38, 0x0F,
  0x7F, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x70, 0x3C,
  0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC3, 0xC1,
  0xE1, 0xE1, 0xF1, 0xFF, 0xF0, 0xF7, 0xF0, 0x7B, 0xF0, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x03, 0xCF, 0x0F, 0xEF,
  0x1F, 0xFF, 0x3F, 0x7F, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x70, 0x3C, 0x78, 0x3C, 0x78, 0x7C,
  0x7F, 0xFC, 0x7F, 0xBC, 0x3F, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x1E, 0x78, 0x1E, 0xFE, 0x1D, 0xFF, 0x1F, 0xBF,
  0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3E, 0x3E, 0x3C, 0x0E,
  0x3C, 0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x3E,
  0x00, 0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7F, 0xE0,
  0x7F, 0x80, 0x7F, 0x00, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F,
  0x3C, 0x0E, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0,
  0x1F, 0xC0, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0xF7, 0x81, 0xEF, 0x07, 0x9E,
  0x0F, 0x1C, 0x3C, 0x38, 0x78, 0x71, 0xE0, 0xF3, 0xC1, 0xE7, 0x03, 0xDE,
  0x03, 0xB8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xE1, 0xC3,
  0xF1, 0xE3, 0xB8, 0xF1, 0xDC, 0x78, 0xEE, 0x2C, 0xE7, 0x36, 0x73, 0x9B,
  0x39, 0xCD, 0x9C, 0xEC, 0xDC, 0x76, 0x6E, 0x3B, 0x37, 0x1F, 0x1F, 0x0F,
  0x8F, 0x87, 0xC7, 0xC3, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x00, 0x1E,
  0x07, 0xC7, 0x81, 0xE0, 0xF0, 0xF0, 0x3C, 0x78, 0x07, 0xBE, 0x01, 0xEF,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x3D, 0xE0, 0x1F, 0x78, 0x07, 0x8F, 0x03, 0xC3, 0xC1, 0xE0, 0x78, 0xF8,
  0x1F, 0x00, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xE7, 0x83, 0xCE,
  0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x73, 0xC1, 0xE7, 0x83,
  0xCF, 0xDF, 0x9F, 0xFF, 0x1F, 0xDE, 0x0E, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x1F, 0xFE,
  0x1F, 0xFE, 0x3F, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x00,
  0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xF0,
  0x01, 0xF0, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x00, 0x0F, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x81, 0xFF, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x01, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x00, 0x1F, 0x07, 0x3F, 0x87, 0x7F, 0xC7, 0x73, 0xCF, 0x71,
  0xFE, 0xF0, 0xFE, 0x00, 0x78,
};

const GFXglyph JetBrainsMono_BoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 8, 22, 18, 5, -22 },
  { 23, 11, 9, 18, 5, -22 },
  { 36, 19, 22, 18, 0, -22 },
  { 89, 17, 30, 18, 1, -26 },
  { 153, 21, 22, 18, -1, -22 },
  { 211, 17, 22, 18, 0, -22 },
  { 258, 5, 9, 18, 8, -22 },
  { 264, 13, 29, 18, 4, -25 },
  { 312, 12, 29, 18, 2, -25 },
  { 356, 17, 15, 18, 1, -18 },
  { 388, 15, 14, 18, 2, -17 },
  { 415, 9, 10, 18, 2, -5 },
  { 427, 11, 4, 18, 4, -12 },
  { 433, 6, 5, 18, 5, -5 },
  { 437, 19, 28, 18, 0, -25 },
  { 504, 16, 22, 18, 1, -22 },
  { 548, 15, 22, 18, 1, -22 },
  { 590, 16, 22, 18, 1, -22 },
  { 634, 16, 22, 18, 1, -22 },
  { 678, 16, 22, 18, 1, -22 },
  { 722, 16, 22, 18, 1, -22 },
  { 766, 15, 22, 18, 1, -22 },
  { 808, 15, 22, 18, 3, -22 },
  { 850, 16, 22, 18, 1, -22 },
  { 894, 16, 22, 18, 2, -22 },
  { 938, 8, 17, 18, 5, -17 },
  { 955, 10, 22, 18, 3, -17 },
  { 983, 15, 16, 18, 2, -18 },
  { 1013, 15, 11, 18, 2, -15 },
  { 1034, 15, 16, 18, 1, -18 },
  { 1064, 13, 22, 18, 4, -22 },
  { 1100, 19, 27, 18, 0, -22 },
  { 1165, 16, 22, 18, 0, -22 },
  { 1209, 17, 22, 18, 1, -22 },
  { 1256, 17, 22, 18, 1, -22 },
  { 1303, 16, 22, 18, 1, -22 },
  { 1347, 17, 22, 18, 1, -22 },
  { 1394, 17, 22, 18, 1, -22 },
  { 1441, 17, 22, 18, 1, -22 },
  { 1488, 17, 22, 18, 1, -22 },
  { 1535, 16, 22, 18, 1, -22 },
  { 1579, 17, 22, 18, 0, -22 },
  { 1626, 18, 22, 18, 1, -22 },
  { 1676, 13, 22, 18, 2, -22 },
  { 1712, 18, 22, 18, 0, -22 },
  { 1762, 17, 22, 18, 1, -22 },
  { 1809, 16, 22, 18, 1, -22 },
  { 1853, 17, 22, 18, 1, -22 },
  { 1900, 16, 27, 18, 1, -22 },
  { 1954, 17, 22, 18, 1, -22 },
  { 2001, 17, 22, 18, 1, -22 },
  { 2048, 16, 22, 18, 3, -22 },
  { 2092, 17, 22, 18, 1, -22 },
  { 2139, 16, 22, 18, 3, -22 },
  { 2183, 19, 22, 18, 1, -22 },
  { 2236, 19, 22, 18, 0, -22 },
  { 2289, 16, 22, 18, 3, -22 },
  { 2333, 16, 22, 18, 1, -22 },
  { 2377, 13, 28, 18, 4, -25 },
  { 2423, 10, 28, 18, 4, -25 },
  { 2458, 13, 28, 18, 2, -25 },
  { 2504, 14, 12, 18, 2, -22 },
  { 2525, 15, 3, 18, 0, 1 },
  { 2531, 7, 5, 18, 7, -24 },
  { 2536, 16, 17, 18, 1, -17 },
  { 2570, 16, 22, 18, 1, -22 },
  { 2614, 16, 17, 18, 1, -17 },
  { 2648, 17, 22, 18, 1, -22 },
  { 2695, 16, 17, 18, 1, -17 },
  { 2729, 21, 27, 18, -2, -22 },
  { 2800, 15, 22, 18, 2, -17 },
  { 2842, 16, 22, 18, 1, -22 },
  { 2886, 15, 24, 18, 1, -24 },
  { 2931, 16, 29, 18, 0, -24 },
  { 2989, 17, 22, 18, 1, -22 },
  { 3036, 13, 22, 18, 3, -22 },
  { 3072, 17, 17, 18, 0, -17 },
  { 3109, 16, 17, 18, 1, -17 },
  { 3143, 16, 17, 18, 1, -17 },
  { 3177, 17, 22, 18, 0, -17 },
  { 3224, 16, 22, 18, 1, -17 },
  { 3268, 16, 17, 18, 1, -17 },
  { 3302, 16, 17, 18, 1, -17 },
  { 3336, 15, 21, 18, 2, -21 },
  { 3376, 16, 17, 18, 1, -17 },
  { 3410, 15, 17, 18, 3, -17 },
  { 3442, 17, 17, 18, 2, -17 },
  { 3479, 18, 17, 18, 0, -17 },
  { 3518, 15, 22, 18, 2, -17 },
  { 3560, 16, 17, 18, 1, -17 },
  { 3594, 16, 28, 18, 2, -25 },
  { 3650, 9, 28, 18, 5, -25 },
  { 3682, 15, 28, 18, 1, -25 },
  { 3735, 16, 7, 18, 1, -14 },
};

const GFXfont JetBrainsMono_BoldItalic30pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic30pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _JETBRAINSMONO_BOLDITALIC30PT7B_H_
