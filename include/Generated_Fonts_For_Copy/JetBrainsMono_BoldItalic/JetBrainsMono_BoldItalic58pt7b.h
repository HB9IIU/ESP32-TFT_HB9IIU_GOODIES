#ifndef _JETBRAINSMONO_BOLDITALIC58PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x3F,
  0x00, 0x7F, 0x83, 0xFD, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE,
  0x7F, 0x07, 0xF9, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFC, 0xFE,
  0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xF8, 0xFC, 0x07,
  0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x7E, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFC, 0x71, 0xFE, 0x07, 0xF8, 0xF1, 0xFE, 0x07, 0xF8, 0xF0, 0xFE,
  0x07, 0xF0, 0xF0, 0xFE, 0x07, 0xF0, 0xF0, 0xFE, 0x0F, 0xF0, 0xF0, 0x00,
  0x0F, 0xF0, 0xE0, 0x00, 0x0F, 0xF0, 0xE0, 0x00, 0x0F, 0xF9, 0xE0, 0x00,
  0x07, 0xFD, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0x9F, 0xF8, 0x00, 0x07, 0x8F, 0xF8,
  0x00, 0x07, 0x87, 0xF8, 0x00, 0x07, 0x87, 0xF8, 0x00, 0x07, 0x83, 0xF8,
  0x00, 0x07, 0x87, 0xF8, 0xFF, 0x07, 0x07, 0xF8, 0xFF, 0x07, 0x07, 0xF0,
  0xFF, 0x0F, 0x0F, 0xF0, 0x7F, 0x8F, 0x1F, 0xF0, 0x7F, 0xCF, 0x3F, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0xFC,
  0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x81, 0xF8,
  0x00, 0x3E, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x80, 0xF8, 0x7E, 0x00, 0x03,
  0xE0, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x8F, 0x80, 0x00, 0x3F, 0x07,
  0xC7, 0xC0, 0x00, 0x0F, 0xFF, 0xF3, 0xE0, 0x00, 0x01, 0xFF, 0xF9, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x7E, 0x00, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x7E, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0x9F, 0xFF, 0xC0, 0x00,
  0x07, 0xCF, 0xE3, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x7C, 0x00, 0x01, 0xF0,
  0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x7E, 0x07, 0xC0, 0x00, 0x7E, 0x1F, 0x01,
  0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x1F, 0x00,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x01, 0xF0,
  0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0x80, 0x01, 0xFF, 0xC0,
  0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x01,
  0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x01, 0xFE, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F, 0x8F, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0xFE, 0x0F, 0xC1, 0xFE, 0x7F, 0x0F, 0xE0, 0x7F,
  0x7F, 0x07, 0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0x81, 0xFC, 0x03,
  0xFF, 0x80, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xFC, 0x03, 0xFF, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xEF, 0xE0, 0x3F, 0xFF, 0xE7, 0xF0, 0x0F, 0xFF, 0xC1, 0xFC, 0x03,
  0xFF, 0x80, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xBF, 0xDF, 0xEF,
  0xF7, 0xF3, 0xF9, 0xFD, 0xFE, 0xFF, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3,
  0xF1, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x08, 0x03, 0xF0,
  0x06, 0x3E, 0x07, 0xE0, 0x3C, 0x7F, 0x07, 0x83, 0xF9, 0xFF, 0x0F, 0x1F,
  0xF3, 0xFF, 0x1C, 0x7F, 0xFF, 0xFF, 0xBB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x07,
  0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x40,
  0x02, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x01,
  0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE0, 0x1F, 0x87, 0xF9, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xCF, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xE7,
  0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x03,
  0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE,
  0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x1E, 0x0F, 0xE1,
  0xFC, 0x7E, 0x1F, 0xC3, 0xF9, 0xFE, 0x3F, 0x87, 0xF3, 0xFC, 0x7F, 0x0F,
  0xE7, 0xF8, 0xFE, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x0F, 0xC7, 0xF0, 0xFE,
  0x02, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x7F, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0x7F, 0x00, 0x3F, 0xE7, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xF0,
  0x07, 0xC0, 0xFF, 0x00, 0x78, 0x0F, 0xE0, 0x06, 0x00, 0xFE, 0x00, 0x40,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x07,
  0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x1F,
  0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x03, 0xFE, 0x07, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xA0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x1F,
  0xF0, 0x0F, 0xE1, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x00,
  0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F,
  0x1F, 0xC0, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF9, 0xFF, 0xC0, 0x0F,
  0xEF, 0xFF, 0xC0, 0x7F, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0x80, 0x7F, 0xC1, 0xFC, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xEF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFE, 0x3F,
  0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x3F, 0x9F, 0xC0, 0x01, 0xFE, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x3F,
  0xC7, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xF0, 0x00,
  0x7F, 0xBF, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F,
  0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xE3, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0,
  0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFF, 0x03,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFE,
  0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xF0, 0xFF, 0xC3, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x07,
  0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x07,
  0xF9, 0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xF7, 0xF0, 0x1F, 0xFF, 0x7F, 0x00, 0x7F,
  0xF7, 0xF8, 0x00, 0x38, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x3F, 0xC0, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8,
  0x3F, 0xF0, 0x3F, 0xC0, 0x18, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x10, 0x1F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x04,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0xFC, 0x01, 0xFE, 0x7E, 0x0F, 0xC0, 0x7F, 0xF7, 0xE1,
  0xF8, 0x0F, 0xFF, 0x7E, 0x1F, 0x80, 0xFF, 0xF7, 0xC1, 0xF8, 0x1F, 0xC1,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x83,
  0xF0, 0x0F, 0xC3, 0xF0, 0x3F, 0x00, 0xFC, 0x3F, 0x03, 0xF0, 0x1F, 0xC3,
  0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x7E, 0x01,
  0xF8, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x7E, 0x01, 0xF8, 0x7E, 0x07,
  0xE0, 0x1F, 0x87, 0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x3F, 0x07,
  0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0xFF,
  0xF0, 0xFC, 0x07, 0xFF, 0xBF, 0x0F, 0xC0, 0x3F, 0xFB, 0xE0, 0xFC, 0x01,
  0xFE, 0x3E, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xC0,
  0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0xC0, 0x7E, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0xFF, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xF8, 0x03, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01,
  0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x1F,
  0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x7F,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFC,
  0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x7F, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x1F, 0xFE, 0x07, 0xF0, 0x03, 0xFE,
  0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFE,
  0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC,
  0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF8,
  0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x03,
  0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xFF, 0x87, 0xF0, 0x7F, 0xFF, 0x0F,
  0xE0, 0xFF, 0xFE, 0x1F, 0xC1, 0xFF, 0xFC, 0x7F, 0x83, 0xFF, 0xF0, 0xFF,
  0x07, 0xFF, 0xE1, 0xFC, 0x0F, 0xFF, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x80,
  0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x7F, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0,
  0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F,
  0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF8,
  0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x03,
  0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xE0,
  0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x01, 0xD0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0x7C, 0x07, 0xFF, 0x03, 0xEF, 0x80, 0xFD,
  0xE0, 0xFB, 0xF0, 0x1F, 0x3C, 0x1F, 0x7E, 0x03, 0xE7, 0xC3, 0xEF, 0xC0,
  0xFC, 0xF8, 0xF9, 0xF8, 0x1F, 0x9F, 0x1F, 0x7F, 0x03, 0xF3, 0xE7, 0xCF,
  0xC0, 0x7E, 0x7C, 0xF9, 0xF8, 0x0F, 0xC7, 0xBE, 0x3F, 0x01, 0xF8, 0xF7,
  0xC7, 0xE0, 0x7F, 0x1E, 0xF1, 0xFC, 0x0F, 0xE3, 0xFE, 0x3F, 0x81, 0xFC,
  0x7F, 0xC7, 0xE0, 0x3F, 0x8F, 0xF0, 0xFC, 0x07, 0xE1, 0xFE, 0x3F, 0x80,
  0xFC, 0x3F, 0x87, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x3F, 0x81, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xC0, 0x0F, 0xC0,
  0x7F, 0xE0, 0x07, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x3F, 0xF8, 0x03, 0xF8,
  0x1F, 0xFC, 0x01, 0xFC, 0x0F, 0xFF, 0x00, 0xFE, 0x07, 0xFF, 0x80, 0x7E,
  0x03, 0xFF, 0xC0, 0x3F, 0x01, 0xFF, 0xE0, 0x3F, 0x81, 0xFD, 0xF0, 0x1F,
  0xC0, 0xFE, 0xFC, 0x0F, 0xE0, 0x7E, 0x7E, 0x07, 0xF0, 0x3F, 0x3F, 0x03,
  0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0x0F, 0xC7, 0xC1, 0xFC, 0x07, 0xE3, 0xE0,
  0xFE, 0x07, 0xF1, 0xF8, 0x7F, 0x03, 0xF8, 0xFC, 0x3F, 0x81, 0xFC, 0x7E,
  0x1F, 0x80, 0xFE, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0x87, 0xE0, 0x3F, 0x07,
  0xE7, 0xF0, 0x3F, 0x83, 0xF3, 0xF8, 0x1F, 0xC1, 0xF9, 0xFC, 0x0F, 0xE0,
  0xFC, 0xFE, 0x07, 0xF0, 0x3E, 0x7E, 0x03, 0xF0, 0x1F, 0xBF, 0x01, 0xF8,
  0x0F, 0xDF, 0x81, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0x03, 0xF7, 0xE0, 0x7F,
  0x00, 0xFB, 0xF0, 0x3F, 0x80, 0x7D, 0xF0, 0x1F, 0x80, 0x3F, 0xF8, 0x0F,
  0xC0, 0x1F, 0xFC, 0x0F, 0xE0, 0x0F, 0xFE, 0x07, 0xF0, 0x07, 0xFF, 0x03,
  0xF8, 0x01, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0x7F, 0xC0,
  0x7E, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xEF, 0xFF, 0x03, 0xFE, 0x03, 0xFE,
  0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0,
  0x7F, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x1F,
  0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8,
  0x01, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xEF, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x03,
  0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F,
  0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF0,
  0xFF, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0x7F,
  0x80, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0x07, 0xF8, 0x01, 0xFF,
  0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFE,
  0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xDF, 0xFE, 0x03, 0xFC, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0,
  0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0,
  0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80,
  0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07,
  0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03,
  0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0x01, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x81, 0xFC, 0xFC, 0x07,
  0xF0, 0x3F, 0x1F, 0x81, 0xFE, 0x07, 0xE3, 0xF0, 0x3F, 0x80, 0xFC, 0x7E,
  0x07, 0xF0, 0x3F, 0x8F, 0xC0, 0xEE, 0x07, 0xE1, 0xF8, 0x3D, 0xC0, 0xFC,
  0x3F, 0x07, 0xF8, 0x1F, 0x87, 0xC0, 0xFF, 0x07, 0xE1, 0xF8, 0x3D, 0xE0,
  0xFC, 0x3F, 0x07, 0xBC, 0x1F, 0x87, 0xE0, 0xF7, 0x83, 0xF0, 0xFC, 0x1E,
  0xF0, 0xFC, 0x1F, 0x87, 0x9E, 0x1F, 0x83, 0xF0, 0xF3, 0xC3, 0xF0, 0x7E,
  0x1E, 0x78, 0x7E, 0x0F, 0xC7, 0x8F, 0x1F, 0x81, 0xF8, 0xF1, 0xE3, 0xF0,
  0x3F, 0x1E, 0x3C, 0x7E, 0x07, 0xE3, 0xC7, 0x8F, 0xC0, 0xFC, 0xF0, 0xF3,
  0xF0, 0x1F, 0x9E, 0x1E, 0x7E, 0x03, 0xE3, 0xC3, 0xCF, 0xC0, 0x7C, 0x78,
  0x79, 0xF0, 0x0F, 0x9E, 0x0E, 0x3E, 0x01, 0xF3, 0xC1, 0xCF, 0xC0, 0x3E,
  0x78, 0x79, 0xF8, 0x0F, 0xDE, 0x0F, 0x3E, 0x01, 0xFB, 0xC1, 0xE7, 0xC0,
  0x3F, 0x78, 0x3D, 0xF8, 0x07, 0xEF, 0x07, 0xBF, 0x00, 0xFF, 0xC0, 0xF7,
  0xC0, 0x1F, 0xF8, 0x1E, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7D, 0xE0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x03,
  0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x0F,
  0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x1F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0x7F,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xF7, 0xF8,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x03,
  0xFB, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0x87, 0xE0,
  0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03,
  0xF0, 0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x07, 0xE3, 0xF8,
  0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0,
  0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xE1, 0xFC, 0x03, 0xFF, 0xCF,
  0xF0, 0x3F, 0xFF, 0xBF, 0xC0, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x87, 0xF8, 0x03, 0xFE, 0x1F,
  0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0,
  0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0xFF, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x00, 0x7F, 0xC3, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xBF, 0x80, 0xFF, 0xFE, 0xFE, 0x01, 0xFF, 0xE3,
  0xF8, 0x03, 0xFF, 0x0F, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x0F, 0xF8, 0x01, 0xFC, 0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFE, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x0F,
  0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF,
  0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F,
  0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xF8, 0x1F, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0x9F, 0xFF, 0x80, 0xFE, 0x3F, 0xFC, 0x03, 0xF8, 0x7F, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xE0, 0x7F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF9,
  0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xF3, 0xFC,
  0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x03,
  0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE1, 0xFC, 0x00,
  0xFF, 0xF3, 0xFC, 0x03, 0xFF, 0xFB, 0xFC, 0x07, 0xFF, 0xFB, 0xF8, 0x07,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xE0, 0x0F, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x3F,
  0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F,
  0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xFF, 0xDF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xBF, 0x80, 0x3F, 0xFF, 0xBF, 0x80, 0x1F, 0xFE, 0x3F, 0x80, 0x0F,
  0xFC, 0x3F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x00, 0xFE,
  0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE1,
  0xFC, 0x03, 0xFF, 0xCF, 0xF0, 0x1F, 0xFF, 0xBF, 0xC0, 0xFF, 0xFE, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x87,
  0xF8, 0x03, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF8,
  0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x87, 0xF8, 0x07, 0xFC, 0x1F,
  0xF8, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x7F, 0x03, 0xFF,
  0xF9, 0xFC, 0x07, 0xFF, 0xEF, 0xF0, 0x0F, 0xFE, 0x3F, 0x80, 0x0F, 0xF0,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x0F, 0xF8, 0x01, 0xFC, 0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFE, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFC, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xFC, 0x7F,
  0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0,
  0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01,
  0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0xFE,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F,
  0xC0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x0F, 0xF8, 0x01, 0xFC, 0x0F, 0xF8, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xF8, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x07, 0xE3, 0xF0, 0x7E, 0x01, 0xF9, 0xFE, 0x7F, 0xC0, 0x7E, 0xFF, 0x9F,
  0xF8, 0x1F, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFC, 0x3F,
  0x0F, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xE0, 0x7E, 0x0F, 0xE0,
  0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x0F, 0xE0, 0xFC, 0x0F, 0x83, 0xF8, 0x3F,
  0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0x7C, 0x0F, 0xC1,
  0xFC, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xC1, 0xFC, 0x1F, 0x81, 0xF0, 0x7F,
  0x07, 0xE0, 0x7C, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0x81,
  0xF8, 0x3F, 0x83, 0xE0, 0x7E, 0x0F, 0xE0, 0xF8, 0x1F, 0x83, 0xF0, 0x3E,
  0x0F, 0xE0, 0xFC, 0x0F, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC1,
  0xF8, 0x3F, 0x07, 0xF0, 0x7C, 0x0F, 0xC1, 0xFC, 0x1F, 0x03, 0xF0, 0x7E,
  0x07, 0xC1, 0xFC, 0x1F, 0x81, 0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0xC3,
  0xF8, 0x3F, 0x07, 0xE0, 0x07, 0xF0, 0xFF, 0x80, 0x1F, 0xCF, 0xFF, 0x80,
  0x7F, 0x7F, 0xFF, 0x03, 0xFB, 0xFF, 0xFC, 0x0F, 0xEF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0,
  0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F,
  0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x07,
  0xF8, 0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x07,
  0xF1, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xCF, 0xE0,
  0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03,
  0xF8, 0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xF3,
  0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC3, 0xFE,
  0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0xE0, 0x01, 0xFC, 0xFF, 0xF8,
  0x01, 0xFD, 0xFF, 0xFC, 0x03, 0xFB, 0xFF, 0xFC, 0x03, 0xFB, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE,
  0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC,
  0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0x9F, 0xFF, 0x80, 0x3F, 0x8F, 0xFF, 0x00, 0x3F, 0x87, 0xFE, 0x00,
  0x3F, 0x80, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE1, 0xFC, 0x03, 0xFF, 0xC7, 0xF0,
  0x3F, 0xFF, 0xBF, 0x81, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xFB, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x87, 0xF8, 0x03, 0xFE, 0x1F, 0xC0,
  0x0F, 0xF8, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF,
  0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00,
  0x7F, 0xC3, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xBF, 0x80, 0xFF, 0xFE, 0xFE, 0x01, 0xFF, 0xE3, 0xF8,
  0x03, 0xFF, 0x0F, 0xE0, 0x00, 0xE0, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0xC0, 0x0F, 0xE7,
  0xFF, 0xC0, 0x1F, 0x9F, 0xFF, 0xC0, 0x7F, 0x7F, 0xFF, 0xC0, 0xFE, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x01,
  0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F,
  0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x87,
  0xFE, 0x0F, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFE, 0x1F, 0xC0,
  0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F,
  0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xE1, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F,
  0xF0, 0x7F, 0x80, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0,
  0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01,
  0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0xFE,
  0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F,
  0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0,
  0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFC, 0xFE,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7E,
  0x03, 0xF0, 0x1F, 0xBE, 0x01, 0xF8, 0x0F, 0xDF, 0x01, 0xFC, 0x07, 0xCF,
  0x80, 0xFE, 0x07, 0xE7, 0xC0, 0x7F, 0x03, 0xF3, 0xE0, 0x7F, 0x81, 0xF1,
  0xF0, 0x3F, 0xC1, 0xF8, 0xF8, 0x1D, 0xE0, 0xFC, 0x7C, 0x1E, 0xF0, 0x7E,
  0x3E, 0x0F, 0x78, 0x7E, 0x1F, 0x07, 0x3C, 0x3F, 0x0F, 0x87, 0x9E, 0x1F,
  0x87, 0xC3, 0xCF, 0x0F, 0x83, 0xE1, 0xE7, 0x8F, 0xC1, 0xF1, 0xE3, 0xC7,
  0xE0, 0xF8, 0xF1, 0xE3, 0xE0, 0x7C, 0x78, 0xF3, 0xF0, 0x3E, 0x38, 0x79,
  0xF8, 0x1F, 0x3C, 0x3C, 0xF8, 0x0F, 0x9E, 0x1E, 0xFC, 0x07, 0xCE, 0x0F,
  0x7E, 0x03, 0xEF, 0x07, 0xBE, 0x01, 0xF7, 0x83, 0xDF, 0x00, 0xFB, 0xC1,
  0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0,
  0x3B, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xFC,
  0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0x8F,
  0xF0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xE1, 0xFE,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0,
  0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xDF,
  0xC0, 0xFF, 0xFF, 0x7F, 0x03, 0xFF, 0xFB, 0xFC, 0x07, 0xFF, 0xCF, 0xE0,
  0x0F, 0xFC, 0x3F, 0x80, 0x07, 0x80, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x01, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x03, 0xF1, 0xFF, 0xF0, 0x0F, 0xCF, 0xFF, 0xE0,
  0x3F, 0x7F, 0xFF, 0xC0, 0xFD, 0xFF, 0xFF, 0x03, 0xF7, 0xE1, 0xFE, 0x1F,
  0xFF, 0x83, 0xFC, 0xFE, 0xFC, 0x07, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0xCF,
  0xC0, 0x3F, 0xFE, 0x3F, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
};

const GFXglyph JetBrainsMono_BoldItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 16, 42, 35, 10, -42 },
  { 85, 22, 17, 35, 10, -42 },
  { 132, 35, 42, 35, 1, -42 },
  { 316, 32, 58, 35, 2, -50 },
  { 548, 42, 43, 35, -3, -43 },
  { 774, 33, 44, 35, 1, -43 },
  { 956, 9, 17, 35, 16, -42 },
  { 976, 25, 56, 35, 8, -49 },
  { 1151, 25, 56, 35, 3, -49 },
  { 1326, 31, 30, 35, 3, -35 },
  { 1443, 29, 28, 35, 3, -33 },
  { 1545, 16, 18, 35, 5, -9 },
  { 1581, 20, 7, 35, 8, -23 },
  { 1599, 11, 11, 35, 10, -10 },
  { 1615, 36, 54, 35, 0, -48 },
  { 1858, 31, 44, 35, 3, -43 },
  { 2029, 28, 42, 35, 2, -42 },
  { 2176, 31, 43, 35, 2, -43 },
  { 2343, 31, 43, 35, 2, -42 },
  { 2510, 29, 42, 35, 3, -42 },
  { 2663, 30, 43, 35, 3, -42 },
  { 2825, 30, 43, 35, 2, -42 },
  { 2987, 30, 42, 35, 6, -42 },
  { 3145, 31, 44, 35, 2, -43 },
  { 3316, 29, 43, 35, 5, -43 },
  { 3472, 15, 33, 35, 10, -32 },
  { 3534, 20, 41, 35, 5, -32 },
  { 3637, 29, 32, 35, 4, -35 },
  { 3753, 28, 21, 35, 4, -30 },
  { 3827, 29, 32, 35, 2, -35 },
  { 3943, 25, 42, 35, 7, -42 },
  { 4075, 36, 53, 35, 0, -43 },
  { 4314, 31, 42, 35, -1, -42 },
  { 4477, 32, 42, 35, 2, -42 },
  { 4645, 31, 44, 35, 3, -43 },
  { 4816, 32, 42, 35, 2, -42 },
  { 4984, 32, 42, 35, 3, -42 },
  { 5152, 33, 42, 35, 2, -42 },
  { 5326, 31, 44, 35, 3, -43 },
  { 5497, 33, 42, 35, 2, -42 },
  { 5671, 31, 42, 35, 3, -42 },
  { 5834, 34, 43, 35, 0, -42 },
  { 6017, 35, 42, 35, 2, -42 },
  { 6201, 27, 42, 35, 3, -42 },
  { 6343, 35, 42, 35, 1, -42 },
  { 6527, 33, 42, 35, 2, -42 },
  { 6701, 31, 44, 35, 3, -43 },
  { 6872, 33, 42, 35, 2, -42 },
  { 7046, 31, 53, 35, 3, -43 },
  { 7252, 32, 42, 35, 2, -42 },
  { 7420, 32, 44, 35, 2, -43 },
  { 7596, 30, 42, 35, 6, -42 },
  { 7754, 32, 43, 35, 3, -42 },
  { 7926, 31, 42, 35, 6, -42 },
  { 8089, 35, 42, 35, 3, -42 },
  { 8273, 38, 42, 35, -1, -42 },
  { 8473, 32, 42, 35, 6, -42 },
  { 8641, 32, 42, 35, 2, -42 },
  { 8809, 25, 54, 35, 7, -48 },
  { 8978, 19, 54, 35, 9, -48 },
  { 9107, 25, 54, 35, 4, -48 },
  { 9276, 26, 22, 35, 5, -42 },
  { 9348, 29, 7, 35, 0, 1 },
  { 9374, 13, 9, 35, 14, -46 },
  { 9389, 30, 33, 35, 3, -32 },
  { 9513, 30, 43, 35, 2, -42 },
  { 9675, 29, 33, 35, 3, -32 },
  { 9795, 32, 43, 35, 3, -42 },
  { 9967, 29, 33, 35, 3, -32 },
  { 10087, 39, 52, 35, -3, -42 },
  { 10341, 30, 42, 35, 3, -32 },
  { 10499, 30, 42, 35, 2, -42 },
  { 10657, 29, 46, 35, 2, -46 },
  { 10824, 31, 56, 35, 1, -46 },
  { 11041, 33, 42, 35, 2, -42 },
  { 11215, 26, 42, 35, 5, -42 },
  { 11352, 34, 32, 35, 0, -32 },
  { 11488, 30, 32, 35, 2, -32 },
  { 11608, 29, 33, 35, 3, -32 },
  { 11728, 32, 42, 35, 0, -32 },
  { 11896, 30, 42, 35, 3, -32 },
  { 12054, 31, 32, 35, 3, -32 },
  { 12178, 30, 33, 35, 2, -32 },
  { 12302, 29, 41, 35, 4, -41 },
  { 12451, 30, 33, 35, 3, -32 },
  { 12575, 30, 32, 35, 5, -32 },
  { 12695, 33, 32, 35, 3, -32 },
  { 12827, 34, 32, 35, 0, -32 },
  { 12963, 30, 42, 35, 3, -32 },
  { 13121, 30, 32, 35, 2, -32 },
  { 13241, 30, 54, 35, 5, -48 },
  { 13444, 16, 54, 35, 10, -48 },
  { 13552, 31, 54, 35, 1, -48 },
  { 13762, 30, 13, 35, 3, -27 },
};

const GFXfont JetBrainsMono_BoldItalic58pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic58pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic58pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _JETBRAINSMONO_BOLDITALIC58PT7B_H_
