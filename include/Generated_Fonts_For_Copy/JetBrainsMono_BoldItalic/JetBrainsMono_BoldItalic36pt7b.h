#ifndef _JETBRAINSMONO_BOLDITALIC36PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x07, 0xC1, 0xF8, 0xFC, 0x1F, 0x00, 0x7C, 0x7D,
  0xE1, 0xE7, 0x87, 0x9E, 0x3E, 0xF8, 0xFB, 0xE3, 0xEF, 0x0F, 0x3C, 0x3C,
  0xF0, 0xF3, 0xC3, 0xCF, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x01, 0xE0, 0xE0,
  0x07, 0x07, 0x80, 0x1C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0x83, 0xC0, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x07, 0x07, 0x00, 0x3C, 0x1C,
  0x00, 0xE0, 0xF0, 0x03, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x70, 0x78, 0x01,
  0xC1, 0xC0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x27, 0x83,
  0x80, 0x1C, 0x1E, 0x00, 0x70, 0x70, 0x03, 0xC1, 0xC0, 0x0E, 0x0F, 0x00,
  0x38, 0x38, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x0F, 0xDF, 0xE0, 0xFB, 0x9F, 0x1F, 0x39, 0xF1, 0xF3, 0x1F,
  0x1F, 0x30, 0x01, 0xF3, 0x00, 0x1F, 0xB0, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x06,
  0x7C, 0x00, 0xE7, 0xC0, 0x0E, 0x3C, 0x78, 0xC7, 0xCF, 0x8C, 0x7C, 0x7C,
  0xCF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xF8, 0x03, 0xC0, 0xFF, 0x01, 0xE0, 0x79, 0xE0, 0x70, 0x3C, 0x38,
  0x38, 0x0E, 0x0E, 0x1C, 0x03, 0x87, 0x8E, 0x00, 0xE1, 0xC7, 0x00, 0x38,
  0x73, 0xC0, 0x0F, 0x3D, 0xE0, 0x03, 0xFE, 0x70, 0x00, 0x7F, 0x38, 0x00,
  0x02, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x01, 0xEF, 0xF0, 0x00, 0xF7, 0xFC, 0x00, 0x39, 0xC7, 0x80, 0x1C,
  0xE0, 0xE0, 0x0E, 0x38, 0x78, 0x07, 0x0E, 0x1C, 0x03, 0xC3, 0x87, 0x01,
  0xE0, 0xE1, 0xC0, 0xF0, 0x3F, 0xF0, 0x38, 0x0F, 0xF8, 0x3C, 0x01, 0xF8,
  0x00, 0x00, 0x0C, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0,
  0x3E, 0x3E, 0x03, 0xE0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xC3, 0xE7, 0x9F, 0x1E, 0x3C, 0x79, 0xE3, 0xE3, 0xFF,
  0x1F, 0x0F, 0xF0, 0xF0, 0x7F, 0x07, 0x81, 0xF8, 0x3C, 0x0F, 0x81, 0xE0,
  0x7E, 0x0F, 0xCF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0x9E, 0x07, 0xF8, 0xF8,
  0x7D, 0xE7, 0xBE, 0xFB, 0xEF, 0x3C, 0xF3, 0xCE, 0x00, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x20, 0x07, 0x00, 0x0F, 0x80, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xF8, 0x01, 0xC0, 0x02, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0xE1, 0xC1, 0x9F, 0x38, 0xFF, 0xF7, 0x7F, 0xFF, 0x7F, 0xE7, 0xFF,
  0xE0, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x77, 0x80, 0x1E, 0xF8, 0x07, 0x8F,
  0x01, 0xF1, 0xF0, 0x7C, 0x3E, 0x07, 0x03, 0x80, 0x40, 0x40, 0x00, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0,
  0x78, 0x3E, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xE0, 0x3C,
  0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF8, 0xFC, 0x3C, 0x07, 0xCF, 0x80, 0xF9,
  0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0x80, 0x79, 0xF0, 0x0F, 0x3E, 0x61, 0xE7,
  0x9E, 0x3C, 0xF3, 0xEF, 0x9E, 0x7D, 0xF3, 0xC7, 0x3C, 0x78, 0x07, 0x9F,
  0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x00, 0xF9, 0xE0, 0x1E, 0x3E,
  0x07, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xDE, 0x03,
  0xC7, 0x81, 0xE3, 0xE0, 0x60, 0xF8, 0x10, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x1C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xEF, 0xE1,
  0xF8, 0x3E, 0x1F, 0x01, 0xE1, 0xE0, 0x1E, 0x3E, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC7, 0x80, 0x78, 0x78, 0x0F, 0x87,
  0xC0, 0xF8, 0x7F, 0x7F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x1E, 0x3E, 0x07, 0x9F, 0x03, 0xE7, 0xC0, 0xFB, 0xE0, 0x3E,
  0xF8, 0x0F, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x0F,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xDF, 0xC0, 0xF7,
  0xFC, 0x1F, 0xFF, 0xC3, 0xFB, 0xF8, 0xF8, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x8F, 0x01,
  0xF1, 0xF0, 0x3E, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0x1F, 0x8F, 0x81,
  0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03,
  0xE7, 0x80, 0x7C, 0xF8, 0x1F, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0x80, 0x3C, 0xF0, 0x0F, 0x9E, 0x03, 0xE7, 0xC0, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x0F, 0xC7, 0xE0, 0xF8, 0x1E, 0x1F, 0x01, 0xE1, 0xF0,
  0x1E, 0x1F, 0x01, 0xE1, 0xF0, 0x3E, 0x0F, 0x87, 0xC0, 0xFD, 0xF8, 0x07,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x01, 0xF9, 0xF8, 0x3E, 0x0F, 0x83,
  0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0xC7, 0x80, 0x78,
  0x7C, 0x0F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0x00, 0x70, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0x0F,
  0x9F, 0x01, 0xF7, 0xC0, 0x7D, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x3E, 0xFC, 0x1F, 0x9F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF,
  0x78, 0x0F, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07,
  0xE0, 0x00, 0x0F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xFC, 0xFE, 0x7F, 0x3F, 0x8F,
  0x80, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x81, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x70, 0x00, 0x78, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x81,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0xE0, 0x00, 0x08, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x9F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x10,
  0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x3F,
  0xE0, 0x7F, 0xF1, 0xFF, 0xF3, 0xFF, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0xFF, 0xC3, 0xFF, 0x07,
  0xFC, 0x0F, 0xE0, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x00,
  0x00, 0x06, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0xC0, 0x78, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1C, 0x00,
  0x3C, 0xF0, 0x1C, 0xF3, 0xC1, 0xFB, 0xCF, 0x0F, 0xFE, 0x3C, 0x7C, 0x78,
  0xE1, 0xE1, 0xE3, 0x87, 0x07, 0x9E, 0x3C, 0x1E, 0x78, 0xF0, 0x79, 0xE3,
  0xC1, 0xE7, 0x8F, 0x07, 0x1E, 0x3C, 0x3C, 0x70, 0xF0, 0xF3, 0xC3, 0xC3,
  0xCF, 0x0F, 0xFF, 0x3C, 0x3F, 0xBC, 0xF0, 0x3C, 0xE3, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xEF, 0x00, 0x3D, 0xE0,
  0x0F, 0xBC, 0x01, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0,
  0x7C, 0x78, 0x0F, 0x0F, 0x83, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xE0, 0x3C, 0x78, 0x07, 0x9F,
  0x00, 0xF3, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x0F, 0xFF, 0x80,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xF0, 0xFE, 0x0F, 0x03, 0xF1, 0xF0, 0x1F,
  0x1F, 0x01, 0xF1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x3C, 0x1E, 0x1F,
  0xC3, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x3C, 0x0F, 0xC3, 0xC0,
  0x7C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0xC0, 0x7C, 0x78,
  0x07, 0xC7, 0x80, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1,
  0xFC, 0xFC, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0xF9, 0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x01,
  0xF1, 0xF0, 0x1F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE3, 0xE0,
  0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x3C,
  0x03, 0xC7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0x87,
  0x81, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1,
  0xFC, 0xFC, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0xFF, 0x9E,
  0x1F, 0xF3, 0xC3, 0xFE, 0x78, 0xFF, 0x9F, 0x00, 0xF3, 0xE0, 0x1E, 0x7C,
  0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0xF8, 0x0F,
  0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01,
  0xE1, 0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x3E, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3E, 0x03, 0xC3, 0xC0, 0x7C, 0x3C,
  0x07, 0xC3, 0xC0, 0x7C, 0x7C, 0x07, 0x87, 0xC0, 0x78, 0x7C, 0x07, 0x87,
  0x80, 0xF8, 0x78, 0x0F, 0x87, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF0,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x87, 0x80, 0x78, 0x3E, 0x07, 0xC1,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0x80, 0xFC, 0x3E, 0x03, 0xE0, 0xF0, 0x1F, 0x03, 0xC0, 0xF8, 0x0F, 0x03,
  0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0x1E, 0x1F, 0x00,
  0x78, 0x7C, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x80, 0x3C, 0x3E, 0x01, 0xF0, 0x78,
  0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xE0, 0x3E, 0x07,
  0x80, 0xF8, 0x1E, 0x03, 0xE0, 0xF8, 0x07, 0x83, 0xE0, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0xC3,
  0xF0, 0x7F, 0x0E, 0xE1, 0xF8, 0x3B, 0x8E, 0xE0, 0xEE, 0x3F, 0x87, 0xB9,
  0xDE, 0x1E, 0xE7, 0x78, 0x7B, 0xB9, 0xE1, 0xEE, 0xE7, 0x07, 0x9B, 0xBC,
  0x1E, 0x7C, 0xF0, 0xF9, 0xF3, 0xC3, 0xC7, 0x8F, 0x0F, 0x00, 0x7C, 0x3C,
  0x01, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x1F, 0x00, 0x78, 0x7C, 0x01,
  0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC3,
  0xE0, 0x0F, 0x00, 0x0F, 0xC0, 0xF8, 0x7E, 0x07, 0x83, 0xF0, 0x3C, 0x1F,
  0x81, 0xE1, 0xFE, 0x0F, 0x0F, 0xF0, 0x78, 0x7F, 0x87, 0xC3, 0xDC, 0x3C,
  0x1E, 0xE1, 0xE0, 0xF7, 0x0F, 0x0F, 0xBC, 0x78, 0x79, 0xE3, 0xC3, 0xCF,
  0x3E, 0x1E, 0x39, 0xE0, 0xF1, 0xCF, 0x07, 0x8F, 0x78, 0x3C, 0x7B, 0xC3,
  0xC3, 0xDE, 0x1E, 0x0E, 0xF0, 0xF0, 0x77, 0x07, 0x83, 0xF8, 0x3C, 0x1F,
  0xC1, 0xE0, 0xFE, 0x1F, 0x03, 0xF0, 0xF0, 0x1F, 0x87, 0x80, 0xFC, 0x00,
  0x00, 0x38, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFC, 0xFC,
  0x3E, 0x07, 0x8F, 0x80, 0xF9, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78,
  0xF0, 0x0F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9E, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x07, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF,
  0x80, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x07,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x03, 0xE3,
  0xE0, 0x1F, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x87, 0x80, 0x7C, 0x7C, 0x0F,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1,
  0xF8, 0xFC, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3C, 0x03, 0xC7,
  0x80, 0x79, 0xF0, 0x0F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9E,
  0x01, 0xF3, 0xC0, 0x3C, 0x78, 0x07, 0x9F, 0x00, 0xF3, 0xE0, 0x3E, 0x7C,
  0x07, 0xCF, 0x00, 0xF9, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xFF, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x80,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0x01, 0xF1, 0xF0, 0x1F,
  0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1E, 0x01, 0xF1, 0xE0, 0x1F, 0x1E, 0x03,
  0xE3, 0xE1, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF,
  0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xE0, 0x7C,
  0x1F, 0x07, 0x81, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF8, 0xF8, 0x0F, 0x8F,
  0x80, 0x78, 0x00, 0x18, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE,
  0x0F, 0xC7, 0xE0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x78, 0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x0F, 0x87,
  0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x01, 0xF1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x3E, 0x3E, 0x03,
  0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0,
  0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x78, 0x78,
  0x07, 0x87, 0x80, 0x78, 0x78, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F,
  0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0,
  0x3F, 0xF8, 0x01, 0xFF, 0x00, 0xF0, 0x03, 0xFF, 0x00, 0x7B, 0xE0, 0x1F,
  0x7C, 0x03, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xC3, 0xC0, 0xF8,
  0x78, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x87, 0xC0,
  0xF0, 0xF0, 0x1F, 0x1E, 0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x07, 0xBE, 0x00,
  0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x78, 0x78, 0x3D, 0xE1, 0xE1,
  0xE7, 0x87, 0x87, 0x9E, 0x3E, 0x1E, 0x78, 0xD8, 0x71, 0xE3, 0x63, 0xC7,
  0x0D, 0x8F, 0x1C, 0x76, 0x3C, 0x71, 0x98, 0xE1, 0xC6, 0xE7, 0x87, 0x3B,
  0x9E, 0x3C, 0xEE, 0x70, 0xF3, 0x39, 0xC3, 0xCC, 0xEF, 0x0F, 0x73, 0xBC,
  0x3D, 0xCE, 0xE0, 0xF6, 0x3B, 0x83, 0xD8, 0xDE, 0x0F, 0xE3, 0x78, 0x3F,
  0x0D, 0xC0, 0xEC, 0x37, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F,
  0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xF1,
  0xF0, 0x00, 0xF3, 0xE0, 0x00, 0xFB, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xEF,
  0x80, 0x03, 0xE7, 0x80, 0x07, 0xC7, 0xC0, 0x0F, 0x87, 0xC0, 0x0F, 0x83,
  0xC0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x01, 0xE0, 0xFC, 0x01,
  0xF0, 0xF8, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xC0, 0x7C, 0x3C,
  0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x01, 0xE1, 0xF0, 0x1F, 0x3E, 0x01,
  0xF3, 0xC0, 0x0F, 0x7C, 0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0, 0xF8, 0x07, 0x80, 0x78, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01,
  0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x07, 0xFE,
  0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x80, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7B,
  0xC0, 0x3D, 0xE0, 0x3C, 0x70, 0x1E, 0x3C, 0x1E, 0x1E, 0x1F, 0x0F, 0x0F,
  0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF7, 0x80, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xF8, 0x7C, 0x3C, 0x3E, 0x1F, 0x03, 0xF3,
  0xC3, 0xFE, 0xF1, 0xFF, 0xBC, 0xFF, 0xFF, 0x3E, 0x0F, 0xDF, 0x01, 0xF7,
  0xC0, 0x79, 0xF0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xEF, 0x80, 0xFB, 0xE0,
  0x3E, 0xF8, 0x0F, 0x3E, 0x03, 0xCF, 0x81, 0xF3, 0xE0, 0xFC, 0xFF, 0xFF,
  0x1F, 0xFF, 0xC7, 0xFD, 0xF0, 0xFE, 0x78, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xCF, 0xC0,
  0xFB, 0xFC, 0x1E, 0xFF, 0xC3, 0xFF, 0xF8, 0x7C, 0x1F, 0x9F, 0x01, 0xF3,
  0xE0, 0x3E, 0x7C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0xC7,
  0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0xFB, 0xFE, 0x1F, 0x3F, 0x00, 0x01, 0xFC, 0x01,
  0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3E, 0x0F, 0xDF, 0x01, 0xF7, 0xC0,
  0x7D, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x03, 0xEF, 0x80, 0xF3, 0xE0, 0x7C, 0xFF, 0xFE, 0x1F,
  0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0xFC, 0xF0, 0x7F,
  0xDE, 0x1F, 0xFB, 0xC7, 0xFF, 0xF8, 0xF8, 0x3F, 0x3E, 0x03, 0xE7, 0xC0,
  0x78, 0xF8, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01,
  0xF3, 0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x81, 0xF1, 0xF0, 0x7E, 0x3F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xDF, 0x07, 0xF3, 0xC0, 0x01, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7E, 0x7E, 0x3E, 0x07, 0x8F, 0x01, 0xF7, 0xC0, 0x7D,
  0xE0, 0x1E, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xFB, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x7C, 0xFC, 0x3E, 0x1F, 0xFF,
  0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x83, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF3, 0xC3,
  0xFE, 0xF1, 0xFF, 0xBC, 0xFF, 0xFF, 0x3E, 0x0F, 0xDF, 0x01, 0xF7, 0xC0,
  0x79, 0xF0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xE7, 0x80, 0xFB, 0xE0, 0x3E,
  0xF8, 0x0F, 0x3E, 0x07, 0xCF, 0xC3, 0xF1, 0xFF, 0xBC, 0x7F, 0xFF, 0x0F,
  0xF7, 0xC0, 0xF1, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07,
  0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xCF,
  0xC0, 0xFB, 0xFC, 0x1E, 0xFF, 0xC3, 0xFF, 0xF8, 0x7C, 0x1F, 0x1F, 0x01,
  0xF3, 0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3E, 0x3C, 0x07,
  0xC7, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x0F,
  0x1E, 0x03, 0xE3, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x10, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x07, 0xE3, 0xE0, 0x3E, 0x1F,
  0x03, 0xE0, 0xF0, 0x3E, 0x07, 0x83, 0xE0, 0x3C, 0x3F, 0x03, 0xE1, 0xF0,
  0x1F, 0x1F, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x81,
  0xE0, 0x7C, 0x0F, 0x01, 0xF0, 0x78, 0x0F, 0x87, 0xC0, 0x3E, 0x00, 0x7F,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0x0F, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0x1E, 0x71, 0xE0, 0xF7, 0xDF, 0x87, 0xFE, 0xFE, 0x3C,
  0x79, 0xF1, 0xE3, 0x87, 0x8F, 0x1C, 0x78, 0xF0, 0xE3, 0xC7, 0x87, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1C, 0x3C, 0x78, 0xE1, 0xE7, 0x87,
  0x1E, 0x3C, 0x38, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xE1, 0xE3,
  0xC7, 0x0F, 0x1E, 0x38, 0xF1, 0xE1, 0xC7, 0x80, 0x1F, 0x3F, 0x03, 0xEF,
  0xF0, 0x7B, 0xFF, 0x0F, 0xFF, 0xE1, 0xF0, 0x7C, 0x7C, 0x07, 0xCF, 0x80,
  0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x1F, 0x1E, 0x03,
  0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x1F, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F,
  0x8F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0x80, 0x01, 0xFC, 0x01, 0xFF,
  0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3E, 0x0F, 0x8F, 0x01, 0xF7, 0xC0, 0x7D,
  0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8,
  0x0F, 0xBE, 0x03, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xFF, 0xFE, 0x1F, 0xFF,
  0x03, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0x9F, 0x80, 0xFB, 0xFC, 0x0F, 0x7F,
  0xE0, 0xFF, 0xFE, 0x0F, 0x83, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0,
  0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x03, 0xE1, 0xE0, 0x3E, 0x3E,
  0x03, 0xE3, 0xE0, 0x3C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3F, 0xFF, 0x83,
  0xFF, 0xF8, 0x7D, 0xFF, 0x07, 0xCF, 0xC0, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE3,
  0xC3, 0xFE, 0xF1, 0xFF, 0xBC, 0xFF, 0xFF, 0x3E, 0x0F, 0xDF, 0x01, 0xF7,
  0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xEF, 0x80, 0xFB, 0xE0,
  0x3E, 0xF8, 0x0F, 0x3E, 0x03, 0xCF, 0x81, 0xF3, 0xE0, 0xFC, 0xFF, 0xFF,
  0x1F, 0xFF, 0xC7, 0xFD, 0xE0, 0xFE, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x1E, 0x3F, 0x03,
  0xDF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xF0, 0x7C, 0x7C, 0x07, 0xCF,
  0x80, 0xF9, 0xE0, 0x1E, 0x3C, 0x07, 0xCF, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF1, 0xE0, 0x3E, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF3, 0xC0, 0x3C, 0x7E,
  0x1F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xDF,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xD0, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x3E, 0x03, 0xCF,
  0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0xDF, 0x01, 0xF7, 0xC0,
  0x79, 0xF0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xE7, 0x80, 0xFB, 0xE0, 0x3E,
  0xF8, 0x0F, 0xBE, 0x03, 0xCF, 0x81, 0xF3, 0xE0, 0xFC, 0x7F, 0xFE, 0x1F,
  0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0xF8, 0x03, 0xFF, 0x00, 0xFB, 0xE0,
  0x1F, 0x3C, 0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xE0,
  0xF0, 0x7C, 0x3E, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xCF,
  0x80, 0x7D, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0xF0, 0x7F, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x1F, 0x0E, 0xF1, 0xB0, 0xEF, 0x1B, 0x1E, 0xF1, 0xB1, 0xCF,
  0x3B, 0x1C, 0xF3, 0x33, 0xCF, 0x33, 0x3C, 0xF7, 0x33, 0x8F, 0x63, 0x78,
  0xF6, 0x37, 0x8F, 0xE3, 0x70, 0xFC, 0x37, 0x0F, 0xC3, 0xF0, 0xEC, 0x3E,
  0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0x1F, 0x80, 0xF8, 0x7C,
  0x0F, 0x81, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x3C, 0x7C, 0x01, 0xF7, 0xC0,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xEF, 0x00, 0x3E, 0x7C, 0x03,
  0xF1, 0xE0, 0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x01, 0xF1, 0xF0, 0x0F,
  0xC0, 0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F, 0x7C, 0x07,
  0xDF, 0x01, 0xE7, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x0F, 0x9E, 0x03, 0xEF,
  0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0x3E, 0x07, 0xCF, 0xE7, 0xF1, 0xFF,
  0xFC, 0x7F, 0xDF, 0x0F, 0xE7, 0xC0, 0xC1, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x07, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x00,
  0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80,
  0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C,
  0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81,
  0xE0, 0x78, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x07,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x07,
  0xFF, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x07, 0xF8, 0x3D, 0xFF, 0x07, 0xBF, 0xF0, 0xEF, 0x1F,
  0x3D, 0xE1, 0xFF, 0xBC, 0x3F, 0xE7, 0x83, 0xF8, 0x00, 0x18, 0x00,
};

const GFXglyph JetBrainsMono_BoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 10, 26, 22, 6, -26 },
  { 34, 14, 11, 22, 6, -26 },
  { 54, 22, 26, 22, 0, -26 },
  { 126, 20, 36, 22, 1, -31 },
  { 216, 26, 26, 22, -2, -26 },
  { 301, 21, 27, 22, 0, -27 },
  { 372, 6, 11, 22, 10, -26 },
  { 381, 16, 35, 22, 5, -30 },
  { 451, 15, 35, 22, 2, -30 },
  { 517, 19, 19, 22, 2, -22 },
  { 563, 18, 17, 22, 2, -20 },
  { 602, 10, 11, 22, 3, -5 },
  { 616, 13, 4, 22, 5, -14 },
  { 623, 7, 6, 22, 6, -6 },
  { 629, 23, 34, 22, 0, -30 },
  { 727, 19, 27, 22, 2, -27 },
  { 792, 18, 26, 22, 1, -26 },
  { 851, 20, 27, 22, 1, -27 },
  { 919, 20, 26, 22, 1, -26 },
  { 984, 18, 26, 22, 2, -26 },
  { 1043, 19, 26, 22, 2, -26 },
  { 1105, 19, 26, 22, 1, -26 },
  { 1167, 19, 26, 22, 3, -26 },
  { 1229, 20, 27, 22, 1, -27 },
  { 1297, 18, 27, 22, 3, -27 },
  { 1358, 9, 20, 22, 6, -20 },
  { 1381, 13, 26, 22, 3, -20 },
  { 1424, 18, 20, 22, 3, -22 },
  { 1469, 18, 13, 22, 2, -18 },
  { 1499, 19, 20, 22, 1, -22 },
  { 1547, 15, 26, 22, 5, -26 },
  { 1596, 22, 33, 22, 0, -27 },
  { 1687, 19, 26, 22, 0, -26 },
  { 1749, 20, 26, 22, 1, -26 },
  { 1814, 19, 27, 22, 2, -27 },
  { 1879, 20, 26, 22, 1, -26 },
  { 1944, 20, 26, 22, 2, -26 },
  { 2009, 21, 26, 22, 1, -26 },
  { 2078, 19, 27, 22, 2, -27 },
  { 2143, 20, 26, 22, 1, -26 },
  { 2208, 19, 26, 22, 2, -26 },
  { 2270, 21, 26, 22, 0, -26 },
  { 2339, 22, 26, 22, 1, -26 },
  { 2411, 16, 26, 22, 2, -26 },
  { 2463, 22, 26, 22, 0, -26 },
  { 2535, 21, 26, 22, 1, -26 },
  { 2604, 19, 27, 22, 2, -27 },
  { 2669, 21, 26, 22, 1, -26 },
  { 2738, 19, 33, 22, 2, -27 },
  { 2817, 20, 26, 22, 1, -26 },
  { 2882, 20, 27, 22, 1, -27 },
  { 2950, 19, 26, 22, 4, -26 },
  { 3012, 20, 26, 22, 2, -26 },
  { 3077, 19, 26, 22, 4, -26 },
  { 3139, 22, 26, 22, 2, -26 },
  { 3211, 24, 26, 22, -1, -26 },
  { 3289, 20, 26, 22, 3, -26 },
  { 3354, 20, 26, 22, 1, -26 },
  { 3419, 16, 34, 22, 4, -30 },
  { 3487, 12, 34, 22, 5, -30 },
  { 3538, 15, 34, 22, 3, -30 },
  { 3602, 17, 14, 22, 3, -26 },
  { 3632, 18, 4, 22, 0, 1 },
  { 3641, 8, 5, 22, 9, -28 },
  { 3646, 18, 20, 22, 2, -20 },
  { 3691, 19, 26, 22, 1, -26 },
  { 3753, 18, 20, 22, 2, -20 },
  { 3798, 19, 26, 22, 2, -26 },
  { 3860, 18, 20, 22, 2, -20 },
  { 3905, 25, 32, 22, -2, -26 },
  { 4005, 18, 26, 22, 2, -20 },
  { 4064, 19, 26, 22, 1, -26 },
  { 4126, 18, 28, 22, 1, -28 },
  { 4189, 20, 34, 22, 0, -28 },
  { 4274, 21, 26, 22, 1, -26 },
  { 4343, 16, 26, 22, 3, -26 },
  { 4395, 21, 20, 22, 0, -20 },
  { 4448, 19, 20, 22, 1, -20 },
  { 4496, 18, 20, 22, 2, -20 },
  { 4541, 20, 26, 22, 0, -20 },
  { 4606, 18, 26, 22, 2, -20 },
  { 4665, 19, 20, 22, 2, -20 },
  { 4713, 19, 20, 22, 1, -20 },
  { 4761, 19, 25, 22, 2, -25 },
  { 4821, 18, 20, 22, 2, -20 },
  { 4866, 19, 20, 22, 3, -20 },
  { 4914, 20, 20, 22, 2, -20 },
  { 4964, 21, 20, 22, 0, -20 },
  { 5017, 18, 26, 22, 2, -20 },
  { 5076, 19, 20, 22, 1, -20 },
  { 5124, 19, 34, 22, 3, -30 },
  { 5205, 10, 34, 22, 6, -30 },
  { 5248, 19, 34, 22, 1, -30 },
  { 5329, 19, 9, 22, 2, -17 },
};

const GFXfont JetBrainsMono_BoldItalic36pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic36pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic36pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _JETBRAINSMONO_BOLDITALIC36PT7B_H_
