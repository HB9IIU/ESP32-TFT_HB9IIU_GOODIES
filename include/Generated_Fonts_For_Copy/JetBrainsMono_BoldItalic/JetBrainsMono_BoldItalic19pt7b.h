#ifndef _JETBRAINSMONO_BOLDITALIC19PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xCE, 0x73, 0x98, 0xC6, 0x31, 0x00, 0x07, 0x70, 0x66, 0xCF,
  0x9F, 0x7C, 0xF9, 0x80, 0x06, 0x60, 0x66, 0x0C, 0x60, 0xCC, 0x3F, 0xF1,
  0x8C, 0x19, 0x81, 0x98, 0x31, 0x8F, 0xFC, 0xFF, 0xC6, 0x30, 0x66, 0x06,
  0x60, 0x02, 0x00, 0x80, 0x20, 0x3E, 0x3F, 0xCD, 0x77, 0x4D, 0xD0, 0x74,
  0x0F, 0x81, 0xF8, 0x2E, 0x09, 0xB2, 0x6E, 0xBB, 0xFC, 0x7E, 0x04, 0x01,
  0x00, 0x40, 0x0E, 0x0C, 0x7C, 0x63, 0x33, 0x0C, 0xD8, 0x32, 0xC0, 0xFE,
  0x00, 0x10, 0x00, 0x80, 0x07, 0xF0, 0x34, 0xC1, 0xB3, 0x0C, 0xCC, 0x63,
  0x63, 0x07, 0x80, 0x07, 0x83, 0xF8, 0x63, 0x0C, 0x01, 0x80, 0x30, 0x0F,
  0x03, 0xE3, 0x66, 0xCC, 0xF1, 0x8E, 0x71, 0xC7, 0xF8, 0xFB, 0x80, 0x6F,
  0xFD, 0x80, 0x03, 0x0F, 0x1E, 0x38, 0x30, 0x70, 0x60, 0x60, 0x60, 0xE0,
  0xE0, 0xC0, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x18, 0x10, 0x1C, 0x1E, 0x06,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x38,
  0xF0, 0xC0, 0x06, 0x03, 0x80, 0xC1, 0xB3, 0xF7, 0xCF, 0xC1, 0xC0, 0xD8,
  0x77, 0x38, 0xC0, 0x0E, 0x03, 0x80, 0xC0, 0x31, 0xFF, 0xBF, 0xE1, 0xC0,
  0x70, 0x18, 0x00, 0x3B, 0x9C, 0xCE, 0x60, 0x7F, 0xFC, 0x7F, 0xE0, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0x0F, 0x0F, 0xE3, 0x1D, 0x83, 0x60, 0xD8, 0x76, 0xDB, 0xB6,
  0xE1, 0xB0, 0x6C, 0x1B, 0x8C, 0xFF, 0x1F, 0x80, 0x07, 0x0F, 0x8F, 0xCC,
  0xC4, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x8F, 0xFF, 0xFC,
  0x0F, 0x0F, 0xE7, 0x1D, 0x87, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x07,
  0x07, 0x83, 0x80, 0xFF, 0xBF, 0xC0, 0x3F, 0xCF, 0xF0, 0x18, 0x1C, 0x0E,
  0x03, 0x81, 0xF0, 0x0E, 0x01, 0x80, 0x6C, 0x3B, 0x0C, 0xFF, 0x1F, 0x80,
  0x01, 0xC0, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x19, 0x86, 0xE3, 0xBF,
  0xEF, 0xF8, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xCF, 0xF3, 0x00, 0xC0, 0x70,
  0x1B, 0xC7, 0xF9, 0x86, 0x01, 0x80, 0x60, 0x3B, 0x8C, 0xFF, 0x1F, 0x80,
  0x03, 0x83, 0x83, 0x83, 0x81, 0x81, 0x91, 0xFE, 0xE7, 0xE1, 0xE0, 0xF0,
  0x7C, 0x7F, 0xF3, 0xF0, 0xFF, 0xFF, 0xEC, 0x1B, 0x0E, 0x03, 0x01, 0xC0,
  0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x00, 0x0F, 0x0F,
  0xE3, 0x1D, 0xC7, 0x71, 0x8C, 0xE3, 0xF0, 0xFC, 0x63, 0xB8, 0x6C, 0x1B,
  0x8E, 0xFF, 0x1F, 0x80, 0x1E, 0x3F, 0xB8, 0xF8, 0x3C, 0x1E, 0x1F, 0x9D,
  0xFE, 0x36, 0x06, 0x07, 0x07, 0x03, 0x07, 0x00, 0x11, 0xDE, 0x20, 0x00,
  0x00, 0x77, 0xB8, 0x08, 0x73, 0xC6, 0x00, 0x00, 0x00, 0x38, 0xC7, 0x18,
  0xE3, 0x00, 0x00, 0xC1, 0xF1, 0xF1, 0xF0, 0x60, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x40, 0x7F, 0xDF, 0xE7, 0xF8, 0x00, 0x00, 0x3F, 0xEF, 0xF8,
  0x60, 0x3C, 0x07, 0x80, 0xF0, 0x18, 0x3C, 0x7C, 0xF0, 0xE0, 0x40, 0x00,
  0x3C, 0x3F, 0x81, 0xC0, 0x60, 0x30, 0x38, 0xF8, 0x78, 0x30, 0x38, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x07, 0xC1, 0xFE, 0x38, 0x63, 0x03, 0x60, 0x36,
  0x7A, 0x66, 0x66, 0x66, 0x6C, 0x64, 0xC6, 0xCC, 0x6C, 0xFC, 0xC7, 0xCC,
  0x00, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x78, 0x36, 0x0D,
  0x87, 0x61, 0x98, 0xE6, 0x31, 0x8F, 0xE7, 0xFD, 0x87, 0xE1, 0xF8, 0x30,
  0x3F, 0x0F, 0xE7, 0x1D, 0xC7, 0x61, 0xD8, 0xE7, 0xF1, 0xFE, 0xE1, 0xB8,
  0x6C, 0x1B, 0x0E, 0xFF, 0x3F, 0x80, 0x0F, 0x0F, 0xF3, 0x1D, 0xC3, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x3B, 0x8E, 0xFF, 0x1F, 0x80,
  0x3F, 0x0F, 0xE7, 0x1D, 0xC7, 0x61, 0xD8, 0x76, 0x1D, 0x86, 0xE1, 0xB8,
  0x6E, 0x3B, 0x1C, 0xFF, 0x3F, 0x00, 0x3F, 0xCF, 0xF3, 0x00, 0xC0, 0x70,
  0x1C, 0x07, 0xF9, 0xFE, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xFF, 0x3F, 0xC0,
  0x3F, 0xE7, 0xF8, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x1F, 0xE3, 0xFC, 0x60,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x0F, 0x0F, 0xF3, 0x1D,
  0xC3, 0x60, 0x18, 0x06, 0x05, 0x9E, 0xEF, 0xB8, 0x6C, 0x3B, 0x8E, 0xFF,
  0x1F, 0x80, 0x30, 0xCC, 0x37, 0x0D, 0xC7, 0x71, 0xD8, 0x67, 0xF9, 0xFE,
  0xE1, 0xB8, 0xEE, 0x3B, 0x0C, 0xC3, 0x30, 0xC0, 0x3F, 0xCF, 0xF0, 0xE0,
  0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0xFF,
  0x3F, 0xC0, 0x07, 0xE0, 0xFC, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x01, 0xC0, 0x3B, 0x86, 0x71, 0xC7, 0xF0, 0x7C, 0x00, 0x30, 0xE6,
  0x19, 0xC7, 0x39, 0xC6, 0x30, 0xCE, 0x1F, 0x83, 0xF0, 0xE6, 0x1C, 0xE3,
  0x9C, 0x61, 0x8C, 0x39, 0x87, 0x00, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0F, 0xFF, 0xF8, 0x38, 0x73,
  0x8E, 0x3C, 0xA3, 0xDE, 0x3D, 0x63, 0xF6, 0x77, 0x66, 0x6E, 0x60, 0xC6,
  0x0C, 0x60, 0xC6, 0x0C, 0xE0, 0xCE, 0x1C, 0x38, 0xCE, 0x37, 0x8D, 0xE3,
  0x68, 0xDB, 0x76, 0xD9, 0xB6, 0xED, 0xB3, 0x6C, 0x7B, 0x1E, 0xC7, 0x31,
  0xC0, 0x0F, 0x0F, 0xE3, 0x1D, 0xC7, 0x61, 0xD8, 0x76, 0x19, 0x86, 0xE1,
  0xB8, 0x6C, 0x3B, 0x8C, 0xFF, 0x1F, 0x80, 0x3F, 0x07, 0xF9, 0xC7, 0x38,
  0x67, 0x0C, 0xC1, 0x98, 0xF3, 0xFC, 0xFE, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x00, 0x0F, 0x0F, 0xE3, 0x1D, 0xC7, 0x61, 0xD8, 0x76, 0x1B,
  0x86, 0xE1, 0xB8, 0x6C, 0x3B, 0x8C, 0xFF, 0x1F, 0x80, 0xE0, 0x18, 0x07,
  0x00, 0x3F, 0x0F, 0xF7, 0x1D, 0xC3, 0x60, 0xD8, 0x77, 0xF9, 0xFC, 0xE6,
  0x39, 0x8E, 0x73, 0x1C, 0xC3, 0x30, 0xE0, 0x0F, 0x8F, 0xF3, 0x1D, 0xC3,
  0x70, 0x1C, 0x03, 0xE0, 0x7C, 0x03, 0x80, 0x6C, 0x1B, 0x8E, 0xFF, 0x1F,
  0x80, 0xFF, 0xFF, 0xF0, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x00, 0x30, 0xCC, 0x37, 0x0D, 0xC7,
  0x61, 0xD8, 0x76, 0x19, 0x86, 0xE1, 0xB8, 0x6C, 0x3B, 0x8C, 0xFF, 0x1F,
  0x80, 0xC0, 0xF8, 0x7E, 0x1B, 0x8E, 0xE3, 0x18, 0xC6, 0x61, 0x98, 0x6E,
  0x1B, 0x06, 0xC1, 0xE0, 0x78, 0x1E, 0x00, 0x66, 0x6C, 0xCD, 0x39, 0xE5,
  0x3C, 0xAD, 0x95, 0xB6, 0xB6, 0xB6, 0xD7, 0x9E, 0xF3, 0x9E, 0x73, 0x8E,
  0x71, 0xCE, 0x00, 0x38, 0x71, 0x8E, 0x1C, 0xC1, 0xDC, 0x0F, 0x80, 0xF0,
  0x07, 0x00, 0xF0, 0x0F, 0x01, 0xB0, 0x3B, 0x87, 0x18, 0x61, 0x8E, 0x1C,
  0xC0, 0xF8, 0x66, 0x39, 0x8C, 0x67, 0x1D, 0x83, 0xC0, 0xF0, 0x38, 0x0E,
  0x03, 0x80, 0xC0, 0x30, 0x0C, 0x00, 0x3F, 0xCF, 0xF0, 0x1C, 0x0E, 0x07,
  0x01, 0x80, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x80, 0xFF, 0x3F, 0xC0,
  0x1F, 0x1F, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70,
  0x70, 0x60, 0x60, 0x60, 0x7C, 0xFC, 0xC3, 0x0E, 0x18, 0x61, 0x87, 0x1C,
  0x30, 0xC3, 0x0E, 0x38, 0x61, 0x87, 0x1C, 0x30, 0x1F, 0x8F, 0x80, 0xC0,
  0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x60,
  0x30, 0x18, 0x7C, 0x7E, 0x00, 0x06, 0x07, 0x83, 0xC3, 0x63, 0x31, 0x8D,
  0x87, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xC6, 0x70, 0x0C, 0x0F, 0xF7, 0x39,
  0x86, 0x61, 0xB8, 0x6E, 0x3B, 0x0E, 0xE3, 0xBF, 0xC7, 0xB0, 0x30, 0x0C,
  0x07, 0x01, 0xD8, 0x6F, 0x9E, 0xE6, 0x19, 0x86, 0xE1, 0xB8, 0x6E, 0x3B,
  0x8C, 0xFF, 0x37, 0x80, 0x0E, 0x0F, 0xE7, 0xB9, 0x86, 0x60, 0x38, 0x0E,
  0x03, 0x0E, 0xE3, 0xBF, 0xC7, 0xE0, 0x00, 0xC0, 0x30, 0x0C, 0x37, 0x3F,
  0xDC, 0xE6, 0x19, 0x86, 0xE1, 0xB8, 0xEC, 0x3B, 0x8E, 0xFF, 0x1E, 0xC0,
  0x0E, 0x1F, 0xDC, 0xEC, 0x36, 0x1F, 0xFF, 0x81, 0x80, 0xE3, 0xFF, 0x9F,
  0x80, 0x00, 0xF8, 0x0F, 0xC0, 0xE0, 0x06, 0x00, 0x30, 0x0F, 0xF8, 0xFF,
  0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x30, 0x1F, 0x80, 0xF8, 0x00, 0x0C, 0x0F, 0xF7, 0x39, 0x86, 0x61, 0xB8,
  0x6E, 0x3B, 0x8E, 0xFF, 0x9E, 0xC0, 0x30, 0x0C, 0x7F, 0x3F, 0x80, 0x30,
  0x0C, 0x07, 0x01, 0xD8, 0x6F, 0x9E, 0xE6, 0x19, 0x86, 0xE1, 0xB8, 0xEE,
  0x3B, 0x0E, 0xC3, 0x30, 0xC0, 0x07, 0x03, 0x81, 0x80, 0x00, 0x01, 0xF1,
  0xF8, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC7, 0xFF, 0xFE, 0x00, 0xC0,
  0x70, 0x0C, 0x00, 0x00, 0x47, 0xE1, 0xF8, 0x06, 0x01, 0x80, 0xE0, 0x38,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0xFE, 0x3F, 0x00, 0x30, 0x06, 0x00,
  0xC0, 0x38, 0x17, 0x1C, 0xC7, 0x19, 0xC3, 0x30, 0x7E, 0x1F, 0xC3, 0x98,
  0x63, 0x8C, 0x31, 0x87, 0x00, 0xFC, 0xF8, 0x18, 0x18, 0x38, 0x38, 0x38,
  0x30, 0x30, 0x30, 0x30, 0x70, 0x3F, 0x1F, 0x04, 0xC7, 0xFC, 0xD9, 0xB3,
  0x36, 0x66, 0xCD, 0x99, 0x33, 0x26, 0x6C, 0xD9, 0x9B, 0x37, 0x00, 0x16,
  0x1B, 0xE7, 0xB9, 0x86, 0x61, 0xB8, 0x6E, 0x3B, 0x8E, 0xC3, 0xB0, 0xCC,
  0x30, 0x0E, 0x1F, 0xDE, 0xEC, 0x36, 0x1F, 0x0F, 0x87, 0x87, 0xE3, 0x7F,
  0x9F, 0x80, 0x0B, 0x06, 0xF8, 0xF7, 0x18, 0x63, 0x0C, 0xE1, 0x9C, 0x33,
  0x8E, 0x71, 0x8F, 0xF1, 0xBC, 0x30, 0x0E, 0x01, 0xC0, 0x00, 0x0C, 0x0F,
  0xF7, 0x39, 0x86, 0x61, 0xB8, 0x6E, 0x3B, 0x0E, 0xE3, 0x3F, 0xC7, 0xB0,
  0x0C, 0x07, 0x01, 0xC0, 0x03, 0x1F, 0xE7, 0xBD, 0xC7, 0x61, 0xD8, 0x06,
  0x01, 0x80, 0xE0, 0x38, 0x0C, 0x00, 0x0E, 0x0F, 0xE7, 0x19, 0x80, 0x70,
  0x1F, 0xC0, 0xF8, 0x0E, 0xC3, 0xBF, 0xC7, 0xE0, 0x0C, 0x03, 0x01, 0xC3,
  0xFF, 0xFF, 0xC6, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xFC, 0x1F,
  0x00, 0x71, 0xD8, 0x66, 0x19, 0x86, 0xE1, 0xB8, 0xEE, 0x3B, 0x8C, 0xFF,
  0x1F, 0x80, 0xC1, 0xE1, 0xB0, 0xDC, 0xEE, 0x63, 0x71, 0xB0, 0xF8, 0x78,
  0x3C, 0x00, 0xCC, 0x79, 0x9B, 0x33, 0x6E, 0x6D, 0x59, 0xAB, 0x3D, 0x67,
  0x28, 0xE7, 0x1C, 0xE0, 0x38, 0xE3, 0x38, 0x7E, 0x07, 0x80, 0xE0, 0x1E,
  0x06, 0xC1, 0xDC, 0x71, 0x9C, 0x38, 0x71, 0xD8, 0x66, 0x19, 0x86, 0xE1,
  0xB8, 0xEE, 0x3B, 0xFC, 0x7B, 0x00, 0xC0, 0x31, 0xFC, 0xFE, 0x00, 0x7F,
  0xDF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xFF, 0x3F, 0xC0,
  0x01, 0xC1, 0xE0, 0x70, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0xF8, 0x3E,
  0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x1E, 0x07, 0x80, 0x1C,
  0x61, 0x86, 0x38, 0xE3, 0x8C, 0x30, 0xC3, 0x1C, 0x71, 0x86, 0x18, 0x63,
  0x80, 0x1C, 0x07, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x07,
  0xC1, 0xF0, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x78, 0x3C, 0x00,
  0x38, 0xDF, 0x3C, 0xDF, 0x3E, 0x02, 0x00,
};

const GFXglyph JetBrainsMono_BoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 5, 14, 11, 3, -14 },
  { 10, 7, 6, 11, 3, -14 },
  { 16, 12, 14, 11, 0, -14 },
  { 37, 10, 20, 11, 1, -17 },
  { 62, 14, 14, 11, -1, -14 },
  { 87, 11, 14, 11, 0, -14 },
  { 107, 3, 6, 11, 5, -14 },
  { 110, 8, 18, 11, 3, -16 },
  { 128, 8, 18, 11, 1, -16 },
  { 146, 10, 10, 11, 1, -12 },
  { 159, 10, 9, 11, 1, -11 },
  { 171, 5, 6, 11, 2, -3 },
  { 175, 7, 2, 11, 2, -7 },
  { 177, 4, 3, 11, 3, -3 },
  { 179, 12, 18, 11, 0, -16 },
  { 206, 10, 14, 11, 1, -14 },
  { 224, 9, 14, 11, 1, -14 },
  { 240, 10, 14, 11, 1, -14 },
  { 258, 10, 14, 11, 1, -14 },
  { 276, 10, 14, 11, 1, -14 },
  { 294, 10, 14, 11, 1, -14 },
  { 312, 9, 14, 11, 1, -14 },
  { 328, 10, 14, 11, 2, -14 },
  { 346, 10, 14, 11, 1, -14 },
  { 364, 9, 14, 11, 2, -14 },
  { 380, 5, 11, 11, 3, -11 },
  { 387, 6, 14, 11, 2, -11 },
  { 398, 10, 10, 11, 1, -11 },
  { 411, 10, 7, 11, 1, -10 },
  { 420, 9, 10, 11, 1, -11 },
  { 432, 9, 14, 11, 2, -14 },
  { 448, 12, 17, 11, 0, -14 },
  { 474, 10, 14, 11, 0, -14 },
  { 492, 10, 14, 11, 1, -14 },
  { 510, 10, 14, 11, 1, -14 },
  { 528, 10, 14, 11, 1, -14 },
  { 546, 10, 14, 11, 1, -14 },
  { 564, 11, 14, 11, 1, -14 },
  { 584, 10, 14, 11, 1, -14 },
  { 602, 10, 14, 11, 1, -14 },
  { 620, 10, 14, 11, 1, -14 },
  { 638, 11, 14, 11, 0, -14 },
  { 658, 11, 14, 11, 1, -14 },
  { 678, 9, 14, 11, 1, -14 },
  { 694, 12, 14, 11, 0, -14 },
  { 715, 10, 14, 11, 1, -14 },
  { 733, 10, 14, 11, 1, -14 },
  { 751, 11, 14, 11, 1, -14 },
  { 771, 10, 17, 11, 1, -14 },
  { 793, 10, 14, 11, 1, -14 },
  { 811, 10, 14, 11, 1, -14 },
  { 829, 10, 14, 11, 2, -14 },
  { 847, 10, 14, 11, 1, -14 },
  { 865, 10, 14, 11, 2, -14 },
  { 883, 11, 14, 11, 1, -14 },
  { 903, 12, 14, 11, 0, -14 },
  { 924, 10, 14, 11, 2, -14 },
  { 942, 10, 14, 11, 1, -14 },
  { 960, 8, 18, 11, 2, -16 },
  { 978, 6, 18, 11, 3, -16 },
  { 992, 9, 18, 11, 1, -16 },
  { 1013, 9, 8, 11, 1, -14 },
  { 1022, 9, 3, 11, 0, 0 },
  { 1026, 4, 3, 11, 5, -15 },
  { 1028, 10, 11, 11, 1, -11 },
  { 1042, 10, 14, 11, 1, -14 },
  { 1060, 10, 11, 11, 1, -11 },
  { 1074, 10, 14, 11, 1, -14 },
  { 1092, 9, 11, 11, 1, -11 },
  { 1105, 13, 17, 11, -1, -14 },
  { 1133, 10, 14, 11, 1, -11 },
  { 1151, 10, 14, 11, 1, -14 },
  { 1169, 9, 15, 11, 1, -15 },
  { 1186, 10, 18, 11, 0, -15 },
  { 1209, 11, 14, 11, 1, -14 },
  { 1229, 8, 14, 11, 2, -14 },
  { 1243, 11, 11, 11, 0, -11 },
  { 1259, 10, 11, 11, 1, -11 },
  { 1273, 9, 11, 11, 1, -11 },
  { 1286, 11, 14, 11, 0, -11 },
  { 1306, 10, 14, 11, 1, -11 },
  { 1324, 10, 11, 11, 1, -11 },
  { 1338, 10, 11, 11, 1, -11 },
  { 1352, 10, 13, 11, 1, -13 },
  { 1369, 10, 10, 11, 1, -10 },
  { 1382, 9, 10, 11, 2, -10 },
  { 1394, 11, 10, 11, 1, -10 },
  { 1408, 11, 10, 11, 0, -10 },
  { 1422, 10, 13, 11, 1, -10 },
  { 1439, 10, 10, 11, 1, -10 },
  { 1452, 10, 18, 11, 2, -16 },
  { 1475, 6, 18, 11, 3, -16 },
  { 1489, 10, 18, 11, 0, -16 },
  { 1512, 10, 5, 11, 1, -9 },
};

const GFXfont JetBrainsMono_BoldItalic19pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic19pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _JETBRAINSMONO_BOLDITALIC19PT7B_H_
