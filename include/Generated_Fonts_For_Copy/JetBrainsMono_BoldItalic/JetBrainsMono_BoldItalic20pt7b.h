#ifndef _JETBRAINSMONO_BOLDITALIC20PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCC, 0x63, 0x39, 0xCC, 0x63, 0x00, 0x04, 0x73, 0x80, 0x77,
  0x67, 0x67, 0x66, 0xE6, 0xE6, 0x06, 0x30, 0x63, 0x06, 0x60, 0xC6, 0x3F,
  0xF3, 0xFF, 0x18, 0xC1, 0x8C, 0x19, 0x83, 0x18, 0xFF, 0xE3, 0x30, 0x63,
  0x06, 0x30, 0x66, 0x00, 0x03, 0x00, 0x40, 0x1C, 0x0F, 0xE3, 0xFC, 0xED,
  0xDD, 0x03, 0xA0, 0x7C, 0x07, 0xE0, 0x3E, 0x06, 0xE0, 0x9D, 0x93, 0x3A,
  0xE7, 0xF8, 0x7E, 0x03, 0x00, 0x60, 0x08, 0x00, 0x0E, 0x06, 0x3E, 0x18,
  0xCC, 0x61, 0x99, 0x83, 0x36, 0x07, 0xD8, 0x07, 0x60, 0x00, 0x80, 0x03,
  0x60, 0x0F, 0xE0, 0x36, 0x60, 0xC8, 0x83, 0x33, 0x0C, 0x36, 0x30, 0x78,
  0x00, 0x07, 0x80, 0xFC, 0x1C, 0xE1, 0x8E, 0x18, 0x01, 0x80, 0x1C, 0x03,
  0xC1, 0x76, 0x66, 0x7C, 0x63, 0xC6, 0x38, 0xE3, 0x87, 0xFC, 0x7C, 0xE0,
  0x76, 0x66, 0x6E, 0x01, 0x83, 0x83, 0xC3, 0x83, 0x81, 0x81, 0xC0, 0xC0,
  0x60, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07,
  0x00, 0x80, 0x10, 0x0E, 0x07, 0x80, 0xE0, 0x70, 0x18, 0x0C, 0x06, 0x03,
  0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x38, 0x38, 0x78, 0x38, 0x10,
  0x00, 0x06, 0x00, 0xC1, 0x18, 0xF2, 0xFF, 0xFE, 0x18, 0x07, 0x81, 0xB8,
  0x73, 0x8C, 0x60, 0x06, 0x03, 0x80, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0,
  0x70, 0x1C, 0x00, 0x39, 0xDC, 0xCE, 0x60, 0xFF, 0xFF, 0xF0, 0x27, 0xF7,
  0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x07, 0x03, 0xF8, 0xE7, 0x38,
  0x67, 0x0C, 0xC1, 0x99, 0x33, 0x76, 0x6D, 0xDC, 0x3B, 0x86, 0x60, 0xCE,
  0x38, 0xFE, 0x1F, 0x80, 0x07, 0x03, 0xC3, 0xF0, 0xDC, 0x67, 0x01, 0xC0,
  0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x7F, 0xEF, 0xF8, 0x0F,
  0x03, 0xF8, 0xE7, 0x38, 0x66, 0x0C, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0xF0, 0x3C, 0x0E, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xCF, 0xF3, 0xFC,
  0x0E, 0x07, 0x03, 0x80, 0xF0, 0x3E, 0x01, 0xC0, 0x70, 0x1B, 0x06, 0xE3,
  0xBF, 0xC7, 0xE0, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC7, 0xE1, 0xB8, 0x6F, 0xFB, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x3F, 0xE7,
  0xF8, 0xFF, 0x18, 0x03, 0x00, 0xE4, 0x1F, 0xE3, 0xDE, 0x01, 0xC0, 0x38,
  0x06, 0x70, 0xCE, 0x39, 0xFE, 0x1F, 0x80, 0x03, 0x81, 0xC0, 0x60, 0x38,
  0x1C, 0x0E, 0x03, 0x71, 0xFE, 0xF1, 0xF8, 0x7C, 0x1F, 0x06, 0xE3, 0xBF,
  0xC7, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0x80, 0xC0, 0x70, 0x18,
  0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x00, 0x0F, 0x03, 0xF8,
  0xE7, 0x38, 0x67, 0x0C, 0xE3, 0x8E, 0xE0, 0xF0, 0x3F, 0x8C, 0x33, 0x86,
  0x60, 0xCE, 0x39, 0xFE, 0x1F, 0x80, 0x1E, 0x0F, 0xE7, 0x3B, 0x87, 0xC1,
  0xF0, 0x7C, 0x3B, 0xFE, 0x7B, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x0F,
  0x00, 0x38, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x73, 0xC7, 0x00, 0x1C, 0x3C,
  0x70, 0x00, 0x00, 0x00, 0x02, 0x38, 0x71, 0xC3, 0x0E, 0x18, 0x00, 0x00,
  0x60, 0x38, 0x1F, 0x1F, 0x07, 0x80, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x70, 0x02, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xEF, 0xF8,
  0x60, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x70, 0x78, 0x7C, 0xF8, 0x38,
  0x08, 0x00, 0x78, 0x7E, 0xFF, 0x07, 0x07, 0x07, 0x0E, 0x7C, 0x78, 0x60,
  0x60, 0x00, 0x40, 0xE0, 0xE0, 0x03, 0xC0, 0xFE, 0x18, 0x73, 0x03, 0x30,
  0x36, 0x1B, 0x67, 0xF6, 0x63, 0x66, 0x36, 0x66, 0xEC, 0x6C, 0xC6, 0xCF,
  0xEC, 0x76, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xE0, 0x0C, 0x00, 0x03, 0x81,
  0xE0, 0x78, 0x1E, 0x0D, 0x83, 0x71, 0xDC, 0x67, 0x39, 0xCF, 0xF3, 0xFD,
  0xC3, 0x60, 0xF8, 0x3E, 0x0C, 0x3F, 0x07, 0xF8, 0xCF, 0x38, 0x77, 0x0C,
  0xE3, 0x9F, 0xE3, 0xF8, 0x63, 0x8C, 0x3B, 0x87, 0x70, 0xEC, 0x39, 0xFE,
  0x3F, 0x80, 0x07, 0x03, 0xF8, 0xE7, 0x38, 0x77, 0x0C, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0xCE, 0x38, 0xFE, 0x0F, 0x80, 0x3E,
  0x07, 0xF0, 0xFF, 0x38, 0x67, 0x0C, 0xE1, 0x98, 0x33, 0x06, 0x61, 0xDC,
  0x3B, 0x87, 0x70, 0xCE, 0x79, 0xFE, 0x3F, 0x00, 0x3F, 0xE7, 0xFC, 0xFF,
  0x98, 0x03, 0x00, 0xE0, 0x1F, 0xE3, 0xFC, 0x7F, 0x8C, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0xFF, 0x98, 0x07, 0x00,
  0xE0, 0x1C, 0x13, 0xFC, 0x7F, 0x8C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x30, 0x00, 0x07, 0x03, 0xF8, 0xE7, 0x38, 0x77, 0x0C, 0xE0, 0x18, 0x03,
  0x3E, 0x67, 0xDC, 0x3B, 0x87, 0x70, 0xCE, 0x38, 0xFE, 0x0F, 0x80, 0x30,
  0xE6, 0x1C, 0xC3, 0xB8, 0x67, 0x0C, 0xE1, 0x9F, 0xF3, 0xFE, 0x7F, 0xCC,
  0x33, 0x86, 0x70, 0xCE, 0x39, 0x87, 0x30, 0xE0, 0x3F, 0xE7, 0xF8, 0xFF,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC1, 0xFF, 0x3F, 0xC0, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xCE, 0x1C, 0xE3,
  0x87, 0xF8, 0x3E, 0x00, 0x30, 0x73, 0x0E, 0x30, 0xC7, 0x1C, 0x73, 0x87,
  0x30, 0x7F, 0x07, 0xE0, 0x7F, 0x06, 0x70, 0xE3, 0x0E, 0x30, 0xE3, 0x8C,
  0x38, 0xC1, 0xC0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0,
  0x70, 0x38, 0x18, 0x0C, 0x06, 0x07, 0xFF, 0xFE, 0x18, 0x73, 0xC7, 0x3C,
  0xF3, 0xCF, 0x3D, 0xB3, 0x5F, 0x35, 0x67, 0x76, 0x76, 0x66, 0x06, 0x60,
  0xE6, 0x0E, 0x60, 0xCE, 0x0C, 0xE0, 0xC0, 0x38, 0x67, 0x0C, 0xE3, 0xB4,
  0x76, 0xCC, 0xD9, 0x9B, 0x33, 0x66, 0x6D, 0xDC, 0xFB, 0x9E, 0x63, 0xCC,
  0x79, 0x8F, 0x30, 0xE0, 0x07, 0x03, 0xF8, 0xE7, 0x38, 0x67, 0x0C, 0xE1,
  0x98, 0x33, 0x0E, 0x61, 0xDC, 0x3B, 0x86, 0x70, 0xCE, 0x38, 0xFE, 0x1F,
  0x80, 0x3F, 0x07, 0xF8, 0xFF, 0xB8, 0x77, 0x0E, 0xE1, 0xDC, 0x33, 0xFE,
  0x7F, 0x8C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x00, 0x07, 0x03,
  0xF8, 0xE7, 0x38, 0x67, 0x0C, 0xC1, 0x98, 0x33, 0x0E, 0x61, 0xDC, 0x3B,
  0x86, 0x70, 0xCE, 0x38, 0xFE, 0x1F, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0x3F, 0x07, 0xF8, 0xFF, 0x38, 0x77, 0x0E, 0xE1, 0xD8, 0x73, 0xFC,
  0x7F, 0x0C, 0xC3, 0x9C, 0x71, 0x8E, 0x31, 0x87, 0x30, 0xE0, 0x0F, 0x03,
  0xF8, 0xE7, 0x38, 0x77, 0x00, 0xE0, 0x0F, 0x01, 0xF8, 0x0F, 0x80, 0x38,
  0x07, 0x60, 0xCE, 0x39, 0xFE, 0x1F, 0x80, 0xFF, 0xFF, 0xFB, 0xFF, 0x06,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x80, 0x70, 0x0C, 0x00, 0x30, 0xE6, 0x1C, 0xC3, 0xB8, 0x77, 0x0C, 0xE1,
  0x98, 0x33, 0x0E, 0x61, 0xDC, 0x3B, 0x86, 0x70, 0xCE, 0x38, 0xFE, 0x1F,
  0x80, 0xE0, 0xFC, 0x1B, 0x87, 0x70, 0xC6, 0x18, 0xC7, 0x18, 0xC3, 0x38,
  0x66, 0x0C, 0xC1, 0xB8, 0x36, 0x07, 0xC0, 0xF0, 0x1E, 0x00, 0x67, 0x36,
  0x63, 0x66, 0x76, 0x66, 0x6E, 0x6C, 0xA6, 0xCA, 0xCD, 0xAC, 0xD2, 0xCD,
  0x2C, 0xD2, 0x8F, 0x38, 0xE3, 0x8E, 0x38, 0xE7, 0x00, 0x38, 0x38, 0xC3,
  0x87, 0x38, 0x39, 0xC0, 0xDC, 0x07, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0xF8, 0x06, 0xE0, 0x73, 0x07, 0x1C, 0x38, 0xE3, 0x83, 0x80, 0xC0, 0xFC,
  0x19, 0x87, 0x31, 0xC7, 0x30, 0xEE, 0x0D, 0x81, 0xF0, 0x3C, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x00, 0x3F, 0xE7, 0xF8, 0xFF, 0x00,
  0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E,
  0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0x8F, 0xC7, 0xE3, 0x01, 0x80, 0xC0, 0xE0,
  0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x3E,
  0x3F, 0x00, 0xC1, 0xC3, 0x83, 0x06, 0x0E, 0x1C, 0x38, 0x30, 0x60, 0xE1,
  0xC1, 0x83, 0x07, 0x0E, 0x1C, 0x18, 0x38, 0x1F, 0x8F, 0xC7, 0xE0, 0x70,
  0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38,
  0x1C, 0x0E, 0x3E, 0x3F, 0x00, 0x0E, 0x07, 0x07, 0x87, 0xE3, 0x33, 0x19,
  0x8D, 0x87, 0xFF, 0xFF, 0xFF, 0xFC, 0xE6, 0x70, 0x1E, 0xCF, 0xB7, 0x1D,
  0x87, 0x61, 0xF8, 0x6E, 0x1B, 0x86, 0xE3, 0xBF, 0xE7, 0xB8, 0x30, 0x0C,
  0x03, 0x01, 0xC0, 0x77, 0x9F, 0xF7, 0x1D, 0x87, 0x61, 0xD8, 0x7E, 0x1B,
  0x86, 0xE3, 0xB7, 0xCD, 0xE0, 0x1F, 0x8F, 0xF7, 0x1D, 0x87, 0x60, 0x38,
  0x0E, 0x03, 0x86, 0xE3, 0x9F, 0xC7, 0xE0, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x61, 0xEC, 0x7D, 0x9C, 0x73, 0x0E, 0x61, 0xDC, 0x33, 0x86, 0x70, 0xCE,
  0x39, 0xFF, 0x1E, 0xE0, 0x1F, 0x8F, 0xE7, 0x1D, 0x87, 0x61, 0xFF, 0xFE,
  0x03, 0x80, 0xE3, 0x9F, 0xC7, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x3F, 0x80,
  0xE0, 0x03, 0x00, 0x7F, 0xE1, 0xFF, 0x09, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x03,
  0xE0, 0x0E, 0x00, 0x00, 0x1E, 0xCF, 0xB7, 0x1D, 0x87, 0x61, 0xF8, 0x6E,
  0x1B, 0x8E, 0xFD, 0x9F, 0xE0, 0x38, 0x0C, 0x0F, 0x1F, 0x87, 0x80, 0x30,
  0x0C, 0x03, 0x01, 0xC0, 0x77, 0x9F, 0xF7, 0x1D, 0x87, 0x61, 0xD8, 0x6E,
  0x1B, 0x86, 0xE1, 0xB0, 0xEC, 0x38, 0x03, 0x01, 0xC0, 0x70, 0x00, 0x00,
  0x0F, 0xC3, 0xE1, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x0F,
  0xFF, 0xFE, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x3F, 0x87, 0xF0,
  0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18,
  0x07, 0x0F, 0xE3, 0xF8, 0x78, 0x00, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x0E, 0xE3, 0x9C, 0xE3, 0x18, 0x7F, 0x0F, 0xC3, 0x98, 0x73, 0x8E, 0x31,
  0x87, 0x30, 0xE0, 0xFC, 0x7E, 0x3F, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70,
  0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFC, 0x7C, 0x3E, 0xE3, 0xFE, 0x32,
  0x67, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x6E, 0x64, 0xCE, 0xCC, 0xCC,
  0xC0, 0x77, 0x9F, 0xF7, 0x1D, 0x87, 0x61, 0xD8, 0x6E, 0x1B, 0x86, 0xE1,
  0xB0, 0xEC, 0x38, 0x1F, 0x8F, 0xE7, 0x1D, 0x87, 0x61, 0xF8, 0x7E, 0x1B,
  0x86, 0xE3, 0x9F, 0xC7, 0xE0, 0x3B, 0xC7, 0xFC, 0xE3, 0x98, 0x73, 0x0E,
  0x61, 0xDC, 0x33, 0x86, 0x71, 0xCD, 0xF1, 0xBC, 0x30, 0x0E, 0x01, 0xC0,
  0x38, 0x00, 0x1E, 0xCF, 0xB7, 0x1D, 0x87, 0x61, 0xF8, 0x6E, 0x1B, 0x86,
  0xE3, 0xBF, 0xE7, 0xB8, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x37, 0x8F, 0xF9,
  0xC7, 0x38, 0x67, 0x0C, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x00, 0x1F, 0x8F, 0xF7, 0x1D, 0x80, 0x7C, 0x0F, 0xE0, 0x38, 0x06, 0xC1,
  0xBF, 0xE7, 0xF0, 0x0E, 0x03, 0x00, 0xC1, 0xFF, 0xFF, 0xC7, 0x01, 0xC0,
  0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x1F, 0x87, 0xE0, 0x70, 0xDC, 0x36,
  0x1D, 0x87, 0x61, 0xF8, 0x6E, 0x1B, 0x86, 0xE3, 0x9F, 0xC7, 0xE0, 0xC1,
  0xF0, 0x6E, 0x3B, 0x8C, 0xE7, 0x19, 0x86, 0xE1, 0xB0, 0x6C, 0x1E, 0x07,
  0x80, 0xC6, 0x79, 0xCF, 0x29, 0xE5, 0x6D, 0xED, 0xAD, 0xB5, 0xE6, 0xBC,
  0xF7, 0x9C, 0xE3, 0x9C, 0x00, 0x38, 0x71, 0x8E, 0x1D, 0xC0, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xB8, 0x3B, 0x87, 0x1C, 0xE1, 0xC0, 0x70, 0xDC,
  0x36, 0x1D, 0x87, 0x61, 0xF8, 0x6E, 0x1B, 0x8E, 0xFF, 0x9E, 0xE0, 0x38,
  0x0C, 0x0F, 0x1F, 0x87, 0x80, 0x3F, 0xDF, 0xF0, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x3F, 0xEF, 0xF8, 0x00, 0xC0, 0xF0, 0x7C, 0x18,
  0x06, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x3E, 0x0F, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0x80, 0x60, 0x18, 0x07, 0xC0, 0xE0, 0x39, 0xCE, 0x73, 0x18, 0xCE,
  0x73, 0x98, 0xC6, 0x73, 0x9C, 0xC6, 0x30, 0x1C, 0x03, 0xC0, 0x7C, 0x03,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x07, 0x00, 0xFC, 0x1F, 0x87, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x0F, 0x03, 0xC0, 0x00, 0x7C, 0xFF,
  0x9B, 0x3F, 0x63, 0xC0,
};

const GFXglyph JetBrainsMono_BoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 15, 12, 4, -15 },
  { 11, 8, 6, 12, 3, -15 },
  { 17, 12, 15, 12, 0, -15 },
  { 40, 11, 20, 12, 1, -17 },
  { 68, 15, 15, 12, -1, -15 },
  { 97, 12, 15, 12, 0, -15 },
  { 120, 4, 6, 12, 5, -15 },
  { 123, 9, 20, 12, 3, -17 },
  { 146, 9, 20, 12, 1, -17 },
  { 169, 11, 10, 12, 1, -12 },
  { 183, 10, 9, 12, 1, -11 },
  { 195, 5, 6, 12, 2, -3 },
  { 199, 7, 3, 12, 3, -8 },
  { 202, 4, 4, 12, 3, -4 },
  { 204, 13, 19, 12, 0, -17 },
  { 235, 11, 15, 12, 1, -15 },
  { 256, 10, 15, 12, 1, -15 },
  { 275, 11, 15, 12, 1, -15 },
  { 296, 10, 15, 12, 1, -15 },
  { 315, 10, 15, 12, 1, -15 },
  { 334, 11, 15, 12, 1, -15 },
  { 355, 10, 15, 12, 1, -15 },
  { 374, 10, 15, 12, 2, -15 },
  { 393, 11, 15, 12, 1, -15 },
  { 414, 10, 15, 12, 2, -15 },
  { 433, 6, 11, 12, 3, -11 },
  { 442, 7, 14, 12, 2, -11 },
  { 455, 11, 11, 12, 1, -12 },
  { 471, 10, 7, 12, 1, -10 },
  { 480, 10, 11, 12, 1, -12 },
  { 494, 8, 15, 12, 3, -15 },
  { 509, 12, 19, 12, 0, -15 },
  { 538, 10, 15, 12, 0, -15 },
  { 557, 11, 15, 12, 1, -15 },
  { 578, 11, 15, 12, 1, -15 },
  { 599, 11, 15, 12, 1, -15 },
  { 620, 11, 15, 12, 1, -15 },
  { 641, 11, 15, 12, 1, -15 },
  { 662, 11, 15, 12, 1, -15 },
  { 683, 11, 15, 12, 1, -15 },
  { 704, 11, 15, 12, 1, -15 },
  { 725, 12, 15, 12, 0, -15 },
  { 748, 12, 15, 12, 1, -15 },
  { 771, 9, 15, 12, 1, -15 },
  { 788, 12, 15, 12, 0, -15 },
  { 811, 11, 15, 12, 1, -15 },
  { 832, 11, 15, 12, 1, -15 },
  { 853, 11, 15, 12, 1, -15 },
  { 874, 11, 19, 12, 1, -15 },
  { 901, 11, 15, 12, 1, -15 },
  { 922, 11, 15, 12, 1, -15 },
  { 943, 11, 15, 12, 2, -15 },
  { 964, 11, 15, 12, 1, -15 },
  { 985, 11, 15, 12, 2, -15 },
  { 1006, 12, 15, 12, 1, -15 },
  { 1029, 13, 15, 12, 0, -15 },
  { 1054, 11, 15, 12, 2, -15 },
  { 1075, 11, 15, 12, 1, -15 },
  { 1096, 9, 19, 12, 2, -17 },
  { 1118, 7, 19, 12, 3, -17 },
  { 1135, 9, 19, 12, 1, -17 },
  { 1157, 9, 8, 12, 2, -15 },
  { 1166, 10, 3, 12, 0, 0 },
  { 1170, 4, 3, 12, 5, -16 },
  { 1172, 10, 11, 12, 1, -11 },
  { 1186, 10, 15, 12, 1, -15 },
  { 1205, 10, 11, 12, 1, -11 },
  { 1219, 11, 15, 12, 1, -15 },
  { 1240, 10, 11, 12, 1, -11 },
  { 1254, 14, 19, 12, -1, -15 },
  { 1288, 10, 15, 12, 1, -11 },
  { 1307, 10, 15, 12, 1, -15 },
  { 1326, 10, 16, 12, 1, -16 },
  { 1346, 11, 20, 12, 0, -16 },
  { 1374, 11, 15, 12, 1, -15 },
  { 1395, 9, 15, 12, 2, -15 },
  { 1412, 12, 11, 12, 0, -11 },
  { 1429, 10, 11, 12, 1, -11 },
  { 1443, 10, 11, 12, 1, -11 },
  { 1457, 11, 15, 12, 0, -11 },
  { 1478, 10, 15, 12, 1, -11 },
  { 1497, 11, 11, 12, 1, -11 },
  { 1513, 10, 11, 12, 1, -11 },
  { 1527, 10, 14, 12, 1, -14 },
  { 1545, 10, 11, 12, 1, -11 },
  { 1559, 10, 11, 12, 2, -11 },
  { 1573, 11, 11, 12, 1, -11 },
  { 1589, 12, 11, 12, 0, -11 },
  { 1606, 10, 15, 12, 1, -11 },
  { 1625, 10, 11, 12, 1, -11 },
  { 1639, 10, 19, 12, 2, -17 },
  { 1663, 5, 19, 12, 4, -17 },
  { 1675, 11, 19, 12, 0, -17 },
  { 1702, 11, 4, 12, 1, -9 },
};

const GFXfont JetBrainsMono_BoldItalic20pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic20pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _JETBRAINSMONO_BOLDITALIC20PT7B_H_
