#ifndef _JETBRAINSMONO_BOLDITALIC43PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x7E, 0x1F,
  0x7E, 0x1F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8, 0x3C, 0xF0, 0x3C, 0x00, 0x0F,
  0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0E, 0x07, 0x80,
  0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x00,
  0x78, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0E,
  0x07, 0x80, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x84, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0,
  0xF0, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00,
  0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xE7, 0x7F, 0x0F, 0xC6, 0x3F, 0x0F, 0xC6, 0x3F, 0x0F, 0x8E,
  0x3F, 0x0F, 0x8E, 0x00, 0x0F, 0x8E, 0x00, 0x0F, 0xCE, 0x00, 0x0F, 0xEC,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1B, 0xFC, 0x00, 0x38,
  0xFC, 0x00, 0x38, 0xFC, 0x00, 0x38, 0xFC, 0x00, 0x38, 0xFC, 0x7C, 0x38,
  0xFC, 0x7C, 0x30, 0xF8, 0x7E, 0x31, 0xF8, 0x7F, 0xF7, 0xF0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x02, 0x01, 0xFE, 0x00, 0x78,
  0x07, 0xFE, 0x01, 0xE0, 0x1F, 0xFC, 0x03, 0xC0, 0x78, 0x78, 0x0F, 0x00,
  0xF0, 0xF0, 0x3C, 0x01, 0xC1, 0xE0, 0xF0, 0x07, 0x83, 0xC3, 0xC0, 0x0F,
  0x07, 0x8F, 0x00, 0x1E, 0x0F, 0x3C, 0x00, 0x3C, 0x3C, 0x78, 0x00, 0x7F,
  0xF9, 0xE0, 0x00, 0x7F, 0xE7, 0x80, 0x00, 0x7F, 0x9E, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3C, 0xFC, 0x00, 0x00, 0xF7, 0xFE, 0x00, 0x03, 0xDF,
  0xFC, 0x00, 0x0F, 0x3C, 0x7C, 0x00, 0x3C, 0xF0, 0x78, 0x00, 0xF1, 0xE0,
  0xF0, 0x03, 0xC3, 0xC1, 0xE0, 0x07, 0x87, 0x83, 0x80, 0x1E, 0x0F, 0x0F,
  0x00, 0x78, 0x1E, 0x1E, 0x01, 0xE0, 0x3C, 0x7C, 0x07, 0x80, 0x7F, 0xF0,
  0x1E, 0x00, 0x7F, 0xC0, 0x78, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03,
  0xE0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x01, 0x3F,
  0xFC, 0x3E, 0x7E, 0x7C, 0x7E, 0x7C, 0x7E, 0x7C, 0x7C, 0x3E, 0xF8, 0x7C,
  0x1F, 0xF8, 0xFC, 0x1F, 0xF0, 0xF8, 0x0F, 0xE0, 0xF8, 0x0F, 0xE0, 0xF8,
  0x07, 0xC0, 0xF8, 0x0F, 0xE0, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFD, 0xF0, 0x3F, 0xF8, 0xF8, 0x1F, 0xE0, 0xFC, 0x7E, 0xF9, 0xF3, 0xEF,
  0xDF, 0xBF, 0x7C, 0xF9, 0xF3, 0xE7, 0x8F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x78, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x04, 0x07, 0x80,
  0x8E, 0x0F, 0x07, 0x3F, 0x1E, 0x3F, 0x7F, 0xB9, 0xFF, 0xFF, 0xBF, 0xFC,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0xF7, 0x80, 0x03, 0xE7, 0x80, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x80, 0xFC,
  0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xC0, 0x78, 0x01, 0x80, 0x60, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x80, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0xC0, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xC0, 0x04, 0x1F, 0x9F, 0xCF, 0xF7, 0xFF, 0xF9, 0xFC, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xF8, 0x1F,
  0x87, 0xE0, 0x1F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xFC,
  0xFC, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC2, 0x0F, 0x8F,
  0x9F, 0x1F, 0x1F, 0x3E, 0x7E, 0x7E, 0x7C, 0xF8, 0xF8, 0xF9, 0xF1, 0xF0,
  0xE3, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F,
  0x83, 0xF8, 0x7F, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xE7, 0xC0, 0x3E, 0x3E, 0x03, 0xC1, 0xF0,
  0x1C, 0x1F, 0x80, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0x80,
  0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xF8, 0x03,
  0xF1, 0xF8, 0x0F, 0xC3, 0xF8, 0x3F, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xE1, 0xF8, 0x1F,
  0x8F, 0xE0, 0x7E, 0x3F, 0x01, 0xF9, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F,
  0x00, 0x7C, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x1C, 0x00, 0xF9, 0xFE, 0x01, 0xF7, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xC1,
  0xFC, 0x7F, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xDF, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x7F,
  0x83, 0xF9, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x7E, 0xFC, 0x03, 0xF3,
  0xF0, 0x0F, 0xC7, 0xF0, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x1F,
  0xBF, 0x00, 0xFC, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x7C, 0x07, 0xE1, 0xF8, 0x07, 0xF3,
  0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x0F, 0xE7, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7E, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x87, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7E, 0x07, 0xF3,
  0xF0, 0x0F, 0xCF, 0x80, 0x1F, 0x7E, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0,
  0x07, 0xDF, 0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x3F,
  0x9F, 0xE3, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xEF, 0x81, 0xFF, 0x7E, 0x01,
  0xF3, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xC1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0x83, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0xFC, 0x3F, 0x87, 0xF9, 0xFE, 0x1F, 0xC3, 0xF0, 0x00, 0xF8, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x10, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0x10, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x78, 0x7C, 0x00,
  0x0F, 0x0F, 0x01, 0xF9, 0xE1, 0xE0, 0x7F, 0xBC, 0x7C, 0x1F, 0xF7, 0x8F,
  0x87, 0xE3, 0xE1, 0xF0, 0xF0, 0x7C, 0x3C, 0x3E, 0x07, 0x87, 0x87, 0xC1,
  0xF0, 0xF0, 0xF8, 0x3E, 0x3E, 0x1E, 0x07, 0xC7, 0xC3, 0xC0, 0xF8, 0xF8,
  0x78, 0x1E, 0x1E, 0x1F, 0x03, 0xC3, 0xC3, 0xE0, 0x78, 0x78, 0x7C, 0x1F,
  0x0F, 0x0F, 0x83, 0xE3, 0xE1, 0xFF, 0xFC, 0x7C, 0x1F, 0xFF, 0x0F, 0x81,
  0xFD, 0xE1, 0xF0, 0x1C, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xE1,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F,
  0x7C, 0x00, 0x7C, 0xF0, 0x03, 0xF3, 0xC0, 0x0F, 0x8F, 0x00, 0x3E, 0x3E,
  0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xF8, 0x3E, 0x03,
  0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xC0, 0x1F, 0x3F, 0x00, 0x7C,
  0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0x7C, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xC0, 0xFF, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x7E, 0x0F, 0x80, 0xFC, 0x1F, 0x87, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0x01, 0xF8, 0x3F,
  0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7C,
  0x1F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0xFC,
  0x01, 0xF1, 0xF8, 0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xFC, 0xFF, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80,
  0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x1F, 0x00,
  0x7C, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00,
  0xFC, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x7E, 0x01,
  0xF8, 0x7E, 0x07, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F,
  0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0xFE, 0x3E,
  0x1F, 0xFC, 0xFC, 0x3F, 0xF1, 0xF8, 0x7F, 0xE3, 0xF1, 0xFF, 0xC7, 0xC0,
  0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0xFC, 0x01,
  0xF1, 0xF8, 0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xF8, 0x7F, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x1F,
  0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x03,
  0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x0F, 0x80,
  0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x0F, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x03,
  0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xF0,
  0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x3E,
  0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3F, 0x01,
  0xF8, 0x1F, 0xE3, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0,
  0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xE0,
  0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x07,
  0xC0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x0F, 0x80, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x07, 0xE0,
  0x7C, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0,
  0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F,
  0xF0, 0xFE, 0x07, 0x78, 0x7F, 0x87, 0xFC, 0x7F, 0xC3, 0xFC, 0x3D, 0xE3,
  0xDE, 0x1E, 0x71, 0xEF, 0x0F, 0x38, 0xEF, 0x87, 0x9C, 0xF7, 0xC3, 0xCE,
  0x73, 0xE3, 0xE7, 0xF9, 0xE1, 0xF3, 0xF8, 0xF0, 0xF9, 0xFC, 0xF8, 0x7C,
  0xFE, 0x7C, 0x3E, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x1F, 0x80, 0x1F, 0x8F,
  0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x0F, 0x83, 0xF8, 0x07, 0xC1, 0xFC, 0x07, 0xC0, 0xFE,
  0x03, 0xE0, 0xFF, 0x81, 0xF0, 0x7F, 0xC0, 0xF8, 0x3F, 0xE0, 0x7C, 0x1E,
  0xF0, 0x3E, 0x0F, 0x78, 0x3E, 0x07, 0xBE, 0x1F, 0x07, 0xDF, 0x0F, 0x83,
  0xE7, 0x87, 0xC1, 0xF3, 0xC3, 0xE0, 0xF9, 0xE1, 0xF0, 0x7C, 0xF0, 0xF0,
  0x3E, 0x7C, 0xF8, 0x3E, 0x1E, 0x7C, 0x1F, 0x0F, 0x3E, 0x0F, 0x87, 0x9F,
  0x07, 0xC3, 0xCF, 0x83, 0xE1, 0xF7, 0x81, 0xF0, 0x7B, 0xC0, 0xF0, 0x3D,
  0xE0, 0xF8, 0x1E, 0xF0, 0x7C, 0x0F, 0xF8, 0x3E, 0x07, 0xFC, 0x1F, 0x03,
  0xFE, 0x0F, 0x80, 0xFE, 0x07, 0xC0, 0x7F, 0x07, 0xC0, 0x3F, 0x83, 0xE0,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0,
  0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF8, 0x03,
  0xE3, 0xF0, 0x07, 0xC7, 0xE0, 0x1F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xF0, 0x0F, 0xC7,
  0xC0, 0x1F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0xFC,
  0x03, 0xF1, 0xF8, 0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xF8, 0xFF, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7C,
  0x1F, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F,
  0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC1, 0xFC, 0x1F, 0x87, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x00,
  0x7E, 0x3E, 0x00, 0xFC, 0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xF0, 0x07,
  0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7E, 0x7E, 0x00, 0xF8,
  0xFC, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F,
  0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xFC, 0x01, 0xF1, 0xF8,
  0x07, 0xE3, 0xF0, 0x1F, 0x83, 0xF8, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7C, 0x1F, 0xF0, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0,
  0x0F, 0x83, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x0F, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xE0, 0xFC, 0x01,
  0xF0, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x1F,
  0x03, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xE0,
  0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7C, 0x00,
  0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x8F, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x00,
  0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x01,
  0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xF3,
  0xE0, 0x07, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xE1, 0xF0,
  0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E,
  0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3C, 0x1F, 0x07, 0xCF, 0x07, 0xC1, 0xF3, 0xC1, 0xF0, 0x78, 0xF0, 0x7C,
  0x1E, 0x7C, 0x3F, 0x0F, 0x9F, 0x0F, 0xC3, 0xE7, 0xC3, 0xF0, 0xF1, 0xF1,
  0xDC, 0x3C, 0x7C, 0x77, 0x1F, 0x1F, 0x1D, 0xC7, 0xC7, 0xC7, 0x71, 0xE1,
  0xE3, 0x9C, 0x78, 0x78, 0xE7, 0x3E, 0x1E, 0x39, 0xCF, 0x87, 0x8E, 0x73,
  0xC1, 0xE7, 0x1C, 0xF0, 0x79, 0xC7, 0x7C, 0x1E, 0x71, 0x9E, 0x07, 0xB8,
  0x67, 0x81, 0xEE, 0x39, 0xE0, 0x7B, 0x8E, 0xF8, 0x1E, 0xE3, 0xBC, 0x0F,
  0xF0, 0xEF, 0x03, 0xFC, 0x3B, 0xC0, 0xF7, 0x0E, 0xF0, 0x3D, 0xC3, 0xF8,
  0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x03,
  0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x0F,
  0xC3, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7E, 0xFC,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x7E,
  0x7C, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0xC0,
  0x1F, 0x8F, 0x80, 0x0F, 0x9F, 0x80, 0x0F, 0x9F, 0x00, 0x0F, 0xBE, 0x00,
  0x07, 0xBE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7E, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x03, 0xE7, 0xC0,
  0x3E, 0x7C, 0x07, 0xC3, 0xC0, 0xF8, 0x3C, 0x0F, 0x83, 0xE1, 0xF0, 0x3E,
  0x1F, 0x03, 0xE3, 0xE0, 0x1F, 0x7E, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF8, 0x7E, 0x1F, 0x87, 0xC3, 0xF0, 0xFC, 0x00, 0xFC, 0x7C, 0x0F, 0xF9,
  0xF0, 0x7F, 0xF7, 0xC3, 0xFF, 0xDF, 0x1F, 0xFF, 0xFC, 0x7E, 0x07, 0xF3,
  0xF0, 0x1F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0,
  0x1F, 0x9F, 0x80, 0x7E, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0x7C, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x1F,
  0xC7, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xEF, 0x83, 0xFF, 0x3E, 0x07, 0xF9,
  0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC3, 0xF0,
  0x0F, 0x9F, 0xF0, 0x1F, 0x7F, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1,
  0xFC, 0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xE0,
  0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x01,
  0xF8, 0xFE, 0x07, 0xE1, 0xFE, 0x1F, 0xC3, 0xEF, 0xFF, 0x07, 0xDF, 0xFC,
  0x0F, 0xBF, 0xF0, 0x3F, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7E, 0x07, 0xE3,
  0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x01, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x7F, 0x1F,
  0xC3, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x7C, 0x03, 0xFE, 0x7C, 0x07, 0xFF, 0x7C, 0x0F, 0xFF, 0x7C, 0x1F, 0xFF,
  0xFC, 0x1F, 0x81, 0xFC, 0x3F, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0x7F, 0x1F, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFB, 0xE0, 0x3F, 0xF3, 0xE0, 0x1F, 0xE7, 0xE0, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xC3, 0xF8,
  0x7C, 0x07, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF9, 0xF8,
  0x03, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x47,
  0xC0, 0x3E, 0x1F, 0x81, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x7C, 0x0F, 0xF9, 0xF0, 0x7F, 0xF7, 0xC3, 0xFF,
  0xDF, 0x1F, 0xFF, 0xFC, 0x7E, 0x07, 0xF3, 0xF0, 0x1F, 0x8F, 0x80, 0x3E,
  0x3E, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7C,
  0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0x7E, 0x03,
  0xF1, 0xFC, 0x3F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFE, 0xF8, 0x3F, 0xFB, 0xE0,
  0x7F, 0xCF, 0x80, 0x30, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x0F, 0x9F, 0xF0, 0x1F, 0x7F, 0xF0, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0,
  0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0xFC, 0x03,
  0xF1, 0xF8, 0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xC3,
  0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0xFC, 0x1F, 0x01,
  0xFC, 0x1F, 0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F,
  0xE0, 0x3E, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x1F,
  0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07,
  0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x03,
  0xF0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0x1E, 0x3E, 0x07, 0xBF, 0x3F, 0x83, 0xDF, 0xDF,
  0xC1, 0xFF, 0xFF, 0xF1, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x7C, 0x7C, 0x3C,
  0x3C, 0x3E, 0x1E, 0x1E, 0x1F, 0x0E, 0x1F, 0x0F, 0x0F, 0x0F, 0x8F, 0x87,
  0x87, 0xC7, 0xC3, 0xC3, 0xE3, 0xE1, 0xE1, 0xF1, 0xF0, 0xF0, 0xF0, 0xF8,
  0x70, 0xF8, 0x78, 0x78, 0x7C, 0x3C, 0x3C, 0x3E, 0x3E, 0x1E, 0x1F, 0x1F,
  0x0F, 0x0F, 0x8F, 0x87, 0x87, 0x87, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE1,
  0xE1, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x3F, 0xE0,
  0x3E, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F, 0x87,
  0xE0, 0x3F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C,
  0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07,
  0xE3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x7E, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3E, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0x9F, 0x80, 0x7E,
  0x7C, 0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xFC,
  0x01, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x7E, 0x1F, 0xC7, 0xF8, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xC3, 0xF0,
  0x07, 0xCF, 0xF8, 0x07, 0xDF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E,
  0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C,
  0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xF8, 0x3F, 0xC3, 0xF8, 0x3E, 0xFF, 0xF0,
  0x3E, 0xFF, 0xE0, 0x3E, 0xFF, 0xC0, 0x7E, 0x7F, 0x80, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x7C,
  0x0F, 0xF9, 0xF0, 0x7F, 0xF7, 0xC3, 0xFF, 0xDF, 0x1F, 0xFF, 0xFC, 0x7E,
  0x07, 0xF3, 0xF0, 0x1F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF9, 0xF8, 0x03,
  0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x1F, 0x3F, 0x00, 0x7C, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0,
  0x7E, 0x1F, 0xC7, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xEF, 0x83, 0xFF, 0x3E,
  0x07, 0xF9, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x0F, 0x8F, 0xE0, 0x1F, 0x3F, 0xE0, 0x3E, 0xFF, 0xE0, 0xFB, 0xFF,
  0xE1, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x8F, 0x80, 0x3F,
  0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7C, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xCF,
  0x80, 0x3F, 0x3F, 0x01, 0xFC, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x1F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xE0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E,
  0x7E, 0x01, 0xF9, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C,
  0x03, 0xF1, 0xF0, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0xC7, 0xF8, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7C, 0xFC, 0x03, 0xF3, 0xF0,
  0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x3E,
  0x07, 0xE0, 0xF8, 0x1F, 0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0xFC, 0x03,
  0xE3, 0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0x7C, 0x00, 0xFD, 0xF0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0xF0, 0x3C, 0x1F, 0xF0, 0x7C, 0x1E, 0xF0, 0x7C, 0x1E,
  0xF0, 0x7C, 0x1E, 0xF0, 0xFC, 0x3C, 0xF0, 0xFC, 0x3C, 0xF0, 0xDC, 0x3C,
  0xF1, 0xDC, 0x7C, 0xF1, 0xDC, 0x78, 0xF1, 0xDC, 0x78, 0xF3, 0x9C, 0xF8,
  0xF3, 0x9C, 0xF0, 0xF3, 0x9C, 0xF0, 0xF7, 0x1C, 0xF0, 0xF7, 0x1D, 0xE0,
  0xF7, 0x1D, 0xE0, 0xF6, 0x1D, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80,
  0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0, 0x7E, 0x03,
  0xF0, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x1F,
  0x9F, 0x80, 0x03, 0xEF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x01, 0xF9,
  0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x7C,
  0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xF8,
  0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF9, 0xF8, 0x07,
  0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0x7E, 0x07, 0xF1, 0xFE, 0x7F, 0xC7, 0xFF,
  0xFE, 0x0F, 0xFE, 0xF8, 0x3F, 0xF3, 0xE0, 0x3F, 0x8F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x20, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x7C, 0xFF,
  0xE0, 0xFB, 0xFF, 0xC1, 0xE7, 0xCF, 0xC3, 0xCF, 0x0F, 0xDF, 0xBE, 0x0F,
  0xFE, 0x7C, 0x1F, 0xFC, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0x80,
};

const GFXglyph JetBrainsMono_BoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 11, 31, 26, 8, -31 },
  { 44, 16, 13, 26, 7, -31 },
  { 70, 27, 31, 26, 0, -31 },
  { 175, 24, 43, 26, 1, -37 },
  { 304, 31, 32, 26, -2, -32 },
  { 428, 24, 32, 26, 1, -32 },
  { 524, 7, 13, 26, 12, -31 },
  { 536, 19, 41, 26, 6, -36 },
  { 634, 18, 41, 26, 2, -36 },
  { 727, 23, 22, 26, 2, -26 },
  { 791, 22, 20, 26, 2, -24 },
  { 846, 13, 14, 26, 3, -7 },
  { 869, 15, 5, 26, 6, -17 },
  { 879, 9, 8, 26, 7, -8 },
  { 888, 27, 41, 26, 0, -36 },
  { 1027, 23, 32, 26, 2, -32 },
  { 1119, 21, 31, 26, 2, -31 },
  { 1201, 24, 32, 26, 1, -32 },
  { 1297, 23, 31, 26, 2, -31 },
  { 1387, 22, 31, 26, 2, -31 },
  { 1473, 23, 31, 26, 2, -31 },
  { 1563, 22, 31, 26, 2, -31 },
  { 1649, 22, 31, 26, 4, -31 },
  { 1735, 24, 32, 26, 1, -32 },
  { 1831, 22, 32, 26, 3, -32 },
  { 1919, 11, 24, 26, 7, -24 },
  { 1952, 15, 31, 26, 4, -24 },
  { 2011, 22, 24, 26, 3, -26 },
  { 2077, 21, 16, 26, 3, -22 },
  { 2119, 21, 24, 26, 2, -26 },
  { 2182, 19, 31, 26, 5, -31 },
  { 2256, 27, 40, 26, 0, -32 },
  { 2391, 22, 31, 26, 0, -31 },
  { 2477, 24, 31, 26, 1, -31 },
  { 2570, 23, 32, 26, 2, -32 },
  { 2662, 24, 31, 26, 1, -31 },
  { 2755, 24, 31, 26, 2, -31 },
  { 2848, 24, 31, 26, 2, -31 },
  { 2941, 23, 32, 26, 2, -32 },
  { 3033, 25, 31, 26, 1, -31 },
  { 3130, 23, 31, 26, 2, -31 },
  { 3220, 25, 31, 26, 0, -31 },
  { 3317, 26, 31, 26, 1, -31 },
  { 3418, 19, 31, 26, 3, -31 },
  { 3492, 25, 31, 26, 1, -31 },
  { 3589, 25, 31, 26, 1, -31 },
  { 3686, 23, 32, 26, 2, -32 },
  { 3778, 25, 31, 26, 1, -31 },
  { 3875, 23, 40, 26, 2, -32 },
  { 3990, 25, 31, 26, 1, -31 },
  { 4087, 24, 32, 26, 1, -32 },
  { 4183, 23, 31, 26, 4, -31 },
  { 4273, 24, 31, 26, 2, -31 },
  { 4366, 22, 31, 26, 5, -31 },
  { 4452, 26, 31, 26, 2, -31 },
  { 4553, 28, 31, 26, -1, -31 },
  { 4662, 24, 31, 26, 4, -31 },
  { 4755, 23, 31, 26, 2, -31 },
  { 4845, 19, 41, 26, 5, -36 },
  { 4943, 15, 41, 26, 6, -36 },
  { 5020, 19, 41, 26, 3, -36 },
  { 5118, 20, 16, 26, 3, -31 },
  { 5158, 21, 5, 26, 0, 1 },
  { 5172, 9, 6, 26, 11, -34 },
  { 5179, 22, 24, 26, 2, -24 },
  { 5245, 23, 31, 26, 1, -31 },
  { 5335, 22, 24, 26, 2, -24 },
  { 5401, 24, 31, 26, 2, -31 },
  { 5494, 22, 24, 26, 2, -24 },
  { 5560, 29, 39, 26, -2, -31 },
  { 5702, 22, 32, 26, 2, -24 },
  { 5790, 23, 31, 26, 1, -31 },
  { 5880, 22, 34, 26, 1, -34 },
  { 5974, 24, 42, 26, 0, -34 },
  { 6100, 24, 31, 26, 2, -31 },
  { 6193, 19, 31, 26, 4, -31 },
  { 6267, 25, 24, 26, 0, -24 },
  { 6342, 23, 24, 26, 1, -24 },
  { 6411, 22, 24, 26, 2, -24 },
  { 6477, 24, 32, 26, 0, -24 },
  { 6573, 22, 32, 26, 2, -24 },
  { 6661, 23, 24, 26, 2, -24 },
  { 6730, 22, 24, 26, 2, -24 },
  { 6796, 22, 30, 26, 3, -30 },
  { 6879, 22, 24, 26, 2, -24 },
  { 6945, 22, 24, 26, 4, -24 },
  { 7011, 24, 24, 26, 3, -24 },
  { 7083, 26, 24, 26, 0, -24 },
  { 7161, 22, 32, 26, 2, -24 },
  { 7249, 23, 24, 26, 1, -24 },
  { 7318, 22, 41, 26, 4, -36 },
  { 7431, 11, 41, 26, 8, -36 },
  { 7488, 22, 41, 26, 1, -36 },
  { 7601, 23, 10, 26, 2, -20 },
};

const GFXfont JetBrainsMono_BoldItalic43pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic43pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _JETBRAINSMONO_BOLDITALIC43PT7B_H_
