#ifndef _JETBRAINSMONO_BOLDITALIC56PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xE3,
  0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x7F, 0x83, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0,
  0x7F, 0x9F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xE0, 0x7F,
  0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F,
  0x01, 0xF0, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0x3D, 0xFF, 0x03, 0xFC,
  0x71, 0xFE, 0x07, 0xF0, 0xE1, 0xFC, 0x0F, 0xE1, 0xC3, 0xF8, 0x3F, 0x87,
  0x87, 0xF0, 0x7F, 0x0F, 0x00, 0x00, 0xFE, 0x1E, 0x00, 0x01, 0xFE, 0x38,
  0x00, 0x03, 0xFC, 0x70, 0x00, 0x07, 0xFC, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0x3F, 0xE0,
  0x00, 0x1C, 0x3F, 0xC0, 0x00, 0x38, 0x7F, 0x80, 0x00, 0x70, 0x7F, 0x00,
  0x01, 0xE0, 0xFE, 0x3F, 0xC3, 0xC1, 0xFC, 0x7F, 0x07, 0x87, 0xF0, 0xFF,
  0x0E, 0x0F, 0xE1, 0xFE, 0x1C, 0x3F, 0xC1, 0xFE, 0x38, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x1F,
  0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0x80,
  0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x0F, 0x80,
  0x07, 0xC0, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0x03, 0xE0,
  0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x07,
  0xC0, 0x00, 0x7C, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x07, 0xC7, 0xC0, 0x00,
  0x1F, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0xFF, 0xE7, 0xC0, 0x00, 0x03, 0xFF,
  0xE7, 0xE0, 0x00, 0x01, 0xFF, 0xE7, 0xE0, 0x00, 0x00, 0x3F, 0xE3, 0xE0,
  0x00, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xFE, 0x00, 0x00, 0x01, 0xF3, 0xFF,
  0xC0, 0x00, 0x01, 0xF3, 0xFF, 0xE0, 0x00, 0x01, 0xF3, 0xFF, 0xF8, 0x00,
  0x01, 0xF1, 0xF0, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x3E, 0x00, 0x01, 0xF8,
  0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x07,
  0xC0, 0x00, 0xF8, 0x1E, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x00,
  0xF8, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xFC,
  0x00, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0x8F, 0xF0,
  0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x03, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0x1F, 0xFF, 0xC0, 0xFE, 0x3F, 0xDF, 0xE0, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC,
  0x3F, 0x07, 0xF3, 0xF8, 0x7F, 0x07, 0xF3, 0xF0, 0x7F, 0x03, 0xFF, 0xF0,
  0x7F, 0x03, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xC0, 0x7E, 0x01, 0xFF, 0xC0,
  0x7E, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x87, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xEF, 0xE0, 0x3F, 0xFF, 0xCF, 0xE0,
  0x1F, 0xFF, 0x87, 0xF0, 0x0F, 0xFE, 0x07, 0xF8, 0x00, 0x40, 0x00, 0x00,
  0x3F, 0x9F, 0xCF, 0xE7, 0xF7, 0xFB, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F,
  0x8F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x0C, 0x01,
  0xF0, 0x06, 0x3C, 0x07, 0xC0, 0xF9, 0xFC, 0x1F, 0x0F, 0xE7, 0xFC, 0x78,
  0xFF, 0xBF, 0xF9, 0xE7, 0xFE, 0xFF, 0xF7, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF8,
  0x7F, 0x80, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0x80, 0x1E, 0x00, 0x06, 0x00, 0x20, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x07, 0x81, 0xFC, 0x3F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE,
  0x7F, 0xC3, 0xF8, 0x04, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x0F,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x3E, 0x1F,
  0xC3, 0xF9, 0xFC, 0x7F, 0x0F, 0xC7, 0xF1, 0xFC, 0x3F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0x87, 0xF1, 0xFC, 0x7E, 0x1F, 0xC3, 0xE3, 0xF8, 0x7F,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFE, 0x3F, 0x80,
  0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x01, 0xFE,
  0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xF7, 0xF0, 0x07, 0xF8,
  0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0x03, 0xF8, 0x03, 0xC0, 0x7F, 0x00,
  0x60, 0x1F, 0xC0, 0x18, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC,
  0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x10,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x02, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF8,
  0xFF, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F,
  0xFC, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x50,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x0F,
  0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x00,
  0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0x7F,
  0x1F, 0xC0, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF9, 0xFF, 0xC0, 0x1F, 0xDF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x1F,
  0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x1F,
  0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xE0,
  0x3F, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xDF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0xFF, 0x80, 0x7F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF3, 0xF8,
  0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xE0, 0x01, 0xFC,
  0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF,
  0xE7, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x40, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07,
  0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8,
  0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x03,
  0xFC, 0x3F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xFE,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x7F,
  0xC0, 0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF9, 0xFC, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F,
  0xBF, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0xFE,
  0x01, 0xFF, 0xEF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x0F, 0xF8, 0x0F, 0xE0, 0x02, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0x00, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x04,
  0x1F, 0x83, 0xE0, 0x0F, 0xF3, 0xF0, 0xFC, 0x03, 0xFF, 0x7E, 0x1F, 0x80,
  0xFF, 0xEF, 0x83, 0xF0, 0x3F, 0xFF, 0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC1, 0xF8, 0x0F, 0xC1, 0xF0, 0x3F, 0x01, 0xF8, 0x7E, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC1, 0xF8, 0x07, 0xC1, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x07, 0xE0,
  0x3F, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xF8, 0x1F, 0x00, 0xFC, 0x1F, 0x07,
  0xE0, 0x1F, 0x87, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x1F, 0x80, 0x7C, 0x1F,
  0x83, 0xF0, 0x1F, 0x83, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xFE,
  0x0F, 0x81, 0xFE, 0x7F, 0xC3, 0xF0, 0x1F, 0xFE, 0xF8, 0x7E, 0x03, 0xFF,
  0xBE, 0x0F, 0xC0, 0x3F, 0xE7, 0xC1, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7F,
  0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x1F,
  0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x7F, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8,
  0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x3F,
  0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x81, 0xFC, 0x01, 0xFF, 0x03, 0xF8, 0x01,
  0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x07,
  0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0x83,
  0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0xC3, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x03, 0xF8, 0x03, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F,
  0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0,
  0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0x81, 0xFC,
  0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xC0, 0xFF, 0x83, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0xFF, 0xFC, 0x3F, 0x83, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF, 0xC7,
  0xF0, 0x7F, 0xFE, 0x1F, 0xC1, 0xFF, 0xF8, 0x7F, 0x07, 0xFF, 0xE1, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07,
  0xF0, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0xFE,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F,
  0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x03,
  0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x81,
  0xF7, 0x80, 0x7F, 0xE0, 0x7D, 0xE0, 0x3F, 0xF0, 0x1F, 0x78, 0x0F, 0x7C,
  0x07, 0xDF, 0x07, 0xDF, 0x01, 0xF7, 0xC1, 0xFF, 0xC0, 0x7D, 0xF0, 0xFB,
  0xF0, 0x3F, 0x7C, 0x3E, 0xFC, 0x0F, 0xCF, 0x1F, 0x3F, 0x03, 0xF3, 0xC7,
  0xCF, 0x80, 0xFC, 0xF1, 0xE7, 0xE0, 0x3F, 0x3C, 0xF9, 0xF8, 0x0F, 0xCF,
  0xBC, 0x7E, 0x07, 0xF3, 0xFF, 0x1F, 0x81, 0xF8, 0xFF, 0xCF, 0xE0, 0x7E,
  0x3F, 0xE3, 0xF0, 0x1F, 0x87, 0xF8, 0xFC, 0x07, 0xE1, 0xFC, 0x3F, 0x01,
  0xF8, 0x7F, 0x0F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0x03, 0xFE, 0x00, 0x7E, 0x03, 0xFE, 0x00, 0x7E, 0x03, 0xFE, 0x00,
  0x7E, 0x07, 0xFE, 0x00, 0x7E, 0x07, 0xFF, 0x00, 0xFE, 0x07, 0xFF, 0x00,
  0xFE, 0x07, 0xFF, 0x00, 0xFC, 0x07, 0xDF, 0x00, 0xFC, 0x07, 0xDF, 0x00,
  0xFC, 0x0F, 0xDF, 0x00, 0xFC, 0x0F, 0xDF, 0x81, 0xFC, 0x0F, 0xDF, 0x81,
  0xFC, 0x0F, 0xCF, 0x81, 0xF8, 0x0F, 0xCF, 0x81, 0xF8, 0x0F, 0xCF, 0x81,
  0xF8, 0x1F, 0xCF, 0xC1, 0xF8, 0x1F, 0xCF, 0xC3, 0xF8, 0x1F, 0xCF, 0xC3,
  0xF8, 0x1F, 0x87, 0xC3, 0xF8, 0x1F, 0x87, 0xC3, 0xF0, 0x1F, 0x87, 0xE3,
  0xF0, 0x3F, 0x87, 0xE3, 0xF0, 0x3F, 0x87, 0xE3, 0xF0, 0x3F, 0x83, 0xE7,
  0xF0, 0x3F, 0x03, 0xE7, 0xF0, 0x3F, 0x03, 0xE7, 0xE0, 0x3F, 0x03, 0xF7,
  0xE0, 0x3F, 0x03, 0xF7, 0xE0, 0x7F, 0x03, 0xF7, 0xE0, 0x7F, 0x01, 0xF7,
  0xE0, 0x7E, 0x01, 0xF7, 0xE0, 0x7E, 0x01, 0xFF, 0xC0, 0x7E, 0x01, 0xFF,
  0xC0, 0x7E, 0x01, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0xFF,
  0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0xFC, 0x00, 0xFF, 0xC0, 0xFC, 0x00, 0xFF,
  0x80, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07,
  0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0,
  0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07,
  0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0,
  0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07,
  0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xC0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xF0, 0x1F, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0,
  0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF,
  0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE1,
  0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE,
  0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00,
  0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x81, 0xFC, 0x03,
  0xFF, 0x03, 0xF8, 0x01, 0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFE,
  0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xF0, 0x7F, 0x01, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8,
  0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x01,
  0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8,
  0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07,
  0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFC, 0xFE,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0,
  0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x01, 0xFC,
  0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x00,
  0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0xFE,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x7E, 0x7F, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x0F, 0xCF, 0xC0,
  0xFE, 0x07, 0xE3, 0xF0, 0x3F, 0x81, 0xF8, 0xFC, 0x0F, 0xE0, 0x7E, 0x3F,
  0x03, 0xF8, 0x1F, 0x8F, 0x81, 0xFE, 0x0F, 0xC3, 0xE0, 0x7F, 0x83, 0xF1,
  0xF8, 0x1D, 0xE0, 0xFC, 0x7E, 0x0F, 0x70, 0x3F, 0x1F, 0x83, 0xDC, 0x1F,
  0x87, 0xE0, 0xF7, 0x07, 0xE1, 0xF8, 0x39, 0xC1, 0xF8, 0x7E, 0x1E, 0x70,
  0x7C, 0x1F, 0x87, 0xBC, 0x3F, 0x07, 0xE1, 0xEF, 0x0F, 0xC1, 0xF8, 0x73,
  0xC3, 0xF0, 0x7E, 0x3C, 0xF0, 0xF8, 0x1F, 0x8F, 0x3C, 0x7E, 0x07, 0xC3,
  0xCF, 0x1F, 0x81, 0xF1, 0xE3, 0xC7, 0xE0, 0x7C, 0x78, 0xF1, 0xF0, 0x1F,
  0x1E, 0x3C, 0xFC, 0x07, 0xC7, 0x0F, 0x3F, 0x01, 0xF3, 0xC3, 0xCF, 0xC0,
  0x7C, 0xF0, 0xF3, 0xE0, 0x3F, 0x3C, 0x3C, 0xF8, 0x0F, 0xDE, 0x0F, 0x7E,
  0x03, 0xF7, 0x83, 0xDF, 0x00, 0xFD, 0xE0, 0xE7, 0xC0, 0x3F, 0x78, 0x39,
  0xF0, 0x0F, 0xFC, 0x0E, 0xFC, 0x03, 0xFF, 0x03, 0xBE, 0x00, 0xFB, 0xC0,
  0xEF, 0x80, 0x3E, 0xE0, 0x7B, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xEF, 0xF0, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x0F, 0xF1, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFE,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x3F, 0x01, 0xFC,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x1F, 0x87,
  0xF0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0xE1, 0xFC, 0x03, 0xFF, 0xC7,
  0xF0, 0x1F, 0xFF, 0xBF, 0x80, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0x83, 0xFC, 0x03, 0xFE, 0x1F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0xFF, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F,
  0xC0, 0x7F, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFD, 0xFC, 0x0F, 0xFF,
  0xF7, 0xE0, 0x1F, 0xFF, 0xBF, 0x80, 0x3F, 0xFC, 0xFE, 0x00, 0x7F, 0xC3,
  0xF8, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xC7, 0xFF,
  0x80, 0xFE, 0x7F, 0xFE, 0x07, 0xF7, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x87, 0xF8,
  0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1,
  0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x03,
  0xFC, 0x7F, 0x80, 0x1F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFF, 0x07, 0xEF, 0xFF, 0xF0, 0x7F, 0x7F, 0xFF, 0x83, 0xF9,
  0xFF, 0xF8, 0x1F, 0xCF, 0xFF, 0x00, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F,
  0xF0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3, 0xF8, 0x00,
  0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xF0,
  0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x3F, 0x80,
  0x7F, 0xF8, 0xFE, 0x03, 0xFF, 0xF7, 0xF0, 0x1F, 0xFF, 0xDF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0x80,
  0x7F, 0xC3, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F,
  0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8,
  0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F,
  0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0,
  0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x01,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xBF,
  0x81, 0xFF, 0xFE, 0xFC, 0x03, 0xFF, 0xF7, 0xF0, 0x07, 0xFF, 0x9F, 0xC0,
  0x0F, 0xF8, 0x7F, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0x83, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFC, 0x00, 0xFE,
  0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE3, 0xF0,
  0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x07,
  0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC3, 0xF8, 0x0F, 0xFF, 0x1F, 0xC0, 0xFF,
  0xFD, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x7F, 0xC0, 0xFF, 0xC3, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x0F, 0xE1,
  0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF1,
  0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF,
  0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFD,
  0xFC, 0x07, 0xFF, 0xCF, 0xE0, 0x1F, 0xFC, 0xFE, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x3F, 0xC0,
  0x0F, 0xC7, 0xFF, 0x80, 0xFE, 0x7F, 0xFE, 0x07, 0xF7, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0x80,
  0x7F, 0x87, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F,
  0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x7F, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x07,
  0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0x7F,
  0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F,
  0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xE3,
  0xE0, 0xFC, 0x03, 0xF7, 0xF8, 0xFF, 0x01, 0xFB, 0xFC, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F,
  0x83, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3F, 0x07,
  0xE0, 0xF8, 0x3F, 0x83, 0xF0, 0x7C, 0x1F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1,
  0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF8,
  0x3F, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0xFE, 0x0F, 0xC1, 0xF0, 0x7E,
  0x0F, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xF0, 0x7E, 0x0F, 0x83,
  0xF0, 0x7F, 0x07, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0xFC, 0x1F, 0x81, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x83, 0xF0, 0x7C,
  0x1F, 0xC3, 0xF8, 0x3E, 0x0F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x1F,
  0xFE, 0x03, 0xF9, 0xFF, 0xF8, 0x1F, 0xDF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFE, 0x01, 0xFE, 0x1F,
  0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x1F,
  0xC7, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x8F,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1,
  0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80,
  0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE,
  0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xC7, 0xF0,
  0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F,
  0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF,
  0x80, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x05, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF1, 0xFF, 0xE0, 0x0F,
  0xE7, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x07, 0xF8,
  0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80,
  0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF8,
  0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7E, 0xFF, 0xFF, 0x01,
  0xFD, 0xFF, 0xFE, 0x03, 0xF9, 0xFF, 0xF8, 0x07, 0xF3, 0xFF, 0xC0, 0x0F,
  0xE3, 0xFF, 0x00, 0x1F, 0xC0, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0xFC, 0x03, 0xFF,
  0xC7, 0xF0, 0x1F, 0xFF, 0xBF, 0x80, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0x83, 0xFC, 0x03, 0xFE,
  0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07,
  0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0x87, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFD, 0xFC, 0x0F,
  0xFF, 0xF7, 0xE0, 0x1F, 0xFF, 0xBF, 0x80, 0x3F, 0xFC, 0xFE, 0x00, 0x7F,
  0xC3, 0xF8, 0x00, 0x10, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xE1, 0xFF, 0x00, 0x3F, 0x8F, 0xFF, 0x00,
  0xFE, 0x7F, 0xFE, 0x03, 0xFB, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0x7F, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x1F, 0xE0,
  0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x01,
  0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3F,
  0xC0, 0x1F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x9F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xC3, 0xFE, 0x03, 0xFE, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x01, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x01,
  0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8,
  0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xF1, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8,
  0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F,
  0xCF, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE,
  0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0xFC, 0x1F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFC,
  0xFE, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x3F, 0x7C, 0x07, 0xE0, 0x3E, 0x7C,
  0x07, 0xE0, 0x3E, 0xFC, 0x0F, 0xE0, 0x7E, 0xFC, 0x0F, 0xE0, 0x7E, 0xFC,
  0x0F, 0xE0, 0x7C, 0xFC, 0x1F, 0xE0, 0xFC, 0xFC, 0x1F, 0xE0, 0xFC, 0xFC,
  0x1D, 0xE0, 0xF8, 0xFC, 0x3D, 0xE1, 0xF8, 0xFC, 0x3D, 0xE1, 0xF8, 0xFC,
  0x3D, 0xE1, 0xF0, 0xFC, 0x39, 0xE1, 0xF0, 0xFC, 0x79, 0xE3, 0xF0, 0xFC,
  0x79, 0xE3, 0xE0, 0xFC, 0x71, 0xE3, 0xE0, 0xFC, 0xF1, 0xE7, 0xE0, 0xFC,
  0xF1, 0xE7, 0xC0, 0xFC, 0xE1, 0xE7, 0xC0, 0xFD, 0xE1, 0xEF, 0xC0, 0xFD,
  0xE1, 0xEF, 0xC0, 0xFD, 0xC1, 0xEF, 0x80, 0xFF, 0xC1, 0xEF, 0x80, 0xFF,
  0xC1, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xF0,
  0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1,
  0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1,
  0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF,
  0x8F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xBF, 0x81, 0xFF, 0xF9,
  0xFC, 0x07, 0xFF, 0x8F, 0xC0, 0x1F, 0xF8, 0xFE, 0x00, 0x3E, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x0F, 0xC7, 0xFF, 0xC0, 0x7E, 0x7F, 0xFE, 0x03, 0xF7,
  0xFF, 0xF8, 0x1F, 0xBF, 0x9F, 0xE0, 0xFF, 0xF8, 0x7F, 0x0F, 0xDF, 0x81,
  0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0xE7, 0xE0, 0x3F, 0xFF, 0x3F, 0x00, 0xFF,
  0xF1, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
};

const GFXglyph JetBrainsMono_BoldItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 15, 41, 34, 10, -41 },
  { 78, 22, 17, 34, 9, -41 },
  { 125, 34, 41, 34, 1, -41 },
  { 300, 31, 57, 34, 2, -49 },
  { 521, 41, 41, 34, -3, -41 },
  { 732, 32, 42, 34, 1, -41 },
  { 900, 9, 17, 34, 15, -41 },
  { 920, 24, 54, 34, 8, -47 },
  { 1082, 24, 54, 34, 3, -47 },
  { 1244, 30, 29, 34, 3, -34 },
  { 1353, 28, 27, 34, 3, -32 },
  { 1448, 16, 17, 34, 5, -8 },
  { 1482, 20, 7, 34, 7, -22 },
  { 1500, 12, 11, 34, 9, -10 },
  { 1517, 35, 52, 34, 0, -46 },
  { 1745, 30, 42, 34, 3, -41 },
  { 1903, 27, 41, 34, 2, -41 },
  { 2042, 30, 41, 34, 2, -41 },
  { 2196, 30, 42, 34, 2, -41 },
  { 2354, 29, 41, 34, 2, -41 },
  { 2503, 29, 42, 34, 3, -41 },
  { 2656, 29, 42, 34, 2, -41 },
  { 2809, 30, 41, 34, 5, -41 },
  { 2963, 30, 42, 34, 2, -41 },
  { 3121, 29, 41, 34, 4, -41 },
  { 3270, 15, 32, 34, 9, -31 },
  { 3330, 19, 40, 34, 5, -31 },
  { 3425, 28, 31, 34, 4, -34 },
  { 3534, 28, 21, 34, 3, -29 },
  { 3608, 28, 31, 34, 2, -34 },
  { 3717, 24, 41, 34, 7, -41 },
  { 3840, 35, 51, 34, 0, -41 },
  { 4064, 30, 41, 34, -1, -41 },
  { 4218, 31, 41, 34, 2, -41 },
  { 4377, 30, 42, 34, 3, -41 },
  { 4535, 31, 41, 34, 2, -41 },
  { 4694, 31, 41, 34, 2, -41 },
  { 4853, 32, 41, 34, 2, -41 },
  { 5017, 30, 42, 34, 3, -41 },
  { 5175, 31, 41, 34, 2, -41 },
  { 5334, 30, 41, 34, 3, -41 },
  { 5488, 33, 42, 34, 0, -41 },
  { 5662, 33, 41, 34, 2, -41 },
  { 5832, 26, 41, 34, 3, -41 },
  { 5966, 34, 41, 34, 1, -41 },
  { 6141, 32, 41, 34, 2, -41 },
  { 6305, 29, 42, 34, 3, -41 },
  { 6458, 32, 41, 34, 2, -41 },
  { 6622, 30, 51, 34, 3, -41 },
  { 6814, 31, 41, 34, 2, -41 },
  { 6973, 31, 42, 34, 2, -41 },
  { 7136, 29, 41, 34, 6, -41 },
  { 7285, 31, 42, 34, 3, -41 },
  { 7448, 30, 41, 34, 6, -41 },
  { 7602, 34, 41, 34, 3, -41 },
  { 7777, 36, 41, 34, -1, -41 },
  { 7962, 31, 41, 34, 5, -41 },
  { 8121, 31, 41, 34, 2, -41 },
  { 8280, 24, 52, 34, 7, -46 },
  { 8436, 19, 52, 34, 8, -46 },
  { 8560, 24, 52, 34, 4, -46 },
  { 8716, 26, 22, 34, 4, -41 },
  { 8788, 28, 7, 34, 0, 1 },
  { 8813, 12, 8, 34, 14, -44 },
  { 8825, 30, 32, 34, 2, -31 },
  { 8945, 29, 42, 34, 2, -41 },
  { 9098, 28, 32, 34, 3, -31 },
  { 9210, 30, 42, 34, 3, -41 },
  { 9368, 28, 32, 34, 3, -31 },
  { 9480, 38, 51, 34, -3, -41 },
  { 9723, 29, 41, 34, 3, -31 },
  { 9872, 29, 41, 34, 2, -41 },
  { 10021, 28, 44, 34, 2, -44 },
  { 10175, 31, 54, 34, 0, -44 },
  { 10385, 32, 41, 34, 2, -41 },
  { 10549, 25, 41, 34, 5, -41 },
  { 10678, 33, 31, 34, 0, -31 },
  { 10806, 29, 31, 34, 2, -31 },
  { 10919, 28, 32, 34, 3, -31 },
  { 11031, 31, 41, 34, 0, -31 },
  { 11190, 30, 41, 34, 2, -31 },
  { 11344, 30, 31, 34, 3, -31 },
  { 11461, 29, 32, 34, 2, -31 },
  { 11577, 28, 39, 34, 4, -39 },
  { 11714, 29, 32, 34, 3, -31 },
  { 11830, 29, 31, 34, 5, -31 },
  { 11943, 32, 31, 34, 3, -31 },
  { 12067, 33, 31, 34, 0, -31 },
  { 12195, 29, 41, 34, 3, -31 },
  { 12344, 29, 31, 34, 2, -31 },
  { 12457, 29, 52, 34, 5, -46 },
  { 12646, 15, 52, 34, 10, -46 },
  { 12744, 29, 52, 34, 1, -46 },
  { 12933, 29, 13, 34, 3, -26 },
};

const GFXfont JetBrainsMono_BoldItalic56pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic56pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic56pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _JETBRAINSMONO_BOLDITALIC56PT7B_H_
