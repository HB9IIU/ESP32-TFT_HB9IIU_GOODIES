#ifndef _JETBRAINSMONO_BOLDITALIC54PT7B_H_
#define _JETBRAINSMONO_BOLDITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-BoldItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_BoldItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x87,
  0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0,
  0x7E, 0x7E, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE,
  0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF,
  0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F,
  0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0,
  0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80,
  0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xF7, 0xBF, 0xE0, 0x7F, 0x9E, 0x7F, 0x81, 0xFC,
  0x78, 0xFE, 0x0F, 0xE1, 0xC3, 0xF8, 0x3F, 0x87, 0x0F, 0xE0, 0xFE, 0x1C,
  0x00, 0x03, 0xF8, 0xF0, 0x00, 0x0F, 0xE3, 0xC0, 0x00, 0x3F, 0xCF, 0x00,
  0x00, 0xFF, 0xB8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xDF, 0xF8, 0x00, 0x0F, 0x1F, 0xE0, 0x00, 0x3C, 0x7F, 0x80, 0x00, 0xF0,
  0xFE, 0x00, 0x03, 0x83, 0xF8, 0xFE, 0x0E, 0x0F, 0xE3, 0xF8, 0x38, 0x3F,
  0x0F, 0xE1, 0xE1, 0xFC, 0x3F, 0xC7, 0x8F, 0xF0, 0xFF, 0x9E, 0x7F, 0x81,
  0xFF, 0xF7, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x7C, 0x01, 0xFF, 0xE0, 0x01, 0xF0, 0x07, 0xFF, 0xE0, 0x07,
  0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x7C, 0x00, 0x78,
  0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x0F,
  0x80, 0x07, 0xC0, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0xF8, 0x00, 0x1F,
  0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x1F, 0x3E,
  0x00, 0x00, 0xFF, 0xFC, 0xF8, 0x00, 0x01, 0xFF, 0xF9, 0xF0, 0x00, 0x01,
  0xFF, 0xC7, 0xC0, 0x00, 0x00, 0xFF, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x00, 0xF9,
  0xFF, 0x80, 0x00, 0x03, 0xE7, 0xFF, 0x80, 0x00, 0x0F, 0x9F, 0xFF, 0x80,
  0x00, 0x3E, 0x7F, 0x3F, 0x00, 0x00, 0xF8, 0xF8, 0x3E, 0x00, 0x03, 0xE1,
  0xE0, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0xF8, 0x00, 0x1F, 0x0F, 0x81, 0xF0,
  0x00, 0x7C, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x07, 0xC0,
  0x78, 0x0F, 0x00, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0xFC,
  0x01, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0x80,
  0x07, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0x7E, 0x07, 0xF3, 0xF9, 0xFC, 0x1F, 0x8F, 0xC3,
  0xF8, 0xFC, 0x7F, 0x0F, 0xE7, 0xF1, 0xFC, 0x1F, 0xDF, 0x87, 0xF0, 0x7F,
  0xFC, 0x1F, 0x80, 0xFF, 0xF0, 0x7E, 0x01, 0xFF, 0x81, 0xF8, 0x07, 0xFC,
  0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03,
  0xF8, 0x0F, 0xFC, 0x0F, 0xF0, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x7F, 0x01, 0xFF, 0xF0, 0xFE, 0x03, 0xFF,
  0x01, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x06, 0x01, 0xF8, 0x06, 0x1E, 0x07,
  0xC0, 0xF8, 0xFE, 0x1F, 0x0F, 0xE3, 0xFE, 0x38, 0xFF, 0x9F, 0xFC, 0xE7,
  0xFE, 0xFF, 0xFB, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xC0,
  0xFF, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x80, 0x0C,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x03, 0xF0, 0xFF, 0x3F, 0xF7,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0x87, 0xE0, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xF8, 0x1F, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0x80,
  0x07, 0xF1, 0xF8, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF1, 0xF8, 0x00, 0x7F,
  0x3F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF1,
  0xF0, 0xFE, 0x3F, 0x1F, 0x8F, 0xE3, 0xF3, 0xF8, 0xFE, 0x7F, 0x3F, 0x8F,
  0xC7, 0xF1, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC7, 0xE0, 0xE0, 0xFC, 0x7E,
  0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x01,
  0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x8F,
  0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0xC7,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xCF, 0xC0, 0x1F, 0xE7,
  0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF0, 0x7F, 0x00, 0x70, 0x1F, 0xC0, 0x38,
  0x07, 0xF0, 0x08, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x0F,
  0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x0F,
  0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC3, 0xFC, 0x01,
  0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x9F, 0xFC, 0x01, 0xFD, 0xFF, 0xF0, 0x0F,
  0xDF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC1, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x7F,
  0x83, 0xFF, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x07, 0xF7,
  0xFF, 0x00, 0xFE, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x3F, 0xF0, 0x3F, 0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xE7, 0xF0,
  0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFC, 0xFE,
  0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x87, 0xFE, 0x3F,
  0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0,
  0x01, 0xFC, 0x7E, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8,
  0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xE0, 0xFE,
  0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x03,
  0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xF7, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC1, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFF,
  0x00, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x3F, 0xE1, 0xFC, 0x00, 0xFE,
  0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x7E, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xE7, 0xF0, 0x03, 0xFC, 0x7F,
  0x80, 0x7F, 0xC7, 0xFF, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0x7F, 0x00, 0xFF, 0xEF, 0xE0, 0x01, 0xF1, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0x81, 0xFC, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x01, 0xF8, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0x7F, 0x81, 0xFC, 0x00, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x20, 0xFC, 0x7E, 0x01, 0xFE, 0x7E, 0x3F, 0x01, 0xFF, 0xBE, 0x1F, 0x81,
  0xFF, 0xDF, 0x0F, 0xC1, 0xFF, 0xFF, 0x87, 0xC0, 0xFC, 0x1F, 0xC3, 0xE0,
  0xFC, 0x07, 0xE3, 0xF0, 0x7E, 0x03, 0xF1, 0xF8, 0x3E, 0x01, 0xF0, 0xFC,
  0x1F, 0x00, 0xF8, 0x7E, 0x0F, 0x80, 0xFC, 0x3E, 0x0F, 0xC0, 0x7E, 0x1F,
  0x07, 0xE0, 0x3F, 0x0F, 0x83, 0xF0, 0x1F, 0x8F, 0xC1, 0xF8, 0x0F, 0x87,
  0xE0, 0xF8, 0x07, 0xC3, 0xF0, 0x7C, 0x07, 0xE1, 0xF8, 0x3E, 0x03, 0xF0,
  0xF8, 0x1F, 0x81, 0xF8, 0x7C, 0x0F, 0xE3, 0xFC, 0x7E, 0x07, 0xFF, 0xFE,
  0x3F, 0x03, 0xFF, 0xBE, 0x1F, 0x80, 0xFF, 0x9F, 0x0F, 0xC0, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xCF, 0x80, 0x01, 0xF8,
  0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE,
  0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x3F,
  0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xE0, 0x7E,
  0x00, 0x7F, 0x81, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7E, 0x03, 0xFF, 0x03, 0xF8,
  0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFC, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0,
  0x7E, 0x00, 0x7F, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x3F, 0xE0, 0xFC, 0x00,
  0xFF, 0x07, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE,
  0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xFC, 0x3F,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00,
  0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0x7E,
  0x1F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0xFE, 0x00,
  0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xF0, 0x7E, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F,
  0xE1, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x0F, 0xFF, 0xC3, 0xF0, 0x7F, 0xFE, 0x3F, 0x83, 0xFF,
  0xE1, 0xFC, 0x1F, 0xFF, 0x0F, 0xE0, 0xFF, 0xF8, 0x7F, 0x0F, 0xFF, 0xC3,
  0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0,
  0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xF9, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x03, 0xF8,
  0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0,
  0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03,
  0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F,
  0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0xE7, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xF0,
  0x03, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF0,
  0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0,
  0x7F, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xC1, 0xFE, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC,
  0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF,
  0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xDF, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x07, 0xFE, 0x07, 0xDE, 0x07, 0xBE, 0x0F, 0xDE, 0x0F, 0xBE,
  0x0F, 0xDE, 0x0F, 0x7E, 0x0F, 0xDE, 0x1F, 0x7E, 0x0F, 0xDE, 0x1E, 0x7C,
  0x0F, 0x9F, 0x3E, 0x7C, 0x0F, 0x9F, 0x3C, 0xFC, 0x0F, 0x9F, 0x7C, 0xFC,
  0x1F, 0x8F, 0x7C, 0xFC, 0x1F, 0x8F, 0x78, 0xFC, 0x1F, 0x8F, 0xF9, 0xF8,
  0x1F, 0x8F, 0xF1, 0xF8, 0x1F, 0x8F, 0xF1, 0xF8, 0x1F, 0x8F, 0xE1, 0xF8,
  0x3F, 0x8F, 0xE1, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0,
  0x03, 0xFC, 0x00, 0xFC, 0x1F, 0xF0, 0x03, 0xF0, 0x7F, 0xC0, 0x0F, 0xC1,
  0xFF, 0x80, 0x3F, 0x07, 0xFE, 0x01, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x7F,
  0xE0, 0x1F, 0x81, 0xFF, 0x80, 0x7E, 0x0F, 0xFF, 0x01, 0xF8, 0x3F, 0xFC,
  0x07, 0xE0, 0xFD, 0xF0, 0x1F, 0x83, 0xF7, 0xC0, 0xFE, 0x0F, 0xDF, 0x03,
  0xF0, 0x3F, 0x7E, 0x0F, 0xC1, 0xF9, 0xF8, 0x3F, 0x07, 0xE3, 0xE0, 0xFC,
  0x1F, 0x8F, 0x83, 0xF0, 0x7E, 0x3E, 0x1F, 0xC1, 0xF8, 0xF8, 0x7E, 0x07,
  0xE3, 0xF1, 0xF8, 0x3F, 0x87, 0xC7, 0xE0, 0xFC, 0x1F, 0x1F, 0x83, 0xF0,
  0x7C, 0x7E, 0x0F, 0xC1, 0xF1, 0xF8, 0x3F, 0x07, 0xE7, 0xC0, 0xFC, 0x1F,
  0xBF, 0x07, 0xF0, 0x3E, 0xFC, 0x1F, 0xC0, 0xFB, 0xF0, 0x7E, 0x03, 0xEF,
  0xC1, 0xF8, 0x0F, 0xFF, 0x07, 0xE0, 0x3F, 0xFC, 0x1F, 0x80, 0x7F, 0xE0,
  0x7E, 0x01, 0xFF, 0x83, 0xF8, 0x07, 0xFE, 0x0F, 0xC0, 0x1F, 0xF8, 0x3F,
  0x00, 0x7F, 0xE0, 0xFC, 0x00, 0xFF, 0x83, 0xF0, 0x03, 0xFC, 0x0F, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF1, 0xFC,
  0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07,
  0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F,
  0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7,
  0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xF8, 0x7E, 0x00,
  0x1F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xF0,
  0x0F, 0xE0, 0x7F, 0xEF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x81, 0xFC, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xE0,
  0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0xFF, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x7F,
  0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xF8, 0x1F, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0,
  0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xF1, 0xF8, 0x00, 0x7F,
  0x3F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8,
  0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F,
  0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F,
  0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x01,
  0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0xEF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0xFF,
  0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xF0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x01, 0xF8, 0x01,
  0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0x81,
  0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x3F,
  0xC3, 0xFE, 0x01, 0xFE, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x07,
  0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFE, 0x0F,
  0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0,
  0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0xCF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0xFE, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC7,
  0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xF9, 0xF8,
  0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x3F, 0x3E, 0x03, 0xF0, 0x3F,
  0x3E, 0x07, 0xF0, 0x3F, 0x3E, 0x07, 0xF0, 0x3E, 0x7E, 0x07, 0xF0, 0x7E,
  0x7E, 0x07, 0xF0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7C,
  0x7E, 0x0E, 0xF0, 0xFC, 0x7E, 0x1E, 0xF0, 0xFC, 0x7E, 0x1E, 0xE0, 0xFC,
  0x7E, 0x1E, 0xE0, 0xF8, 0x7E, 0x1C, 0xE1, 0xF8, 0x7C, 0x3C, 0xE1, 0xF8,
  0x7C, 0x3C, 0xE1, 0xF0, 0x7C, 0x38, 0xE1, 0xF0, 0x7C, 0x78, 0xE3, 0xF0,
  0x7C, 0x78, 0xE3, 0xF0, 0x7C, 0x79, 0xE3, 0xE0, 0x7C, 0x71, 0xE3, 0xE0,
  0x7C, 0xF1, 0xE3, 0xE0, 0x7C, 0xF1, 0xE7, 0xE0, 0xFC, 0xF1, 0xE7, 0xC0,
  0xFC, 0xE1, 0xE7, 0xC0, 0xFD, 0xE1, 0xE7, 0xC0, 0xFD, 0xE1, 0xEF, 0xC0,
  0xF9, 0xC1, 0xEF, 0x80, 0xFB, 0xC1, 0xEF, 0x80, 0xFB, 0xC1, 0xEF, 0x80,
  0xFB, 0xC1, 0xFF, 0x00, 0xFB, 0x81, 0xDF, 0x00, 0xFF, 0x81, 0xDF, 0x00,
  0xFF, 0x81, 0xDF, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0,
  0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01,
  0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x7E, 0x3F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xEF,
  0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFB, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x9F, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0xC3, 0xF8, 0x07, 0xFF, 0x1F, 0x80, 0x7F, 0xFC, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0x7F,
  0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xF0,
  0x1F, 0xF0, 0x7F, 0xE3, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xEF,
  0xC0, 0x3F, 0xFE, 0x7E, 0x01, 0xFF, 0xE3, 0xF0, 0x03, 0xFE, 0x3F, 0x80,
  0x01, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x1F, 0xE0, 0x0F, 0xE7, 0xFF, 0x80, 0xFE, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFD, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x01, 0xFE,
  0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC,
  0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F,
  0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x87,
  0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xEF, 0xFF, 0xE0, 0xFE, 0xFF,
  0xFC, 0x0F, 0xE7, 0xFF, 0x80, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xF8, 0x0F, 0xF0,
  0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFC, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF9, 0xFC,
  0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xC7, 0xF8, 0x07, 0xF8, 0x7F, 0xE7, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x0F,
  0xFE, 0x3F, 0x00, 0x7F, 0xFC, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F,
  0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0x81, 0xFF, 0x8F, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xEF, 0xC0,
  0x1F, 0xFF, 0x3F, 0x00, 0x7F, 0xF8, 0xFC, 0x00, 0x7F, 0xC7, 0xF0, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xE0, 0xFF, 0x87,
  0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE7, 0xF0, 0x1F, 0xFC, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x9F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8,
  0x7F, 0x81, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x87, 0xF0, 0x1F, 0xFC, 0x7E, 0x03, 0xFF, 0xE7, 0xE0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0x3F, 0xE3,
  0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x00,
  0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC,
  0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xE0,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x7F,
  0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xBF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0x7F, 0x03, 0xFF, 0xF7, 0xF0, 0x1F, 0xFC, 0x7E, 0x00, 0x7F, 0x87,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE7, 0xFF, 0x80, 0xFE, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFD, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1,
  0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0,
  0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0xFE,
  0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F,
  0xC7, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7F,
  0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03,
  0xF8, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07,
  0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7F,
  0x03, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE,
  0x01, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xF8,
  0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xE7, 0xC1, 0xF8, 0x0F, 0x9F,
  0xC7, 0xF8, 0x1F, 0x7F, 0xDF, 0xF0, 0x3E, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x7E, 0x0F, 0x83,
  0xF0, 0xFC, 0x1F, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F,
  0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0x7E, 0x1F, 0x83, 0xC1, 0xF8,
  0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC3,
  0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0xC1, 0xE0, 0xFC, 0x3F,
  0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x07, 0xE1, 0xF8,
  0x3E, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x1F, 0x83,
  0xE0, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x7F, 0xF8, 0x0F, 0xEF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xDF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x1F, 0xF0, 0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC,
  0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x0F,
  0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC7, 0xF0, 0x01,
  0xFC, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x87,
  0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x87, 0xF8, 0x0F, 0xF0,
  0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFC, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F,
  0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x07,
  0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC,
  0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF8, 0x07, 0xF0, 0x7F, 0xE7, 0xFE,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x7F,
  0x80, 0x0F, 0xE7, 0xFF, 0x80, 0x3F, 0xBF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xF7, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0x81,
  0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x07,
  0xF8, 0x07, 0xF8, 0x1F, 0xFC, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFB,
  0xFF, 0xF8, 0x0F, 0xEF, 0xFF, 0xC0, 0x3F, 0x9F, 0xFE, 0x00, 0xFE, 0x3F,
  0xE0, 0x03, 0xF0, 0x08, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x07, 0xFF, 0x1F, 0x80, 0x7F,
  0xFC, 0xFC, 0x07, 0xFF, 0xEF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xC0, 0x7F, 0xC3, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0,
  0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x03,
  0xF8, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0,
  0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC,
  0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE3, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xEF, 0xC0, 0x3F, 0xFE, 0x7E, 0x01, 0xFF, 0xE7, 0xF0,
  0x03, 0xFE, 0x3F, 0x80, 0x01, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x7F, 0xF8, 0x0F,
  0xCF, 0xFF, 0xC0, 0xFD, 0xFF, 0xFE, 0x0F, 0xDF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x1F, 0xF0, 0x1F, 0xF1, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xF1,
  0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFF, 0x3F, 0x80,
  0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0x81, 0xFE, 0x0F, 0xE0,
  0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x03,
  0xF8, 0xFF, 0x80, 0x7F, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE1, 0xFC, 0x00,
  0xFE, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3,
  0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC,
  0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xE0,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F,
  0x0F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F,
  0xE7, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0,
  0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F,
  0x87, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x3F,
  0x80, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x87, 0xF0, 0x03,
  0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x9F,
  0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x07, 0xC0,
  0x7F, 0xF8, 0x1F, 0x80, 0xFB, 0xF0, 0x3F, 0x01, 0xF7, 0xE0, 0x7E, 0x07,
  0xEF, 0xC1, 0xFC, 0x0F, 0x9F, 0x83, 0xF8, 0x1F, 0x3F, 0x07, 0x70, 0x7E,
  0x7E, 0x0E, 0xE0, 0xF8, 0xFC, 0x3D, 0xC1, 0xF1, 0xF8, 0x73, 0x87, 0xE3,
  0xF0, 0xE7, 0x0F, 0x87, 0xE3, 0xCE, 0x1F, 0x0F, 0xC7, 0x9C, 0x3E, 0x1F,
  0x8E, 0x38, 0xFC, 0x3F, 0x3C, 0xF1, 0xF0, 0x7E, 0x79, 0xE3, 0xE0, 0xFC,
  0xE3, 0xCF, 0xC1, 0xFB, 0xC7, 0x9F, 0x03, 0xE7, 0x8F, 0x3E, 0x07, 0xCE,
  0x1E, 0xFC, 0x0F, 0x9C, 0x3D, 0xF0, 0x1F, 0x78, 0x7B, 0xE0, 0x3E, 0xE0,
  0xF7, 0xC0, 0x7D, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07,
  0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xF8,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0,
  0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x80,
  0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0xFE, 0x7F,
  0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F,
  0xC7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0,
  0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC,
  0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x01, 0xFE, 0x7F, 0x80,
  0x3F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFF, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x7F, 0x07, 0xFF, 0xCF, 0xC0, 0x7F, 0xF1,
  0xF8, 0x01, 0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xC7, 0xFF, 0xC0, 0x7E, 0x7F, 0xFF, 0x03,
  0xF3, 0xFF, 0xF8, 0x1F, 0x9F, 0x8F, 0xE0, 0xF9, 0xF8, 0x3F, 0x8F, 0xCF,
  0xC1, 0xFF, 0xFE, 0x7E, 0x07, 0xFF, 0xE3, 0xE0, 0x1F, 0xFE, 0x1F, 0x00,
  0xFF, 0xE1, 0x00, 0x01, 0xFE, 0x00,
};

const GFXglyph JetBrainsMono_BoldItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 14, 39, 32, 10, -39 },
  { 70, 20, 16, 32, 9, -39 },
  { 110, 32, 39, 32, 1, -39 },
  { 266, 30, 55, 32, 2, -47 },
  { 473, 39, 40, 32, -3, -40 },
  { 668, 30, 41, 32, 1, -40 },
  { 822, 8, 16, 32, 15, -39 },
  { 838, 23, 53, 32, 8, -46 },
  { 991, 23, 53, 32, 3, -46 },
  { 1144, 30, 28, 32, 2, -33 },
  { 1249, 27, 26, 32, 3, -31 },
  { 1337, 16, 17, 32, 4, -8 },
  { 1371, 19, 6, 32, 7, -21 },
  { 1386, 11, 11, 32, 9, -10 },
  { 1402, 34, 51, 32, 0, -45 },
  { 1619, 28, 41, 32, 3, -40 },
  { 1763, 26, 39, 32, 2, -39 },
  { 1890, 29, 40, 32, 2, -40 },
  { 2035, 29, 40, 32, 2, -39 },
  { 2180, 28, 39, 32, 2, -39 },
  { 2317, 29, 40, 32, 2, -39 },
  { 2462, 28, 40, 32, 2, -39 },
  { 2602, 28, 39, 32, 5, -39 },
  { 2739, 29, 41, 32, 2, -40 },
  { 2888, 28, 40, 32, 4, -40 },
  { 3028, 14, 31, 32, 9, -30 },
  { 3083, 18, 39, 32, 5, -30 },
  { 3171, 27, 30, 32, 4, -33 },
  { 3273, 27, 20, 32, 3, -28 },
  { 3341, 27, 30, 32, 2, -33 },
  { 3443, 23, 39, 32, 7, -39 },
  { 3556, 33, 50, 32, 0, -40 },
  { 3763, 28, 39, 32, 0, -39 },
  { 3900, 30, 39, 32, 2, -39 },
  { 4047, 29, 41, 32, 3, -40 },
  { 4196, 29, 39, 32, 2, -39 },
  { 4338, 30, 39, 32, 2, -39 },
  { 4485, 31, 39, 32, 2, -39 },
  { 4637, 29, 41, 32, 3, -40 },
  { 4786, 30, 39, 32, 2, -39 },
  { 4933, 29, 39, 32, 2, -39 },
  { 5075, 31, 40, 32, 0, -39 },
  { 5230, 32, 39, 32, 2, -39 },
  { 5386, 25, 39, 32, 3, -39 },
  { 5508, 32, 39, 32, 1, -39 },
  { 5664, 30, 39, 32, 2, -39 },
  { 5811, 28, 41, 32, 3, -40 },
  { 5955, 31, 39, 32, 2, -39 },
  { 6107, 28, 50, 32, 3, -40 },
  { 6282, 30, 39, 32, 2, -39 },
  { 6429, 30, 41, 32, 2, -40 },
  { 6583, 29, 39, 32, 5, -39 },
  { 6725, 30, 40, 32, 2, -39 },
  { 6875, 28, 39, 32, 6, -39 },
  { 7012, 32, 39, 32, 3, -39 },
  { 7168, 35, 39, 32, -1, -39 },
  { 7339, 30, 39, 32, 5, -39 },
  { 7486, 29, 39, 32, 2, -39 },
  { 7628, 23, 51, 32, 7, -45 },
  { 7775, 18, 51, 32, 8, -45 },
  { 7890, 23, 51, 32, 4, -45 },
  { 8037, 25, 21, 32, 4, -39 },
  { 8103, 27, 6, 32, 0, 1 },
  { 8124, 12, 7, 32, 13, -42 },
  { 8135, 29, 31, 32, 2, -30 },
  { 8248, 28, 40, 32, 2, -39 },
  { 8388, 27, 31, 32, 3, -30 },
  { 8493, 30, 40, 32, 2, -39 },
  { 8643, 27, 31, 32, 3, -30 },
  { 8748, 37, 49, 32, -3, -39 },
  { 8975, 28, 40, 32, 3, -30 },
  { 9115, 28, 39, 32, 2, -39 },
  { 9252, 27, 42, 32, 2, -42 },
  { 9394, 30, 52, 32, 0, -42 },
  { 9589, 31, 39, 32, 2, -39 },
  { 9741, 24, 39, 32, 5, -39 },
  { 9858, 31, 30, 32, 0, -30 },
  { 9975, 28, 30, 32, 2, -30 },
  { 10080, 27, 31, 32, 3, -30 },
  { 10185, 30, 40, 32, 0, -30 },
  { 10335, 29, 40, 32, 2, -30 },
  { 10480, 28, 30, 32, 3, -30 },
  { 10585, 28, 31, 32, 2, -30 },
  { 10694, 27, 38, 32, 4, -38 },
  { 10823, 28, 31, 32, 3, -30 },
  { 10932, 28, 30, 32, 5, -30 },
  { 11037, 31, 30, 32, 3, -30 },
  { 11154, 32, 30, 32, 0, -30 },
  { 11274, 27, 40, 32, 3, -30 },
  { 11409, 28, 30, 32, 2, -30 },
  { 11514, 29, 51, 32, 4, -45 },
  { 11699, 15, 51, 32, 9, -45 },
  { 11795, 28, 51, 32, 1, -45 },
  { 11974, 29, 12, 32, 2, -25 },
};

const GFXfont JetBrainsMono_BoldItalic54pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_BoldItalic54pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_BoldItalic54pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _JETBRAINSMONO_BOLDITALIC54PT7B_H_
