#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC42PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0x3C, 0x7D,
  0xF1, 0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1C, 0x3C,
  0xF0, 0xE3, 0xC7, 0x8F, 0x1E, 0x00, 0x00, 0x38, 0xF0, 0x07, 0x8E, 0x00,
  0x70, 0xE0, 0x07, 0x1E, 0x00, 0xF1, 0xC0, 0x0E, 0x1C, 0x00, 0xE3, 0xC0,
  0x1E, 0x38, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x03, 0x87, 0x00, 0x38, 0xF0, 0x07, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x1E,
  0x00, 0xF1, 0xC0, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0xC3,
  0x80, 0x1C, 0x78, 0x03, 0xC7, 0x00, 0x38, 0x70, 0x03, 0x8F, 0x00, 0x78,
  0xF0, 0x07, 0x8E, 0x00, 0x70, 0xE0, 0x0F, 0x1E, 0x00, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x78, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F,
  0xFC, 0x1F, 0x7E, 0x0F, 0xB1, 0x03, 0xCC, 0x00, 0xF3, 0x00, 0x3C, 0x80,
  0x0F, 0x20, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x27, 0xC0, 0x19,
  0xE0, 0x06, 0x78, 0x41, 0x9E, 0x1C, 0x4F, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xF8, 0x0F, 0xF8, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x07, 0xC0, 0x3C, 0x07, 0xF0, 0x1C, 0x07, 0xF8, 0x1E, 0x07,
  0x9C, 0x0E, 0x03, 0x8F, 0x0F, 0x01, 0xC7, 0x87, 0x01, 0xE3, 0x87, 0x80,
  0xE1, 0xC3, 0x80, 0x70, 0xE3, 0xC0, 0x78, 0xF1, 0xC0, 0x3C, 0x79, 0xE0,
  0x1E, 0x38, 0xE0, 0x0E, 0x1C, 0xE3, 0xE7, 0x1E, 0xF3, 0xFB, 0xCE, 0x73,
  0xFF, 0xFF, 0x79, 0xCF, 0x7F, 0x39, 0xE7, 0xBF, 0x3C, 0xE3, 0xC0, 0x1C,
  0xF1, 0xE0, 0x1E, 0x78, 0xF0, 0x0E, 0x38, 0x70, 0x0F, 0x1C, 0x38, 0x07,
  0x0E, 0x1C, 0x07, 0x8F, 0x1E, 0x03, 0x87, 0x8E, 0x03, 0xC3, 0xC7, 0x01,
  0xC1, 0xE7, 0x01, 0xC0, 0x7F, 0x81, 0xE0, 0x3F, 0x80, 0xE0, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3E, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0x78, 0xF8, 0x07, 0xCF, 0x00, 0x7D,
  0xF0, 0x07, 0xDE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x1F, 0x1F, 0xF1, 0xE3, 0xEF, 0x9E, 0x7C, 0xFB, 0xE7,
  0x87, 0xBC, 0xF8, 0x7F, 0xCF, 0x87, 0xF8, 0xF0, 0x3F, 0x8F, 0x03, 0xF0,
  0xF0, 0x3F, 0x0F, 0x87, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xEF,
  0x83, 0xF8, 0xFC, 0x3E, 0x79, 0xF3, 0xE7, 0xCF, 0x1E, 0x3C, 0x71, 0xE3,
  0xC0, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x10, 0xE0, 0x73, 0x83,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0x0F, 0xFC, 0x7E, 0x03, 0xFC, 0x1F, 0x78,
  0xF9, 0xE1, 0xE3, 0xC3, 0x0E, 0x00, 0x20, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x0F,
  0x1F, 0x1F, 0x1E, 0x3E, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x39, 0xFF, 0xFF, 0xF9, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0x8F, 0x0F,
  0x0F, 0x1F, 0x0F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0xF8, 0x1E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0,
  0xF8, 0xF0, 0xF8, 0xF9, 0xF0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F,
  0x80, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xE1, 0xFF, 0x1F, 0xF1, 0xF7,
  0x9F, 0xFC, 0x73, 0xE1, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE,
  0x01, 0xC3, 0xF0, 0x18, 0x1F, 0x01, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x38, 0x7E, 0x04, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x07, 0xF0,
  0x07, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x18, 0x0F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xBC,
  0x00, 0x77, 0x80, 0x1D, 0xF0, 0x07, 0xBE, 0x00, 0xE7, 0x80, 0x38, 0xF0,
  0x0F, 0x1E, 0x01, 0xC7, 0xC0, 0x78, 0xF8, 0x1E, 0x1E, 0x03, 0x83, 0xC0,
  0xF0, 0x78, 0x1C, 0x1F, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE7,
  0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xE0, 0x21, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x80,
  0x7C, 0x30, 0x3F, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF3, 0xE0, 0x3D, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xF8,
  0xF8, 0x7C, 0x3E, 0x3F, 0x07, 0x8F, 0x81, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x3E, 0x0F, 0x8F, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3E, 0x07,
  0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0x3F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0,
  0x3C, 0x3C, 0x1F, 0x0F, 0x07, 0xC3, 0xC1, 0xE0, 0xF8, 0xF8, 0x1F, 0x7C,
  0x07, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x0F,
  0x9F, 0x87, 0xC3, 0xE1, 0xF0, 0x78, 0xF8, 0x1E, 0x3E, 0x07, 0xCF, 0x01,
  0xE3, 0xC0, 0x78, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0xEF, 0xC1, 0xFF, 0xE0,
  0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE0,
  0xFF, 0xF0, 0xF8, 0xF8, 0x78, 0x3C, 0x7C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07,
  0x8F, 0x03, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0xFC, 0xF8,
  0xFE, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xE7, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x1F, 0x1F, 0x8F, 0xC7, 0xC3, 0xE0, 0x00,
  0xE0, 0x1E, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x07, 0xF0, 0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x18, 0x7C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x3E, 0x03, 0xC0, 0x3C, 0x00, 0xF0,
  0x1C, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x0E, 0x0F, 0xE3,
  0x8E, 0x0F, 0xF1, 0xC7, 0x0F, 0x78, 0xE7, 0x0E, 0x3C, 0x73, 0x8F, 0x1C,
  0x3B, 0xC7, 0x0E, 0x1D, 0xC3, 0x87, 0x1C, 0xE3, 0x87, 0x8E, 0x71, 0xC3,
  0x87, 0x78, 0xE1, 0xC3, 0xB8, 0xF1, 0xE3, 0x9C, 0x78, 0xF1, 0xCE, 0x3C,
  0x71, 0xC7, 0x1E, 0x78, 0xE3, 0x87, 0xFF, 0xE1, 0xC3, 0xF7, 0xE0, 0xE0,
  0xF1, 0xE0, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x08, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00,
  0x7D, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x03,
  0xE3, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x03, 0xE1, 0xE0, 0x78, 0x3C, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xC0, 0xF8, 0xF8,
  0x1F, 0x1F, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0,
  0x3F, 0xF8, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x1F,
  0x0F, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x0F, 0x3F,
  0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1E, 0x1F, 0x01, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xC0, 0xF8, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x07, 0x83, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0xC0, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x80,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xC7, 0xF0, 0x7C,
  0x3F, 0x07, 0xC1, 0xF0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1,
  0xF0, 0x1F, 0x1F, 0x03, 0xF1, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7E,
  0x3E, 0x07, 0xC3, 0xC0, 0x7C, 0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0x7C, 0x3F,
  0x07, 0xCF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xF0, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0xFE, 0x06, 0x07, 0xE0, 0x10, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x1F, 0xE3, 0xE0, 0xFF, 0x1F, 0x07, 0xF8, 0xF8,
  0x3F, 0xC7, 0xC3, 0xFE, 0x3E, 0x01, 0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF8,
  0x78, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF8, 0x1F, 0x07, 0xE0,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F,
  0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0x01,
  0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3C,
  0x07, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xF0, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF0, 0x00, 0x80, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0,
  0x3C, 0x1F, 0x00, 0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x78,
  0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xFB, 0xE0,
  0x03, 0xDF, 0x00, 0x0F, 0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F,
  0x00, 0x3E, 0x7C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xE0, 0x1F, 0x0F, 0x80,
  0x7C, 0x3E, 0x01, 0xE0, 0xF8, 0x07, 0x83, 0xE0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0xFF, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xC0,
  0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x07,
  0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3D, 0xE0, 0x7F, 0xC0, 0xF7, 0x83, 0xDE, 0x03,
  0xDE, 0x0F, 0x78, 0x0F, 0x78, 0x3D, 0xE0, 0x7D, 0xE1, 0xEF, 0x81, 0xF7,
  0x87, 0xBE, 0x07, 0x9E, 0x3C, 0xF0, 0x1E, 0x78, 0xF3, 0xC0, 0x79, 0xE7,
  0x9F, 0x03, 0xE7, 0x9E, 0x7C, 0x0F, 0x1E, 0xF1, 0xF0, 0x3C, 0x7B, 0xC7,
  0x80, 0xF1, 0xEE, 0x1E, 0x03, 0xC7, 0xF8, 0xF8, 0x1F, 0x1F, 0xE3, 0xE0,
  0x78, 0x7F, 0x0F, 0x01, 0xE1, 0xFC, 0x3C, 0x07, 0x87, 0xE0, 0xF0, 0x3E,
  0x1F, 0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x03, 0xC1, 0xF0, 0x78, 0x00, 0x03,
  0xF0, 0x0F, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x1E, 0x07,
  0xF0, 0x1E, 0x07, 0xF0, 0x1E, 0x07, 0xF8, 0x3E, 0x07, 0xF8, 0x3C, 0x0F,
  0xF8, 0x3C, 0x0F, 0x78, 0x3C, 0x0F, 0x78, 0x7C, 0x0F, 0x78, 0x7C, 0x0F,
  0x3C, 0x78, 0x1F, 0x3C, 0x78, 0x1F, 0x3C, 0x78, 0x1E, 0x3C, 0xF8, 0x1E,
  0x3C, 0xF8, 0x1E, 0x3C, 0xF0, 0x3E, 0x1E, 0xF0, 0x3C, 0x1E, 0xF0, 0x3C,
  0x1F, 0xF0, 0x3C, 0x1F, 0xE0, 0x3C, 0x1F, 0xE0, 0x7C, 0x1F, 0xE0, 0x78,
  0x0F, 0xE0, 0x78, 0x0F, 0xE0, 0x78, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8,
  0x0F, 0xC0, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xE0, 0x7E, 0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x03, 0xE3,
  0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01,
  0xF3, 0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C,
  0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x83, 0xF1,
  0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xC7,
  0xE0, 0x7C, 0x3F, 0x07, 0xC1, 0xF0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xF8,
  0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xE1, 0xF0, 0x7C, 0x1F,
  0x1F, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xE0, 0x7E, 0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x03, 0xE3, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0,
  0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3,
  0xE0, 0x1F, 0x9F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x83, 0xF1, 0xF8, 0x1F,
  0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x7C, 0x7E, 0x0F, 0x87, 0xC1, 0xE0, 0xF8, 0x3C, 0x1F,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0x83, 0xE0, 0xF0, 0x7C,
  0x3E, 0x1F, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0xF9, 0xE0, 0x1F, 0x3E, 0x03, 0xC7, 0xC0, 0x78, 0xF8, 0x0F, 0x0F, 0x03,
  0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F,
  0x81, 0xF1, 0xF0, 0x3E, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xE1, 0xC0, 0x7C, 0x04, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x40, 0x3E, 0x07, 0x07, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x3E,
  0x07, 0xC1, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC1, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x07, 0xC0,
  0xF8, 0x3C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF8, 0x1F, 0x07,
  0xC0, 0xF8, 0x3C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x3C, 0x07, 0xC3, 0xE0, 0x3C, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x03, 0xE1, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0xFB, 0xC0, 0x3E,
  0xF0, 0x1F, 0x3C, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0xF8, 0xF0, 0x3C, 0x3C,
  0x1F, 0x0F, 0x07, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x3C, 0x3C, 0x0F, 0x1F,
  0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xDF, 0x00,
  0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x07, 0x80, 0xFB, 0xC0, 0x7C, 0x07, 0xDE, 0x03, 0xE0, 0x3C, 0xF0, 0x1F,
  0x03, 0xE7, 0x81, 0xF8, 0x1E, 0x3C, 0x0F, 0xC1, 0xF1, 0xE0, 0xFE, 0x0F,
  0x8F, 0x07, 0xF0, 0x78, 0xF8, 0x3F, 0x87, 0xC7, 0xC3, 0xFC, 0x3C, 0x3E,
  0x1F, 0xE1, 0xE1, 0xF1, 0xEF, 0x1F, 0x0F, 0x8F, 0x70, 0xF0, 0x7C, 0x7B,
  0x8F, 0x83, 0xE7, 0x9C, 0x7C, 0x1F, 0x3C, 0xE3, 0xC0, 0xFB, 0xC7, 0x3E,
  0x07, 0xDE, 0x39, 0xE0, 0x3C, 0xF1, 0xDF, 0x01, 0xEF, 0x1E, 0xF8, 0x0F,
  0x78, 0xF7, 0x80, 0x7B, 0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1,
  0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x03, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x7C, 0x07, 0x81, 0xF0, 0x1E, 0x0F, 0x80, 0x7C, 0x3C, 0x01,
  0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x3E, 0x00, 0x3C, 0xF0, 0x00, 0xF7,
  0xC0, 0x03, 0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xDE, 0x00, 0x1E, 0x78,
  0x00, 0xF9, 0xE0, 0x07, 0xC7, 0x80, 0x1F, 0x1F, 0x00, 0xF8, 0x7C, 0x03,
  0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x00, 0x78,
  0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xE3, 0xE1, 0xE1,
  0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x7C, 0x07, 0xBC,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xF0, 0xF8, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0x78, 0x07, 0xDE,
  0x01, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1E, 0x0F, 0x0F, 0x81, 0xE3,
  0xC0, 0x79, 0xE0, 0x1E, 0xF8, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0xF9, 0xF1, 0xE3, 0xE3, 0xC3, 0x80, 0x03, 0xE3, 0xC1, 0xFC, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0x1F, 0x8F, 0x83, 0xE3, 0xE0, 0xF9, 0xF0, 0x3C,
  0x7C, 0x0F, 0x1F, 0x07, 0xC7, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x3E,
  0x07, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xDE, 0x03, 0xE7, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE7, 0xC0, 0xFB, 0xF8, 0x3D,
  0xFE, 0x0F, 0xFF, 0xC3, 0xE1, 0xF1, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x07,
  0xC7, 0x81, 0xF1, 0xE0, 0x7C, 0xF8, 0x1E, 0x3E, 0x07, 0x8F, 0x03, 0xE3,
  0xC0, 0xF8, 0xF0, 0x3E, 0x7C, 0x0F, 0x1F, 0x07, 0xC7, 0xC1, 0xE1, 0xF0,
  0xF8, 0x7F, 0xFC, 0x3D, 0xFF, 0x0F, 0x7F, 0x83, 0xCF, 0xC0, 0x01, 0xFC,
  0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xF0, 0x87, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x87, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x3E, 0x7C, 0x07, 0xF7, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x81, 0xF1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F,
  0x07, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x81,
  0xE0, 0xF8, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3E, 0x0F, 0x03, 0xC0, 0xF8,
  0x7C, 0x0F, 0x87, 0xC0, 0xFD, 0xFC, 0x0F, 0xFB, 0xC0, 0x7F, 0xB8, 0x03,
  0xE3, 0x80, 0x01, 0xF8, 0x03, 0xFC, 0x0F, 0xFE, 0x0F, 0xBE, 0x1F, 0x1F,
  0x3E, 0x1F, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x78, 0xFC, 0x7F, 0xF8,
  0xFF, 0xF0, 0xFF, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x08, 0xFC, 0x30, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0xF0, 0x1F, 0xCF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xC7, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x1F,
  0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0x83,
  0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x03, 0xE1, 0xF0,
  0x3E, 0x3F, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFD, 0xE0, 0x0F, 0x9E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0xC0, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xCF, 0x83,
  0xFF, 0xE1, 0xEF, 0xF0, 0xFF, 0xF8, 0x7E, 0x7C, 0x3E, 0x1E, 0x3E, 0x0F,
  0x1F, 0x07, 0x8F, 0x87, 0xC7, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF1, 0xF0,
  0x78, 0xF0, 0x7C, 0x78, 0x3E, 0x7C, 0x1E, 0x3E, 0x0F, 0x1F, 0x07, 0x8F,
  0x07, 0xC7, 0x83, 0xE7, 0xC1, 0xE3, 0xE0, 0xF1, 0xE0, 0xF8, 0x00, 0x80,
  0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0x00, 0x04, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0xC7, 0xC0, 0xF0,
  0xF0, 0x1E, 0x3E, 0x03, 0xCF, 0x80, 0xFB, 0xE0, 0x1E, 0x78, 0x03, 0xDF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x01, 0xF7, 0xC0, 0x7C, 0xF8, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3E,
  0x07, 0x87, 0xC1, 0xF0, 0xF8, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0x07, 0x3F, 0x0F, 0x83, 0xDF, 0xEF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0x8F, 0xC7, 0xC3, 0xE1,
  0xF0, 0xF1, 0xF0, 0xF8, 0x3C, 0x7C, 0x3E, 0x0F, 0x1E, 0x0F, 0x87, 0xC7,
  0x83, 0xC1, 0xE3, 0xE0, 0xF0, 0x78, 0xF8, 0x3C, 0x1E, 0x3C, 0x1F, 0x0F,
  0x8F, 0x07, 0xC3, 0xE3, 0xC1, 0xE0, 0xF1, 0xF0, 0x78, 0x3C, 0x7C, 0x3E,
  0x0F, 0x1E, 0x0F, 0x87, 0xC7, 0x83, 0xC1, 0xF1, 0xE0, 0xF0, 0x78, 0xF8,
  0x3C, 0x1E, 0x3E, 0x1F, 0x07, 0x8F, 0x07, 0xC3, 0xE0, 0x07, 0x1F, 0x07,
  0xBF, 0xC3, 0xDF, 0xE1, 0xFF, 0xF0, 0xFC, 0x78, 0x7C, 0x3C, 0x7C, 0x1E,
  0x3E, 0x0F, 0x1F, 0x0F, 0x8F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xE3, 0xE0,
  0xF1, 0xE0, 0xF8, 0xF0, 0x7C, 0xF8, 0x3C, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E,
  0x0F, 0x8F, 0x07, 0xCF, 0x83, 0xC7, 0xC1, 0xE3, 0xC1, 0xF0, 0x01, 0xF8,
  0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0x1F, 0x3E, 0x1F, 0x3C, 0x0F,
  0x7C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1E, 0xF8, 0x1E, 0xF0, 0x3E, 0xF0, 0x3E, 0xF8, 0x7C, 0xF8, 0xFC,
  0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x01, 0xC7, 0xC0, 0x3C,
  0xFE, 0x03, 0xDF, 0xE0, 0x3F, 0xFF, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x1F, 0x0F, 0x81, 0xE0,
  0xF8, 0x1E, 0x0F, 0x03, 0xE0, 0xF0, 0x3E, 0x0F, 0x03, 0xE1, 0xF0, 0x3C,
  0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1F, 0x0F, 0x81, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x3C, 0xFC, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF3, 0xC1, 0xFC, 0xF0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0x1F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF0,
  0x3C, 0x7C, 0x0F, 0x1E, 0x07, 0xC7, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E,
  0x3E, 0x07, 0x8F, 0x83, 0xE3, 0xC0, 0xF8, 0xF0, 0x3C, 0x3E, 0x1F, 0x0F,
  0x8F, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xDE, 0x03, 0xE7, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x07, 0x1E,
  0x1E, 0xF8, 0x3D, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xE1, 0xE0, 0x87, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE2, 0x07, 0xC7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F,
  0xE0, 0x00, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0xFF, 0x3F,
  0xE7, 0xFE, 0x7F, 0xE1, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x0F, 0x07, 0x8F, 0x83,
  0xC7, 0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xF9, 0xF0, 0x78, 0xF8, 0x3C, 0x78,
  0x1E, 0x3C, 0x1F, 0x1E, 0x0F, 0x9F, 0x07, 0x8F, 0x83, 0xC7, 0x83, 0xE3,
  0xC1, 0xF1, 0xE0, 0xF1, 0xF0, 0x78, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x3F,
  0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFB, 0xC1, 0xF9, 0xE0, 0xF0, 0x3F, 0xE0,
  0x7B, 0xC1, 0xF7, 0x83, 0xCF, 0x07, 0x9E, 0x1F, 0x3C, 0x3C, 0x78, 0xF8,
  0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x78, 0x1E, 0xF0, 0x3F,
  0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x3E, 0x0F, 0xBC, 0x1F, 0x07, 0x9E,
  0x1F, 0x83, 0xCF, 0x0F, 0xC3, 0xC7, 0x87, 0xE1, 0xE3, 0xC7, 0xF1, 0xF1,
  0xE3, 0xF8, 0xF0, 0xF3, 0xFC, 0x78, 0xF9, 0xFE, 0x78, 0x7C, 0xEF, 0x3C,
  0x3E, 0xF7, 0x9E, 0x1F, 0x73, 0xDE, 0x0F, 0x79, 0xEF, 0x07, 0xBC, 0xFF,
  0x03, 0xDC, 0x7F, 0x81, 0xFE, 0x3B, 0xC0, 0xFF, 0x1F, 0xC0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x03, 0xC3,
  0xC0, 0x3C, 0x7C, 0x03, 0xCF, 0x80, 0x3E, 0xF0, 0x03, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01,
  0xF3, 0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x3E, 0x07, 0xC3, 0xE0,
  0xF8, 0x3E, 0x00, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x07,
  0x83, 0xE0, 0x3C, 0x1E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0xF8,
  0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF3, 0xE0, 0x07, 0x9E, 0x00, 0x3D,
  0xF0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x7F, 0x00,
  0xFE, 0x01, 0xFE, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xE0, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8,
  0x07, 0xF0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xC0, 0x0C, 0x00, 0x00, 0x3E, 0x01,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0xFE,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 12, 30, 10, 0, -30 },
  { 46, 14, 11, 16, 4, -30 },
  { 66, 20, 30, 19, 0, -30 },
  { 141, 18, 34, 17, 0, -32 },
  { 218, 25, 30, 28, 2, -30 },
  { 312, 20, 30, 20, 0, -30 },
  { 387, 7, 11, 9, 4, -30 },
  { 397, 13, 37, 11, 1, -30 },
  { 458, 13, 37, 11, -3, -30 },
  { 519, 14, 16, 16, 4, -32 },
  { 547, 16, 20, 19, 2, -25 },
  { 587, 8, 11, 9, -2, -5 },
  { 598, 10, 5, 12, 1, -14 },
  { 605, 6, 6, 9, 0, -6 },
  { 610, 20, 30, 15, -2, -30 },
  { 685, 16, 30, 17, 1, -30 },
  { 745, 13, 30, 18, 4, -30 },
  { 794, 20, 30, 17, -2, -30 },
  { 869, 19, 30, 17, -1, -30 },
  { 941, 19, 30, 18, -1, -30 },
  { 1013, 18, 30, 17, 0, -30 },
  { 1081, 18, 30, 17, 1, -30 },
  { 1149, 19, 30, 17, 1, -30 },
  { 1221, 18, 30, 17, 0, -30 },
  { 1289, 17, 30, 17, 0, -30 },
  { 1353, 9, 23, 10, 0, -23 },
  { 1379, 12, 29, 10, -2, -23 },
  { 1423, 16, 20, 19, 2, -25 },
  { 1463, 16, 12, 19, 2, -21 },
  { 1487, 16, 20, 19, 2, -25 },
  { 1527, 14, 30, 13, 1, -30 },
  { 1580, 25, 33, 26, 1, -30 },
  { 1684, 19, 30, 19, -3, -30 },
  { 1756, 20, 30, 19, 0, -30 },
  { 1831, 20, 30, 18, 1, -30 },
  { 1906, 20, 30, 21, 0, -30 },
  { 1981, 18, 30, 16, 0, -30 },
  { 2049, 18, 30, 16, 0, -30 },
  { 2117, 21, 30, 22, 2, -30 },
  { 2196, 23, 30, 22, 0, -30 },
  { 2283, 17, 30, 12, -2, -30 },
  { 2347, 17, 39, 10, -6, -30 },
  { 2430, 22, 30, 18, 0, -30 },
  { 2513, 13, 30, 15, 0, -30 },
  { 2562, 30, 30, 28, 0, -30 },
  { 2675, 24, 30, 23, 0, -30 },
  { 2765, 21, 30, 22, 1, -30 },
  { 2844, 20, 30, 18, 0, -30 },
  { 2919, 21, 37, 22, 1, -30 },
  { 3017, 19, 30, 19, 0, -30 },
  { 3089, 20, 30, 17, -1, -30 },
  { 3164, 16, 30, 16, 3, -30 },
  { 3224, 21, 30, 21, 1, -30 },
  { 3303, 18, 30, 19, 4, -30 },
  { 3371, 29, 30, 29, 3, -30 },
  { 3480, 22, 30, 17, -2, -30 },
  { 3563, 17, 30, 17, 3, -30 },
  { 3627, 20, 30, 16, -2, -30 },
  { 3702, 16, 37, 12, -1, -30 },
  { 3776, 8, 30, 15, 4, -30 },
  { 3806, 16, 37, 12, -3, -30 },
  { 3880, 18, 17, 18, 0, -30 },
  { 3919, 14, 2, 13, -4, 4 },
  { 3923, 7, 7, 12, 6, -32 },
  { 3930, 18, 23, 19, 1, -23 },
  { 3982, 18, 32, 19, 0, -32 },
  { 4054, 15, 23, 15, 1, -23 },
  { 4098, 20, 32, 19, 1, -32 },
  { 4178, 16, 23, 17, 1, -23 },
  { 4224, 21, 42, 11, -5, -32 },
  { 4335, 20, 33, 19, -1, -23 },
  { 4418, 17, 32, 19, 0, -32 },
  { 4486, 11, 32, 9, 0, -32 },
  { 4530, 16, 42, 9, -5, -32 },
  { 4614, 19, 32, 17, 0, -32 },
  { 4690, 11, 32, 9, 0, -32 },
  { 4734, 26, 23, 27, 0, -23 },
  { 4809, 17, 23, 19, 0, -23 },
  { 4858, 16, 23, 18, 1, -23 },
  { 4904, 20, 33, 19, -2, -23 },
  { 4987, 18, 33, 19, 1, -23 },
  { 5062, 15, 23, 13, 0, -23 },
  { 5106, 15, 23, 14, 0, -23 },
  { 5150, 12, 28, 11, 1, -28 },
  { 5192, 17, 23, 18, 1, -23 },
  { 5241, 15, 23, 16, 3, -23 },
  { 5285, 25, 23, 25, 2, -23 },
  { 5357, 20, 23, 16, -2, -23 },
  { 5415, 21, 33, 16, -3, -23 },
  { 5502, 17, 23, 13, -2, -23 },
  { 5551, 16, 37, 14, 1, -30 },
  { 5625, 5, 42, 16, 5, -32 },
  { 5652, 15, 37, 14, -2, -30 },
  { 5722, 16, 6, 19, 2, -18 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC42PT7B_H_
