#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC22PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x0C, 0x30, 0xC6, 0x00, 0x01, 0x8E,
  0x38, 0x66, 0xCD, 0xBB, 0x6C, 0xD9, 0x80, 0x06, 0x40, 0x98, 0x33, 0x06,
  0x40, 0xD8, 0x7F, 0xD6, 0x40, 0xD8, 0x13, 0x06, 0x43, 0xFE, 0x13, 0x06,
  0x60, 0xD8, 0x13, 0x06, 0x60, 0x02, 0x00, 0x80, 0xFC, 0x7E, 0x3C, 0x8D,
  0x03, 0x40, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x2C, 0x0B, 0x33, 0xCF, 0xE1,
  0xF0, 0x10, 0x04, 0x00, 0x18, 0x31, 0xE3, 0x1B, 0x10, 0xD9, 0x8C, 0xC8,
  0x66, 0xC3, 0x24, 0xDB, 0x6F, 0xFE, 0xDB, 0xB6, 0xC3, 0x66, 0x1B, 0x31,
  0x99, 0x8C, 0xD8, 0xC6, 0xCE, 0x1C, 0x07, 0x03, 0xE1, 0x98, 0x66, 0x1B,
  0x86, 0xC1, 0xE0, 0x70, 0x3C, 0xDF, 0xBE, 0x7F, 0x1E, 0xC7, 0x31, 0xCF,
  0xF9, 0xEE, 0x76, 0x66, 0xCC, 0x06, 0x1C, 0x30, 0xC1, 0x86, 0x0C, 0x38,
  0x60, 0xC1, 0x83, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0xC1, 0x80, 0x0E, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x70, 0xC1, 0x86, 0x0C,
  0x30, 0x63, 0x80, 0x18, 0x18, 0xD8, 0xFE, 0x3F, 0x38, 0xEC, 0x4C, 0x08,
  0x18, 0x0C, 0x06, 0x03, 0x0F, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x00,
  0x33, 0x76, 0xEC, 0x7F, 0xE0, 0x7F, 0x80, 0x00, 0xE0, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03,
  0x00, 0xC0, 0x18, 0x06, 0x00, 0x07, 0x07, 0xC6, 0x67, 0x33, 0x19, 0x8D,
  0xC6, 0xC7, 0x63, 0xB1, 0x98, 0xDC, 0xEE, 0x63, 0x71, 0xF0, 0xF0, 0x0E,
  0x38, 0xF3, 0xEF, 0xCB, 0x86, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x0E, 0x1C,
  0x30, 0x07, 0x83, 0xF1, 0xDC, 0x23, 0x00, 0xC0, 0x70, 0x18, 0x0E, 0x07,
  0x01, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x0F, 0xF3, 0xFC, 0x0F, 0x1F, 0xC4,
  0xE0, 0x30, 0x18, 0x1C, 0x1C, 0x3C, 0x3E, 0x03, 0x81, 0xC0, 0xE0, 0x74,
  0x73, 0xF9, 0xF0, 0x01, 0x81, 0xC0, 0xE0, 0xF0, 0xF0, 0x58, 0x6C, 0x66,
  0x27, 0x33, 0x31, 0xBF, 0xEF, 0xF0, 0x70, 0x30, 0x18, 0x1F, 0x8F, 0xC7,
  0xE3, 0x03, 0x81, 0x80, 0xF8, 0xFE, 0x27, 0x01, 0x80, 0xC0, 0xE0, 0x74,
  0x73, 0xF9, 0xF0, 0x07, 0x87, 0xC6, 0x06, 0x07, 0x03, 0x03, 0xF9, 0xFC,
  0xE6, 0x63, 0xB1, 0x98, 0xCC, 0xE6, 0x73, 0xF0, 0xF0, 0x3F, 0xBF, 0xDF,
  0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03,
  0x03, 0x81, 0x80, 0x0F, 0x0F, 0xCE, 0x66, 0x33, 0x19, 0xDC, 0x7C, 0x3C,
  0x3E, 0x3B, 0xB8, 0xD8, 0x6C, 0x37, 0x3B, 0xF8, 0xF8, 0x0F, 0x0F, 0xCE,
  0xE6, 0x33, 0x1B, 0x8D, 0xCE, 0xE7, 0x7F, 0x9F, 0x80, 0xC0, 0xE0, 0x60,
  0x73, 0xF1, 0xF0, 0x39, 0xCC, 0x00, 0x00, 0x00, 0x03, 0x39, 0xC0, 0x0C,
  0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC7, 0x1C, 0x63, 0x8C, 0x00, 0x00,
  0x81, 0xC3, 0xC7, 0x8F, 0x07, 0x01, 0xE0, 0x3E, 0x07, 0x80, 0xC0, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x70, 0x3E, 0x07, 0xC0, 0xF8,
  0x3C, 0x78, 0xF0, 0xE0, 0x40, 0x00, 0x1E, 0x3F, 0x27, 0x03, 0x07, 0x06,
  0x0C, 0x1C, 0x38, 0x30, 0x30, 0x00, 0x00, 0x60, 0x60, 0xE0, 0x01, 0xE0,
  0x1F, 0xC0, 0xC1, 0x86, 0x02, 0x11, 0xCC, 0xCF, 0xB2, 0x64, 0xD9, 0x32,
  0x6C, 0xC9, 0x32, 0x64, 0xD9, 0x93, 0x6C, 0xCE, 0xE1, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0xF8,
  0x6C, 0x36, 0x3B, 0x19, 0x9C, 0xCF, 0xE7, 0xF7, 0x1B, 0x0F, 0x87, 0x83,
  0x1F, 0x07, 0xF1, 0x9C, 0x63, 0x38, 0xCE, 0x73, 0x18, 0xFC, 0x3F, 0x1C,
  0xE7, 0x19, 0x8E, 0x63, 0xB9, 0xCF, 0xF3, 0xF0, 0x07, 0x87, 0xF3, 0xC8,
  0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xE0,
  0x38, 0x8F, 0xE1, 0xF8, 0x1F, 0x03, 0xF8, 0x7F, 0x0C, 0x73, 0x8E, 0x71,
  0xCC, 0x39, 0x87, 0x30, 0xCE, 0x39, 0xC7, 0x30, 0xC6, 0x39, 0xCE, 0x3F,
  0x87, 0xE0, 0x1F, 0xC7, 0xE1, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xFC,
  0x3F, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0F, 0xE3, 0xF0, 0x1F, 0xC7,
  0xE1, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xFC, 0x3F, 0x1F, 0x87, 0x01,
  0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0x07, 0xC3, 0xFC, 0x73, 0x1C, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x3E, 0xE7, 0x98, 0xF3, 0x06, 0x61, 0xCE, 0x39,
  0xC6, 0x1F, 0xC1, 0xF8, 0x1C, 0x71, 0xC7, 0x18, 0x61, 0x86, 0x38, 0x63,
  0x8E, 0x30, 0xE3, 0xFC, 0x3F, 0xC7, 0x1C, 0x71, 0xC6, 0x1C, 0x61, 0x8E,
  0x18, 0xE3, 0x8E, 0x38, 0x1F, 0x8F, 0xC1, 0x81, 0xC0, 0xC0, 0x60, 0x30,
  0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC1, 0xE1, 0xF8, 0x03, 0x81,
  0xC0, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80,
  0xC0, 0x60, 0x70, 0x38, 0x18, 0x1C, 0x3E, 0x1E, 0x00, 0x1C, 0x71, 0x8E,
  0x18, 0xC1, 0x98, 0x3B, 0x83, 0xF0, 0x36, 0x03, 0xE0, 0x3E, 0x07, 0x60,
  0x76, 0x06, 0x60, 0x67, 0x06, 0x70, 0xE3, 0x0C, 0x30, 0x1C, 0x30, 0x60,
  0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x06, 0x1C, 0x3F, 0xFE, 0x1C,
  0x0F, 0x1E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3E, 0x36, 0x3C, 0x36,
  0x6C, 0x36, 0x6C, 0x36, 0xFC, 0x76, 0xDC, 0x66, 0xD8, 0x67, 0x98, 0x67,
  0x98, 0x67, 0x38, 0xE7, 0x38, 0xC6, 0x30, 0x1C, 0x38, 0xE1, 0x87, 0x0C,
  0x3C, 0x63, 0xE7, 0x1B, 0x30, 0xD9, 0x86, 0xCC, 0x36, 0x63, 0xBF, 0x18,
  0xF0, 0xC7, 0x86, 0x3C, 0x31, 0xE3, 0x8F, 0x18, 0x70, 0x07, 0x87, 0xF3,
  0x9C, 0xC3, 0x70, 0xD8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1B, 0x0E,
  0xC3, 0xB9, 0xCF, 0xE1, 0xF0, 0x1F, 0x07, 0xF1, 0x9C, 0x63, 0x38, 0xCE,
  0x33, 0x1C, 0xCE, 0x3F, 0x9F, 0xC7, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03,
  0x80, 0x07, 0x87, 0xF3, 0x9C, 0xC3, 0x70, 0xD8, 0x3E, 0x0F, 0x83, 0xE1,
  0xF8, 0x7C, 0x1B, 0x0E, 0xC3, 0xB9, 0xCF, 0xE1, 0xF0, 0x1C, 0x03, 0x00,
  0xE0, 0x38, 0x1F, 0x07, 0xE1, 0x9C, 0x67, 0x39, 0xCE, 0x73, 0x1C, 0xCE,
  0x3F, 0x1F, 0x86, 0x61, 0x98, 0x67, 0x19, 0xCE, 0x73, 0x0C, 0x0F, 0x87,
  0xF3, 0xD8, 0xE0, 0x30, 0x0E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70,
  0x1C, 0x07, 0x23, 0x8F, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0x38, 0x30, 0x30,
  0x30, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0x38, 0xE6,
  0x18, 0xC3, 0x18, 0x67, 0x1C, 0xE3, 0x98, 0x63, 0x0C, 0xE3, 0x9C, 0x73,
  0x8E, 0x61, 0x8C, 0x71, 0xCE, 0x3F, 0x83, 0xE0, 0xC1, 0xF0, 0x6C, 0x3B,
  0x0C, 0xC7, 0x31, 0x8C, 0x63, 0x30, 0xCC, 0x37, 0x0D, 0x83, 0x60, 0xF0,
  0x3C, 0x0E, 0x03, 0x80, 0xC3, 0x0F, 0x86, 0x1B, 0x1C, 0x36, 0x38, 0xEC,
  0x71, 0x99, 0xE7, 0x33, 0xCC, 0x67, 0x98, 0xDB, 0x71, 0xB6, 0xC3, 0xCD,
  0x87, 0x9E, 0x0F, 0x3C, 0x1C, 0x78, 0x38, 0xE0, 0x61, 0xC0, 0x1C, 0x70,
  0xCE, 0x0C, 0xC0, 0xDC, 0x0D, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xF0, 0x1F, 0x03, 0xB0, 0x33, 0x07, 0x30, 0x63, 0x0E, 0x38, 0xC3, 0xE1,
  0xB9, 0xDC, 0xCE, 0xC3, 0x61, 0xE0, 0xF0, 0x70, 0x38, 0x18, 0x0C, 0x06,
  0x07, 0x03, 0x81, 0x80, 0x0F, 0xE3, 0xF8, 0x07, 0x00, 0xC0, 0x38, 0x06,
  0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x3F,
  0xC7, 0xF0, 0x0F, 0x87, 0xC3, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18,
  0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x3E, 0x1F,
  0x00, 0xCC, 0xE6, 0x66, 0x66, 0x67, 0x33, 0x33, 0x33, 0x0F, 0x87, 0xC0,
  0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0,
  0x60, 0x30, 0x18, 0x1C, 0x0C, 0x1E, 0x1F, 0x00, 0x06, 0x03, 0x03, 0xC1,
  0xE1, 0xB1, 0xD8, 0xCE, 0xC3, 0xE1, 0x80, 0xFE, 0xE6, 0x73, 0x1E, 0xCF,
  0xF3, 0xB9, 0xC6, 0x71, 0x98, 0xE6, 0x39, 0x8C, 0xE3, 0x39, 0xC7, 0xF1,
  0xF8, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xFC, 0xFE, 0x73, 0x31, 0xB8,
  0xDC, 0x6C, 0x36, 0x3B, 0x1B, 0x9D, 0xFC, 0xDC, 0x00, 0x0F, 0x1F, 0x38,
  0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0x62, 0x7C, 0x3C, 0x00, 0x60, 0x1C,
  0x03, 0x00, 0x60, 0x0C, 0x3F, 0x87, 0xF1, 0xDC, 0x71, 0x8E, 0x31, 0x8E,
  0x31, 0xC6, 0x31, 0xC6, 0x39, 0xC3, 0xF8, 0x7A, 0x00, 0x0F, 0x0F, 0xCC,
  0x6E, 0x76, 0x33, 0xF1, 0xE0, 0xC0, 0xE0, 0x30, 0x1F, 0x87, 0xC0, 0x00,
  0xE0, 0x3C, 0x0E, 0x01, 0x80, 0x30, 0x0F, 0x83, 0xE0, 0x38, 0x06, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0x60, 0x1C, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x61, 0xFC, 0x77, 0x1C, 0x63,
  0x8C, 0x63, 0x8C, 0x71, 0x8C, 0x71, 0x8E, 0x70, 0xFE, 0x1F, 0x80, 0x30,
  0x06, 0x21, 0xC7, 0xF0, 0xFC, 0x00, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81,
  0xFC, 0xFE, 0x73, 0x31, 0xB8, 0xDC, 0xEC, 0x66, 0x33, 0x1B, 0x9D, 0xCE,
  0xC6, 0x00, 0x08, 0x71, 0x80, 0x00, 0xE3, 0x8C, 0x31, 0xC7, 0x18, 0x61,
  0x8E, 0x38, 0xC0, 0x01, 0x01, 0xC0, 0xC0, 0x00, 0x00, 0x38, 0x1C, 0x0C,
  0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06,
  0x07, 0x0F, 0x07, 0x80, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x73,
  0x38, 0xCC, 0x36, 0x0F, 0x87, 0xC1, 0xF0, 0x7E, 0x1B, 0x8E, 0x63, 0x18,
  0xC7, 0x00, 0x1C, 0x71, 0x86, 0x18, 0xE3, 0x8C, 0x31, 0xC7, 0x18, 0x61,
  0x8E, 0x38, 0xC0, 0x37, 0x38, 0xFF, 0xF3, 0x9D, 0xCC, 0x67, 0x73, 0x99,
  0xCC, 0x66, 0x31, 0x98, 0xC6, 0x63, 0x3B, 0x9C, 0xCE, 0x63, 0x31, 0x8C,
  0x37, 0x9F, 0xCE, 0x66, 0x37, 0x1B, 0x9D, 0x8C, 0xC6, 0x63, 0x73, 0xB9,
  0xD8, 0xC0, 0x0F, 0x0F, 0xCC, 0xEE, 0x36, 0x1B, 0x0D, 0x8E, 0xC6, 0xE3,
  0x33, 0x9F, 0x87, 0x80, 0x1B, 0xC7, 0xF1, 0xCC, 0x63, 0x18, 0xCE, 0x33,
  0x0C, 0xC7, 0x31, 0x9C, 0xE7, 0xF1, 0xB8, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xC0, 0x00, 0x0E, 0xC7, 0xF3, 0xB8, 0xC6, 0x71, 0x98, 0xE6, 0x39, 0x8C,
  0xE3, 0x39, 0xC7, 0xF1, 0xF8, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x00,
  0x37, 0x3E, 0x3E, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xC0,
  0x1F, 0x3E, 0x72, 0x70, 0x70, 0x38, 0x1C, 0x0C, 0x0C, 0x8C, 0xFC, 0xF8,
  0x10, 0xC3, 0x1F, 0xF9, 0x86, 0x18, 0xE3, 0x8C, 0x30, 0xC3, 0xCF, 0x00,
  0x39, 0xCC, 0x63, 0x18, 0xC6, 0x73, 0x9C, 0xE6, 0x31, 0x8C, 0x67, 0x39,
  0xC7, 0xE1, 0xF8, 0xE3, 0xE7, 0xE6, 0xE6, 0xEC, 0xEC, 0xFC, 0xF8, 0x58,
  0x70, 0x70, 0x60, 0xE7, 0x1F, 0x39, 0xBB, 0xCD, 0xDE, 0xEC, 0xF6, 0x6D,
  0xB3, 0x6F, 0x1A, 0x78, 0xF3, 0xC7, 0x9C, 0x38, 0xE1, 0xC6, 0x00, 0x18,
  0xC6, 0x61, 0xB8, 0x7C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x36, 0x0D, 0x86,
  0x73, 0x9C, 0x1C, 0x71, 0xC6, 0x1C, 0xC0, 0xCC, 0x0D, 0xC0, 0xD8, 0x0F,
  0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x0F, 0x00, 0xF0, 0x00, 0x1F, 0x8F, 0x89, 0xC0, 0xC0, 0xE0, 0x60, 0x60,
  0x70, 0x30, 0x38, 0x3F, 0x9F, 0x80, 0x01, 0x83, 0xC3, 0x81, 0x80, 0xC0,
  0x60, 0x70, 0x38, 0x38, 0x38, 0x3C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0,
  0x70, 0x3C, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x1E,
  0x0E, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x07, 0x0F, 0x1C, 0x18, 0x38,
  0x38, 0x30, 0x30, 0xF0, 0xE0, 0xF8, 0xFF, 0xE1, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 16, 5, 0, -16 },
  { 13, 7, 6, 8, 2, -16 },
  { 19, 11, 16, 10, 0, -16 },
  { 41, 10, 18, 9, 0, -17 },
  { 64, 13, 16, 15, 1, -16 },
  { 90, 10, 16, 11, 0, -16 },
  { 110, 4, 6, 5, 2, -16 },
  { 113, 7, 19, 6, 0, -16 },
  { 130, 7, 19, 6, -2, -16 },
  { 147, 8, 9, 9, 2, -17 },
  { 156, 9, 10, 10, 1, -13 },
  { 168, 4, 6, 5, -1, -3 },
  { 171, 6, 2, 6, 0, -7 },
  { 173, 3, 3, 5, 0, -3 },
  { 175, 11, 16, 8, -1, -16 },
  { 197, 9, 16, 9, 0, -16 },
  { 215, 7, 16, 9, 2, -16 },
  { 229, 10, 16, 9, -1, -16 },
  { 249, 9, 16, 9, 0, -16 },
  { 267, 9, 16, 9, 0, -16 },
  { 285, 9, 16, 9, 0, -16 },
  { 303, 9, 16, 9, 1, -16 },
  { 321, 9, 16, 9, 1, -16 },
  { 339, 9, 16, 9, 0, -16 },
  { 357, 9, 16, 9, 0, -16 },
  { 375, 5, 12, 5, 0, -12 },
  { 383, 6, 15, 5, -1, -12 },
  { 395, 9, 10, 10, 1, -13 },
  { 407, 9, 6, 10, 1, -11 },
  { 414, 9, 10, 10, 1, -13 },
  { 426, 8, 16, 7, 0, -16 },
  { 442, 14, 18, 14, 0, -16 },
  { 474, 9, 16, 10, -1, -16 },
  { 492, 10, 16, 10, 0, -16 },
  { 512, 10, 16, 9, 1, -16 },
  { 532, 11, 16, 11, 0, -16 },
  { 554, 10, 16, 8, 0, -16 },
  { 574, 10, 16, 8, 0, -16 },
  { 594, 11, 16, 11, 1, -16 },
  { 616, 12, 16, 11, 0, -16 },
  { 640, 9, 16, 7, -1, -16 },
  { 658, 9, 20, 5, -3, -16 },
  { 681, 12, 16, 10, 0, -16 },
  { 705, 7, 16, 8, 0, -16 },
  { 719, 16, 16, 15, 0, -16 },
  { 751, 13, 16, 12, 0, -16 },
  { 777, 10, 16, 12, 1, -16 },
  { 797, 10, 16, 10, 0, -16 },
  { 817, 10, 20, 12, 1, -16 },
  { 842, 10, 16, 10, 0, -16 },
  { 862, 10, 16, 9, 0, -16 },
  { 882, 8, 16, 8, 2, -16 },
  { 898, 11, 16, 11, 1, -16 },
  { 920, 10, 16, 10, 2, -16 },
  { 940, 15, 16, 15, 2, -16 },
  { 970, 12, 16, 9, -1, -16 },
  { 994, 9, 16, 9, 2, -16 },
  { 1012, 11, 16, 8, -1, -16 },
  { 1034, 9, 20, 6, -1, -16 },
  { 1057, 4, 16, 8, 2, -16 },
  { 1065, 9, 20, 6, -2, -16 },
  { 1088, 9, 9, 9, 0, -16 },
  { 1099, 7, 1, 7, -2, 2 },
  { 1100, 4, 4, 6, 3, -17 },
  { 1102, 10, 12, 10, 0, -12 },
  { 1117, 9, 17, 10, 0, -17 },
  { 1137, 8, 12, 8, 0, -12 },
  { 1149, 11, 17, 10, 0, -17 },
  { 1173, 9, 12, 9, 0, -12 },
  { 1187, 11, 22, 6, -3, -17 },
  { 1218, 11, 17, 10, -1, -12 },
  { 1242, 9, 17, 10, 0, -17 },
  { 1262, 6, 17, 5, 0, -17 },
  { 1275, 9, 22, 5, -3, -17 },
  { 1300, 10, 17, 9, 0, -17 },
  { 1322, 6, 17, 5, 0, -17 },
  { 1335, 14, 12, 14, 0, -12 },
  { 1356, 9, 12, 10, 0, -12 },
  { 1370, 9, 12, 9, 0, -12 },
  { 1384, 10, 17, 10, -1, -12 },
  { 1406, 10, 17, 10, 0, -12 },
  { 1428, 8, 12, 7, 0, -12 },
  { 1440, 8, 12, 8, 0, -12 },
  { 1452, 6, 15, 6, 1, -15 },
  { 1464, 10, 12, 10, 0, -12 },
  { 1479, 8, 12, 8, 1, -12 },
  { 1491, 13, 12, 13, 1, -12 },
  { 1511, 10, 12, 8, -1, -12 },
  { 1526, 12, 17, 8, -2, -12 },
  { 1552, 9, 12, 7, -1, -12 },
  { 1566, 9, 19, 7, 0, -16 },
  { 1588, 2, 22, 8, 3, -17 },
  { 1594, 8, 19, 7, -1, -16 },
  { 1613, 9, 3, 10, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC22PT7B_H_
