#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC64PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x00, 0x1F,
  0xC3, 0xF8, 0xFE, 0x3F, 0xCF, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F,
  0x1F, 0xC3, 0xF0, 0xFC, 0x1F, 0x87, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF0,
  0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3E, 0x07, 0xC1,
  0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFC, 0xE3, 0x80, 0x3F, 0x8C, 0x18, 0x03, 0xF0, 0xC0, 0x00,
  0x3F, 0x1C, 0x00, 0x03, 0xF1, 0xC0, 0x00, 0x3F, 0x18, 0x00, 0x03, 0xF1,
  0x80, 0x00, 0x3F, 0xB8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xEF, 0xE0, 0x00,
  0x0C, 0xFF, 0x00, 0x00, 0xC7, 0xF0, 0x00, 0x1C, 0x7F, 0x00, 0x01, 0xC7,
  0xE0, 0x40, 0x18, 0x7E, 0x06, 0x01, 0x8F, 0xE0, 0x70, 0x18, 0xFE, 0x07,
  0xE3, 0xBF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x3F,
  0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0x80, 0x3F,
  0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x01, 0xF8, 0xFC, 0x07, 0xE0, 0x07, 0xC3,
  0xF0, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x3F, 0x03, 0xE0,
  0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0xFC, 0x00, 0x7C, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0x3E, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x7C, 0x00,
  0x1F, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0x7C,
  0x7E, 0x00, 0x0F, 0x83, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F, 0x8F, 0xC3, 0xFC,
  0xF8, 0x3E, 0x3E, 0x3F, 0xFB, 0xE1, 0xF9, 0xF8, 0xFF, 0xEF, 0xC7, 0xC7,
  0xC7, 0xFF, 0xBF, 0xFE, 0x3E, 0x3F, 0x3F, 0x7F, 0xF8, 0xF8, 0xF8, 0x7D,
  0xFF, 0xC7, 0xC7, 0xC1, 0xF3, 0xFE, 0x3F, 0x1F, 0x07, 0xC7, 0xF0, 0xF8,
  0xFC, 0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x7C, 0x00, 0x1F, 0x0F, 0x83, 0xF0,
  0x00, 0xFC, 0x3E, 0x0F, 0xC0, 0x03, 0xE1, 0xF8, 0x3E, 0x00, 0x1F, 0x87,
  0xC0, 0xF8, 0x00, 0x7C, 0x1F, 0x03, 0xE0, 0x03, 0xF0, 0x7C, 0x1F, 0x80,
  0x0F, 0x81, 0xF0, 0x7C, 0x00, 0x7E, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x3F,
  0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x3E, 0x00, 0x3E, 0x03, 0xF0, 0xF8, 0x01,
  0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0xC0, 0x1F, 0x3F, 0x00, 0x3E, 0x00, 0x7F,
  0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF8,
  0xFE, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFE, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0xC1, 0xFC, 0x3F, 0xFF, 0x87, 0xF0, 0xFE,
  0xFE, 0x1F, 0x87, 0xF3, 0xF8, 0xFE, 0x3F, 0x87, 0xF3, 0xF0, 0xFC, 0x1F,
  0xDF, 0xC7, 0xF0, 0x7F, 0xFF, 0x1F, 0xC0, 0xFF, 0xF8, 0xFE, 0x03, 0xFF,
  0xE3, 0xF8, 0x0F, 0xFF, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0x80, 0x7F, 0xE0,
  0xFE, 0x01, 0xFF, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xC1, 0xFF, 0xC0, 0xFF, 0xDF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xCF, 0xF0, 0x3F, 0xFE, 0x1F, 0xE0, 0x3F, 0xE0,
  0x7F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF0, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x06, 0x07, 0xC0, 0x0F, 0x0F, 0x80, 0x1F, 0x9F, 0x02, 0x7F, 0xBE, 0x7C,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F,
  0xBF, 0x00, 0xFF, 0x3F, 0x01, 0xFC, 0x7E, 0x01, 0xF0, 0x7E, 0x01, 0xE0,
  0xFE, 0x01, 0x81, 0xF0, 0x01, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F,
  0x80, 0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x0E, 0x1F, 0x9F, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFE, 0x7E, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC3, 0xF8,
  0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F,
  0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0x7F,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xE3, 0xF8, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F,
  0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x7F, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF,
  0xF0, 0xFF, 0xFE, 0x7F, 0xDF, 0xC7, 0xF3, 0xF8, 0x78, 0x7E, 0x0E, 0x1F,
  0xC0, 0x83, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFC, 0x3F, 0xE0, 0x0F, 0x80, 0xFF, 0x00, 0x38, 0x07, 0xF8,
  0x01, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x7C, 0x1F, 0xF0, 0x07, 0x00, 0xFF, 0x00, 0x40, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x80, 0x03, 0xFC, 0x0E, 0x00, 0x7F, 0xC0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0x79, 0xF8,
  0x00, 0x0F, 0x9F, 0x80, 0x01, 0xF3, 0xF8, 0x00, 0x1F, 0x3F, 0x80, 0x03,
  0xE3, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0xF8, 0x7F,
  0x00, 0x1F, 0x07, 0xF0, 0x01, 0xF0, 0x7F, 0x00, 0x3E, 0x07, 0xE0, 0x07,
  0xE0, 0xFE, 0x00, 0x7C, 0x0F, 0xE0, 0x0F, 0x80, 0xFE, 0x01, 0xF8, 0x0F,
  0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x07,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x60, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x02, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC1, 0x00, 0x07, 0xF8,
  0x20, 0x01, 0xFE, 0x07, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x07, 0xF8, 0x04, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE3, 0xF8, 0x03, 0xF9, 0xFF, 0x00, 0xFE, 0xFF, 0xE0,
  0x3F, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0x07,
  0xF8, 0x7F, 0x81, 0xFE, 0x3F, 0xE0, 0x3F, 0x8F, 0xF0, 0x0F, 0xE3, 0xFC,
  0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x3F,
  0xC3, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xE0,
  0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFB, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0,
  0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xCF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF3, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x3F,
  0xC1, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x87, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0x8F, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F,
  0xC0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFF, 0x0F, 0xE0,
  0x1F, 0xE1, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x83, 0xF8, 0x3F, 0xE0,
  0x7F, 0xDF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE,
  0xFC, 0x01, 0xFF, 0xBF, 0x80, 0x1F, 0xC7, 0xF0, 0x00, 0x40, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x07,
  0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0xC0, 0x7F, 0x81,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x04, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x78, 0x3F,
  0xC1, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xC0, 0x7C, 0x07, 0xFF, 0x87, 0x81,
  0xF0, 0x1F, 0xFF, 0x0F, 0x83, 0xE0, 0x7F, 0xFC, 0x1F, 0x0F, 0x81, 0xF8,
  0xF8, 0x3E, 0x1F, 0x07, 0xE1, 0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF0,
  0xF8, 0x3E, 0x0F, 0x81, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xC1, 0xF0,
  0x3E, 0x0F, 0x8F, 0x83, 0xE0, 0x7C, 0x1F, 0x1F, 0x07, 0xC1, 0xF8, 0x3E,
  0x3E, 0x1F, 0x03, 0xE0, 0x78, 0x78, 0x3E, 0x07, 0xC1, 0xF1, 0xF0, 0x7C,
  0x0F, 0x83, 0xE3, 0xE0, 0xF8, 0x3F, 0x07, 0x87, 0xC3, 0xE0, 0x7C, 0x0F,
  0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x1F, 0x0F, 0x83, 0xF0, 0x78, 0x3C, 0x1F,
  0x07, 0xE1, 0xF0, 0x78, 0x3E, 0x1F, 0xC3, 0xC1, 0xF0, 0x7E, 0x3F, 0x8F,
  0x83, 0xE0, 0xFF, 0xEF, 0xFE, 0x07, 0xC0, 0xFF, 0xDF, 0xF8, 0x0F, 0x81,
  0xFF, 0x3F, 0xE0, 0x0F, 0x01, 0xFC, 0x3F, 0x80, 0x1E, 0x00, 0x60, 0x1C,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x03,
  0xFC, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xBF, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0x3F,
  0x00, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0x7F, 0x07,
  0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x1F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF3,
  0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7, 0xF8, 0x00, 0x7F, 0x7F, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0xFF, 0xC0, 0x3F, 0x80, 0xFF, 0x00,
  0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F,
  0x00, 0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0xC0, 0x3F, 0x81, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01,
  0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0x7F,
  0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0x80,
  0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0x07, 0x80,
  0x3F, 0xE0, 0x08, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x40, 0x0F, 0xF8, 0x0E, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0xFE, 0x03, 0xFC,
  0x01, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F,
  0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFE,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFE, 0x0F, 0xF0,
  0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03,
  0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F,
  0xC0, 0xFF, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0x81, 0xF0, 0x01, 0xFF, 0x00, 0x38, 0x01, 0xFF, 0x00, 0x04, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x03, 0xFF, 0xC1, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0x01, 0xFF,
  0xF0, 0x7F, 0x00, 0xFF, 0xF0, 0x3F, 0x80, 0x7F, 0xF8, 0x1F, 0xC0, 0x3F,
  0xFC, 0x1F, 0xE0, 0x20, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0,
  0x03, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x02, 0x3F, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03,
  0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xDF, 0xC0,
  0x1F, 0x9F, 0x00, 0x7E, 0xFE, 0x00, 0xFC, 0xF8, 0x07, 0xE7, 0xE0, 0x07,
  0xE7, 0xE0, 0x3F, 0x7F, 0x00, 0x7F, 0x3F, 0x03, 0xF3, 0xF8, 0x03, 0xF9,
  0xF8, 0x1F, 0x9F, 0xC0, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x00, 0xFC, 0x7E,
  0x0F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF0, 0xFE, 0x7F, 0x00, 0x7F, 0x1F, 0x87,
  0xE3, 0xF8, 0x03, 0xF8, 0xFC, 0x3F, 0x1F, 0xC0, 0x1F, 0x87, 0xE3, 0xF0,
  0xFC, 0x00, 0xFC, 0x3F, 0x1F, 0x8F, 0xE0, 0x0F, 0xE1, 0xF9, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xCF, 0xC3, 0xF8, 0x03, 0xF8, 0x7E, 0xFC, 0x1F, 0xC0,
  0x1F, 0x83, 0xF7, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xFF, 0x83, 0xF8, 0x03, 0xF0,
  0x3F, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xFF, 0xC1, 0xFC, 0x00, 0xFC, 0x0F,
  0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xFE,
  0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFF, 0x01,
  0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x03, 0xFE, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x0F,
  0xE0, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x03, 0xF0, 0x03, 0xFF,
  0xC0, 0x1F, 0x80, 0x1F, 0xFF, 0x01, 0xFC, 0x00, 0xFD, 0xF8, 0x0F, 0xE0,
  0x07, 0xEF, 0xC0, 0x7F, 0x00, 0x7F, 0x7E, 0x03, 0xF0, 0x03, 0xFB, 0xF0,
  0x1F, 0x80, 0x1F, 0x9F, 0x81, 0xFC, 0x00, 0xFC, 0xFE, 0x0F, 0xE0, 0x07,
  0xE3, 0xF0, 0x7F, 0x00, 0x7F, 0x1F, 0x83, 0xF0, 0x03, 0xF8, 0xFC, 0x3F,
  0x80, 0x1F, 0x87, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFC, 0x7E, 0x00, 0x7F, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0x3F, 0x3F, 0x80,
  0x1F, 0x81, 0xF9, 0xFC, 0x00, 0xFC, 0x0F, 0xCF, 0xE0, 0x0F, 0xE0, 0x7E,
  0x7E, 0x00, 0x7F, 0x03, 0xFB, 0xF0, 0x03, 0xF8, 0x0F, 0xDF, 0x80, 0x1F,
  0x80, 0x7F, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F, 0xFE,
  0x00, 0x7F, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0x80,
  0x1F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x0F,
  0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x03,
  0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0x80,
  0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x01,
  0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF,
  0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x0F,
  0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xE1, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x81,
  0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0,
  0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x0F,
  0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x0F, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x07,
  0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xFC, 0xFF, 0x00,
  0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03,
  0xFC, 0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFC,
  0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x0F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xF8, 0xFF, 0xC0, 0x1F, 0xC1, 0xFF, 0x00, 0xFE,
  0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0,
  0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE,
  0x03, 0xFC, 0x07, 0xE0, 0x3F, 0xC0, 0x7F, 0x03, 0xFE, 0x03, 0xF8, 0x7F,
  0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00,
  0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFC,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xBF, 0x80, 0x3F, 0xE0, 0x1C, 0x01, 0xFE, 0x00,
  0x40, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x20, 0x00, 0xFF, 0x01, 0xC0, 0x0F,
  0xF0, 0x1F, 0x81, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03,
  0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x07,
  0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x07,
  0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F,
  0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x1F,
  0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F,
  0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F,
  0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x1F, 0xEF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x0F,
  0xC1, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0xFC, 0xFE, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF9, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x1F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x8F,
  0xE0, 0x0F, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0xC0, 0x1F, 0xC3, 0xF8,
  0x03, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xF0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFF,
  0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xFF, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0xF8,
  0x1F, 0xC0, 0x7F, 0x03, 0xFF, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0x7E, 0x0F,
  0xE0, 0x1F, 0xC1, 0xFB, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xDF, 0x83, 0xF8,
  0x07, 0xF0, 0xFC, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xE7, 0xE1, 0xFC, 0x01,
  0xFC, 0x3E, 0x3F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF1, 0xF8, 0xFE, 0x00, 0x7F,
  0x1F, 0x8F, 0x87, 0xF0, 0x03, 0xF9, 0xF8, 0x7C, 0x7F, 0x00, 0x1F, 0x8F,
  0xC3, 0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x1F, 0x1F, 0x80, 0x07, 0xE7, 0xE0,
  0xF9, 0xFC, 0x00, 0x3F, 0x3F, 0x07, 0xCF, 0xE0, 0x01, 0xFB, 0xF0, 0x3E,
  0xFE, 0x00, 0x0F, 0xDF, 0x81, 0xF7, 0xF0, 0x00, 0x7E, 0xFC, 0x0F, 0xBF,
  0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x7E, 0x7F, 0x00,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x01, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xF9, 0xFC,
  0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1,
  0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8,
  0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xEF, 0xE0, 0x01,
  0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xE7, 0xE0,
  0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF8,
  0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC0,
  0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0x7E, 0x7F, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0x80,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF0,
  0x7E, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x07, 0xFE, 0x7F, 0x00,
  0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0x7E, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x07, 0xF8, 0x7F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0xC0,
  0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8,
  0x7F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE,
  0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x07, 0xFC, 0x07, 0xF9, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xDF, 0x80, 0x3F, 0xF9, 0xF8, 0x03,
  0xFF, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x1F,
  0x80, 0x0F, 0xEF, 0xFC, 0x01, 0xFB, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xE1, 0xFE, 0x0F, 0xF8, 0x1F,
  0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE,
  0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03,
  0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F,
  0xF1, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0x3F, 0xFC,
  0x07, 0xE7, 0xFF, 0x00, 0xF8, 0x7F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0x06, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x04, 0x07, 0xF8, 0x18, 0x0F, 0xFD,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0xF3, 0xF8, 0x00, 0xFF, 0xF7,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xF0,
  0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x07,
  0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x7F, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x7E, 0x00, 0x0F, 0xFC, 0xFC,
  0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x03, 0xFC, 0x7F, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0xFE,
  0x3F, 0x81, 0xFE, 0x3F, 0x07, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x20,
  0x7F, 0x80, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0x84, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xF9, 0xFC, 0x00, 0x7F, 0xFB,
  0xF0, 0x01, 0xFF, 0xF7, 0xE0, 0x07, 0xFF, 0xEF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xC3, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8,
  0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x07,
  0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0x00, 0x0F, 0xFC, 0xFE,
  0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x03, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x03, 0x00, 0x0F, 0xE0, 0x07,
  0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xCF, 0xFC, 0x01, 0xFB, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F,
  0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFE,
  0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF0,
  0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0,
  0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0x7F, 0x01,
  0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F,
  0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x00, 0xFE, 0x01, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0xFE, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFB,
  0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x03, 0xFC,
  0x7E, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFE,
  0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00,
  0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0xFE, 0x03, 0xF8,
  0x01, 0xF1, 0xFF, 0x87, 0xFC, 0x01, 0xF3, 0xFF, 0x9F, 0xFE, 0x03, 0xF7,
  0xFF, 0xDF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x1F, 0x80, 0x7E,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x00,
  0xFC, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x1F,
  0x80, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x3F, 0x80, 0x7E,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x3F, 0xF0, 0x07, 0xCF, 0xFF,
  0x01, 0xFB, 0xFF, 0xE0, 0x3F, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0x87, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8,
  0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x83, 0xF8, 0x07, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x83,
  0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x07,
  0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F,
  0x80, 0x7E, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F,
  0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x07, 0xF0,
  0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xE1, 0xFE, 0x1F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3,
  0xF8, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x1F,
  0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF0, 0x03, 0xFB, 0xF8, 0x03,
  0xFD, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x1F, 0x80,
  0x7F, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x7F, 0x83, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3E, 0x0F, 0xE0, 0x00, 0xF8,
  0xFF, 0xC0, 0x03, 0xE7, 0xFF, 0x80, 0x1F, 0x9F, 0xFE, 0x00, 0x7E, 0xFF,
  0xFC, 0x01, 0xFF, 0xDF, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F,
  0x00, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03,
  0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03,
  0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xFB, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xF7, 0xFF, 0xC0, 0x1F, 0xDF, 0xFE, 0x00, 0x7F, 0x3F,
  0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xE0, 0x60, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x07, 0xFE, 0x3F, 0x00, 0xFF, 0xF7,
  0xE0, 0x1F, 0xFF, 0x7E, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07,
  0xF8, 0x7F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x03,
  0xFC, 0x1F, 0xC0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x83,
  0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x07, 0xFD, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xDF, 0x80, 0x3F, 0xFB, 0xF8, 0x03, 0xFF, 0x3F,
  0x80, 0x1F, 0xE3, 0xF8, 0x00, 0x38, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0xFE,
  0x03, 0xE3, 0xF8, 0x07, 0xCF, 0xF0, 0x1F, 0xBF, 0xE0, 0x3F, 0x7F, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x84, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFE, 0xFC, 0x07, 0xF8, 0x1C, 0x07,
  0xF0, 0x08, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x80,
  0x0F, 0xE0, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xFF, 0x0F, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xF0, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE3, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x01, 0x80, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xE0,
  0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x7F, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x07,
  0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x1F,
  0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xC0, 0xFE,
  0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0,
  0x7F, 0x81, 0xF8, 0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0xFF, 0x80,
  0xFF, 0x7F, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xEF, 0xC0, 0x7F, 0xF9,
  0xF0, 0x07, 0xFE, 0x3E, 0x00, 0x7F, 0x8F, 0xC0, 0x01, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xEF,
  0xC0, 0x1F, 0x9F, 0x80, 0x7F, 0x3F, 0x00, 0xFE, 0x7E, 0x03, 0xF8, 0xFC,
  0x07, 0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x87, 0xE0, 0x7E, 0x0F, 0xC1,
  0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F,
  0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xF0, 0x0F, 0xCF, 0xC0,
  0x1F, 0x9F, 0x80, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x01, 0xFD, 0xFC, 0x07,
  0xF8, 0x07, 0xE7, 0xF0, 0x1F, 0xE0, 0x3F, 0x9F, 0x80, 0xFF, 0x80, 0xFE,
  0x7E, 0x03, 0xFE, 0x03, 0xF1, 0xF8, 0x0F, 0xF8, 0x1F, 0xC7, 0xE0, 0x7F,
  0xE0, 0x7E, 0x1F, 0x81, 0xFF, 0x83, 0xF8, 0x7E, 0x0F, 0xFE, 0x0F, 0xC1,
  0xF8, 0x3F, 0xF8, 0x3F, 0x07, 0xE0, 0xFF, 0xE1, 0xFC, 0x1F, 0x87, 0xFF,
  0x87, 0xE0, 0x7E, 0x1F, 0x7E, 0x3F, 0x81, 0xF8, 0xFD, 0xF8, 0xFC, 0x07,
  0xE3, 0xF7, 0xE3, 0xF0, 0x1F, 0x8F, 0x9F, 0x9F, 0xC0, 0x7E, 0x7E, 0x7C,
  0x7E, 0x01, 0xF9, 0xF1, 0xF1, 0xF8, 0x07, 0xE7, 0xC7, 0xCF, 0xC0, 0x1F,
  0xBF, 0x1F, 0x3F, 0x00, 0x7E, 0xF8, 0x7D, 0xFC, 0x01, 0xFB, 0xE1, 0xF7,
  0xE0, 0x07, 0xFF, 0x87, 0xDF, 0x80, 0x1F, 0x7C, 0x1F, 0x7C, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xFC, 0x7E,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F,
  0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8,
  0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x4F, 0xFF,
  0x00, 0x37, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFB, 0x00, 0x1F, 0xFC, 0x80, 0x01, 0xFC,
  0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 18, 47, 16, 0, -46 },
  { 107, 21, 17, 24, 6, -46 },
  { 152, 31, 46, 29, 0, -46 },
  { 331, 28, 53, 26, 0, -49 },
  { 517, 38, 47, 43, 3, -46 },
  { 741, 30, 47, 31, 0, -46 },
  { 918, 10, 17, 14, 6, -46 },
  { 940, 21, 56, 17, 1, -46 },
  { 1087, 21, 56, 17, -5, -46 },
  { 1234, 23, 25, 25, 5, -49 },
  { 1306, 25, 31, 29, 3, -38 },
  { 1403, 13, 17, 14, -3, -8 },
  { 1431, 16, 7, 18, 1, -21 },
  { 1445, 9, 10, 14, 0, -9 },
  { 1457, 31, 46, 23, -3, -46 },
  { 1636, 26, 47, 26, 1, -46 },
  { 1789, 19, 46, 27, 6, -46 },
  { 1899, 29, 46, 26, -2, -46 },
  { 2066, 28, 47, 26, -1, -46 },
  { 2231, 28, 46, 27, -1, -46 },
  { 2392, 27, 47, 26, 0, -46 },
  { 2551, 26, 47, 26, 2, -46 },
  { 2704, 28, 46, 26, 2, -46 },
  { 2865, 28, 47, 26, 0, -46 },
  { 3030, 27, 47, 26, 0, -46 },
  { 3189, 14, 36, 15, 0, -35 },
  { 3252, 18, 44, 15, -3, -35 },
  { 3351, 26, 30, 29, 2, -38 },
  { 3449, 26, 19, 29, 2, -32 },
  { 3511, 25, 30, 29, 3, -38 },
  { 3605, 22, 47, 20, 1, -46 },
  { 3735, 39, 51, 40, 1, -46 },
  { 3984, 28, 46, 28, -4, -46 },
  { 4145, 30, 46, 29, 0, -46 },
  { 4318, 29, 47, 27, 2, -46 },
  { 4489, 31, 46, 32, 0, -46 },
  { 4668, 28, 46, 25, 0, -46 },
  { 4829, 28, 46, 24, 0, -46 },
  { 4990, 33, 47, 33, 2, -46 },
  { 5184, 35, 46, 33, 0, -46 },
  { 5386, 27, 46, 19, -3, -46 },
  { 5542, 27, 59, 15, -10, -46 },
  { 5742, 34, 46, 28, 0, -46 },
  { 5938, 19, 46, 23, 0, -46 },
  { 6048, 45, 46, 43, 0, -46 },
  { 6307, 37, 46, 35, 0, -46 },
  { 6520, 31, 47, 34, 2, -46 },
  { 6703, 30, 46, 28, 0, -46 },
  { 6876, 31, 57, 34, 2, -46 },
  { 7097, 29, 46, 29, 0, -46 },
  { 7264, 29, 47, 25, -1, -46 },
  { 7435, 25, 46, 24, 4, -46 },
  { 7579, 32, 47, 32, 2, -46 },
  { 7767, 28, 46, 28, 6, -46 },
  { 7928, 45, 46, 44, 4, -46 },
  { 8187, 35, 46, 26, -4, -46 },
  { 8389, 26, 46, 26, 5, -46 },
  { 8539, 31, 46, 24, -3, -46 },
  { 8718, 25, 56, 18, -2, -46 },
  { 8893, 13, 46, 23, 6, -46 },
  { 8968, 24, 56, 18, -4, -46 },
  { 9136, 27, 27, 27, 0, -46 },
  { 9228, 21, 5, 20, -6, 5 },
  { 9242, 11, 10, 18, 9, -49 },
  { 9256, 28, 36, 29, 1, -35 },
  { 9382, 27, 50, 28, 0, -49 },
  { 9551, 23, 36, 22, 1, -35 },
  { 9655, 31, 50, 29, 1, -49 },
  { 9849, 24, 36, 26, 1, -35 },
  { 9957, 32, 64, 17, -8, -49 },
  { 10213, 31, 50, 29, -2, -35 },
  { 10407, 27, 49, 28, 0, -49 },
  { 10573, 17, 48, 14, 0, -48 },
  { 10675, 25, 63, 14, -8, -48 },
  { 10872, 29, 49, 26, 0, -49 },
  { 11050, 17, 49, 14, 0, -49 },
  { 11155, 40, 35, 42, 0, -35 },
  { 11330, 27, 35, 28, 0, -35 },
  { 11449, 25, 36, 28, 1, -35 },
  { 11562, 30, 50, 28, -3, -35 },
  { 11750, 28, 50, 28, 1, -35 },
  { 11925, 23, 35, 20, 0, -35 },
  { 12026, 24, 36, 22, -1, -35 },
  { 12134, 17, 43, 17, 2, -42 },
  { 12226, 27, 36, 28, 1, -35 },
  { 12348, 23, 35, 24, 4, -35 },
  { 12449, 38, 35, 38, 3, -35 },
  { 12616, 30, 35, 24, -3, -35 },
  { 12748, 33, 50, 24, -5, -35 },
  { 12955, 24, 35, 20, -2, -35 },
  { 13060, 25, 56, 21, 1, -46 },
  { 13235, 7, 64, 24, 8, -49 },
  { 13291, 24, 56, 21, -4, -46 },
  { 13459, 26, 9, 29, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC64PT7B_H_
