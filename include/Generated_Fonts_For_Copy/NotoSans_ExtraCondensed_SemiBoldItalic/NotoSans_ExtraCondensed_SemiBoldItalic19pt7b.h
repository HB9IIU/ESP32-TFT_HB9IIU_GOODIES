#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC19PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xCE, 0x63, 0x18, 0xC4, 0x63, 0x00, 0x8E, 0x60, 0x6F, 0x3D,
  0xB6, 0xD8, 0x0D, 0x86, 0xC2, 0x43, 0x63, 0xFB, 0xFC, 0x48, 0x6C, 0x24,
  0x7F, 0x9B, 0x09, 0x84, 0x86, 0xC0, 0x04, 0x1F, 0x3F, 0x35, 0x38, 0x38,
  0x38, 0x1C, 0x0E, 0x16, 0x96, 0xFC, 0xFC, 0x20, 0x20, 0x30, 0xCF, 0x11,
  0x26, 0x64, 0x8D, 0xB1, 0xB4, 0x25, 0xBF, 0xAD, 0x6D, 0x21, 0x6C, 0x6D,
  0x99, 0x22, 0x3C, 0xC7, 0x00, 0x0E, 0x0F, 0x84, 0xC6, 0x63, 0x60, 0xF0,
  0x70, 0x73, 0x6D, 0xE7, 0xB3, 0xD8, 0xCF, 0xE3, 0xD8, 0x7F, 0x6C, 0x04,
  0x31, 0x84, 0x30, 0xC6, 0x18, 0x61, 0x0C, 0x30, 0xC3, 0x0C, 0x10, 0x60,
  0x18, 0x60, 0x83, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x84, 0x30, 0xC6, 0x10,
  0xC0, 0x20, 0xCB, 0x3F, 0x3D, 0xCD, 0x84, 0x10, 0x20, 0x47, 0xFF, 0xE2,
  0x04, 0x08, 0x10, 0x36, 0x6C, 0xC0, 0x7F, 0xC0, 0x5F, 0x00, 0x01, 0x80,
  0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x10, 0x18, 0x18, 0x0C, 0x0C, 0x06,
  0x06, 0x00, 0x0E, 0x1F, 0x3B, 0x33, 0x33, 0x63, 0x63, 0x66, 0x66, 0xC6,
  0xC6, 0xCC, 0x7C, 0x78, 0x09, 0xDF, 0xFD, 0x98, 0xC6, 0x31, 0x98, 0xC6,
  0x30, 0x07, 0x0F, 0xC6, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0E, 0x0E, 0x07, 0xE7, 0xF0, 0x0E, 0x3F, 0x23, 0x03, 0x03, 0x06, 0x3C,
  0x3C, 0x0E, 0x06, 0x06, 0x0C, 0xFC, 0xF8, 0x03, 0x07, 0x07, 0x0A, 0x1E,
  0x16, 0x36, 0x66, 0x4C, 0xFE, 0xFE, 0x0C, 0x0C, 0x18, 0x1F, 0x1F, 0x30,
  0x30, 0x30, 0x20, 0x7C, 0x4E, 0x06, 0x06, 0x06, 0x8C, 0xFC, 0xF8, 0x07,
  0x0F, 0x18, 0x30, 0x30, 0x6C, 0x7E, 0x66, 0x66, 0xE6, 0xC6, 0x6E, 0x7C,
  0x78, 0x7F, 0x7F, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60,
  0x60, 0xC0, 0xC0, 0x0E, 0x1F, 0x33, 0x33, 0x33, 0x36, 0x1C, 0x3C, 0x6E,
  0xC6, 0xC6, 0xC6, 0xFC, 0x78, 0x0E, 0x1E, 0x33, 0x73, 0x63, 0x63, 0x67,
  0x7E, 0x3E, 0x06, 0x0C, 0x0C, 0xF8, 0xF0, 0x33, 0x00, 0x00, 0x04, 0xEC,
  0x18, 0xC0, 0x00, 0x00, 0x00, 0x73, 0x19, 0x8C, 0x00, 0x02, 0x1C, 0xF7,
  0x8E, 0x0F, 0x07, 0x83, 0x02, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x81, 0xC1,
  0xE0, 0xF0, 0xE7, 0xBC, 0x60, 0x80, 0x1C, 0x7C, 0x98, 0x30, 0xC1, 0x86,
  0x18, 0x20, 0xC0, 0x02, 0x0E, 0x1C, 0x00, 0x03, 0x80, 0xFE, 0x18, 0x21,
  0x03, 0x27, 0xB2, 0x5B, 0x6D, 0xB4, 0x92, 0x59, 0x25, 0xB6, 0xDB, 0x4C,
  0xD8, 0x40, 0x06, 0x00, 0x3F, 0x00, 0x80, 0x07, 0x07, 0x07, 0x0F, 0x0F,
  0x1B, 0x1B, 0x1B, 0x3F, 0x3F, 0x63, 0x63, 0xE3, 0xC3, 0x1C, 0x0F, 0x8C,
  0xE6, 0x33, 0x19, 0x98, 0xF8, 0xFC, 0x63, 0x31, 0x98, 0xDC, 0xCF, 0xE7,
  0xE0, 0x0E, 0x1F, 0x39, 0x70, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xF8, 0x78, 0x1C, 0x0F, 0x8E, 0xE6, 0x33, 0x19, 0x8C, 0xC6, 0xC3,
  0x63, 0xB1, 0x99, 0xDC, 0xCF, 0xC7, 0xC0, 0x1F, 0x1F, 0x38, 0x30, 0x30,
  0x30, 0x3E, 0x7E, 0x60, 0x60, 0x60, 0xE0, 0xFC, 0xF8, 0x1F, 0x1F, 0x38,
  0x30, 0x30, 0x30, 0x30, 0x7E, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0x07,
  0x0F, 0xCE, 0x2E, 0x06, 0x07, 0x03, 0x01, 0x9E, 0xC3, 0x63, 0xB1, 0x98,
  0xCF, 0xE3, 0xF0, 0x18, 0xC6, 0x33, 0x8C, 0xC3, 0x31, 0x8C, 0x63, 0xF9,
  0xFE, 0x63, 0x98, 0xC6, 0x33, 0x8C, 0xC3, 0x31, 0xC0, 0x1F, 0x1F, 0x0C,
  0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0xF8, 0x03,
  0x03, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x18,
  0x18, 0x18, 0x38, 0xF0, 0xE0, 0x18, 0xC6, 0x63, 0x38, 0xCC, 0x36, 0x0F,
  0x83, 0xC1, 0xF0, 0x7C, 0x1B, 0x06, 0xE1, 0x98, 0xC6, 0x31, 0x80, 0x18,
  0x63, 0x8C, 0x30, 0xC3, 0x18, 0x61, 0x86, 0x38, 0xFF, 0xE0, 0x1C, 0x38,
  0xE1, 0xCF, 0x0E, 0x78, 0xF3, 0xC5, 0x9E, 0x78, 0xB3, 0xCD, 0xB6, 0x6D,
  0xB3, 0x7B, 0x1B, 0xD8, 0x9C, 0xCC, 0xE6, 0x66, 0x30, 0x18, 0x63, 0x0C,
  0xF3, 0x1E, 0x63, 0xCC, 0x79, 0x8B, 0x33, 0x2C, 0x67, 0x8C, 0xF1, 0x9E,
  0x23, 0xCC, 0x71, 0x86, 0x00, 0x0E, 0x0F, 0x8C, 0xEC, 0x36, 0x1F, 0x0F,
  0x0F, 0x86, 0xC3, 0x61, 0xB1, 0xD8, 0xCF, 0xC3, 0xC0, 0x1E, 0x0F, 0x8E,
  0xE6, 0x33, 0x19, 0x9C, 0xCC, 0xFE, 0x7C, 0x30, 0x18, 0x1C, 0x0C, 0x06,
  0x00, 0x0E, 0x0F, 0x8C, 0xEC, 0x36, 0x1F, 0x0F, 0x0F, 0x86, 0xC3, 0x61,
  0xB1, 0xD8, 0xCF, 0xC3, 0xC0, 0x60, 0x30, 0x1C, 0x00, 0x1C, 0x0F, 0x8C,
  0xE6, 0x73, 0x39, 0x98, 0xDC, 0xFC, 0x7C, 0x36, 0x1B, 0x0D, 0xCC, 0x66,
  0x30, 0x0E, 0x3F, 0x39, 0x30, 0x30, 0x30, 0x38, 0x1C, 0x0C, 0x0E, 0x0E,
  0x8C, 0xFC, 0xF8, 0x7F, 0x7E, 0x98, 0x18, 0x30, 0x30, 0x30, 0x30, 0x70,
  0x60, 0x60, 0x60, 0x60, 0xE0, 0x31, 0x98, 0xD8, 0x6C, 0x66, 0x33, 0x1B,
  0x8D, 0x8E, 0xC6, 0x63, 0x31, 0x99, 0xCF, 0xC3, 0xC0, 0xC3, 0xC7, 0xC6,
  0xC6, 0xCC, 0xCC, 0xD8, 0xD8, 0xD8, 0xF0, 0xF0, 0xE0, 0xE0, 0xC0, 0x63,
  0x1D, 0x8C, 0x66, 0x71, 0x99, 0xCC, 0x67, 0x31, 0xBC, 0xC4, 0xF6, 0x36,
  0xD8, 0xDB, 0xC3, 0x4F, 0x0F, 0x3C, 0x3C, 0xE0, 0xE3, 0x83, 0x8C, 0x00,
  0x18, 0xC6, 0x71, 0x98, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x30, 0x1E, 0x07,
  0x83, 0x61, 0x98, 0x66, 0x31, 0xC0, 0xC7, 0x8F, 0x36, 0x6D, 0x9B, 0x3C,
  0x70, 0x60, 0xC3, 0x06, 0x0C, 0x18, 0x00, 0x1F, 0x8F, 0xC0, 0xE0, 0x60,
  0x60, 0x30, 0x30, 0x38, 0x18, 0x18, 0x0C, 0x0C, 0x07, 0xE7, 0xF0, 0x0F,
  0x0E, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60,
  0x60, 0x60, 0x78, 0xF0, 0xDB, 0x6C, 0x9B, 0x6D, 0xB6, 0x40, 0x1E, 0x3C,
  0x18, 0x60, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x06, 0x0C, 0x78,
  0xF0, 0x04, 0x0C, 0x0E, 0x1E, 0x36, 0x36, 0x63, 0xC3, 0xFE, 0xD9, 0x80,
  0x3D, 0x9B, 0x9C, 0xCC, 0x66, 0x33, 0x33, 0x99, 0xCC, 0x7E, 0x3A, 0x00,
  0x18, 0x18, 0x30, 0x30, 0x3F, 0x33, 0x73, 0x63, 0x63, 0x63, 0x66, 0xE6,
  0xFC, 0xFC, 0x1E, 0x65, 0xC3, 0x06, 0x0C, 0x38, 0x70, 0x78, 0xF0, 0x01,
  0x80, 0xC0, 0x60, 0x31, 0xF1, 0xB9, 0x8C, 0xC6, 0x63, 0x33, 0x31, 0x98,
  0xC7, 0xE3, 0xA0, 0x1E, 0x65, 0x8B, 0x37, 0xCC, 0x30, 0x60, 0x6C, 0xF8,
  0x01, 0x03, 0xC1, 0x80, 0xC0, 0xC0, 0xF8, 0x30, 0x18, 0x1C, 0x0C, 0x06,
  0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x38, 0x18, 0x00, 0x1D,
  0x9B, 0x9C, 0xCC, 0x66, 0x33, 0x33, 0x99, 0xDC, 0xFE, 0x3E, 0x03, 0x01,
  0x89, 0xC7, 0xC1, 0x80, 0x18, 0x18, 0x30, 0x30, 0x3F, 0x3B, 0x33, 0x63,
  0x66, 0x66, 0x66, 0xC6, 0xC6, 0xCC, 0x18, 0xC0, 0x03, 0x19, 0xCC, 0x63,
  0x19, 0x8C, 0x60, 0x06, 0x0C, 0x00, 0x00, 0xC1, 0x83, 0x0C, 0x18, 0x30,
  0x61, 0x83, 0x06, 0x0C, 0x18, 0x61, 0xC2, 0x00, 0x18, 0x0C, 0x0C, 0x06,
  0x13, 0x31, 0xB0, 0xB0, 0xD8, 0x78, 0x3E, 0x1B, 0x19, 0x8C, 0xC6, 0x70,
  0x18, 0xCC, 0x63, 0x18, 0xCC, 0x63, 0x19, 0xCC, 0x60, 0x3F, 0xF3, 0x7B,
  0x33, 0x36, 0x23, 0x66, 0x66, 0x66, 0x66, 0x6C, 0x66, 0xCC, 0x6C, 0xCC,
  0x3F, 0x3B, 0x33, 0x63, 0x66, 0x66, 0x66, 0xC6, 0xC6, 0xCC, 0x04, 0x1E,
  0x37, 0x63, 0x63, 0x63, 0x66, 0xC6, 0xE6, 0x7C, 0x78, 0x1F, 0x8C, 0xC6,
  0x66, 0x33, 0x19, 0x8C, 0xCC, 0xE6, 0x7E, 0x37, 0x18, 0x0C, 0x0C, 0x06,
  0x00, 0x1D, 0x9B, 0x98, 0xCC, 0x66, 0x33, 0x33, 0x19, 0xCC, 0xFE, 0x3E,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x3E, 0x79, 0xC3, 0x06, 0x0C, 0x18,
  0x70, 0xC1, 0x80, 0x3E, 0xC9, 0x83, 0x83, 0x83, 0x07, 0x0C, 0xF9, 0xE0,
  0x31, 0x19, 0xF6, 0x33, 0x18, 0xC6, 0x31, 0xCE, 0x00, 0x33, 0x33, 0x63,
  0x63, 0x66, 0x66, 0x66, 0xEE, 0xFC, 0x74, 0xC7, 0x9B, 0x36, 0xCD, 0x9B,
  0x3C, 0x78, 0xE1, 0xC0, 0xCE, 0x79, 0xDB, 0x7B, 0x6F, 0x6D, 0x79, 0xEF,
  0x3D, 0x47, 0x38, 0xE7, 0x18, 0xC0, 0x3B, 0x8D, 0x87, 0x83, 0xC1, 0xC0,
  0xE0, 0xF0, 0x78, 0x66, 0x73, 0x00, 0x18, 0xC6, 0x61, 0x98, 0x64, 0x1B,
  0x06, 0xC1, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x1C, 0x0C,
  0x00, 0x3F, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x7C, 0xFC, 0x03,
  0x0E, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x30, 0x60, 0xF0, 0x30, 0x30, 0x70,
  0x60, 0x60, 0x70, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x10, 0x38, 0x30,
  0x60, 0xC1, 0x87, 0x06, 0x0E, 0x3C, 0x61, 0x83, 0x06, 0x0C, 0x70, 0xE0,
  0xF3, 0xFE, 0x30,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 6, 5, 7, 2, -14 },
  { 14, 9, 14, 9, 0, -14 },
  { 30, 8, 15, 8, 0, -14 },
  { 45, 11, 14, 13, 1, -14 },
  { 65, 9, 14, 9, 0, -14 },
  { 81, 3, 5, 4, 2, -14 },
  { 83, 6, 17, 5, 0, -14 },
  { 96, 6, 17, 5, -1, -14 },
  { 109, 6, 8, 7, 2, -15 },
  { 115, 7, 9, 9, 1, -11 },
  { 123, 4, 5, 4, -1, -2 },
  { 126, 5, 2, 5, 0, -6 },
  { 128, 3, 3, 4, 0, -3 },
  { 130, 9, 14, 7, -1, -14 },
  { 146, 8, 14, 8, 0, -14 },
  { 160, 5, 14, 8, 2, -14 },
  { 169, 9, 14, 8, -1, -14 },
  { 185, 8, 14, 8, 0, -14 },
  { 199, 8, 14, 8, 0, -14 },
  { 213, 8, 14, 8, 0, -14 },
  { 227, 8, 14, 8, 0, -14 },
  { 241, 8, 14, 8, 1, -14 },
  { 255, 8, 14, 8, 0, -14 },
  { 269, 8, 14, 8, 0, -14 },
  { 283, 4, 10, 4, 0, -10 },
  { 288, 5, 13, 4, -1, -10 },
  { 297, 7, 9, 9, 1, -11 },
  { 305, 7, 5, 9, 1, -9 },
  { 310, 7, 9, 9, 1, -11 },
  { 318, 7, 14, 6, 0, -14 },
  { 331, 12, 16, 12, 0, -14 },
  { 355, 8, 14, 8, -1, -14 },
  { 369, 9, 14, 9, 0, -14 },
  { 385, 8, 14, 8, 1, -14 },
  { 399, 9, 14, 9, 0, -14 },
  { 415, 8, 14, 7, 0, -14 },
  { 429, 8, 14, 7, 0, -14 },
  { 443, 9, 14, 10, 1, -14 },
  { 459, 10, 14, 10, 0, -14 },
  { 477, 8, 14, 6, -1, -14 },
  { 491, 8, 18, 4, -3, -14 },
  { 509, 10, 14, 8, 0, -14 },
  { 527, 6, 14, 7, 0, -14 },
  { 538, 13, 14, 13, 0, -14 },
  { 561, 11, 14, 10, 0, -14 },
  { 581, 9, 14, 10, 1, -14 },
  { 597, 9, 14, 8, 0, -14 },
  { 613, 9, 17, 10, 1, -14 },
  { 633, 9, 14, 8, 0, -14 },
  { 649, 8, 14, 8, 0, -14 },
  { 663, 8, 14, 7, 1, -14 },
  { 677, 9, 14, 9, 1, -14 },
  { 693, 8, 14, 8, 2, -14 },
  { 707, 14, 14, 13, 1, -14 },
  { 732, 10, 14, 8, -1, -14 },
  { 750, 7, 14, 8, 2, -14 },
  { 763, 9, 14, 7, -1, -14 },
  { 779, 8, 17, 5, -1, -14 },
  { 796, 3, 14, 7, 2, -14 },
  { 802, 7, 17, 5, -1, -14 },
  { 817, 8, 8, 8, 0, -14 },
  { 825, 7, 1, 6, -2, 2 },
  { 826, 3, 3, 5, 3, -15 },
  { 828, 9, 10, 9, 0, -10 },
  { 840, 8, 14, 8, 0, -14 },
  { 854, 7, 10, 7, 0, -10 },
  { 863, 9, 14, 9, 0, -14 },
  { 879, 7, 10, 8, 0, -10 },
  { 888, 9, 20, 5, -2, -15 },
  { 911, 9, 15, 9, 0, -10 },
  { 928, 8, 14, 8, 0, -14 },
  { 942, 5, 14, 4, 0, -14 },
  { 951, 7, 19, 4, -2, -14 },
  { 968, 9, 14, 8, 0, -14 },
  { 984, 5, 14, 4, 0, -14 },
  { 993, 12, 10, 12, 0, -10 },
  { 1008, 8, 10, 8, 0, -10 },
  { 1018, 8, 11, 8, 0, -11 },
  { 1029, 9, 14, 8, -1, -10 },
  { 1045, 9, 15, 8, 0, -10 },
  { 1062, 7, 10, 6, 0, -10 },
  { 1071, 7, 10, 7, 0, -10 },
  { 1080, 5, 13, 5, 1, -13 },
  { 1089, 8, 10, 8, 0, -10 },
  { 1099, 7, 10, 7, 1, -10 },
  { 1108, 11, 10, 11, 1, -10 },
  { 1122, 9, 10, 7, -1, -10 },
  { 1134, 10, 15, 7, -2, -10 },
  { 1153, 8, 10, 6, -1, -10 },
  { 1163, 8, 17, 6, 0, -14 },
  { 1180, 2, 19, 7, 2, -15 },
  { 1185, 7, 17, 6, -1, -14 },
  { 1200, 7, 3, 9, 1, -8 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic19pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC19PT7B_H_
