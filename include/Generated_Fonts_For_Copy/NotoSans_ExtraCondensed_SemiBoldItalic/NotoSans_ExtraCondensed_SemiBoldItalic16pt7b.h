#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC16PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x66, 0x64, 0x0C, 0xC0, 0xDC, 0xAD, 0x60, 0x1B, 0x12,
  0x16, 0x7F, 0x24, 0x2C, 0xFE, 0xFC, 0x58, 0x50, 0xD0, 0x08, 0x3C, 0xFB,
  0x47, 0x06, 0x06, 0x0E, 0x1D, 0x5B, 0xE1, 0x02, 0x00, 0x20, 0x39, 0xB4,
  0x92, 0xC9, 0x45, 0xFF, 0xAA, 0xBD, 0x14, 0x92, 0x49, 0x48, 0xE0, 0x08,
  0x1C, 0x36, 0x34, 0x3C, 0x38, 0x7B, 0x5E, 0xDE, 0xCC, 0xDC, 0xF6, 0xFA,
  0x19, 0x8C, 0x46, 0x21, 0x18, 0xC6, 0x31, 0x84, 0x20, 0x10, 0xC6, 0x31,
  0x8C, 0x63, 0x11, 0x8C, 0x46, 0x62, 0x00, 0x11, 0x4F, 0xCC, 0x79, 0x20,
  0x30, 0xC3, 0x3F, 0x30, 0xC3, 0x00, 0x2D, 0x60, 0xFF, 0xF0, 0x03, 0x02,
  0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x08, 0x38,
  0xDB, 0x36, 0x6C, 0x91, 0x66, 0xCD, 0x93, 0x63, 0x80, 0x37, 0xFA, 0x26,
  0x66, 0x4C, 0xC0, 0x04, 0x1E, 0x13, 0x03, 0x02, 0x06, 0x0C, 0x18, 0x10,
  0x30, 0x7C, 0xFC, 0x08, 0x7C, 0x98, 0x30, 0x47, 0x0E, 0x06, 0x0C, 0x1A,
  0x67, 0x80, 0x0E, 0x18, 0x51, 0xE2, 0xC9, 0x92, 0x7E, 0xFC, 0x30, 0x40,
  0x3E, 0x60, 0x83, 0x07, 0x8B, 0x83, 0x06, 0x0D, 0x33, 0xC0, 0x06, 0x3C,
  0xC1, 0x06, 0x0F, 0x9B, 0x26, 0xCD, 0x99, 0xE3, 0xC0, 0x3E, 0x0C, 0x10,
  0x60, 0x83, 0x04, 0x18, 0x20, 0xC3, 0x80, 0x08, 0x7C, 0x9B, 0x32, 0x47,
  0x0E, 0x36, 0xCD, 0x9B, 0x63, 0xC0, 0x08, 0x78, 0x9B, 0x36, 0x6D, 0x9F,
  0x3E, 0x0C, 0x32, 0xE7, 0x80, 0x27, 0x20, 0x00, 0x0C, 0xC0, 0x11, 0xC4,
  0x00, 0x00, 0x0C, 0x62, 0x30, 0x0C, 0xEE, 0x30, 0x70, 0x70, 0x40, 0xFC,
  0x00, 0x3F, 0xFC, 0x83, 0x83, 0x87, 0x7B, 0x88, 0x00, 0x11, 0xF4, 0xC3,
  0x18, 0x42, 0x18, 0x60, 0x04, 0x30, 0x02, 0x03, 0xE1, 0x0C, 0x89, 0x6F,
  0x56, 0x95, 0x2D, 0x4A, 0xD6, 0xB6, 0xCC, 0x01, 0x00, 0x3C, 0x00, 0x0E,
  0x14, 0x28, 0xF1, 0x66, 0xCF, 0xBF, 0x66, 0x8F, 0x18, 0x3E, 0x6C, 0xC9,
  0x37, 0xCF, 0x99, 0x23, 0xCD, 0xBB, 0xE0, 0x0C, 0x7D, 0x93, 0x0C, 0x18,
  0x30, 0x60, 0x81, 0x83, 0x43, 0x80, 0x3E, 0x37, 0x33, 0x23, 0x63, 0x63,
  0x66, 0x66, 0xCC, 0xFC, 0xF0, 0x3E, 0x60, 0xC1, 0x07, 0xCF, 0x18, 0x30,
  0xC1, 0xF3, 0xE0, 0x3E, 0x60, 0xC1, 0x06, 0x0F, 0x98, 0x30, 0xC1, 0x83,
  0x00, 0x0C, 0x3F, 0x72, 0x60, 0xC0, 0xC0, 0xDE, 0xC4, 0x8C, 0xCC, 0xEC,
  0x7C, 0x31, 0x99, 0x8C, 0xC4, 0x67, 0xF3, 0xF1, 0x98, 0xCC, 0xC6, 0x63,
  0x33, 0x00, 0x3E, 0x10, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x63, 0xE0,
  0x0C, 0x30, 0xC2, 0x18, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0xE3, 0x80, 0x33,
  0x36, 0x24, 0x2C, 0x78, 0x78, 0x78, 0x48, 0x4C, 0xCC, 0xCC, 0x31, 0x8C,
  0x46, 0x31, 0x88, 0xC7, 0xFE, 0x38, 0xE7, 0x1C, 0xE3, 0x9C, 0xE7, 0x94,
  0xF7, 0x9E, 0xB2, 0xF6, 0x4C, 0x99, 0xB3, 0x26, 0x00, 0x39, 0x9C, 0xCE,
  0x65, 0x26, 0xB3, 0x59, 0xBC, 0x9C, 0x4E, 0x63, 0x31, 0x80, 0x08, 0x7D,
  0x9B, 0x3C, 0x78, 0xF1, 0xE3, 0x8D, 0x9B, 0x67, 0x80, 0x3E, 0x36, 0x33,
  0x22, 0x66, 0x7C, 0x78, 0x60, 0xC0, 0xC0, 0xC0, 0x08, 0x7D, 0x9B, 0x3C,
  0x78, 0xF1, 0xE3, 0x8D, 0x9B, 0x67, 0x83, 0x03, 0x06, 0x00, 0x3E, 0x6C,
  0xD9, 0x36, 0x6F, 0x9E, 0x24, 0x4D, 0x9B, 0x30, 0x0C, 0x7C, 0xCB, 0x06,
  0x06, 0x0E, 0x0C, 0x0C, 0x13, 0xE7, 0x80, 0xFC, 0xC3, 0x08, 0x61, 0x86,
  0x18, 0x43, 0x0C, 0x00, 0x63, 0x66, 0x66, 0x46, 0xC4, 0xCC, 0xCC, 0x8C,
  0x8C, 0xD8, 0xF0, 0xC7, 0x8F, 0x36, 0x6C, 0x9B, 0x34, 0x78, 0x70, 0xC1,
  0x80, 0xC6, 0x79, 0xCB, 0x33, 0x66, 0x6D, 0xC9, 0xAB, 0x3D, 0x67, 0x38,
  0xE7, 0x1C, 0xC3, 0x18, 0x00, 0x1B, 0x8D, 0x87, 0x83, 0xC1, 0xC0, 0xE0,
  0x70, 0x78, 0x2C, 0x36, 0x31, 0x80, 0xCE, 0x99, 0x62, 0xC7, 0x0E, 0x18,
  0x30, 0x60, 0x83, 0x00, 0x1F, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30,
  0x60, 0x7C, 0xFC, 0x1E, 0x30, 0x40, 0x83, 0x06, 0x0C, 0x10, 0x20, 0xC1,
  0x82, 0x07, 0x1E, 0x00, 0x92, 0x6D, 0xB6, 0x49, 0x30, 0x1C, 0x30, 0x82,
  0x18, 0x61, 0x84, 0x10, 0xC3, 0x0C, 0xE3, 0x80, 0x18, 0x38, 0xF1, 0x26,
  0x58, 0xC0, 0xF8, 0xCC, 0x1A, 0x7D, 0x9B, 0x34, 0x59, 0xB3, 0x6E, 0x68,
  0x30, 0x60, 0xC1, 0x63, 0xEC, 0xD9, 0xB3, 0x45, 0x9B, 0xB5, 0xC0, 0x1C,
  0xF6, 0x18, 0x43, 0x0C, 0x3A, 0x78, 0x03, 0x03, 0x02, 0x1E, 0x3E, 0x66,
  0x66, 0x44, 0xCC, 0xCC, 0xDC, 0x78, 0x1C, 0xF6, 0x53, 0x7B, 0x0C, 0x32,
  0x78, 0x07, 0x0C, 0x0C, 0x0E, 0x1E, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30,
  0x30, 0x30, 0x20, 0xE0, 0xC0, 0x1A, 0x7D, 0x9B, 0x34, 0x59, 0xB3, 0x6E,
  0x68, 0x10, 0x67, 0xCE, 0x00, 0x30, 0x60, 0xC1, 0x63, 0xEC, 0xD9, 0x32,
  0x4D, 0x9B, 0x36, 0x40, 0x33, 0x03, 0x26, 0x66, 0x4C, 0xCC, 0x0C, 0x30,
  0x03, 0x08, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x30, 0x8E, 0x30, 0x30, 0x60,
  0xC1, 0x32, 0xCD, 0x9E, 0x3C, 0x79, 0xB3, 0x66, 0x60, 0x33, 0x32, 0x26,
  0x66, 0x4C, 0xCC, 0x2D, 0x8F, 0xF6, 0x6D, 0x93, 0x6C, 0xD3, 0x2C, 0xDB,
  0x26, 0xD9, 0x80, 0x2C, 0x7D, 0x9B, 0x26, 0x49, 0xB3, 0x66, 0xC8, 0x18,
  0x79, 0x9B, 0x34, 0x59, 0xB3, 0x2C, 0x78, 0x16, 0x1F, 0x33, 0x33, 0x33,
  0x22, 0x66, 0x76, 0x7C, 0x60, 0x40, 0xC0, 0xC0, 0x1A, 0x7D, 0x9B, 0x34,
  0x59, 0xB3, 0x6E, 0x68, 0x10, 0x60, 0xC1, 0x80, 0x2C, 0xE6, 0x18, 0x61,
  0x0C, 0x30, 0xC0, 0x3D, 0xE6, 0x18, 0x70, 0xE1, 0xAC, 0xF0, 0x11, 0x8E,
  0xF6, 0x31, 0x88, 0x46, 0x18, 0x26, 0x4D, 0x9B, 0x26, 0xC9, 0xB3, 0x6E,
  0x68, 0xCF, 0x2D, 0xB4, 0xF3, 0xCE, 0x38, 0xC0, 0xCD, 0xEC, 0xF6, 0x5F,
  0x6E, 0xB5, 0x53, 0xB9, 0x98, 0xCC, 0x00, 0x33, 0x36, 0x14, 0x1C, 0x18,
  0x38, 0x28, 0x6C, 0xCC, 0x33, 0x32, 0x36, 0x34, 0x3C, 0x3C, 0x38, 0x38,
  0x30, 0x30, 0x20, 0xE0, 0xC0, 0x3E, 0x78, 0x30, 0xC1, 0x06, 0x18, 0x30,
  0xF8, 0x1C, 0x61, 0x84, 0x30, 0xCC, 0x18, 0x61, 0x86, 0x18, 0x70, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0x60, 0x86, 0x18, 0x60, 0xC6, 0x30, 0xC3,
  0x18, 0xE2, 0x00, 0xE7, 0xF8, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 5, 4, 6, 2, -11 },
  { 10, 8, 11, 7, 0, -11 },
  { 21, 7, 13, 7, 0, -12 },
  { 33, 9, 12, 11, 1, -12 },
  { 47, 8, 12, 8, 0, -12 },
  { 59, 2, 4, 4, 2, -11 },
  { 60, 5, 14, 4, 0, -11 },
  { 69, 5, 15, 4, -1, -12 },
  { 79, 6, 6, 6, 1, -12 },
  { 84, 6, 7, 7, 1, -9 },
  { 90, 3, 4, 4, -1, -2 },
  { 92, 4, 2, 4, 0, -5 },
  { 93, 2, 2, 4, 0, -2 },
  { 94, 8, 12, 6, -1, -12 },
  { 106, 7, 12, 7, 0, -12 },
  { 117, 4, 11, 7, 2, -11 },
  { 123, 8, 12, 7, -1, -12 },
  { 135, 7, 12, 7, 0, -12 },
  { 146, 7, 11, 7, 0, -11 },
  { 156, 7, 11, 7, 0, -11 },
  { 166, 7, 12, 7, 0, -12 },
  { 177, 7, 11, 7, 0, -11 },
  { 187, 7, 12, 7, 0, -12 },
  { 198, 7, 12, 7, 0, -12 },
  { 209, 4, 9, 4, 0, -9 },
  { 214, 5, 11, 4, -1, -9 },
  { 221, 6, 7, 7, 1, -9 },
  { 227, 6, 5, 7, 1, -8 },
  { 231, 6, 7, 7, 1, -9 },
  { 237, 6, 12, 5, 0, -12 },
  { 246, 10, 13, 10, 0, -12 },
  { 263, 7, 11, 7, -1, -11 },
  { 273, 7, 11, 7, 0, -11 },
  { 283, 7, 12, 7, 1, -12 },
  { 294, 8, 11, 8, 0, -11 },
  { 305, 7, 11, 6, 0, -11 },
  { 315, 7, 11, 6, 0, -11 },
  { 325, 8, 12, 8, 1, -12 },
  { 337, 9, 11, 8, 0, -11 },
  { 350, 7, 11, 5, -1, -11 },
  { 360, 6, 14, 4, -2, -11 },
  { 371, 8, 11, 7, 0, -11 },
  { 382, 5, 11, 6, 0, -11 },
  { 389, 11, 11, 11, 0, -11 },
  { 405, 9, 11, 9, 0, -11 },
  { 418, 7, 12, 8, 1, -12 },
  { 429, 8, 11, 7, 0, -11 },
  { 440, 7, 15, 8, 1, -12 },
  { 454, 7, 11, 7, 0, -11 },
  { 464, 7, 12, 6, 0, -12 },
  { 475, 6, 11, 6, 1, -11 },
  { 484, 8, 11, 8, 1, -11 },
  { 495, 7, 11, 7, 1, -11 },
  { 505, 11, 11, 11, 1, -11 },
  { 521, 9, 11, 7, -1, -11 },
  { 534, 7, 11, 6, 1, -11 },
  { 544, 8, 11, 6, -1, -11 },
  { 555, 7, 14, 5, -1, -11 },
  { 568, 3, 12, 6, 2, -12 },
  { 573, 6, 14, 5, -1, -11 },
  { 584, 7, 6, 7, 0, -11 },
  { 590, 5, 1, 5, -1, 1 },
  { 591, 3, 2, 4, 2, -12 },
  { 592, 7, 9, 7, 0, -9 },
  { 600, 7, 12, 7, 0, -12 },
  { 611, 6, 9, 6, 0, -9 },
  { 618, 8, 12, 7, 0, -12 },
  { 630, 6, 9, 7, 0, -9 },
  { 637, 8, 16, 4, -2, -12 },
  { 653, 7, 13, 7, 0, -9 },
  { 665, 7, 12, 7, 0, -12 },
  { 676, 4, 12, 3, 0, -12 },
  { 682, 6, 16, 3, -2, -12 },
  { 694, 7, 12, 6, 0, -12 },
  { 705, 4, 12, 3, 0, -12 },
  { 711, 10, 9, 10, 0, -9 },
  { 723, 7, 9, 7, 0, -9 },
  { 731, 7, 9, 7, 0, -9 },
  { 739, 8, 13, 7, -1, -9 },
  { 752, 7, 13, 7, 0, -9 },
  { 764, 6, 9, 5, 0, -9 },
  { 771, 6, 9, 5, 0, -9 },
  { 778, 5, 11, 4, 0, -11 },
  { 785, 7, 9, 7, 0, -9 },
  { 793, 6, 9, 6, 1, -9 },
  { 800, 9, 9, 9, 1, -9 },
  { 811, 8, 9, 6, -1, -9 },
  { 820, 8, 13, 6, -1, -9 },
  { 833, 7, 9, 5, -1, -9 },
  { 841, 6, 14, 5, 0, -11 },
  { 852, 2, 16, 6, 2, -12 },
  { 856, 6, 14, 5, -1, -11 },
  { 867, 6, 3, 7, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC16PT7B_H_
