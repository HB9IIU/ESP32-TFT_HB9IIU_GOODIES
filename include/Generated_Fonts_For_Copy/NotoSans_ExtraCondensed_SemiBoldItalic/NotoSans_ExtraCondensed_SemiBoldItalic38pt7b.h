#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC38PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x00, 0x78,
  0xF7, 0x9F, 0x79, 0xE7, 0x9E, 0xF1, 0xEF, 0x1C, 0xF1, 0xCE, 0x3C, 0xE3,
  0xCE, 0x38, 0x00, 0x71, 0xC0, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x01,
  0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF0, 0x38, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0xE3, 0x80,
  0x38, 0xE0, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE0, 0x71, 0xC0, 0x38,
  0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0x70,
  0x0F, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x1F, 0x80,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x1E, 0xCC, 0x0E, 0x60, 0x0F, 0x30,
  0x07, 0x90, 0x03, 0xE8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x27, 0x80, 0x13, 0xC4,
  0x19, 0xE1, 0x0D, 0xF1, 0xE7, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xF0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x3E, 0x03, 0xC1, 0xFC, 0x0E, 0x0F, 0x70, 0x70, 0x39, 0xC1, 0xC1, 0xC7,
  0x0E, 0x07, 0x1C, 0x38, 0x1C, 0x71, 0xC0, 0xF1, 0xC7, 0x03, 0x87, 0x38,
  0x0E, 0x38, 0xE0, 0x38, 0xE7, 0x1C, 0xE3, 0xBC, 0xFB, 0x9C, 0xE7, 0xFF,
  0xF7, 0xBD, 0xFF, 0x9C, 0xE7, 0x7C, 0xF7, 0x1C, 0x43, 0x9C, 0x70, 0x1C,
  0x71, 0xC0, 0x73, 0xC7, 0x03, 0x8E, 0x1C, 0x0E, 0x38, 0xE0, 0x70, 0xE3,
  0x81, 0xC3, 0x8E, 0x0E, 0x0E, 0x70, 0x38, 0x3F, 0xC1, 0xC0, 0xFE, 0x0F,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1E, 0x3C, 0x07,
  0x8E, 0x01, 0xE3, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0xBC, 0x01, 0xEE,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0xF1, 0xFE, 0x3C,
  0xF7, 0x9E, 0x79, 0xF7, 0x9E, 0x3D, 0xEF, 0x0F, 0xF3, 0xC1, 0xF8, 0xF0,
  0x7E, 0x3C, 0x1F, 0x0F, 0x07, 0xC3, 0xE7, 0xF8, 0xFF, 0xFE, 0x1F, 0xF7,
  0x83, 0xF1, 0xF0, 0x7D, 0xE7, 0x9E, 0x73, 0xCF, 0x3C, 0xE3, 0x80, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0xC7, 0x07, 0xB8,
  0xBF, 0xFF, 0xFF, 0xE1, 0xFF, 0x0F, 0x80, 0xFE, 0x0F, 0x70, 0xF3, 0xC3,
  0x8F, 0x08, 0x60, 0x02, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x1F, 0x1F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0x70, 0xF0, 0x7F,
  0xDF, 0xF7, 0xFB, 0xFE, 0x7B, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x40, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0xFB, 0xE1, 0xE3,
  0xC7, 0x87, 0x8F, 0x0F, 0x3C, 0x1E, 0x78, 0x3D, 0xF0, 0x7B, 0xC1, 0xF7,
  0x83, 0xCF, 0x07, 0xBE, 0x0F, 0x78, 0x1E, 0xF0, 0x7D, 0xE0, 0xF3, 0xC1,
  0xE7, 0x83, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x7C, 0x78, 0xF0, 0xFF, 0xE1,
  0xFF, 0x81, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0xFC, 0x3F, 0x0F, 0xE3,
  0xFC, 0xFF, 0xBE, 0xF7, 0xBC, 0x47, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x10, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0xF8, 0x38, 0x7C, 0x08, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7F,
  0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x00, 0x10, 0x00, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x38, 0xF8, 0x10, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x3F, 0xC0,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF1, 0x00, 0xF8, 0xF3,
  0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xBC, 0x01,
  0xDE, 0x01, 0xDE, 0x00, 0xEF, 0x00, 0xE7, 0x80, 0xE3, 0xC0, 0x71, 0xC0,
  0x71, 0xE0, 0x78, 0xF0, 0x38, 0x78, 0x38, 0x3C, 0x3C, 0x3C, 0x1F, 0xFF,
  0xCF, 0xFF, 0xE7, 0xFF, 0xE4, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x80, 0xF8, 0xF3, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80,
  0x00, 0x08, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xE2, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3D, 0xF0,
  0x7B, 0xF8, 0x7F, 0xF8, 0x7E, 0x7C, 0xFC, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF0,
  0xFB, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xFF, 0x8F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x20, 0x01, 0xFC, 0x03, 0xFE,
  0x07, 0xFF, 0x0F, 0x8F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F,
  0x0F, 0x1E, 0x0F, 0x3E, 0x0F, 0xFC, 0x07, 0xF8, 0x03, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x3E, 0xF8, 0x7C, 0x7C, 0x78, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF8, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0,
  0x1F, 0xC0, 0x00, 0x20, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0x9E,
  0x0F, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x1F, 0x3C, 0x1F,
  0x3C, 0x1F, 0x3C, 0x3E, 0x3C, 0x3E, 0x3E, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE,
  0x0F, 0xBC, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xF0, 0x87, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0x07,
  0x83, 0xE3, 0xE1, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x00, 0x01, 0xC0,
  0x7C, 0x0F, 0x83, 0xE0, 0x3C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x00, 0x00, 0x02,
  0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x00, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xC0, 0x0F, 0x80, 0x07, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3E, 0x03, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x01,
  0x00, 0x7F, 0x0F, 0xFC, 0x7F, 0xE1, 0x8F, 0x90, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xC0, 0x1F, 0x0F, 0x80, 0xF0, 0x0E, 0x07, 0x80, 0x1C, 0x3C,
  0x00, 0x70, 0xE0, 0x01, 0xC7, 0x07, 0xE3, 0x1C, 0x7F, 0x8C, 0xE1, 0xCE,
  0x33, 0x8E, 0x38, 0xDC, 0x71, 0xC7, 0x71, 0xC7, 0x1D, 0xC6, 0x1C, 0x76,
  0x38, 0x71, 0xF8, 0xE3, 0x86, 0xE3, 0x8E, 0x3B, 0x8E, 0x38, 0xEE, 0x39,
  0xE7, 0x38, 0xE7, 0x9C, 0xE3, 0xF7, 0xE3, 0x8F, 0x9F, 0x0E, 0x0C, 0x30,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x40, 0x0F,
  0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x03, 0xDC, 0x01,
  0xEE, 0x01, 0xE7, 0x00, 0xF3, 0x80, 0x71, 0xC0, 0x78, 0xE0, 0x3C, 0x70,
  0x3C, 0x38, 0x1E, 0x3C, 0x1F, 0x1E, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF,
  0xC3, 0xC1, 0xE3, 0xE0, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF8, 0x1E, 0x78,
  0x0F, 0x7C, 0x07, 0xBC, 0x03, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xF8, 0x1E, 0x3F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x7C, 0x3C, 0x1F,
  0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF1, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xC1,
  0xF1, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x87, 0x83, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xE0,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xE7, 0x03, 0xF0, 0x40, 0xF8, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x40, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF1, 0xF0, 0x3C, 0x7C,
  0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xF1, 0xE0, 0x7C, 0xF8, 0x1E, 0x3C, 0x07,
  0x8F, 0x03, 0xE3, 0xC0, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x0F, 0x87,
  0x8F, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xF0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF8, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x00,
  0x06, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0x3C, 0x1F,
  0x80, 0x83, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x7F, 0x9E, 0x0F, 0xE3, 0xC1,
  0xFC, 0x78, 0x7F, 0x9F, 0x01, 0xF3, 0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x80,
  0xF1, 0xF0, 0x3E, 0x1E, 0x07, 0xC3, 0xE0, 0xF0, 0x7F, 0x7E, 0x07, 0xFF,
  0xC0, 0x7F, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0x81,
  0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF0, 0x3E, 0x07,
  0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xC0, 0xF0,
  0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x1E, 0x07, 0xC0,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0xF8, 0x1E, 0x07,
  0xC0, 0xF0, 0x3C, 0x07, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFC, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x4F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x03, 0xC1, 0xF0,
  0x78, 0x3E, 0x07, 0x83, 0xC0, 0x78, 0x7C, 0x07, 0x8F, 0x80, 0x78, 0xF0,
  0x0F, 0x1F, 0x00, 0xF3, 0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0xC0, 0x1F, 0xF8,
  0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x03, 0xC7, 0x80, 0x78,
  0x78, 0x07, 0x87, 0x80, 0x78, 0x7C, 0x07, 0x87, 0xC0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C,
  0x07, 0x80, 0x78, 0x07, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xE0,
  0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x03,
  0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x0E, 0xF0, 0x7B, 0xC3, 0xDE, 0x0F,
  0x78, 0x77, 0x81, 0xEF, 0x1E, 0xF0, 0x3D, 0xE3, 0x9E, 0x07, 0x3C, 0xF3,
  0xC1, 0xE7, 0x9E, 0xF8, 0x3C, 0xF7, 0x9E, 0x07, 0x9E, 0xF3, 0xC0, 0xF3,
  0xDC, 0x78, 0x1C, 0x7F, 0x8F, 0x07, 0x8F, 0xE3, 0xC0, 0xF1, 0xFC, 0x78,
  0x1E, 0x3F, 0x0F, 0x03, 0xC7, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x0F, 0x03, 0xC1, 0xE1, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x1F, 0x81, 0xE0,
  0x7E, 0x07, 0x81, 0xF8, 0x1E, 0x07, 0xE0, 0x78, 0x1F, 0x81, 0xE0, 0xFF,
  0x0F, 0x03, 0xFC, 0x3C, 0x0F, 0xF0, 0xF0, 0x3B, 0xC3, 0xC1, 0xE7, 0x0E,
  0x07, 0x9C, 0x78, 0x1E, 0x79, 0xE0, 0x79, 0xE7, 0x81, 0xC7, 0x9E, 0x0F,
  0x1E, 0xF0, 0x3C, 0x3B, 0xC0, 0xF0, 0xEF, 0x03, 0xC3, 0xFC, 0x0E, 0x0F,
  0xF0, 0x78, 0x3F, 0x81, 0xE0, 0xFE, 0x07, 0x81, 0xF8, 0x1E, 0x07, 0xE0,
  0xF0, 0x1F, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x08, 0x00,
  0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7E, 0x7C, 0x1F, 0x07, 0x83,
  0xC0, 0xF0, 0xF8, 0x1F, 0x1E, 0x03, 0xE7, 0xC0, 0x7C, 0xF0, 0x0F, 0x9E,
  0x01, 0xE7, 0xC0, 0x3C, 0xF8, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3E, 0x78,
  0x07, 0xDF, 0x00, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF1, 0xF0,
  0x3E, 0x3E, 0x07, 0x83, 0xC1, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1F, 0x0F, 0x07,
  0xC3, 0xC1, 0xE1, 0xF0, 0x78, 0x78, 0x3E, 0x1E, 0x1F, 0x07, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x07, 0xFE,
  0x01, 0xFF, 0xE0, 0x7E, 0x7C, 0x1F, 0x07, 0x83, 0xC0, 0xF0, 0xF8, 0x1F,
  0x1E, 0x03, 0xE7, 0xC0, 0x7C, 0xF0, 0x0F, 0x9E, 0x01, 0xE7, 0xC0, 0x3C,
  0xF8, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0xDF, 0x00, 0xF3,
  0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0x83,
  0xC1, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xF3, 0xF0, 0x78,
  0xF8, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x87, 0xC7,
  0xC3, 0xC3, 0xC3, 0xE1, 0xE3, 0xE0, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3E, 0x07, 0x8F, 0x07, 0x87, 0x83, 0xC3,
  0xC1, 0xE1, 0xE0, 0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x1E, 0x3C, 0x0F, 0x00,
  0x00, 0x08, 0x00, 0x3F, 0xE0, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x81,
  0xF0, 0x40, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC1, 0x83, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x0F, 0x81, 0xE1, 0xF0, 0x3C, 0x3C, 0x0F, 0x87, 0x81,
  0xE0, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0x81, 0xF0, 0xF0, 0x3E, 0x1E, 0x07,
  0x87, 0xC0, 0xF0, 0xF8, 0x1E, 0x1E, 0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x1E,
  0x1F, 0x03, 0xC3, 0xE0, 0x78, 0x78, 0x1F, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x7C, 0x0F, 0x0F, 0x83, 0xE1, 0xF0, 0x78, 0x3E, 0x1F, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x0F, 0xFC, 0x07,
  0xBE, 0x03, 0xDF, 0x03, 0xCF, 0x81, 0xE7, 0xC1, 0xF3, 0xE0, 0xF1, 0xE0,
  0x78, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x1F, 0x07,
  0x8F, 0x01, 0xC7, 0x80, 0xE7, 0x80, 0x73, 0xC0, 0x3B, 0xC0, 0x1D, 0xE0,
  0x0E, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x81,
  0xEF, 0x03, 0xE0, 0x7B, 0xC0, 0xF8, 0x1E, 0xF0, 0x3E, 0x0F, 0x3C, 0x1F,
  0x83, 0xCF, 0x07, 0xE1, 0xF3, 0xC3, 0xF8, 0x78, 0xF0, 0xFE, 0x1E, 0x3C,
  0x3F, 0x8F, 0x0F, 0x1F, 0xE3, 0xC3, 0xC7, 0x79, 0xF0, 0xF3, 0xDE, 0x78,
  0x3C, 0xF7, 0x9E, 0x0F, 0x39, 0xEF, 0x03, 0xDE, 0x73, 0xC0, 0xF7, 0x1C,
  0xF0, 0x3D, 0xC7, 0x78, 0x0F, 0xF1, 0xDE, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00,
  0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xC0,
  0xF0, 0x3C, 0x1F, 0x03, 0xE1, 0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E,
  0x78, 0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x01, 0xEE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xBC, 0x00, 0xF3, 0xC0,
  0x0F, 0x3C, 0x01, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xC3, 0xE0, 0x7C, 0x3E,
  0x07, 0x81, 0xE0, 0xF0, 0x1E, 0x00, 0xF8, 0x1F, 0x78, 0x3E, 0x78, 0x3C,
  0x78, 0x7C, 0x78, 0x78, 0x78, 0xF0, 0x78, 0xF0, 0x79, 0xE0, 0x79, 0xE0,
  0x7B, 0xC0, 0x3B, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF,
  0x80, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0xF1,
  0xE3, 0xC7, 0x8F, 0x0E, 0x1C, 0x38, 0x78, 0xF1, 0xE3, 0xC7, 0x87, 0x0E,
  0x1C, 0x3C, 0x78, 0xF1, 0xE3, 0xC3, 0x87, 0x0F, 0x1E, 0x3C, 0x78, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF,
  0x00, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xBC, 0x07, 0xBC, 0x0F, 0x1C, 0x0E, 0x1C, 0x1E, 0x1E, 0x3C,
  0x1E, 0x3C, 0x0E, 0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x0F, 0x7F, 0xFB, 0xFF,
  0xFF, 0xFE, 0xF3, 0xE7, 0x9E, 0x38, 0x70, 0x03, 0xC7, 0x0F, 0xEF, 0x0F,
  0xEF, 0x1F, 0xFF, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x3E, 0x78, 0x3E, 0x78,
  0x3C, 0x78, 0x3C, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0xF8, 0xF0, 0xF8, 0xF9, 0xF8, 0xFF, 0xF0, 0x7E, 0xF0, 0x7C,
  0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x3C, 0x0F, 0x7E, 0x0F, 0xFF, 0x0F,
  0xFF, 0x1F, 0x0F, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x3E, 0x78,
  0x3C, 0x7C, 0x7C, 0x7C, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xE7, 0xE0, 0x01,
  0xF0, 0x3F, 0xC3, 0xFE, 0x3F, 0xE3, 0xE1, 0x1E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x47, 0xC6, 0x3F, 0xF0, 0xFF, 0x83, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x03, 0xCF, 0x01, 0xFB, 0xC0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3E, 0x3E, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF8, 0x78, 0x3C,
  0x1E, 0x0F, 0x0F, 0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x3E, 0x7C, 0x0F, 0xFF, 0x01, 0xFD,
  0xC0, 0x3E, 0x70, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0xDF, 0x3E,
  0x3C, 0xF0, 0xF7, 0x83, 0xDE, 0x1E, 0x78, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F,
  0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x87,
  0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF1, 0xC0, 0x7E, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFF, 0x0F, 0x8F, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x78,
  0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1F,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x3C, 0x3E, 0x0F, 0xBF, 0x83,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x20, 0x3C, 0x0F, 0x3F, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x1F, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x3C, 0x0F, 0x7E, 0x0F,
  0xFF, 0x0F, 0xFF, 0x1F, 0x1F, 0x1F, 0x0F, 0x1E, 0x1F, 0x1E, 0x1E, 0x3E,
  0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C, 0x7C, 0x3C, 0x78,
  0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x78, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0,
  0x78, 0x01, 0x00, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0x08, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x07, 0x87, 0x87, 0x83,
  0xC7, 0x81, 0xC7, 0xC1, 0xE3, 0xC0, 0xF3, 0xC0, 0x7B, 0xC0, 0x3F, 0xE0,
  0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xEF,
  0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x38, 0x78, 0x3C, 0x3E, 0x1E,
  0x0F, 0x0F, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x0F, 0x83, 0xC0, 0xF0, 0x00, 0x0E, 0x3C, 0x3C, 0x0E, 0xFE, 0x7E, 0x0E,
  0xFE, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x1F, 0x9F, 0x1F, 0x1F, 0x0F, 0x1E,
  0x1E, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C, 0x1E, 0x1E, 0x3C, 0x1E, 0x1E, 0x3C,
  0x3C, 0x1E, 0x3C, 0x3C, 0x1C, 0x3C, 0x3C, 0x3C, 0x78, 0x3C, 0x3C, 0x78,
  0x3C, 0x3C, 0x78, 0x78, 0x3C, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF0,
  0x78, 0x78, 0xF0, 0x78, 0x78, 0xF0, 0xF0, 0x78, 0x0E, 0x3C, 0x0E, 0x7E,
  0x0E, 0xFE, 0x0F, 0xFF, 0x1F, 0x1F, 0x1F, 0x0F, 0x1E, 0x1F, 0x1E, 0x1E,
  0x3E, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C, 0x78, 0x3C,
  0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x78, 0x78, 0xF0, 0x78, 0xF0, 0x78,
  0xF0, 0x78, 0x03, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE3, 0xE3, 0xC7,
  0x87, 0x9F, 0x0F, 0xBC, 0x1F, 0x78, 0x3D, 0xF0, 0x7B, 0xC0, 0xF7, 0x81,
  0xEF, 0x03, 0xDE, 0x0F, 0xBC, 0x1E, 0x78, 0x3C, 0xF0, 0xF1, 0xF3, 0xE1,
  0xFF, 0x83, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0x8F, 0x00, 0xE7, 0xE0, 0x3B,
  0xFC, 0x0F, 0xDF, 0x07, 0xC3, 0xC1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x87,
  0xC1, 0xE1, 0xE0, 0xF8, 0x78, 0x3C, 0x1F, 0x1F, 0x07, 0xCF, 0x83, 0xFF,
  0xE0, 0xF7, 0xF0, 0x3D, 0xF8, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC7, 0x07, 0xEF, 0x0F, 0xFF, 0x1F, 0xFE, 0x3E, 0x3E,
  0x3C, 0x3E, 0x3C, 0x3E, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8,
  0xF9, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7C, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x0E, 0x38, 0x73, 0xC3, 0xBE, 0x1F, 0xF1, 0xFD, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x3F, 0xF1, 0xFF, 0x87, 0xDE, 0x3E, 0x10, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1E, 0x00, 0x78, 0x83, 0xE3, 0x9F, 0x8F, 0xFC, 0x3F, 0xE0,
  0xFF, 0x00, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xFE, 0x7F, 0x9F, 0xF3,
  0xFE, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE2, 0x3F, 0x87, 0xF0, 0x7E,
  0x00, 0x1E, 0x0F, 0x1E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78,
  0x78, 0x78, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xF9,
  0xF0, 0xFF, 0xF0, 0xFE, 0xF0, 0x7C, 0xE0, 0xF0, 0x3F, 0xC0, 0xFF, 0x07,
  0xBC, 0x1E, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x78, 0xF1, 0xE3, 0xCF,
  0x07, 0x3C, 0x1D, 0xE0, 0x77, 0x81, 0xDC, 0x07, 0xF0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0x7C, 0x3F, 0xC1,
  0xE0, 0xFF, 0x0F, 0x87, 0xBC, 0x3E, 0x1E, 0xF1, 0xF8, 0x7B, 0xC7, 0xE3,
  0xCF, 0x1F, 0x8F, 0x3C, 0xFE, 0x38, 0xF3, 0xB9, 0xE3, 0xCE, 0xE7, 0x8F,
  0x73, 0xBC, 0x3D, 0xCE, 0xF0, 0xFF, 0x3B, 0x83, 0xF8, 0xFE, 0x0F, 0xE3,
  0xF8, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xE0,
  0x3E, 0x1F, 0x80, 0xF8, 0x7C, 0x00, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0x78,
  0xF8, 0x1E, 0x3C, 0x03, 0xDF, 0x00, 0xF7, 0x80, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1E, 0x78, 0x0F, 0x9E, 0x03, 0xC7,
  0x81, 0xE1, 0xF0, 0xF8, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0E,
  0x0F, 0x01, 0xC1, 0xE0, 0x38, 0x3C, 0x07, 0x0F, 0x00, 0xE1, 0xE0, 0x1C,
  0x78, 0x03, 0x8F, 0x00, 0x73, 0xC0, 0x0E, 0x78, 0x01, 0xCE, 0x00, 0x3B,
  0xC0, 0x07, 0x78, 0x00, 0xEE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3,
  0xFE, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0xFE, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x3C, 0x03, 0xF0, 0x1F,
  0xC0, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x07, 0xE0, 0x3F, 0x00, 0xF0,
  0x03, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x7C, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xF0, 0x00, 0x3F, 0x01,
  0x7F, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0x80, 0xFE, 0x80, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 27, 9, 0, -27 },
  { 35, 12, 10, 14, 4, -27 },
  { 50, 18, 27, 17, 0, -27 },
  { 111, 17, 31, 16, 0, -29 },
  { 177, 22, 28, 25, 2, -28 },
  { 254, 18, 27, 18, 0, -27 },
  { 315, 6, 10, 8, 4, -27 },
  { 323, 12, 33, 10, 1, -27 },
  { 373, 12, 34, 10, -3, -28 },
  { 424, 13, 15, 15, 3, -29 },
  { 449, 14, 18, 17, 2, -22 },
  { 481, 8, 10, 9, -2, -5 },
  { 491, 10, 4, 11, 0, -12 },
  { 496, 5, 5, 9, 0, -5 },
  { 500, 19, 27, 14, -2, -27 },
  { 565, 15, 28, 16, 1, -28 },
  { 618, 11, 27, 16, 4, -27 },
  { 656, 17, 28, 16, -1, -28 },
  { 716, 17, 28, 16, -1, -28 },
  { 776, 17, 27, 16, -1, -27 },
  { 834, 16, 27, 16, 0, -27 },
  { 888, 16, 28, 16, 1, -28 },
  { 944, 17, 27, 16, 1, -27 },
  { 1002, 16, 28, 16, 0, -28 },
  { 1058, 16, 28, 16, 0, -28 },
  { 1114, 9, 21, 9, 0, -21 },
  { 1138, 11, 26, 9, -2, -21 },
  { 1174, 15, 17, 17, 1, -22 },
  { 1206, 15, 11, 17, 1, -19 },
  { 1227, 15, 17, 17, 2, -22 },
  { 1259, 13, 28, 12, 1, -28 },
  { 1305, 22, 30, 24, 1, -27 },
  { 1388, 17, 27, 17, -2, -27 },
  { 1446, 18, 27, 17, 0, -27 },
  { 1507, 18, 28, 16, 1, -28 },
  { 1570, 18, 27, 19, 0, -27 },
  { 1631, 16, 27, 15, 0, -27 },
  { 1685, 16, 27, 14, 0, -27 },
  { 1739, 19, 28, 20, 1, -28 },
  { 1806, 21, 27, 20, 0, -27 },
  { 1877, 16, 27, 11, -2, -27 },
  { 1931, 16, 35, 9, -6, -27 },
  { 2001, 20, 27, 17, 0, -27 },
  { 2069, 12, 27, 14, 0, -27 },
  { 2110, 27, 27, 26, 0, -27 },
  { 2202, 22, 27, 21, 0, -27 },
  { 2277, 19, 28, 20, 1, -28 },
  { 2344, 18, 27, 17, 0, -27 },
  { 2405, 19, 34, 20, 1, -28 },
  { 2486, 17, 27, 17, 0, -27 },
  { 2544, 18, 28, 15, -1, -28 },
  { 2607, 14, 27, 14, 3, -27 },
  { 2655, 19, 27, 19, 1, -27 },
  { 2720, 17, 27, 17, 3, -27 },
  { 2778, 26, 27, 26, 3, -27 },
  { 2866, 20, 27, 16, -2, -27 },
  { 2934, 16, 27, 15, 3, -27 },
  { 2988, 18, 27, 14, -2, -27 },
  { 3049, 14, 33, 11, -1, -27 },
  { 3107, 7, 27, 14, 4, -27 },
  { 3131, 15, 33, 11, -3, -27 },
  { 3193, 16, 16, 16, 0, -27 },
  { 3225, 13, 3, 12, -4, 3 },
  { 3230, 6, 6, 11, 6, -29 },
  { 3235, 16, 21, 17, 1, -21 },
  { 3277, 16, 29, 17, 0, -29 },
  { 3335, 13, 21, 13, 1, -21 },
  { 3370, 18, 29, 17, 1, -29 },
  { 3436, 14, 21, 15, 1, -21 },
  { 3473, 18, 38, 10, -4, -29 },
  { 3559, 18, 30, 17, -1, -21 },
  { 3627, 16, 29, 17, 0, -29 },
  { 3685, 10, 29, 8, 0, -29 },
  { 3722, 15, 38, 8, -5, -29 },
  { 3794, 17, 29, 15, 0, -29 },
  { 3856, 10, 29, 8, 0, -29 },
  { 3893, 24, 21, 25, 0, -21 },
  { 3956, 16, 21, 17, 0, -21 },
  { 3998, 15, 21, 16, 1, -21 },
  { 4038, 18, 30, 17, -2, -21 },
  { 4106, 16, 30, 17, 1, -21 },
  { 4166, 13, 21, 12, 0, -21 },
  { 4201, 14, 21, 13, 0, -21 },
  { 4238, 11, 25, 10, 1, -25 },
  { 4273, 16, 21, 17, 1, -21 },
  { 4315, 14, 21, 14, 2, -21 },
  { 4352, 22, 21, 22, 2, -21 },
  { 4410, 18, 21, 15, -2, -21 },
  { 4458, 19, 30, 14, -3, -21 },
  { 4530, 14, 21, 12, -1, -21 },
  { 4567, 14, 33, 13, 1, -27 },
  { 4625, 4, 38, 14, 5, -29 },
  { 4644, 14, 33, 13, -2, -27 },
  { 4702, 16, 6, 17, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC38PT7B_H_
