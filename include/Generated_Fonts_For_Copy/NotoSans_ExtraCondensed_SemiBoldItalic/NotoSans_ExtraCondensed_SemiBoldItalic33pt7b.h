#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC33PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x00, 0x00, 0x04, 0x07,
  0x87, 0xC3, 0xC1, 0xE0, 0x79, 0xEF, 0x3D, 0xE7, 0x38, 0xE7, 0x3C, 0xE7,
  0x1C, 0xE7, 0x1C, 0xE3, 0x80, 0x00, 0xC7, 0x01, 0xC6, 0x01, 0xCE, 0x01,
  0x8E, 0x03, 0x8C, 0x03, 0x9C, 0x03, 0x1C, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F,
  0xFF, 0x06, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x60, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xF8, 0x38, 0xC0, 0x39, 0xC0, 0x31, 0xC0, 0x71, 0x80, 0x73,
  0x80, 0x63, 0x80, 0xE3, 0x00, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0xFF,
  0x0F, 0xFC, 0x3F, 0xE1, 0xE8, 0x87, 0x20, 0x1C, 0x80, 0x7A, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x02, 0xF0, 0x09,
  0xC8, 0x27, 0x31, 0xBC, 0xFF, 0xE3, 0xFF, 0x8F, 0xFC, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x00, 0x80, 0x00, 0x0E, 0x03, 0x83, 0xE0, 0x60, 0xFC, 0x1C,
  0x39, 0xC3, 0x07, 0x38, 0xE0, 0xC7, 0x18, 0x38, 0xC7, 0x07, 0x19, 0xC0,
  0xE7, 0x38, 0x18, 0xEE, 0x03, 0x19, 0xCF, 0x67, 0x73, 0xFF, 0xCE, 0xEF,
  0xFB, 0xB9, 0xDC, 0x67, 0x38, 0x1C, 0xC7, 0x03, 0x18, 0xE0, 0xE7, 0x1C,
  0x18, 0xE3, 0x07, 0x1C, 0xE0, 0xC3, 0x9C, 0x38, 0x77, 0x0E, 0x0F, 0xC1,
  0xC0, 0xF0, 0x00, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0x38, 0x0F, 0x38,
  0x0E, 0x38, 0x0E, 0x38, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x8F, 0x3F, 0xCE, 0x7B, 0xDE, 0x71, 0xDC, 0xF1, 0xFC,
  0xF1, 0xF8, 0xE0, 0xF8, 0xE0, 0xF0, 0xF1, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8,
  0x3E, 0x3C, 0x3B, 0xDE, 0xF7, 0x39, 0xDE, 0xE0, 0x01, 0xC0, 0xE0, 0x78,
  0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0x70,
  0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x38,
  0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x0F,
  0x00, 0x07, 0x00, 0xE1, 0x18, 0x73, 0x1F, 0xFF, 0xFF, 0xC3, 0xF8, 0xF8,
  0x3F, 0x1E, 0x71, 0xCF, 0x11, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x1E, 0x3C, 0x71, 0xE3,
  0x8F, 0x1C, 0x78, 0x7F, 0xBF, 0x9F, 0xDF, 0xE0, 0x23, 0xFF, 0xEF, 0x00,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x3F, 0x83, 0xFC, 0x3F, 0xF1, 0xE7, 0x9E,
  0x3C, 0xF1, 0xE7, 0x0F, 0x78, 0x7B, 0xC3, 0xDC, 0x1D, 0xE0, 0xEF, 0x0F,
  0x78, 0x7B, 0xC3, 0xDC, 0x1C, 0xE1, 0xE7, 0x0F, 0x38, 0x71, 0xC7, 0x8E,
  0x78, 0x7F, 0xC3, 0xFC, 0x0F, 0xC0, 0x01, 0xC0, 0xF0, 0x7C, 0x7E, 0x3F,
  0x9F, 0xEF, 0x79, 0x9C, 0x47, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0,
  0x00, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x7D, 0xF0, 0x61, 0xE0, 0x83, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0x01, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF8, 0x3D, 0xF0, 0x41, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x8C, 0x1F,
  0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1B, 0x80, 0x7F, 0x00, 0xDE, 0x03, 0xB8, 0x0E,
  0x70, 0x19, 0xE0, 0x73, 0xC0, 0xC7, 0x03, 0x8E, 0x0E, 0x1C, 0x18, 0x78,
  0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xE4, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x7E, 0x03, 0xFE, 0x0F, 0xFC,
  0x1B, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x83, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0xFC, 0x07,
  0xE0, 0x7F, 0x81, 0xE2, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xEF, 0x07, 0x7E, 0x1F, 0xF8, 0xF8, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C,
  0x3C, 0xE0, 0xF3, 0x83, 0x8E, 0x1E, 0x38, 0x78, 0xF3, 0xC3, 0xFF, 0x07,
  0xF8, 0x0F, 0xC0, 0x1F, 0xFC, 0x7F, 0xF3, 0xFF, 0xCF, 0xFF, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x1F,
  0xE0, 0xFF, 0xC3, 0xCF, 0x1E, 0x1C, 0x78, 0x71, 0xC3, 0xC7, 0x8F, 0x1E,
  0x78, 0x3F, 0xC0, 0xFE, 0x01, 0xF0, 0x1F, 0xC0, 0xFF, 0x87, 0x8F, 0x1E,
  0x3C, 0xF0, 0x73, 0xC1, 0xCE, 0x07, 0x3C, 0x3C, 0xF0, 0xE3, 0xFF, 0x87,
  0xFC, 0x0F, 0xE0, 0x01, 0xE0, 0x1F, 0xC0, 0xFF, 0x83, 0xDE, 0x1E, 0x3C,
  0x70, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xE0, 0xE3, 0x87, 0x8F, 0x3E,
  0x3F, 0xF8, 0xFF, 0xE1, 0xF7, 0x01, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0xF0, 0x07, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0x0E, 0x3C, 0x78,
  0xF0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x1C, 0x7C, 0xF1,
  0xE0, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x3C, 0x1E, 0x0E, 0x0F, 0x07,
  0x07, 0x80, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0x80,
  0x0C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0xFE,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x01, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x0F, 0x80, 0x70, 0x02, 0x00, 0x00, 0x0F, 0x87, 0xF8, 0xFF, 0x9D,
  0xF2, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x0F, 0xDF, 0x03,
  0xC0, 0xE0, 0xE0, 0x0E, 0x18, 0x00, 0xC7, 0x04, 0x19, 0xC3, 0xF3, 0x30,
  0xFE, 0x66, 0x39, 0x8D, 0xCE, 0x31, 0xB1, 0x8E, 0x36, 0x71, 0xCF, 0xCE,
  0x31, 0xF9, 0xCE, 0x36, 0x31, 0xC6, 0xC6, 0x39, 0x98, 0xEF, 0x73, 0x1F,
  0x7C, 0x61, 0xCF, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xEE,
  0x03, 0xDC, 0x07, 0x38, 0x0E, 0x70, 0x3C, 0xF0, 0x71, 0xE1, 0xE3, 0xC3,
  0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x38, 0x3C, 0xF0, 0x79, 0xE0, 0xF7, 0x81,
  0xEF, 0x03, 0xDC, 0x07, 0xF8, 0x0F, 0x07, 0xE0, 0x0F, 0xF8, 0x3F, 0xF8,
  0x7B, 0xF0, 0xF1, 0xE1, 0xC1, 0xC3, 0x83, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C,
  0x78, 0x7F, 0xE0, 0xFF, 0x03, 0xFF, 0x07, 0x8F, 0x0F, 0x0E, 0x1C, 0x1E,
  0x38, 0x3C, 0xF0, 0x71, 0xE1, 0xE3, 0x83, 0xC7, 0x0F, 0x1F, 0xFE, 0x3F,
  0xF8, 0x7F, 0xC0, 0x00, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x7E, 0xE0, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x84, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0x1F, 0x0F, 0x0F,
  0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F,
  0x3C, 0x0F, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x38, 0x3C, 0x78, 0x3C,
  0x78, 0x78, 0x78, 0xF8, 0x73, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0xFF, 0xC1, 0xFF, 0xC1, 0xFD, 0xE0, 0xF0, 0x20, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x0F, 0xC7, 0x0F, 0xE7, 0x87, 0xF3, 0xC0, 0x71, 0xE0, 0x78, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x0F, 0x1F, 0x07, 0x07, 0x87, 0x83, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0xC0, 0x07, 0x83, 0xC1, 0xC0, 0xF0, 0xF0, 0x38, 0x3C, 0x0E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x78, 0x78, 0x1C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xE0, 0x78, 0x38, 0x1E, 0x1E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x70, 0x3C, 0x3C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0x80, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x7C, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x07, 0x00, 0x00, 0x07, 0x87,
  0x83, 0x83, 0xC1, 0xC3, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0x71, 0xE0, 0x39,
  0xE0, 0x3C, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0x78, 0x03, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xF7, 0x80, 0x73, 0xC0, 0x39, 0xE0, 0x3C, 0x70,
  0x1E, 0x38, 0x0F, 0x1E, 0x07, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE0,
  0xF0, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07,
  0x81, 0xE0, 0x70, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x7C, 0x1F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F,
  0x83, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3B, 0x87, 0x70,
  0x77, 0x0E, 0xE0, 0xEE, 0x3B, 0xC3, 0xDC, 0x77, 0x87, 0xB9, 0xCF, 0x0E,
  0x73, 0x9C, 0x1C, 0xEF, 0x38, 0x39, 0xDC, 0xF0, 0xF3, 0xB9, 0xE1, 0xE7,
  0xE3, 0x83, 0x8F, 0xC7, 0x07, 0x1F, 0x0E, 0x1E, 0x3E, 0x3C, 0x3C, 0x78,
  0x78, 0x70, 0xF0, 0xE0, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x07,
  0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x87, 0x83, 0xF0, 0xF0, 0xFE, 0x1C, 0x1F,
  0xC3, 0x83, 0xBC, 0x70, 0x73, 0x9E, 0x0E, 0x73, 0xC3, 0xCE, 0x70, 0x79,
  0xCE, 0x0E, 0x3B, 0xC1, 0xC7, 0xF8, 0x38, 0x7E, 0x0F, 0x0F, 0xC1, 0xC1,
  0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE1, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0x01,
  0xE0, 0x00, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xBE, 0x1F, 0x0F, 0x1E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0x78, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F,
  0x80, 0x07, 0xE0, 0x0F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xF1, 0xE1, 0xE1,
  0xC3, 0x83, 0x8F, 0x07, 0x1E, 0x1E, 0x3C, 0x3C, 0x70, 0xF8, 0xE3, 0xE3,
  0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xBE, 0x1F, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C,
  0xF0, 0x78, 0x78, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF1, 0xE1, 0xC3, 0xC3, 0x87, 0x8F,
  0x0F, 0x1E, 0x1E, 0x3C, 0x78, 0x70, 0xF0, 0xEF, 0xC3, 0xFF, 0x07, 0xFC,
  0x0F, 0x70, 0x1C, 0xF0, 0x39, 0xE0, 0xF3, 0xC1, 0xE3, 0x83, 0x87, 0x87,
  0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x7C, 0x00, 0xF8, 0x03, 0xFF, 0x07,
  0xFE, 0x0F, 0xFE, 0x0F, 0x04, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x40, 0xF0, 0x71,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE,
  0xFF, 0xE0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0x0F, 0x07,
  0x87, 0x03, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xE0, 0x70, 0x70,
  0x38, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0E, 0x07, 0x0F, 0x07, 0x87,
  0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xE0, 0x70, 0xF0, 0x78, 0x78, 0x3C,
  0x3C, 0x1E, 0x1E, 0x1E, 0x0F, 0x9F, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xBC, 0x1E, 0xF0, 0x7B, 0xC3, 0xCF,
  0x0F, 0x38, 0x38, 0xE1, 0xE3, 0x87, 0x0E, 0x3C, 0x38, 0xF0, 0xE3, 0x83,
  0x9E, 0x0E, 0x70, 0x3B, 0xC0, 0xEE, 0x03, 0xB8, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0x70, 0x1C, 0x0E, 0xE0, 0x78,
  0x3D, 0xC0, 0xF0, 0x73, 0x83, 0xE1, 0xE7, 0x07, 0xC3, 0xCE, 0x0F, 0x07,
  0x1C, 0x3E, 0x1E, 0x38, 0x7C, 0x3C, 0x71, 0xF8, 0x70, 0xE3, 0xF1, 0xE1,
  0xC7, 0xE3, 0x83, 0x9D, 0xCF, 0x07, 0x3B, 0x9E, 0x0E, 0xE7, 0x38, 0x1D,
  0xCE, 0xF0, 0x3B, 0x9D, 0xC0, 0xFE, 0x3B, 0x81, 0xFC, 0x7F, 0x03, 0xF8,
  0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F,
  0x80, 0x7C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0xE0, 0xE0, 0x38, 0x78, 0x0F,
  0x1C, 0x03, 0xCF, 0x00, 0xF3, 0x80, 0x3D, 0xE0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0x70, 0x03, 0xDC, 0x01, 0xE7, 0x00, 0x71,
  0xE0, 0x3C, 0x78, 0x0E, 0x1E, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x7F,
  0x83, 0xFC, 0x3D, 0xE1, 0xCF, 0x1E, 0x78, 0xE1, 0xCF, 0x0E, 0x70, 0x77,
  0x83, 0xB8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x03, 0xF8,
  0x1F, 0x80, 0xFC, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x00, 0xF1, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x78, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x3C, 0x78, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0x03, 0xF8, 0x1F, 0x81, 0xFC,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xE0, 0x1D, 0xC0, 0x77, 0x03, 0x9C, 0x1E, 0x70, 0x70,
  0xE3, 0x83, 0x8E, 0x0E, 0x70, 0x3B, 0xC0, 0x70, 0xFF, 0xFF, 0xFC, 0xF3,
  0x9E, 0x73, 0x80, 0x0F, 0x9C, 0x7F, 0xF1, 0xFF, 0x8F, 0x1E, 0x78, 0x79,
  0xE1, 0xE7, 0x87, 0xBC, 0x1C, 0xF0, 0x73, 0xC3, 0xCF, 0x0F, 0x38, 0x38,
  0xE1, 0xE3, 0x87, 0x8F, 0x3E, 0x3F, 0xF8, 0xFF, 0xC1, 0xF7, 0x00, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0xBE, 0x1F, 0xF8, 0x7F, 0xF1, 0xE3, 0xC7, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3,
  0x83, 0xCE, 0x0F, 0x38, 0x39, 0xE0, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0xF1,
  0xE3, 0xCF, 0xFE, 0x3B, 0xF0, 0xEF, 0x80, 0x07, 0xE1, 0xFC, 0x7F, 0x9E,
  0x27, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xE0, 0x3C, 0x47, 0xF8, 0x7F, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x07, 0xDE, 0x1F,
  0xFC, 0x3F, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x8E, 0x0E, 0x3C, 0x1C,
  0x78, 0x38, 0xF0, 0xF1, 0xE1, 0xE3, 0x83, 0x87, 0x07, 0x0E, 0x1E, 0x1E,
  0x7C, 0x3F, 0xF8, 0x7F, 0xE0, 0x7D, 0xC0, 0x07, 0xC0, 0xFE, 0x1F, 0xF3,
  0xC7, 0x78, 0x77, 0x87, 0x70, 0xEF, 0x7E, 0xFF, 0xCF, 0xF0, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x4F, 0xF8, 0x7F, 0x83, 0xF8, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x05, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x9E, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x01, 0xE7, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0x1E,
  0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1E, 0x3C, 0x1C, 0x3C, 0x1C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x38, 0x78, 0x3C, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF0, 0x1F, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0xC3, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0x3E, 0x00, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0xBE, 0x1F, 0xF8,
  0x7F, 0xF1, 0xE3, 0xC7, 0x8F, 0x3C, 0x3C, 0xF0, 0xE3, 0xC3, 0x8E, 0x1E,
  0x38, 0x79, 0xE1, 0xE7, 0x87, 0x1E, 0x1C, 0x70, 0xF1, 0xC3, 0xCF, 0x0E,
  0x3C, 0x38, 0xF1, 0xE0, 0x03, 0x03, 0xC3, 0xC1, 0xE0, 0x20, 0x00, 0x00,
  0x1C, 0x1E, 0x0F, 0x07, 0x83, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C,
  0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x30, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x5E, 0x03, 0xF0, 0x1F,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x0F, 0x1E, 0x3C, 0x3C, 0xF0, 0x71, 0xC0,
  0xE7, 0x81, 0xDE, 0x07, 0xF8, 0x0E, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF,
  0x81, 0xEF, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x3C, 0x3C, 0x78, 0x78, 0xF0,
  0xE0, 0xE0, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E,
  0x0F, 0x07, 0x83, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0F,
  0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x0C, 0xF1, 0xF0, 0xEF, 0xDF,
  0x87, 0xFF, 0xFE, 0x3C, 0x7C, 0xF1, 0xE3, 0xC7, 0x9E, 0x1C, 0x38, 0xF0,
  0xE1, 0xC7, 0x8F, 0x0E, 0x38, 0x78, 0xF1, 0xC3, 0x87, 0x9E, 0x1C, 0x38,
  0xF0, 0xE1, 0xC7, 0x0F, 0x0E, 0x38, 0x78, 0xF1, 0xC3, 0x87, 0x9E, 0x1C,
  0x38, 0xF1, 0xE1, 0xC7, 0x0F, 0x1E, 0x00, 0x0C, 0xF8, 0x77, 0xE1, 0xFF,
  0xC7, 0x8F, 0x1E, 0x3C, 0x70, 0xE3, 0xC3, 0x8F, 0x0E, 0x38, 0x78, 0xE1,
  0xE7, 0x87, 0x1E, 0x1C, 0x78, 0x71, 0xC3, 0xC7, 0x0F, 0x3C, 0x38, 0xF0,
  0xE3, 0x87, 0x80, 0x07, 0xC0, 0xFF, 0x07, 0xFC, 0x79, 0xE7, 0x87, 0x3C,
  0x3D, 0xC1, 0xDE, 0x0E, 0xF0, 0x77, 0x83, 0xB8, 0x3D, 0xC1, 0xEE, 0x0E,
  0x70, 0xF3, 0xCF, 0x1F, 0xF8, 0x7F, 0x81, 0xF8, 0x00, 0x03, 0x3E, 0x07,
  0x7E, 0x07, 0xFF, 0x07, 0x8F, 0x07, 0x8F, 0x07, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0E, 0x0F, 0x0E, 0x0E, 0x1E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x3C, 0x1E, 0x3C, 0x3F, 0xF8, 0x3F, 0xF0, 0x39, 0xE0, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x07, 0x9C, 0x7F, 0xF1, 0xFF, 0x8F, 0x1E, 0x38, 0x79, 0xE1, 0xE7,
  0x07, 0xBC, 0x1C, 0xF0, 0x73, 0xC3, 0xCE, 0x0F, 0x38, 0x38, 0xE0, 0xE3,
  0x87, 0x8F, 0x3E, 0x3F, 0xF8, 0xFF, 0xC1, 0xF7, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x0C,
  0xF1, 0xDE, 0x1F, 0xE1, 0xFE, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x0F, 0xE1, 0xFF, 0x3F, 0xE3, 0xC2, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x87,
  0x8F, 0xF8, 0xFF, 0x0F, 0xE0, 0x06, 0x07, 0x03, 0x83, 0x81, 0xFB, 0xFD,
  0xFE, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0,
  0x70, 0x38, 0x1F, 0x8F, 0xC3, 0xE0, 0x1C, 0x39, 0xE1, 0xCF, 0x0E, 0x70,
  0xF3, 0x87, 0xBC, 0x39, 0xE1, 0xCE, 0x1E, 0x70, 0xF3, 0x87, 0xBC, 0x39,
  0xE1, 0xCE, 0x1E, 0x70, 0xF3, 0x8F, 0x1F, 0xF8, 0xFF, 0xC3, 0xEE, 0x00,
  0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x1E, 0xE1, 0xCE, 0x3C, 0xE3, 0x8E, 0x78,
  0xE7, 0x0E, 0x70, 0xEE, 0x0E, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0xE1, 0xE1, 0xFC, 0x3C, 0x3B, 0x87, 0x87, 0x71, 0xF1,
  0xEE, 0x3E, 0x39, 0xCE, 0xC7, 0x39, 0xF9, 0xC7, 0x3F, 0x38, 0xEE, 0xEF,
  0x1D, 0xDD, 0xC3, 0xB3, 0xB8, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF1, 0xF8,
  0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x00, 0x0F, 0x0F,
  0x07, 0x1E, 0x07, 0x1C, 0x07, 0xBC, 0x07, 0xB8, 0x03, 0xF8, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0,
  0x1E, 0xE0, 0x1C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0xF0, 0x70, 0x07, 0x87,
  0x83, 0xC3, 0xC1, 0xE1, 0xC0, 0xF1, 0xE0, 0x78, 0xE0, 0x3C, 0xF0, 0x1E,
  0x70, 0x0F, 0x38, 0x07, 0xBC, 0x03, 0xDC, 0x01, 0xFE, 0x00, 0x7E, 0x00,
  0x37, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0x87, 0xFC, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x00,
  0x00, 0x10, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x0F, 0xC0, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x7E, 0x03, 0xE0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x3C,
  0x07, 0xE0, 0x7E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1F, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x78,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0xFC, 0x0F, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0xFC, 0xFF, 0xFF, 0x87, 0xF8,
  0x0E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 24, 8, 0, -24 },
  { 28, 11, 9, 12, 3, -24 },
  { 41, 16, 24, 15, 0, -24 },
  { 89, 14, 27, 14, 0, -25 },
  { 137, 19, 24, 22, 2, -24 },
  { 194, 16, 24, 16, 0, -24 },
  { 242, 5, 9, 7, 3, -24 },
  { 248, 10, 29, 9, 1, -24 },
  { 285, 11, 29, 9, -3, -24 },
  { 325, 11, 12, 13, 3, -25 },
  { 342, 13, 16, 15, 1, -20 },
  { 368, 7, 8, 7, -2, -4 },
  { 375, 9, 4, 9, 0, -11 },
  { 380, 5, 5, 7, 0, -5 },
  { 384, 17, 24, 12, -2, -24 },
  { 435, 13, 24, 14, 1, -24 },
  { 474, 10, 24, 14, 3, -24 },
  { 504, 15, 24, 14, -1, -24 },
  { 549, 15, 24, 14, -1, -24 },
  { 594, 15, 24, 14, -1, -24 },
  { 639, 14, 24, 14, 0, -24 },
  { 681, 14, 24, 14, 1, -24 },
  { 723, 14, 24, 14, 1, -24 },
  { 765, 14, 24, 14, 0, -24 },
  { 807, 14, 24, 14, 0, -24 },
  { 849, 7, 18, 8, 0, -18 },
  { 865, 9, 22, 8, -2, -18 },
  { 890, 13, 15, 15, 1, -19 },
  { 915, 13, 9, 15, 1, -16 },
  { 930, 13, 15, 15, 1, -19 },
  { 955, 11, 24, 10, 1, -24 },
  { 988, 19, 27, 21, 1, -24 },
  { 1053, 15, 24, 15, -2, -24 },
  { 1098, 15, 24, 15, 0, -24 },
  { 1143, 15, 24, 14, 1, -24 },
  { 1188, 16, 24, 16, 0, -24 },
  { 1236, 14, 24, 13, 0, -24 },
  { 1278, 14, 24, 12, 0, -24 },
  { 1320, 17, 24, 17, 1, -24 },
  { 1371, 18, 24, 17, 0, -24 },
  { 1425, 14, 24, 10, -2, -24 },
  { 1467, 14, 31, 8, -5, -24 },
  { 1522, 17, 24, 15, 0, -24 },
  { 1573, 10, 24, 12, 0, -24 },
  { 1603, 23, 24, 22, 0, -24 },
  { 1672, 19, 24, 18, 0, -24 },
  { 1729, 16, 24, 17, 1, -24 },
  { 1777, 15, 24, 14, 0, -24 },
  { 1822, 16, 30, 17, 1, -24 },
  { 1882, 15, 24, 15, 0, -24 },
  { 1927, 16, 24, 13, -1, -24 },
  { 1975, 13, 24, 12, 2, -24 },
  { 2014, 17, 24, 16, 1, -24 },
  { 2065, 14, 24, 15, 3, -24 },
  { 2107, 23, 24, 23, 2, -24 },
  { 2176, 18, 24, 14, -2, -24 },
  { 2230, 13, 24, 13, 3, -24 },
  { 2269, 15, 24, 12, -1, -24 },
  { 2314, 13, 29, 9, -1, -24 },
  { 2362, 7, 24, 12, 3, -24 },
  { 2383, 13, 29, 9, -2, -24 },
  { 2431, 14, 14, 14, 0, -24 },
  { 2456, 11, 2, 10, -3, 3 },
  { 2459, 5, 5, 9, 5, -25 },
  { 2463, 14, 18, 15, 1, -18 },
  { 2495, 14, 25, 15, 0, -25 },
  { 2539, 11, 18, 11, 1, -18 },
  { 2564, 15, 25, 15, 1, -25 },
  { 2611, 12, 18, 13, 1, -18 },
  { 2638, 16, 33, 9, -4, -25 },
  { 2704, 16, 26, 15, -1, -18 },
  { 2756, 14, 25, 15, 0, -25 },
  { 2800, 9, 25, 7, 0, -25 },
  { 2829, 13, 33, 7, -4, -25 },
  { 2883, 15, 25, 13, 0, -25 },
  { 2930, 9, 25, 7, 0, -25 },
  { 2959, 21, 18, 21, 0, -18 },
  { 3007, 14, 18, 15, 0, -18 },
  { 3039, 13, 18, 14, 1, -18 },
  { 3069, 16, 26, 15, -2, -18 },
  { 3121, 14, 26, 15, 1, -18 },
  { 3167, 12, 18, 10, 0, -18 },
  { 3194, 12, 18, 11, 0, -18 },
  { 3221, 9, 22, 9, 1, -22 },
  { 3246, 13, 18, 14, 1, -18 },
  { 3276, 12, 18, 12, 2, -18 },
  { 3303, 19, 18, 19, 2, -18 },
  { 3346, 16, 18, 13, -2, -18 },
  { 3382, 17, 26, 13, -3, -18 },
  { 3438, 13, 18, 11, -1, -18 },
  { 3468, 12, 29, 11, 1, -24 },
  { 3512, 3, 33, 12, 4, -25 },
  { 3525, 12, 29, 11, -2, -24 },
  { 3569, 13, 5, 15, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC33PT7B_H_
