#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC36PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x00, 0x3C, 0xF3,
  0xCF, 0x38, 0xF7, 0x8E, 0x79, 0xE7, 0x9E, 0x71, 0xC7, 0x1C, 0x71, 0xCF,
  0x1C, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x39, 0xC0, 0x38, 0xE0, 0x1C, 0x70,
  0x0E, 0x70, 0x0E, 0x38, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC9, 0xC7,
  0x00, 0xE3, 0x00, 0x63, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x18, 0xE0, 0xFF,
  0xFE, 0x7F, 0xFF, 0x07, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xCE, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0x71, 0x80, 0x71, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x70, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0x4C, 0x1E,
  0x40, 0x1E, 0x40, 0x1E, 0xC0, 0x1E, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0x78, 0x03, 0x78, 0x03,
  0x78, 0x42, 0x78, 0xE2, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x04,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0xE0, 0xFC, 0x0E,
  0x0F, 0xE0, 0x70, 0x73, 0x87, 0x07, 0x1C, 0x70, 0x38, 0xE3, 0x81, 0x8E,
  0x38, 0x1C, 0x71, 0xC0, 0xE3, 0x9C, 0x07, 0x1C, 0xE0, 0x38, 0xEE, 0x39,
  0xCE, 0x73, 0xEE, 0x77, 0x3F, 0xFF, 0x3B, 0x9F, 0xF3, 0x9C, 0xEF, 0x1D,
  0xC7, 0x01, 0xCE, 0x38, 0x0E, 0x71, 0xC0, 0xE3, 0x0E, 0x0E, 0x38, 0xE0,
  0x71, 0xC7, 0x07, 0x0E, 0x38, 0x38, 0x73, 0x83, 0x83, 0xFC, 0x1C, 0x0F,
  0xC1, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xF3,
  0xC0, 0x71, 0xE0, 0x38, 0xF0, 0x1C, 0x70, 0x0E, 0x78, 0x07, 0x38, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFE, 0x3C, 0xFF, 0x9E,
  0x7B, 0xDE, 0x79, 0xEF, 0x38, 0x7F, 0x3C, 0x3F, 0x9E, 0x1F, 0x8F, 0x07,
  0xC7, 0x87, 0xC3, 0xC7, 0xF1, 0xFF, 0xF8, 0x7F, 0xBE, 0x1F, 0x8F, 0x00,
  0x7B, 0xDE, 0xEF, 0x7B, 0xDC, 0xE7, 0x00, 0x00, 0xE0, 0x38, 0x0F, 0x03,
  0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x07,
  0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0,
  0x1C, 0x03, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80,
  0x78, 0x0F, 0x00, 0x04, 0x00, 0x3C, 0x01, 0xE0, 0x8E, 0x07, 0x70, 0x7F,
  0xFB, 0xFF, 0xC3, 0xFF, 0x0F, 0x01, 0xFC, 0x1F, 0xF0, 0xF3, 0x83, 0x1E,
  0x08, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x1F, 0x1E,
  0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0x70, 0xF0, 0x7F, 0xBF, 0xDF, 0xFF,
  0xF0, 0x3B, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0x83, 0xFF, 0x1E,
  0x3C, 0x78, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3D, 0xE0, 0xF7, 0x83, 0xDE,
  0x0F, 0x78, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0xFB, 0xC3, 0xCF,
  0x0F, 0x38, 0x38, 0xE1, 0xE3, 0xCF, 0x8F, 0x3C, 0x3F, 0xE0, 0x7F, 0x01,
  0xF8, 0x00, 0x03, 0xC1, 0xF0, 0xFC, 0x7E, 0x3F, 0x9F, 0xEF, 0x7B, 0x9E,
  0x47, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x00, 0x00,
  0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x07, 0x0F, 0x04, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xF0, 0x00, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x02,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x80, 0x78, 0xE1,
  0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x6E, 0x00, 0xFE, 0x00, 0xDE, 0x01,
  0xDE, 0x03, 0x9C, 0x03, 0xBC, 0x07, 0x3C, 0x0E, 0x3C, 0x0E, 0x3C, 0x1C,
  0x38, 0x38, 0x78, 0x38, 0x78, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF,
  0xFC, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0xFF, 0x83, 0xFF, 0x83,
  0x3F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x90, 0x3E, 0x38, 0xFC, 0x7F, 0xF0, 0xFF, 0xC1, 0xFE, 0x00,
  0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0x20, 0xF8, 0x01, 0xE0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x81, 0xEF, 0xC3, 0xFF, 0x87, 0xFF,
  0x8F, 0x9F, 0x3E, 0x1E, 0x7C, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7,
  0x87, 0x8F, 0x0F, 0x1E, 0x3E, 0x3E, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0x7E,
  0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F,
  0x9E, 0x0E, 0x1E, 0x1E, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0F,
  0x3C, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3C,
  0xF8, 0x78, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0,
  0x78, 0xF8, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x01, 0xF0, 0x07,
  0xF8, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x9E, 0x0F,
  0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0xF9, 0xE1, 0xF3, 0xC7, 0xC7, 0xFF, 0x8F,
  0xFF, 0x0F, 0xDE, 0x0E, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x21, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFC, 0x00, 0x06, 0x0F,
  0x1F, 0x1F, 0x1E, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x78, 0xF8, 0xF8, 0xF0, 0x01, 0x80, 0xF0, 0x7C, 0x1F, 0x07,
  0x80, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xC0,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0x83,
  0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x03, 0x00, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x01, 0xE0, 0x03, 0xF0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7E,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x60,
  0x00, 0x80, 0x00, 0x0F, 0xC3, 0xFE, 0x3F, 0xF3, 0xDF, 0x20, 0xF0, 0x0F,
  0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00,
  0x7E, 0xF8, 0x07, 0x80, 0xE0, 0x70, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00,
  0xE3, 0x87, 0xE7, 0x38, 0x7F, 0x19, 0xC7, 0x38, 0xCC, 0x71, 0xCE, 0xE3,
  0x8C, 0x77, 0x38, 0xE3, 0xB1, 0xC7, 0x1F, 0x8E, 0x38, 0xDC, 0x61, 0xC6,
  0xE7, 0x1C, 0x77, 0x38, 0xE3, 0x39, 0xCF, 0x39, 0xCF, 0xFF, 0x8E, 0x3E,
  0xF8, 0x70, 0xE3, 0x83, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x20, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0xEF, 0x00, 0xEF, 0x01, 0xEF, 0x01, 0xCF, 0x03, 0xCF, 0x03, 0xCF, 0x07,
  0x8F, 0x07, 0x8F, 0x07, 0x8F, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFF, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF8,
  0x0F, 0xF0, 0x0F, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0,
  0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0x0F, 0x07,
  0x87, 0x87, 0x83, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xC0, 0xF1, 0xF0, 0x78,
  0x7C, 0x3C, 0x1E, 0x1E, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xC3,
  0xC3, 0xE1, 0xE3, 0xE1, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xF8, 0x20, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF1, 0x80,
  0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0x8F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07,
  0x87, 0x81, 0xE3, 0xC0, 0xF8, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0xC7,
  0xC1, 0xE1, 0xE0, 0xF8, 0x78, 0x3C, 0x1E, 0x3F, 0x07, 0xFF, 0x83, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFF,
  0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xF0, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0x80, 0x83, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x02, 0x78, 0x7F, 0x1E, 0x1F, 0xCF, 0x87, 0xF3,
  0xE0, 0x3C, 0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0x81, 0xE3, 0xE0, 0x78, 0xF8,
  0x1E, 0x1E, 0x0F, 0x07, 0xE3, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFE,
  0x00, 0x07, 0x81, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F,
  0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1,
  0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8,
  0x3C, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x0F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x81,
  0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x1F, 0xC0, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x13, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0x81, 0xE0,
  0xF0, 0x78, 0x1E, 0x1F, 0x03, 0xC3, 0xC0, 0x70, 0xF0, 0x1E, 0x3C, 0x03,
  0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x78, 0x03, 0xDF, 0x00, 0x7B, 0xC0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xF7, 0x80, 0x3C,
  0xF0, 0x07, 0x9E, 0x00, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x80, 0xF0,
  0xF0, 0x1E, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x80, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0,
  0x7E, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1D, 0xC0, 0xFE,
  0x0E, 0xE0, 0xFF, 0x0F, 0x70, 0x77, 0x07, 0xB8, 0x7F, 0x83, 0xDC, 0x3B,
  0xC1, 0xCE, 0x3D, 0xE0, 0xE7, 0x1C, 0xF0, 0xF3, 0x9E, 0x70, 0x79, 0xCE,
  0x78, 0x3C, 0xE7, 0x3C, 0x1C, 0x77, 0x9E, 0x0E, 0x3B, 0x8F, 0x0F, 0x1F,
  0xCF, 0x07, 0x8F, 0xC7, 0x83, 0xC7, 0xE3, 0xC1, 0xC3, 0xE1, 0xE1, 0xE1,
  0xF0, 0xE0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x00, 0x07, 0xC0, 0x78,
  0x3E, 0x03, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x7E, 0x0F, 0x07, 0xF0,
  0x70, 0x3F, 0x83, 0x81, 0xDC, 0x3C, 0x0E, 0xE1, 0xE0, 0xF7, 0x0F, 0x07,
  0xBC, 0x70, 0x3D, 0xE7, 0x81, 0xCF, 0x3C, 0x0E, 0x39, 0xE0, 0xF1, 0xCF,
  0x07, 0x8E, 0x70, 0x3C, 0x7F, 0x81, 0xC3, 0xFC, 0x0E, 0x1F, 0xE0, 0xF0,
  0x7F, 0x07, 0x83, 0xF0, 0x3C, 0x1F, 0x81, 0xC0, 0xFC, 0x1E, 0x07, 0xE0,
  0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xFE, 0x0F, 0x87, 0x87, 0xC1, 0xE1, 0xE0, 0x7C, 0xF8, 0x1F,
  0x3C, 0x07, 0xCF, 0x01, 0xF7, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E,
  0x01, 0xE7, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0x3E, 0x03, 0xCF, 0x81,
  0xF3, 0xE0, 0x78, 0xF8, 0x3E, 0x1E, 0x1F, 0x07, 0xCF, 0x81, 0xFF, 0xE0,
  0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0xF8, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07,
  0x8F, 0x07, 0x87, 0x83, 0xC3, 0xC3, 0xE1, 0xE3, 0xE0, 0xFF, 0xF0, 0xFF,
  0xF0, 0x7F, 0xE0, 0x3F, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0x87,
  0x87, 0xC1, 0xE1, 0xE0, 0x7C, 0xF8, 0x1F, 0x3C, 0x07, 0xCF, 0x01, 0xF7,
  0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xFB, 0xE0,
  0x3E, 0xF8, 0x0F, 0x3E, 0x03, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0xF8, 0x3E,
  0x1E, 0x1F, 0x07, 0xCF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x07, 0xE0, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E, 0x1F, 0x1E,
  0x3E, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0x78, 0x78, 0x78, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0x7C, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xE0, 0xF8, 0x20, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x82, 0x07, 0xC1, 0xEF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xC0,
  0x00, 0x3F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x0F,
  0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1E, 0x1E, 0x07, 0x87, 0x81,
  0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x3E, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0,
  0xF0, 0x3C, 0x3C, 0x1F, 0x1F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78,
  0x1E, 0x1E, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x7C, 0x3E, 0x1E,
  0x0F, 0xCF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0xF0, 0x0F,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78,
  0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0,
  0xF3, 0xC0, 0xF3, 0xC0, 0xF3, 0x80, 0xF7, 0x80, 0xF7, 0x80, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x78, 0x0E, 0x03, 0xDE, 0x07, 0x81, 0xE7, 0x81, 0xE0, 0x79,
  0xE0, 0xF8, 0x3C, 0x78, 0x3E, 0x0F, 0x1E, 0x0F, 0x83, 0xC7, 0x87, 0xE1,
  0xE1, 0xE1, 0xF8, 0x78, 0x78, 0xFE, 0x3C, 0x1E, 0x3B, 0x8F, 0x07, 0x8E,
  0xE3, 0xC1, 0xE7, 0xF9, 0xE0, 0x79, 0xDE, 0x78, 0x1E, 0xF7, 0x9C, 0x07,
  0xB9, 0xEF, 0x01, 0xCE, 0x7B, 0xC0, 0x77, 0x9D, 0xE0, 0x1D, 0xC7, 0x78,
  0x07, 0x71, 0xDC, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x87,
  0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x0F, 0x01, 0xE1,
  0xE0, 0x3C, 0x78, 0x03, 0x8E, 0x00, 0x7B, 0xC0, 0x0F, 0x70, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3D, 0xE0,
  0x07, 0x9C, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x0F, 0x03, 0xC1, 0xE0,
  0x78, 0x3C, 0x1E, 0x07, 0x80, 0xF0, 0x3F, 0xE0, 0x7B, 0xC1, 0xE3, 0x83,
  0xC7, 0x8F, 0x0F, 0x1E, 0x1E, 0x78, 0x3C, 0xF0, 0x7B, 0xC0, 0xF7, 0x81,
  0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xE3, 0x8E,
  0x3C, 0xF3, 0xCF, 0x1C, 0x71, 0xC7, 0x1E, 0x79, 0xE7, 0x8E, 0x38, 0xE3,
  0x8F, 0x3C, 0xF3, 0xC7, 0x1C, 0x70, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x01, 0xFC, 0x07, 0xF0,
  0x3F, 0xC0, 0x00, 0x60, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7F, 0x01, 0xEE, 0x03, 0x9C, 0x0F, 0x38, 0x3C, 0x78, 0x70, 0x71, 0xE0,
  0xE3, 0x81, 0xCF, 0x03, 0xFC, 0x03, 0x80, 0xFF, 0xFF, 0xFE, 0xF9, 0xE7,
  0x8E, 0x3C, 0x70, 0x03, 0x8E, 0x1F, 0xBC, 0x7F, 0xF8, 0xFF, 0xF3, 0xE3,
  0xC7, 0x87, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3D, 0xE0, 0xF3, 0xC1, 0xE7,
  0x83, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0x3C, 0x78, 0xF8, 0xF1, 0xF1, 0xFF,
  0xE3, 0xFB, 0x83, 0xE7, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x9C, 0x0F, 0xFC, 0x1F, 0xFC,
  0x7F, 0xF8, 0xF8, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x3C,
  0x1E, 0x78, 0x3C, 0xE0, 0x7B, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x9E, 0x1E,
  0x3E, 0x7C, 0xFF, 0xF1, 0xFF, 0xC3, 0x9F, 0x00, 0x03, 0xE0, 0x3F, 0xC3,
  0xFC, 0x3F, 0xC3, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x87,
  0xFC, 0x1F, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x07, 0x3C, 0x0F, 0xDE,
  0x0F, 0xFF, 0x07, 0xFF, 0x87, 0x8F, 0x83, 0xC3, 0xC3, 0xC1, 0xE1, 0xE0,
  0xF0, 0xF0, 0x70, 0xF0, 0x38, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F,
  0x07, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE3, 0xE0, 0xFF, 0xF0, 0x3F, 0x70,
  0x1F, 0x38, 0x00, 0x01, 0xE0, 0x3F, 0x83, 0xFE, 0x3C, 0xF3, 0xC3, 0x9C,
  0x1D, 0xE1, 0xEF, 0x0F, 0x71, 0xF7, 0xFF, 0x3F, 0xE1, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x47, 0xFE, 0x1F, 0xF0, 0x7F, 0x00,
  0x00, 0x02, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xE3, 0x81, 0xF9, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xF0, 0xF0, 0x78,
  0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x1E, 0x0F, 0x0F, 0x07, 0x87,
  0x83, 0xC3, 0xC1, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0xF8, 0x3C, 0xFC,
  0x1F, 0xFE, 0x0F, 0xEE, 0x03, 0xEF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x81, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x00,
  0xC0, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x9C, 0x0E, 0xFC, 0x1F, 0xFC, 0x7F, 0xF8, 0xF8,
  0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0x3C, 0x78, 0x78,
  0xF0, 0xF3, 0xC1, 0xE7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x38, 0x3C, 0xF0,
  0x71, 0xE1, 0xE3, 0xC3, 0xC0, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x00,
  0x00, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0xFE, 0x03, 0xF8, 0x0F,
  0xC0, 0x1C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x0F, 0x0E, 0x1E, 0x0E, 0x1E, 0x1E,
  0x3C, 0x1E, 0x78, 0x1E, 0xF0, 0x1C, 0xF0, 0x1D, 0xE0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7D, 0xE0, 0x79, 0xE0, 0x79, 0xE0, 0x70,
  0xE0, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x07, 0xC1, 0xE0,
  0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x00, 0x0E, 0x78, 0x78, 0x1D, 0xF9,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF1, 0xF1, 0xF1, 0xE3, 0xC3, 0xC3,
  0x87, 0x87, 0x8F, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78,
  0xF0, 0xF0, 0xE1, 0xC1, 0xC3, 0xC7, 0x87, 0x87, 0x8F, 0x0F, 0x0F, 0x1E,
  0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x70, 0x70, 0xF1, 0xE1, 0xE1, 0xE3, 0xC3,
  0xC3, 0xC7, 0x87, 0x87, 0x00, 0x0E, 0x38, 0x1D, 0xF8, 0x3F, 0xF8, 0xFF,
  0xF1, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x9E, 0x0F, 0x3C, 0x3C, 0x78, 0x78,
  0xF0, 0xF1, 0xC1, 0xE7, 0x83, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x70,
  0x79, 0xE0, 0xE3, 0xC3, 0xC7, 0x87, 0x80, 0x03, 0xE0, 0x3F, 0xC1, 0xFF,
  0x87, 0xFE, 0x3C, 0x3C, 0xF0, 0xF7, 0x83, 0xDE, 0x0F, 0x70, 0x3F, 0xC0,
  0xFF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0x3C, 0x3C, 0xF1,
  0xE3, 0xFF, 0x87, 0xFC, 0x0F, 0xC0, 0x03, 0x8E, 0x01, 0xDF, 0x80, 0xFF,
  0xE0, 0xFD, 0xF0, 0x7C, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F,
  0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0x78,
  0x78, 0x7C, 0x3C, 0x3C, 0x1F, 0x3E, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xBE,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x8E, 0x1F, 0xDC,
  0x7F, 0xF8, 0xFF, 0xF3, 0xC3, 0xC7, 0x87, 0x9E, 0x0F, 0x3C, 0x1E, 0x78,
  0x3D, 0xE0, 0x73, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0E, 0x3C, 0x3C,
  0x78, 0x78, 0xF1, 0xF1, 0xFF, 0xE3, 0xFB, 0x83, 0xEF, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0x0E, 0x78, 0x77, 0x83, 0xFC, 0x3F, 0xE1, 0xF9, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x7F, 0xC7, 0xFC, 0x7C, 0xE3, 0xC1, 0x1E, 0x00, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0xC7, 0xC7, 0xFE, 0x3F, 0xE1, 0xFE, 0x00, 0x07, 0x01, 0xC0,
  0xE0, 0x38, 0x0F, 0xCF, 0xF7, 0xFD, 0xFE, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F,
  0x8F, 0xE1, 0xF8, 0x1E, 0x1E, 0x38, 0x3C, 0x70, 0x71, 0xE1, 0xE3, 0xC3,
  0xC7, 0x87, 0x8E, 0x0F, 0x3C, 0x1C, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE3,
  0x83, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0xF8, 0xF3, 0xE1, 0xFF,
  0xC3, 0xFB, 0x83, 0xE7, 0x00, 0xF0, 0x7F, 0x83, 0xFC, 0x1D, 0xE1, 0xEF,
  0x0F, 0x78, 0xF3, 0xC7, 0x9E, 0x38, 0xF3, 0xC7, 0x9C, 0x3D, 0xE1, 0xEE,
  0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x00, 0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x3D, 0xE3, 0xF1,
  0xEF, 0x1F, 0x8E, 0x78, 0xF8, 0xF3, 0xCF, 0xC7, 0x9E, 0x7E, 0x38, 0xF7,
  0x73, 0xC7, 0xBB, 0x9C, 0x3D, 0xDD, 0xE1, 0xFC, 0xEF, 0x0E, 0xE7, 0x70,
  0x77, 0x3F, 0x83, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x7E, 0x07, 0xC3,
  0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x87, 0x83, 0xC3, 0xC1,
  0xE3, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x1D, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x3C, 0xE0, 0x3C, 0x78, 0x1E, 0x3C, 0x1E, 0x1E, 0x1F,
  0x0F, 0x00, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC3, 0xC0,
  0x78, 0x78, 0x0F, 0x1E, 0x00, 0xE3, 0xC0, 0x1C, 0x70, 0x03, 0x9E, 0x00,
  0x73, 0xC0, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x06, 0x00, 0x00, 0x0F,
  0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x18,
  0x07, 0xC0, 0x7E, 0x07, 0xF0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x03, 0xF8, 0x1F, 0x00,
  0xF8, 0x07, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0xF8,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x1F, 0x00, 0xF8, 0x0F, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x1F, 0xC1, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x0F, 0xE0, 0x7E, 0x03, 0xE0, 0x18, 0x00, 0x7F, 0x03, 0xFF, 0x9F,
  0xFF, 0xFE, 0x1F, 0xE8, 0x0F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 10, 26, 9, 0, -26 },
  { 34, 12, 10, 13, 3, -26 },
  { 49, 17, 26, 16, 0, -26 },
  { 105, 16, 29, 15, 0, -27 },
  { 163, 21, 26, 24, 2, -26 },
  { 232, 17, 26, 17, 0, -26 },
  { 288, 5, 10, 8, 4, -26 },
  { 295, 11, 32, 10, 1, -26 },
  { 339, 12, 32, 10, -3, -26 },
  { 387, 13, 14, 14, 3, -28 },
  { 410, 15, 17, 16, 1, -21 },
  { 442, 8, 10, 8, -2, -5 },
  { 452, 9, 4, 10, 0, -12 },
  { 457, 5, 5, 8, 0, -5 },
  { 461, 18, 26, 13, -2, -26 },
  { 520, 14, 26, 15, 1, -26 },
  { 566, 10, 26, 15, 4, -26 },
  { 599, 16, 26, 15, -1, -26 },
  { 651, 16, 26, 15, -1, -26 },
  { 703, 16, 26, 15, -1, -26 },
  { 755, 15, 26, 15, 0, -26 },
  { 804, 15, 26, 15, 1, -26 },
  { 853, 16, 26, 15, 1, -26 },
  { 905, 16, 26, 15, 0, -26 },
  { 957, 15, 26, 15, 0, -26 },
  { 1006, 8, 20, 8, 0, -20 },
  { 1026, 10, 25, 8, -2, -20 },
  { 1058, 15, 17, 16, 1, -21 },
  { 1090, 15, 11, 16, 1, -18 },
  { 1111, 15, 17, 16, 1, -21 },
  { 1143, 12, 26, 11, 1, -26 },
  { 1182, 21, 29, 23, 1, -26 },
  { 1259, 16, 26, 16, -2, -26 },
  { 1311, 17, 26, 16, 0, -26 },
  { 1367, 17, 26, 15, 1, -26 },
  { 1423, 18, 26, 18, 0, -26 },
  { 1482, 16, 26, 14, 0, -26 },
  { 1534, 16, 26, 13, 0, -26 },
  { 1586, 18, 26, 18, 1, -26 },
  { 1645, 20, 26, 18, 0, -26 },
  { 1710, 15, 26, 11, -2, -26 },
  { 1759, 15, 33, 8, -5, -26 },
  { 1821, 19, 26, 16, 0, -26 },
  { 1883, 11, 26, 13, 0, -26 },
  { 1919, 25, 26, 24, 0, -26 },
  { 2001, 21, 26, 20, 0, -26 },
  { 2070, 18, 26, 19, 1, -26 },
  { 2129, 17, 26, 16, 0, -26 },
  { 2185, 18, 32, 19, 1, -26 },
  { 2257, 16, 26, 16, 0, -26 },
  { 2309, 17, 26, 14, -1, -26 },
  { 2365, 14, 26, 14, 2, -26 },
  { 2411, 18, 26, 18, 1, -26 },
  { 2470, 16, 26, 16, 3, -26 },
  { 2522, 26, 26, 25, 2, -26 },
  { 2607, 19, 26, 15, -2, -26 },
  { 2669, 15, 26, 14, 3, -26 },
  { 2718, 17, 26, 13, -1, -26 },
  { 2774, 14, 32, 10, -1, -26 },
  { 2830, 6, 26, 13, 4, -26 },
  { 2850, 14, 32, 10, -3, -26 },
  { 2906, 15, 15, 15, 0, -26 },
  { 2935, 12, 2, 11, -3, 3 },
  { 2938, 6, 6, 10, 5, -28 },
  { 2943, 15, 20, 16, 1, -20 },
  { 2981, 15, 27, 16, 0, -27 },
  { 3032, 13, 20, 13, 1, -20 },
  { 3065, 17, 27, 16, 1, -27 },
  { 3123, 13, 20, 15, 1, -20 },
  { 3156, 18, 37, 9, -4, -28 },
  { 3240, 17, 29, 16, -1, -20 },
  { 3302, 15, 27, 16, 0, -27 },
  { 3353, 9, 27, 8, 0, -27 },
  { 3384, 14, 36, 8, -5, -27 },
  { 3447, 16, 27, 14, 0, -27 },
  { 3501, 10, 27, 8, 0, -27 },
  { 3535, 23, 20, 23, 0, -20 },
  { 3593, 15, 20, 16, 0, -20 },
  { 3631, 14, 20, 16, 1, -20 },
  { 3666, 17, 29, 16, -2, -20 },
  { 3728, 15, 29, 16, 1, -20 },
  { 3783, 13, 20, 11, 0, -20 },
  { 3816, 13, 20, 12, 0, -20 },
  { 3849, 10, 24, 10, 1, -24 },
  { 3879, 15, 20, 16, 1, -20 },
  { 3917, 13, 20, 14, 2, -20 },
  { 3950, 21, 20, 21, 2, -20 },
  { 4003, 17, 20, 14, -2, -20 },
  { 4046, 19, 29, 14, -3, -20 },
  { 4115, 14, 20, 11, -1, -20 },
  { 4150, 13, 32, 12, 1, -26 },
  { 4202, 3, 36, 13, 5, -28 },
  { 4216, 13, 32, 12, -2, -26 },
  { 4268, 15, 5, 16, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC36PT7B_H_
