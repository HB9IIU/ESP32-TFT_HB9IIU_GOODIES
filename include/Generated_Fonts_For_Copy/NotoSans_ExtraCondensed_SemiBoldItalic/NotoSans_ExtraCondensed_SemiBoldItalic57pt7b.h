#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC57PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x30,
  0x00, 0x3F, 0x1F, 0xCF, 0xC7, 0xF7, 0xF1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F,
  0x9F, 0x87, 0xE7, 0xE3, 0xF1, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0x8F,
  0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F, 0x0F, 0x07, 0xC0, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF8,
  0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E,
  0x1F, 0x00, 0x03, 0xC1, 0xE1, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x7C, 0x00, 0x0F,
  0x07, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03,
  0xC1, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFC, 0xC7, 0x80, 0xFC, 0x60,
  0x80, 0x7E, 0x30, 0x00, 0x3F, 0x18, 0x00, 0x1F, 0x9C, 0x00, 0x0F, 0xCC,
  0x00, 0x07, 0xF6, 0x00, 0x03, 0xFB, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0x7F, 0x00, 0x03, 0x9F, 0x80, 0x01, 0x8F, 0xC0, 0x00, 0xC7, 0xE0,
  0x00, 0x63, 0xF0, 0x40, 0x31, 0xF8, 0x38, 0x39, 0xF8, 0x1F, 0x19, 0xFC,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x3E, 0x01,
  0xFF, 0xC0, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x00, 0xF0, 0xF0, 0x1F, 0x00,
  0xF8, 0x78, 0x0F, 0x00, 0x7C, 0x3C, 0x0F, 0x80, 0x3C, 0x1E, 0x07, 0x80,
  0x3E, 0x0F, 0x07, 0xC0, 0x1F, 0x0F, 0x83, 0xC0, 0x0F, 0x07, 0xC3, 0xE0,
  0x0F, 0x83, 0xE1, 0xE0, 0x07, 0xC1, 0xF1, 0xF0, 0x03, 0xE0, 0xF1, 0xF0,
  0x01, 0xF0, 0xF8, 0xF8, 0x00, 0xF0, 0x7C, 0xF8, 0x3C, 0x78, 0x3C, 0x7C,
  0x7F, 0xBC, 0x3E, 0x7C, 0x7F, 0xDF, 0x1E, 0x3E, 0x7F, 0xFF, 0x9F, 0x3E,
  0x3E, 0xFF, 0xFF, 0x1E, 0x3E, 0x3D, 0xFF, 0x9F, 0x3E, 0x1E, 0xFF, 0x8F,
  0x1F, 0x0F, 0x3F, 0x0F, 0x8F, 0x07, 0x80, 0x07, 0x8F, 0x83, 0xC0, 0x07,
  0xC7, 0xC3, 0xE0, 0x03, 0xC3, 0xC1, 0xF0, 0x03, 0xE1, 0xE0, 0xF8, 0x03,
  0xE1, 0xF0, 0x7C, 0x01, 0xF0, 0xF8, 0x3C, 0x01, 0xF0, 0x7C, 0x3E, 0x00,
  0xF8, 0x3E, 0x1F, 0x00, 0xF8, 0x1E, 0x0F, 0x00, 0x7C, 0x0F, 0x0F, 0x80,
  0x7C, 0x07, 0x87, 0xC0, 0x3C, 0x03, 0xE7, 0xC0, 0x3E, 0x01, 0xFF, 0xC0,
  0x1E, 0x00, 0x7F, 0xE0, 0x1F, 0x00, 0x3F, 0xE0, 0x1F, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x0F, 0xC3, 0xFF, 0xE3, 0xF0, 0xFE,
  0xFC, 0x7E, 0x1F, 0x9F, 0x8F, 0xC7, 0xE3, 0xFB, 0xF1, 0xF8, 0x3F, 0x7E,
  0x3F, 0x07, 0xFF, 0x87, 0xE0, 0xFF, 0xF1, 0xF8, 0x0F, 0xFC, 0x3F, 0x01,
  0xFF, 0x87, 0xE0, 0x3F, 0xE0, 0xFC, 0x03, 0xFC, 0x1F, 0x80, 0xFF, 0x03,
  0xF0, 0x1F, 0xE0, 0x7F, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xBF, 0x81, 0xFF, 0xE3, 0xF8, 0x1F, 0xF0, 0x7F, 0x00,
  0x20, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x02, 0x0F, 0x80, 0x78, 0xF8, 0x07, 0xEF, 0x8E,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF0, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFB, 0xE0, 0x3F, 0x3E, 0x07, 0xF3,
  0xF0, 0x3E, 0x1F, 0x01, 0xC1, 0xF8, 0x0C, 0x1E, 0x00, 0x00, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F,
  0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C,
  0x07, 0xC0, 0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF,
  0xFB, 0xFF, 0xE0, 0x1E, 0x3F, 0x7F, 0x7F, 0xFF, 0xFF, 0xFE, 0x7C, 0x10,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFE, 0x3F, 0x01, 0xF8, 0x3F, 0x07,
  0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC,
  0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x00,
  0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xF0, 0x1F,
  0xCF, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF9,
  0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F,
  0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x3F, 0x83, 0xF0, 0xFE, 0x07, 0xF3, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07,
  0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFC, 0xFE, 0xFC, 0xFC,
  0xFC, 0x78, 0xFC, 0x21, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x9F, 0xF0, 0x0F, 0x81, 0xFC, 0x01, 0xC0,
  0x7F, 0x00, 0x40, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xE7, 0xFC, 0x03, 0x80, 0xFE, 0x00,
  0x80, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x20,
  0x03, 0xFC, 0x1E, 0x03, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xDF, 0x00, 0x03, 0xDF, 0x80,
  0x01, 0xEF, 0xC0, 0x01, 0xE7, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xF3, 0xF0,
  0x00, 0xF9, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x78, 0x7E, 0x00, 0x7C, 0x7E,
  0x00, 0x7C, 0x3F, 0x00, 0x3C, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x3E, 0x07,
  0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0x01, 0xF8, 0x0F, 0x80,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x06, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x80, 0x0F, 0xE0, 0x80, 0x1F, 0xE0, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x82, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x8F, 0xC0, 0x1F, 0xBF, 0xE0, 0x3F, 0x7F, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xE7, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x81,
  0xF8, 0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F,
  0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xC3, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x83,
  0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xF0,
  0x3F, 0x83, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xF3, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xDF, 0xC0, 0x3F, 0xC7,
  0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0,
  0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFC,
  0xFE, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0,
  0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x80,
  0xFE, 0x1F, 0x81, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xE3, 0xFE, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFE, 0xFC, 0x07, 0xFD, 0xFC, 0x03, 0xF9,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x80, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x04, 0x00,
  0x00, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F,
  0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x7E, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0,
  0x7F, 0x01, 0xF0, 0x02, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xF0, 0xFE,
  0x04, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xF8,
  0x03, 0xE0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00,
  0xF0, 0x3E, 0x00, 0x00, 0x3C, 0x1F, 0x01, 0xFE, 0x0F, 0x07, 0x81, 0xFF,
  0xE3, 0xC3, 0xE0, 0xFF, 0xF0, 0xF0, 0xF0, 0x3F, 0xFC, 0x3C, 0x3C, 0x1F,
  0x1F, 0x0F, 0x1E, 0x0F, 0x87, 0x83, 0xC7, 0x83, 0xC1, 0xE0, 0xF3, 0xE1,
  0xF0, 0xF8, 0x3C, 0xF0, 0x78, 0x3E, 0x1F, 0x3C, 0x3E, 0x0F, 0x07, 0x8F,
  0x0F, 0x03, 0xC1, 0xE7, 0xC3, 0xC1, 0xF0, 0x79, 0xE0, 0xF0, 0x7C, 0x1E,
  0x78, 0x7C, 0x1F, 0x0F, 0x1E, 0x1F, 0x07, 0x83, 0xC7, 0x87, 0xC3, 0xE0,
  0xF1, 0xE1, 0xE0, 0xF8, 0x78, 0xF8, 0x78, 0x7E, 0x1E, 0x3E, 0x1F, 0x1F,
  0x8F, 0x0F, 0x87, 0xCF, 0xE7, 0x83, 0xE1, 0xFF, 0x7F, 0xE0, 0xF8, 0x3F,
  0xCF, 0xF0, 0x3E, 0x07, 0xE3, 0xF8, 0x0F, 0x80, 0x40, 0x10, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0C, 0x00,
  0x07, 0xF8, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xF8, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC,
  0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0,
  0x7E, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07,
  0xF1, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0,
  0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7E, 0x07, 0xF0,
  0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x81,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x7F, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x03, 0xF0, 0xFF, 0x00, 0x7E, 0x07, 0xF0, 0x1F, 0xC0, 0xFE,
  0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xF0,
  0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x0F, 0xF0, 0x3F, 0x07,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xE0, 0x20, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x04,
  0x01, 0xFF, 0x1E, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFC, 0x3F,
  0xE0, 0x1F, 0x81, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00,
  0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0,
  0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC,
  0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x81, 0xF8,
  0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0xFF,
  0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x01, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x7F,
  0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xE7, 0xF0, 0x07, 0xF8, 0x03, 0x00, 0x7F, 0x80, 0x08, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0x87, 0xF0, 0x3F, 0xF8, 0x3F, 0x01,
  0xFF, 0xC3, 0xF8, 0x0F, 0xFE, 0x1F, 0xC0, 0x7F, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0,
  0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F,
  0x00, 0xFF, 0x83, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xFC, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x43, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F,
  0x81, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE1,
  0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xFC,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xFC, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0x7F, 0x3F,
  0x80, 0x01, 0xF8, 0xFE, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC1, 0xFC, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x7F, 0xF8,
  0x03, 0xEF, 0x80, 0x7D, 0xF8, 0x07, 0xEF, 0x80, 0x7D, 0xF8, 0x07, 0xEF,
  0x80, 0xFD, 0xF8, 0x07, 0xEF, 0x80, 0xF9, 0xF8, 0x07, 0xEF, 0x81, 0xFB,
  0xF0, 0x0F, 0xCF, 0x81, 0xF3, 0xF0, 0x0F, 0xCF, 0x83, 0xF3, 0xF0, 0x0F,
  0xCF, 0xC3, 0xE3, 0xF0, 0x0F, 0xCF, 0xC7, 0xE7, 0xF0, 0x0F, 0x8F, 0xC7,
  0xC7, 0xE0, 0x1F, 0x8F, 0xC7, 0xC7, 0xE0, 0x1F, 0x8F, 0xCF, 0xC7, 0xE0,
  0x1F, 0x8F, 0xCF, 0x87, 0xE0, 0x1F, 0x8F, 0xDF, 0x8F, 0xC0, 0x1F, 0x0F,
  0xDF, 0x0F, 0xC0, 0x3F, 0x0F, 0xFF, 0x0F, 0xC0, 0x3F, 0x07, 0xFE, 0x0F,
  0xC0, 0x3F, 0x07, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xFC, 0x1F, 0x80, 0x3E,
  0x07, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xF8,
  0x1F, 0x80, 0x7E, 0x07, 0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x3F, 0x00,
  0xFC, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0x1F, 0x80,
  0x3F, 0xC0, 0x0F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x03, 0xF0,
  0x0F, 0xF8, 0x01, 0xF8, 0x07, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0x00, 0xFC,
  0x01, 0xFF, 0x80, 0x7E, 0x00, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xE0, 0x1F,
  0x00, 0x7F, 0xF0, 0x1F, 0x80, 0x3F, 0xFC, 0x0F, 0xC0, 0x1F, 0x7E, 0x07,
  0xE0, 0x0F, 0x9F, 0x03, 0xF0, 0x0F, 0xCF, 0x83, 0xF0, 0x07, 0xE7, 0xC1,
  0xF8, 0x03, 0xF3, 0xE0, 0xFC, 0x01, 0xF1, 0xF8, 0x7E, 0x01, 0xF8, 0xFC,
  0x3F, 0x00, 0xFC, 0x3E, 0x3F, 0x00, 0x7E, 0x1F, 0x1F, 0x80, 0x3F, 0x0F,
  0x8F, 0xC0, 0x1F, 0x07, 0xE7, 0xE0, 0x1F, 0x83, 0xF3, 0xE0, 0x0F, 0xC1,
  0xFB, 0xF0, 0x07, 0xE0, 0x7D, 0xF8, 0x03, 0xF0, 0x3E, 0xFC, 0x01, 0xF0,
  0x1F, 0x7E, 0x01, 0xF8, 0x0F, 0xFE, 0x00, 0xFC, 0x07, 0xFF, 0x00, 0x7E,
  0x03, 0xFF, 0x80, 0x3F, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xE0, 0x1F,
  0x80, 0x3F, 0xE0, 0x0F, 0xC0, 0x1F, 0xF0, 0x07, 0xE0, 0x0F, 0xF8, 0x03,
  0xF0, 0x07, 0xFC, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xE1,
  0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xFC, 0x00,
  0x7E, 0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x3F,
  0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07,
  0xF7, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xF7, 0xF0,
  0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0xFE,
  0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x3F, 0xC7, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0x0F, 0xF0, 0x0F, 0xC0, 0xFF, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01,
  0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x07,
  0xE0, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xE0, 0x1F,
  0xC0, 0xFC, 0x07, 0xF0, 0x1F, 0x81, 0xFE, 0x07, 0xF0, 0x7F, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x1F, 0xC0,
  0x7F, 0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x87,
  0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x01,
  0xF9, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC,
  0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x1F,
  0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0,
  0x03, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF1,
  0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x01,
  0xFE, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0xC7, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0x83, 0xFC, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x81, 0xF8,
  0x1F, 0xC0, 0x7E, 0x0F, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x87,
  0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x3F,
  0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x1F, 0xE0, 0x70, 0x0F, 0xF0, 0x04, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x10, 0x01, 0xFC, 0x07, 0x00, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE8, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xF0,
  0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F,
  0xC0, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x01, 0xF8, 0x1F,
  0x80, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00,
  0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0,
  0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xF1, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x07,
  0xF3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7F, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E,
  0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x07,
  0xE1, 0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80,
  0x07, 0xEF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x7E,
  0x00, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x7E, 0x01, 0xFE,
  0x01, 0xF8, 0x7E, 0x01, 0xFE, 0x01, 0xF8, 0x7E, 0x03, 0xFE, 0x03, 0xF0,
  0x7E, 0x03, 0xFE, 0x03, 0xF0, 0x7E, 0x03, 0xFE, 0x07, 0xF0, 0x7E, 0x07,
  0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xFE, 0x07, 0xE0, 0x7E, 0x0F, 0xBE, 0x0F,
  0xC0, 0x7E, 0x0F, 0xBE, 0x0F, 0xC0, 0x7E, 0x0F, 0xFC, 0x0F, 0xC0, 0x7E,
  0x1F, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x7C,
  0x3F, 0x80, 0x7C, 0x3E, 0x7C, 0x3F, 0x00, 0xFC, 0x3E, 0x7C, 0x3F, 0x00,
  0xFC, 0x7E, 0x7C, 0x7E, 0x00, 0xFC, 0x7C, 0x7C, 0x7E, 0x00, 0xFC, 0x7C,
  0x7C, 0xFE, 0x00, 0xFC, 0xF8, 0x7C, 0xFC, 0x00, 0xFC, 0xF8, 0x7C, 0xFC,
  0x00, 0xFD, 0xF8, 0x7D, 0xF8, 0x00, 0xFD, 0xF0, 0x7D, 0xF8, 0x00, 0xFD,
  0xF0, 0x7D, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x03,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xCF, 0xE0, 0x3F, 0x8F, 0xC0, 0x7E,
  0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF0, 0x07, 0xC7, 0xE0, 0x0F,
  0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x08, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x7E, 0x1F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xFD,
  0xF8, 0x00, 0xF9, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xE0,
  0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x80,
  0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xE0, 0xFE, 0x1F, 0xC7, 0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3E,
  0x07, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0xFF, 0xCF, 0x80, 0xFF, 0xE7, 0xC0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0x8F, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F,
  0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE1, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x80,
  0x7E, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x3F, 0x83, 0xF8,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0x7E, 0x01, 0xFF, 0x3E, 0x00,
  0x7F, 0x1F, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x03, 0xF7, 0xFC,
  0x03, 0xFF, 0xFE, 0x03, 0xEF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xF8, 0x7F,
  0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E,
  0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC,
  0x3F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x7F, 0x87, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFD, 0xFF, 0xC0, 0xF9, 0xFF, 0x80,
  0xF8, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xF8, 0x20, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x02, 0x03,
  0xF8, 0x30, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x07,
  0xF3, 0xF8, 0x01, 0xFF, 0x7E, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0,
  0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F,
  0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x3F, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xF7, 0xE0,
  0x07, 0xFC, 0xF8, 0x00, 0x7F, 0x1F, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xBF,
  0x83, 0xF0, 0x7C, 0x3F, 0x03, 0xE3, 0xF8, 0x1F, 0x1F, 0x80, 0xF9, 0xFC,
  0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0xFF, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x0C, 0x1F, 0xE3, 0xE0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xC7, 0xE0, 0x07, 0xFC, 0xF8, 0x01, 0xFF, 0xDF, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x0F,
  0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0xFE,
  0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x83, 0xFC, 0x07, 0xF0,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xDF, 0x80,
  0x1F, 0xF7, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x04, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x01, 0x00, 0x3F, 0x80, 0x30, 0x0F, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF3, 0xF8, 0x03, 0xF7, 0xFC,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFC, 0xFF,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8,
  0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0,
  0xFC, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F,
  0x07, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7F, 0x00,
  0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xF3, 0xF8,
  0x00, 0xFD, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x03, 0xFD, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xC7, 0xF0, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xE3, 0xF8, 0x3F, 0xC0, 0x3E,
  0x7F, 0xC7, 0xFE, 0x03, 0xEF, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x8F, 0xFC, 0x7F, 0x07, 0xF0, 0x7F,
  0x87, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0xFC, 0x07, 0xC0, 0x7E,
  0x0F, 0xC0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC,
  0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0xC1, 0xF8,
  0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xF8,
  0x3F, 0x01, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x03, 0xF0,
  0x1F, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0xFC, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0,
  0x7E, 0x00, 0x03, 0xE3, 0xF8, 0x03, 0xE7, 0xFC, 0x03, 0xEF, 0xFE, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFC, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFC, 0x1F,
  0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x3F,
  0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFE,
  0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x00,
  0x02, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0x1F, 0xC3, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC,
  0x7E, 0x03, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFD, 0xFC,
  0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x07,
  0xF7, 0xE0, 0x1F, 0xBF, 0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xEF,
  0xC0, 0x3F, 0x3F, 0x01, 0xFC, 0xFE, 0x07, 0xF1, 0xF8, 0x3F, 0x87, 0xF1,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x03, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x9F,
  0xF0, 0x01, 0xF7, 0xFF, 0x00, 0x3E, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFE, 0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xF0,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7F, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xFF,
  0xF0, 0x07, 0xDF, 0xFE, 0x01, 0xFB, 0xFF, 0x80, 0x3F, 0x3F, 0xE0, 0x07,
  0xE7, 0xF8, 0x00, 0xFC, 0x10, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x1F, 0x80, 0x7F, 0xCF, 0x80, 0x7F, 0xF7, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0x8F, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xFC,
  0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F,
  0x83, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01,
  0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0x7E, 0x01, 0xFF, 0x7E, 0x00, 0x7F, 0x3F, 0x00,
  0x04, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE3, 0xF0, 0x3E,
  0x7F, 0x03, 0xEF, 0xE0, 0x3E, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFC, 0x20, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFC, 0x0C, 0x1F, 0xC0, 0x41, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x80, 0x7F, 0x0E, 0x0F, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x20, 0x00, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xFF, 0x3F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xE0, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x02, 0x00, 0x00,
  0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7C,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC,
  0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8,
  0x3F, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xF7, 0xC0, 0x7F, 0xE7, 0xC0, 0x3F, 0xC7, 0xC0, 0x02, 0x00, 0x00,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xC0,
  0x7E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x8F, 0x81, 0xF8, 0x7C, 0x0F, 0xC3,
  0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x3E, 0x1F,
  0x01, 0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0xFC, 0x03, 0xE7, 0xE0, 0x1F,
  0x3E, 0x00, 0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x07,
  0xF0, 0x1F, 0xBE, 0x03, 0xF8, 0x0F, 0xDF, 0x01, 0xFC, 0x0F, 0xCF, 0x81,
  0xFE, 0x07, 0xE7, 0xC0, 0xFF, 0x03, 0xF3, 0xE0, 0xFF, 0x83, 0xF3, 0xF0,
  0x7F, 0xC1, 0xF9, 0xF8, 0x3F, 0xE0, 0xF8, 0xFC, 0x3F, 0xF0, 0xFC, 0x7E,
  0x1F, 0xF8, 0x7E, 0x3F, 0x0F, 0x7C, 0x7E, 0x1F, 0x8F, 0xBE, 0x3F, 0x0F,
  0xC7, 0xDF, 0x1F, 0x07, 0xE7, 0xCF, 0x9F, 0x83, 0xF3, 0xE7, 0xCF, 0xC1,
  0xF9, 0xF3, 0xE7, 0xC0, 0xFD, 0xF1, 0xF7, 0xE0, 0x7E, 0xF8, 0xFB, 0xE0,
  0x3F, 0x78, 0x7B, 0xF0, 0x1F, 0xFC, 0x3D, 0xF8, 0x0F, 0xBE, 0x1E, 0xF8,
  0x07, 0xDE, 0x1F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F,
  0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81,
  0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01,
  0xF8, 0xFE, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0x7E, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x3F,
  0x80, 0xFE, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8,
  0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7C, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0x40, 0x03, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 16, 42, 14, 0, -41 },
  { 85, 18, 15, 21, 6, -41 },
  { 119, 28, 41, 26, 0, -41 },
  { 263, 25, 46, 23, 0, -43 },
  { 407, 33, 42, 38, 3, -41 },
  { 581, 27, 42, 28, 0, -41 },
  { 723, 8, 15, 13, 6, -41 },
  { 738, 18, 50, 15, 1, -41 },
  { 851, 18, 50, 15, -4, -41 },
  { 964, 20, 22, 22, 5, -44 },
  { 1019, 23, 27, 26, 2, -34 },
  { 1097, 12, 15, 13, -3, -7 },
  { 1120, 14, 6, 16, 1, -18 },
  { 1131, 8, 9, 13, 0, -8 },
  { 1140, 28, 41, 20, -3, -41 },
  { 1284, 23, 42, 23, 1, -41 },
  { 1405, 16, 41, 24, 6, -41 },
  { 1487, 26, 41, 23, -2, -41 },
  { 1621, 25, 42, 23, -1, -41 },
  { 1753, 25, 41, 24, -1, -41 },
  { 1882, 24, 42, 23, 0, -41 },
  { 2008, 24, 42, 23, 1, -41 },
  { 2134, 25, 41, 23, 2, -41 },
  { 2263, 25, 42, 23, 0, -41 },
  { 2395, 24, 42, 23, 0, -41 },
  { 2521, 13, 32, 13, 0, -31 },
  { 2573, 16, 39, 13, -3, -31 },
  { 2651, 23, 27, 26, 2, -34 },
  { 2729, 23, 16, 26, 2, -28 },
  { 2775, 23, 27, 26, 2, -34 },
  { 2853, 20, 42, 18, 1, -41 },
  { 2958, 34, 46, 36, 1, -41 },
  { 3154, 26, 41, 25, -4, -41 },
  { 3288, 27, 41, 26, 0, -41 },
  { 3427, 26, 42, 24, 2, -41 },
  { 3564, 28, 41, 28, 0, -41 },
  { 3708, 25, 41, 22, 0, -41 },
  { 3837, 25, 41, 21, 0, -41 },
  { 3966, 29, 42, 29, 2, -41 },
  { 4119, 31, 41, 29, 0, -41 },
  { 4278, 24, 41, 17, -3, -41 },
  { 4401, 24, 53, 13, -9, -41 },
  { 4560, 30, 41, 25, 0, -41 },
  { 4714, 17, 41, 21, 0, -41 },
  { 4802, 40, 41, 39, 0, -41 },
  { 5007, 33, 41, 31, 0, -41 },
  { 5177, 27, 42, 30, 2, -41 },
  { 5319, 27, 41, 25, 0, -41 },
  { 5458, 27, 51, 30, 2, -41 },
  { 5631, 26, 41, 25, 0, -41 },
  { 5765, 26, 42, 23, -1, -41 },
  { 5902, 22, 41, 21, 4, -41 },
  { 6015, 28, 42, 28, 2, -41 },
  { 6162, 25, 41, 25, 5, -41 },
  { 6291, 40, 41, 39, 4, -41 },
  { 6496, 31, 41, 24, -3, -41 },
  { 6655, 23, 41, 23, 5, -41 },
  { 6773, 27, 41, 21, -2, -41 },
  { 6912, 22, 50, 16, -2, -41 },
  { 7050, 10, 41, 21, 6, -41 },
  { 7102, 22, 50, 16, -4, -41 },
  { 7240, 24, 24, 24, 0, -41 },
  { 7312, 19, 4, 18, -5, 5 },
  { 7322, 10, 9, 16, 8, -44 },
  { 7334, 25, 32, 25, 1, -31 },
  { 7434, 24, 44, 25, 0, -43 },
  { 7566, 21, 32, 20, 1, -31 },
  { 7650, 27, 44, 25, 1, -43 },
  { 7799, 21, 32, 23, 1, -31 },
  { 7883, 28, 58, 15, -7, -44 },
  { 8086, 27, 45, 25, -1, -31 },
  { 8238, 24, 43, 25, 0, -43 },
  { 8367, 15, 43, 12, 0, -43 },
  { 8448, 22, 57, 12, -7, -43 },
  { 8605, 26, 43, 23, 0, -43 },
  { 8745, 15, 43, 12, 0, -43 },
  { 8826, 36, 31, 37, 0, -31 },
  { 8966, 24, 31, 25, 0, -31 },
  { 9059, 22, 33, 25, 1, -32 },
  { 9150, 27, 44, 25, -3, -31 },
  { 9299, 25, 45, 25, 1, -31 },
  { 9440, 20, 31, 17, 0, -31 },
  { 9518, 20, 32, 20, 0, -31 },
  { 9598, 15, 39, 16, 2, -38 },
  { 9672, 24, 32, 25, 1, -31 },
  { 9768, 21, 31, 21, 3, -31 },
  { 9850, 33, 31, 33, 3, -31 },
  { 9978, 27, 31, 22, -3, -31 },
  { 10083, 30, 45, 22, -5, -31 },
  { 10252, 22, 31, 18, -2, -31 },
  { 10338, 22, 50, 19, 1, -41 },
  { 10476, 6, 57, 21, 7, -44 },
  { 10519, 21, 50, 19, -3, -41 },
  { 10651, 23, 8, 26, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC57PT7B_H_
