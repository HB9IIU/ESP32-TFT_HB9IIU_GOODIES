#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC31PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E,
  0x07, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x1E, 0x0F,
  0x07, 0x80, 0x7B, 0xDC, 0xF7, 0x39, 0xCE, 0x63, 0xB8, 0xCE, 0x73, 0x9C,
  0x01, 0xCE, 0x03, 0x18, 0x0E, 0x70, 0x1C, 0xC0, 0x31, 0x80, 0xE7, 0x0F,
  0xFF, 0x9F, 0xFF, 0x06, 0x70, 0x1C, 0xE0, 0x31, 0x80, 0x63, 0x01, 0xCE,
  0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0x31, 0x80, 0x63, 0x01, 0xCE, 0x03,
  0x98, 0x06, 0x30, 0x1C, 0xE0, 0x00, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0xFC, 0x0F, 0xFC, 0x3F, 0xE1, 0xE9, 0x07, 0x60, 0x1D, 0x80, 0x74, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xB8, 0x02, 0xE0,
  0x1B, 0x88, 0x4E, 0x3D, 0xF8, 0xFF, 0xC3, 0xFE, 0x01, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x1E, 0x07, 0x0F, 0xC3, 0x87, 0x70, 0xC1, 0x9C,
  0x70, 0xE7, 0x18, 0x39, 0xCE, 0x0C, 0x73, 0x03, 0x19, 0xC0, 0xC6, 0x62,
  0x33, 0xBB, 0xEC, 0xCC, 0xFF, 0xF7, 0x77, 0xFB, 0x99, 0xC0, 0xEE, 0x70,
  0x73, 0x1C, 0x18, 0xC6, 0x0E, 0x71, 0x83, 0x1C, 0xE1, 0xC7, 0x38, 0x61,
  0xDC, 0x38, 0x3E, 0x1C, 0x0F, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x1D, 0xE0,
  0x71, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x70, 0x0F, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0xFC, 0xF3, 0xB9, 0xCE, 0x7B, 0x9C, 0xFE, 0x78, 0xFC,
  0xE1, 0xF1, 0xC1, 0xE3, 0x87, 0xC7, 0xFF, 0x8F, 0xF7, 0x8F, 0xCF, 0x00,
  0x7B, 0x9C, 0xE7, 0x73, 0x9C, 0x01, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x03,
  0x81, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x1C, 0x0E,
  0x00, 0x0C, 0x03, 0x80, 0xE3, 0x38, 0xFD, 0xFF, 0xF1, 0xFC, 0xF8, 0x7F,
  0x3D, 0xC6, 0x38, 0x88, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x1E, 0x38, 0x71, 0xE3, 0x8F, 0x1C, 0x78, 0x7F, 0x7F, 0xFF, 0x7F,
  0xFF, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0xFE,
  0x1F, 0xF1, 0xC7, 0x3C, 0x73, 0x87, 0x78, 0x77, 0x0F, 0x70, 0xF7, 0x0F,
  0xF0, 0xEF, 0x0E, 0xE1, 0xEE, 0x1E, 0xE1, 0xCE, 0x1C, 0xE3, 0xCE, 0x38,
  0xE7, 0x8F, 0xF0, 0xFE, 0x07, 0xC0, 0x07, 0x87, 0xC7, 0xE7, 0xE7, 0xF7,
  0xB9, 0xBC, 0x9E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38,
  0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC0, 0x03, 0xF0, 0x1F, 0xE0, 0xFF,
  0xC1, 0x8F, 0x04, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x80, 0x07, 0xF0,
  0xFF, 0xC3, 0xFE, 0x10, 0xF0, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0xE0, 0x7E, 0x03, 0xC0, 0x3F, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x20, 0xF1, 0xFF, 0x8F, 0xF8, 0x7F, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xB8, 0x1D, 0xC0, 0xDE, 0x0E,
  0xE0, 0xE7, 0x06, 0x38, 0x73, 0xC3, 0x1E, 0x30, 0xE3, 0x87, 0x1F, 0xFE,
  0xFF, 0xF0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x07, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F,
  0x81, 0xFE, 0x0F, 0xF8, 0x23, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x20, 0xF1, 0xFF, 0x8F, 0xF8, 0x7F, 0x00, 0x01, 0xF8,
  0x3F, 0x83, 0xFC, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x77,
  0xC3, 0xFE, 0x3F, 0xF9, 0xF3, 0xCF, 0x0E, 0x78, 0x73, 0x87, 0x9C, 0x3C,
  0xE1, 0xC7, 0x0E, 0x38, 0xF1, 0xFF, 0x07, 0xF0, 0x1F, 0x00, 0x3F, 0xF9,
  0xFF, 0xCF, 0xFE, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x00, 0x07, 0xF0,
  0x7F, 0xC3, 0xDE, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x71, 0xE3, 0xCE, 0x1E,
  0xF0, 0x7E, 0x03, 0xE0, 0x3F, 0x83, 0xDE, 0x3C, 0xF3, 0xC3, 0x9C, 0x1C,
  0xE0, 0xE7, 0x07, 0x3C, 0x79, 0xFF, 0x87, 0xF8, 0x1F, 0x80, 0x07, 0xE0,
  0x7F, 0x87, 0xFE, 0x3C, 0xF3, 0xC7, 0x9E, 0x3C, 0xE1, 0xE7, 0x0F, 0x38,
  0x79, 0xC7, 0xCE, 0x3C, 0x7F, 0xE3, 0xF7, 0x0F, 0x78, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x1E, 0x01, 0xE1, 0xFF, 0x0F, 0xF0, 0x7E, 0x00, 0x0E, 0x3C,
  0x78, 0xE0, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x3C, 0x78,
  0xF0, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x70, 0x78, 0x38, 0x1C, 0x1C, 0x0E, 0x0E,
  0x00, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x00, 0x70, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0x07, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x1F,
  0x8F, 0xF3, 0xFC, 0x87, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xF0, 0x38, 0x0C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x03, 0xC0,
  0xF0, 0x38, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x78, 0x38, 0x38, 0x07,
  0x1C, 0x01, 0xC6, 0x00, 0x33, 0x8F, 0xCC, 0xC7, 0xF3, 0x73, 0x98, 0xD8,
  0xC6, 0x36, 0x73, 0x8F, 0x98, 0xE7, 0xC6, 0x31, 0xB1, 0x8C, 0x6C, 0xE7,
  0x3B, 0x39, 0xCC, 0xC7, 0xFE, 0x31, 0xEF, 0x8C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x04, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x06, 0x00, 0x00,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xDC, 0x07, 0x70, 0x1D,
  0xC0, 0xE7, 0x03, 0x9C, 0x1E, 0x70, 0x71, 0xC3, 0xC7, 0x0E, 0x1C, 0x3F,
  0xF1, 0xFF, 0xC7, 0xFF, 0x3C, 0x3C, 0xF0, 0xF7, 0x83, 0xDE, 0x0F, 0x70,
  0x3F, 0xC0, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC3, 0x87, 0x0E, 0x1C,
  0x78, 0x71, 0xE1, 0xC7, 0x0F, 0x1C, 0x78, 0x7F, 0xC3, 0xFC, 0x0F, 0xFC,
  0x38, 0x70, 0xE1, 0xE3, 0x87, 0x9E, 0x1E, 0x70, 0x71, 0xC3, 0xC7, 0x0F,
  0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0x87,
  0xC2, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x84, 0x1F, 0xF0, 0x7F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xF0, 0x71, 0xF0, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F,
  0x1C, 0x1E, 0x38, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0x81, 0xC7, 0x07, 0x8E,
  0x0F, 0x3C, 0x3C, 0x78, 0x78, 0xE1, 0xE1, 0xC7, 0x87, 0xFF, 0x0F, 0xF8,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0x80,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x04, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0xFC, 0xF0, 0xFC, 0xF1, 0xFC, 0xF0, 0x38, 0xF0, 0x38, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0x70, 0x78, 0x70, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x0F,
  0x07, 0x87, 0x83, 0x83, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0xF0, 0xF0, 0x78,
  0x78, 0x38, 0x3C, 0x1C, 0x1C, 0x1E, 0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF,
  0x83, 0x81, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x38, 0x38,
  0x1C, 0x1C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x07, 0x83, 0x80, 0x0F, 0xF0,
  0xFF, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0xFF, 0x0F, 0xF0, 0x00, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x03,
  0xF0, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x0E,
  0x3C, 0x0E, 0x38, 0x1E, 0x78, 0x1E, 0xF0, 0x1D, 0xE0, 0x1D, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x39, 0xC0, 0x39, 0xC0, 0x79,
  0xC0, 0x71, 0xE0, 0x71, 0xE0, 0x70, 0xE0, 0xF0, 0xE0, 0xF0, 0xF0, 0xE0,
  0xF0, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E,
  0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0x80, 0x7C, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0x83, 0xE0,
  0x7E, 0x0F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xD8, 0x3F, 0x07, 0x60, 0xFC,
  0x1D, 0x87, 0x70, 0x76, 0x1D, 0xC3, 0xD8, 0xEF, 0x0E, 0x73, 0xB8, 0x39,
  0xDC, 0xE0, 0xE7, 0x73, 0x83, 0x9D, 0x9E, 0x1E, 0x7E, 0x78, 0x71, 0xF9,
  0xC1, 0xC7, 0xC7, 0x07, 0x1F, 0x1C, 0x3C, 0x78, 0xF0, 0xE1, 0xE3, 0xC3,
  0x87, 0x0E, 0x00, 0x07, 0x83, 0xC3, 0xE0, 0xE0, 0xF8, 0x38, 0x3E, 0x0E,
  0x0F, 0x83, 0x87, 0xE1, 0xE1, 0xDC, 0x70, 0x77, 0x1C, 0x1D, 0xC7, 0x07,
  0x73, 0xC3, 0xDC, 0xE0, 0xE7, 0x38, 0x38, 0xEE, 0x0E, 0x3B, 0x83, 0x8F,
  0xE1, 0xE3, 0xF0, 0x70, 0xFC, 0x1C, 0x3F, 0x07, 0x07, 0xC3, 0xC1, 0xF0,
  0xE0, 0x78, 0x38, 0x1E, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0xF0,
  0xF1, 0xE1, 0xE7, 0x83, 0xCE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D,
  0xC0, 0x7F, 0x80, 0xEF, 0x01, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1C, 0xF0,
  0x79, 0xE1, 0xE3, 0xC7, 0xC3, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x71, 0xE0, 0xE1, 0xE3, 0xC3, 0xC7, 0x87,
  0x0E, 0x0E, 0x1C, 0x3C, 0x38, 0x78, 0xF3, 0xE1, 0xFF, 0x83, 0xFE, 0x07,
  0xF0, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0xF0,
  0xF1, 0xE1, 0xE7, 0x83, 0xCE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D,
  0xC0, 0x7F, 0x80, 0xEF, 0x01, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1C, 0xF0,
  0x79, 0xE1, 0xE3, 0xC7, 0xC3, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x07, 0xF0, 0x3F, 0xE0,
  0xFF, 0xC3, 0x8F, 0x0E, 0x3C, 0x78, 0x71, 0xE3, 0xC7, 0x0F, 0x1C, 0x38,
  0x71, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xE7, 0x03, 0x9C, 0x1E, 0x70,
  0x71, 0xE1, 0xC7, 0x87, 0x1E, 0x3C, 0x38, 0xF0, 0xE3, 0x83, 0xC0, 0x03,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x78, 0x40, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE1, 0x87, 0x83, 0xFF,
  0x0F, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0, 0xF0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0x1E, 0x0E, 0x3C, 0x1C, 0x70, 0x78, 0xE0, 0xF1, 0xC1, 0xE7,
  0x83, 0x8F, 0x07, 0x1C, 0x1E, 0x38, 0x3C, 0xF0, 0x71, 0xE0, 0xE3, 0xC3,
  0xC7, 0x07, 0x8E, 0x0F, 0x3C, 0x1C, 0x78, 0x38, 0xF0, 0xF1, 0xE1, 0xE3,
  0xC7, 0x87, 0xFF, 0x07, 0xFC, 0x07, 0xE0, 0x00, 0xE0, 0x7F, 0x03, 0xF8,
  0x1D, 0xC1, 0xEE, 0x0E, 0x70, 0xF3, 0x87, 0x1C, 0x38, 0xE3, 0xC7, 0x1C,
  0x39, 0xE1, 0xCE, 0x0E, 0x70, 0x77, 0x03, 0xB8, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0x70, 0x38, 0x3D, 0xC1,
  0xE0, 0xE7, 0x07, 0x87, 0x9C, 0x3E, 0x1C, 0x70, 0xF8, 0x71, 0xC3, 0xE3,
  0xC7, 0x1F, 0x0E, 0x1C, 0x7C, 0x78, 0x73, 0xB1, 0xC3, 0xCE, 0xC7, 0x0F,
  0x33, 0x3C, 0x3D, 0xCC, 0xE0, 0xF7, 0x77, 0x83, 0xF9, 0xDC, 0x0E, 0xE7,
  0x70, 0x3B, 0x9F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xC0,
  0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x87, 0x81,
  0xC3, 0x80, 0xE3, 0xC0, 0x71, 0xC0, 0x39, 0xC0, 0x1D, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1D, 0xE0, 0x1E, 0x70, 0x0E, 0x38, 0x0F,
  0x1C, 0x07, 0x0E, 0x07, 0x87, 0x07, 0x83, 0xC0, 0xE0, 0xFE, 0x0E, 0xE1,
  0xEE, 0x1C, 0xF3, 0xCF, 0x38, 0xF7, 0x87, 0x70, 0x7E, 0x07, 0xE0, 0x7C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x0E,
  0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x00, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xF0, 0x7F, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xFE, 0x0F, 0xE0, 0xFC,
  0x00, 0xE3, 0x8E, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x0E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x87, 0x1C, 0x70, 0x07, 0xF0, 0x7F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0xC0, 0x7E, 0x07, 0x70, 0x39, 0x83, 0x8E,
  0x1C, 0x71, 0xC3, 0x9C, 0x0C, 0xE0, 0x7E, 0x03, 0x80, 0xFF, 0xFF, 0xF0,
  0xF1, 0xE7, 0x8E, 0x1C, 0x0F, 0x38, 0xFD, 0xCF, 0xFE, 0x79, 0xE7, 0x8F,
  0x38, 0x79, 0xC3, 0xDE, 0x1C, 0xF0, 0xE7, 0x07, 0x38, 0x79, 0xC3, 0xCE,
  0x1C, 0x71, 0xE3, 0xFF, 0x1F, 0xB8, 0x79, 0xC0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xDE, 0x1D, 0xF0, 0xFF,
  0xC7, 0x8E, 0x78, 0x73, 0xC3, 0x9C, 0x1C, 0xE0, 0xE7, 0x0F, 0x78, 0x7B,
  0xC3, 0x9C, 0x3C, 0xE1, 0xE7, 0x9E, 0x7F, 0xF3, 0xFF, 0x1D, 0xF0, 0x07,
  0xE3, 0xF8, 0xFF, 0x1E, 0x27, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC2, 0x3F, 0xC7, 0xF8, 0x7E, 0x00, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x83,
  0xCE, 0x1F, 0xF8, 0xFF, 0xC3, 0xCF, 0x1E, 0x3C, 0x70, 0xF1, 0xC3, 0xCF,
  0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x1E, 0x38, 0x70, 0xE3, 0xC3,
  0xFF, 0x0F, 0xDC, 0x1E, 0x60, 0x07, 0xC3, 0xFC, 0xFF, 0x9C, 0x77, 0x8E,
  0xE1, 0xFC, 0x7F, 0xFE, 0xFF, 0x1F, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x3C, 0xE3, 0xFC, 0x3F, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x72, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x07,
  0xF8, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x03, 0xCE, 0x0F, 0xDC, 0x3F,
  0xF8, 0x79, 0xE1, 0xE3, 0xC3, 0x87, 0x87, 0x0F, 0x1E, 0x1C, 0x3C, 0x38,
  0x70, 0x70, 0xE1, 0xE1, 0xC3, 0xC3, 0x87, 0x07, 0x1E, 0x0F, 0xFC, 0x1F,
  0xF8, 0x1E, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x08, 0x1C, 0x1E, 0xF8,
  0x3F, 0xE0, 0x7F, 0x80, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xDE, 0x1D, 0xF8, 0xFF, 0xC7, 0x9E, 0x78, 0xF3,
  0xC7, 0x9C, 0x38, 0xE1, 0xC7, 0x0E, 0x78, 0x73, 0xC7, 0x9C, 0x38, 0xE1,
  0xC7, 0x0E, 0x78, 0xF3, 0xC7, 0x9C, 0x38, 0x07, 0x0F, 0x0F, 0x06, 0x00,
  0x00, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x78,
  0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x06,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x0F, 0xC0,
  0xFC, 0x0F, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x8F, 0x1C, 0x78, 0x71, 0xC1, 0xCE, 0x07, 0x78,
  0x3B, 0xC0, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xEE, 0x07, 0x3C,
  0x1C, 0xF0, 0x71, 0xC3, 0xC7, 0x0E, 0x1C, 0x38, 0x78, 0x07, 0x07, 0x0F,
  0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38,
  0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0x1C, 0xF3, 0xC3,
  0xFE, 0xFC, 0x7F, 0xFF, 0x8F, 0x3E, 0x71, 0xC7, 0x8E, 0x78, 0xE1, 0xCE,
  0x1C, 0x39, 0xC3, 0x8F, 0x38, 0x71, 0xCF, 0x1E, 0x39, 0xC3, 0x87, 0x38,
  0x70, 0xE7, 0x0E, 0x3C, 0xE3, 0xC7, 0x3C, 0x70, 0xE7, 0x0E, 0x1C, 0xE1,
  0xC7, 0x80, 0x1C, 0xF0, 0xEF, 0x87, 0xFE, 0x3C, 0xF1, 0xC7, 0x9E, 0x3C,
  0xE1, 0xC7, 0x0E, 0x38, 0x73, 0xC3, 0x9E, 0x3C, 0xE1, 0xC7, 0x0E, 0x38,
  0x73, 0xC7, 0x9C, 0x3C, 0xE1, 0xC0, 0x07, 0xC1, 0xFE, 0x3F, 0xE3, 0x8E,
  0x78, 0xF7, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1E,
  0xE1, 0xCE, 0x3C, 0xFF, 0x87, 0xF0, 0x3E, 0x00, 0x07, 0x3C, 0x0E, 0xFC,
  0x1F, 0xF8, 0x3C, 0x70, 0x70, 0xE1, 0xE1, 0xC3, 0x83, 0x87, 0x07, 0x0E,
  0x1E, 0x3C, 0x3C, 0x78, 0x70, 0xF1, 0xE1, 0xC3, 0xC3, 0xCF, 0x0F, 0xFE,
  0x1D, 0xF8, 0x3B, 0xE0, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0x0F, 0x38, 0xFD, 0xCF, 0xFC, 0x71, 0xE7,
  0x8F, 0x38, 0x79, 0xC3, 0xDE, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC3,
  0xCE, 0x1C, 0x71, 0xE3, 0xFF, 0x1F, 0xF8, 0x7B, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x1C, 0xE3, 0xBC, 0x7F,
  0x0F, 0xE3, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x0F, 0xC3, 0xFC, 0xFF,
  0x1C, 0x23, 0x80, 0x70, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03,
  0xC0, 0x79, 0x0F, 0x3F, 0xC7, 0xF8, 0xFE, 0x00, 0x0E, 0x0C, 0x1C, 0x3F,
  0x7F, 0x7F, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0,
  0xE0, 0xFC, 0xFC, 0x7C, 0x3C, 0x79, 0xC3, 0x8E, 0x1C, 0x70, 0xE7, 0x8F,
  0x3C, 0x79, 0xC3, 0x8E, 0x1C, 0x70, 0xE7, 0x8F, 0x38, 0x71, 0xC3, 0x8E,
  0x3C, 0x71, 0xE3, 0xFF, 0x1F, 0xB0, 0x7B, 0x80, 0xE0, 0xFC, 0x3F, 0x87,
  0x70, 0xEE, 0x39, 0xC7, 0x39, 0xC7, 0x38, 0xEF, 0x1D, 0xC3, 0xB8, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x00, 0xE1, 0xE3, 0xF8, 0xF8,
  0xEE, 0x3E, 0x3B, 0x8F, 0x9C, 0xE7, 0xC7, 0x39, 0xF1, 0xCE, 0x6C, 0xE3,
  0xBB, 0x38, 0xEC, 0xDC, 0x3F, 0x37, 0x0F, 0xCD, 0xC3, 0xE7, 0xE0, 0xF9,
  0xF8, 0x3E, 0x7C, 0x0F, 0x1F, 0x03, 0xC7, 0xC0, 0xE1, 0xE0, 0x00, 0x1E,
  0x3C, 0x38, 0xE0, 0xE7, 0x83, 0x9C, 0x0E, 0xE0, 0x3F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xF0, 0x3D, 0xC0, 0xE7, 0x07,
  0x1C, 0x3C, 0x70, 0xE1, 0xE0, 0x07, 0x07, 0x07, 0x0F, 0x07, 0x0E, 0x07,
  0x0E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07,
  0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0xF1, 0xFF, 0x1F, 0xE0, 0x1E, 0x01,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38,
  0x07, 0x80, 0x7F, 0x8F, 0xF8, 0xFF, 0x80, 0x00, 0xF0, 0x1F, 0x03, 0xF0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x01,
  0xE0, 0x7C, 0x07, 0x00, 0xFC, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0x80, 0x7C, 0x07, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xF0, 0x0E, 0x03, 0xE0, 0x78,
  0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0xFC, 0x0F, 0x80, 0xF0, 0x00, 0x7C, 0x0F, 0xFD, 0xFF, 0xFF, 0x07, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 9, 22, 8, 0, -22 },
  { 26, 10, 8, 12, 3, -22 },
  { 36, 15, 22, 14, 0, -22 },
  { 78, 14, 26, 13, 0, -24 },
  { 124, 18, 22, 21, 2, -22 },
  { 174, 15, 22, 15, 0, -22 },
  { 216, 5, 8, 7, 3, -22 },
  { 221, 10, 27, 8, 0, -22 },
  { 255, 10, 27, 8, -2, -22 },
  { 289, 10, 12, 12, 3, -24 },
  { 304, 12, 14, 14, 1, -18 },
  { 325, 7, 8, 7, -2, -4 },
  { 332, 8, 3, 9, 0, -10 },
  { 335, 4, 4, 7, 0, -4 },
  { 337, 16, 22, 11, -2, -22 },
  { 381, 12, 22, 13, 1, -22 },
  { 414, 9, 22, 13, 3, -22 },
  { 439, 14, 22, 13, -1, -22 },
  { 478, 13, 22, 13, 0, -22 },
  { 514, 13, 22, 13, 0, -22 },
  { 550, 13, 22, 13, 0, -22 },
  { 586, 13, 22, 13, 1, -22 },
  { 622, 13, 22, 13, 1, -22 },
  { 658, 13, 22, 13, 0, -22 },
  { 694, 13, 22, 13, 0, -22 },
  { 730, 7, 17, 7, 0, -17 },
  { 745, 9, 21, 7, -2, -17 },
  { 769, 12, 14, 14, 1, -18 },
  { 790, 12, 9, 14, 1, -15 },
  { 804, 13, 14, 14, 1, -18 },
  { 827, 10, 22, 10, 1, -22 },
  { 855, 18, 25, 19, 1, -22 },
  { 912, 14, 22, 14, -2, -22 },
  { 951, 14, 22, 14, 0, -22 },
  { 990, 14, 22, 13, 1, -22 },
  { 1029, 15, 22, 15, 0, -22 },
  { 1071, 13, 22, 12, 0, -22 },
  { 1107, 13, 22, 11, 0, -22 },
  { 1143, 16, 22, 16, 1, -22 },
  { 1187, 17, 22, 16, 0, -22 },
  { 1234, 12, 22, 9, -1, -22 },
  { 1267, 13, 28, 7, -5, -22 },
  { 1313, 16, 22, 14, 0, -22 },
  { 1357, 9, 22, 11, 0, -22 },
  { 1382, 22, 22, 21, 0, -22 },
  { 1443, 18, 22, 17, 0, -22 },
  { 1493, 15, 22, 16, 1, -22 },
  { 1535, 15, 22, 14, 0, -22 },
  { 1577, 15, 27, 16, 1, -22 },
  { 1628, 14, 22, 14, 0, -22 },
  { 1667, 15, 22, 12, -1, -22 },
  { 1709, 12, 22, 12, 2, -22 },
  { 1742, 15, 22, 15, 1, -22 },
  { 1784, 13, 22, 14, 3, -22 },
  { 1820, 22, 22, 21, 2, -22 },
  { 1881, 17, 22, 13, -2, -22 },
  { 1928, 12, 22, 12, 3, -22 },
  { 1961, 14, 22, 11, -1, -22 },
  { 2000, 12, 27, 9, -1, -22 },
  { 2041, 6, 22, 11, 3, -22 },
  { 2058, 12, 27, 9, -2, -22 },
  { 2099, 13, 13, 13, 0, -22 },
  { 2121, 10, 2, 10, -3, 3 },
  { 2124, 6, 5, 9, 4, -24 },
  { 2128, 13, 17, 14, 1, -17 },
  { 2156, 13, 24, 14, 0, -24 },
  { 2195, 11, 17, 11, 1, -17 },
  { 2219, 14, 24, 14, 1, -24 },
  { 2261, 11, 17, 13, 1, -17 },
  { 2285, 16, 31, 8, -4, -24 },
  { 2347, 15, 24, 14, -1, -17 },
  { 2392, 13, 24, 14, 0, -24 },
  { 2431, 8, 23, 7, 0, -23 },
  { 2454, 12, 30, 7, -4, -23 },
  { 2499, 14, 24, 12, 0, -24 },
  { 2541, 8, 24, 7, 0, -24 },
  { 2565, 19, 17, 20, 0, -17 },
  { 2606, 13, 17, 14, 0, -17 },
  { 2634, 12, 17, 13, 1, -17 },
  { 2660, 15, 24, 14, -2, -17 },
  { 2705, 13, 24, 14, 1, -17 },
  { 2744, 11, 17, 9, 0, -17 },
  { 2768, 11, 17, 11, 0, -17 },
  { 2792, 8, 20, 8, 1, -20 },
  { 2812, 13, 17, 14, 1, -17 },
  { 2840, 11, 17, 12, 2, -17 },
  { 2864, 18, 17, 18, 2, -17 },
  { 2903, 14, 17, 12, -1, -17 },
  { 2933, 16, 24, 12, -3, -17 },
  { 2981, 12, 17, 10, -1, -17 },
  { 3007, 12, 27, 10, 0, -22 },
  { 3048, 3, 31, 11, 4, -24 },
  { 3060, 12, 27, 10, -2, -22 },
  { 3101, 13, 4, 14, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC31PT7B_H_
