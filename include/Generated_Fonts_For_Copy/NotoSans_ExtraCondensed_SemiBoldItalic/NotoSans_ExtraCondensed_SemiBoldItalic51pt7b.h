#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC51PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xC0, 0x1F, 0x00, 0x30, 0x00, 0x3F, 0x3F, 0x3E, 0x3F, 0x7E, 0x3F,
  0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x78, 0x7C,
  0xF8, 0x7C, 0xF8, 0x78, 0xF8, 0x78, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x78,
  0x00, 0x3C, 0x3C, 0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1,
  0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x78,
  0x7C, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x07, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xDB, 0xC0, 0x7C, 0x63, 0x01, 0xF3, 0x00, 0x07, 0xCC,
  0x00, 0x3F, 0x30, 0x00, 0xFC, 0xC0, 0x01, 0xF3, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0x9F,
  0x80, 0x06, 0x7E, 0x00, 0x19, 0xF8, 0x00, 0x67, 0xE1, 0x01, 0x9F, 0x06,
  0x0C, 0x7C, 0x1E, 0x37, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x0F, 0x00, 0xFF, 0x80, 0x78, 0x07, 0xFE, 0x01, 0xE0,
  0x1E, 0x78, 0x0F, 0x00, 0xF1, 0xE0, 0x7C, 0x03, 0xC7, 0x81, 0xE0, 0x1E,
  0x1E, 0x0F, 0x80, 0x78, 0x78, 0x3C, 0x01, 0xE1, 0xE1, 0xF0, 0x0F, 0x07,
  0x87, 0x80, 0x3C, 0x1E, 0x3E, 0x00, 0xF0, 0xF8, 0xF0, 0x03, 0xC3, 0xC7,
  0x80, 0x0F, 0x0F, 0x1E, 0x00, 0x3C, 0x3C, 0xF0, 0xFC, 0xF1, 0xE3, 0xC7,
  0xFB, 0xC7, 0x9E, 0x3F, 0xEF, 0x3C, 0x79, 0xFF, 0xBF, 0xF3, 0xCF, 0x9F,
  0xFF, 0x9F, 0x3C, 0x7D, 0xFC, 0x78, 0xF1, 0xF3, 0xC3, 0xE7, 0x87, 0xC0,
  0x0F, 0x1E, 0x1E, 0x00, 0x7C, 0x78, 0x78, 0x01, 0xE3, 0xE1, 0xE0, 0x0F,
  0x8F, 0x07, 0x80, 0x3C, 0x3C, 0x3E, 0x01, 0xE0, 0xF0, 0xF0, 0x07, 0x83,
  0xC3, 0xC0, 0x3C, 0x0F, 0x0F, 0x00, 0xF0, 0x3C, 0x78, 0x07, 0x80, 0xF1,
  0xE0, 0x1E, 0x03, 0xFF, 0x00, 0xF0, 0x0F, 0xFC, 0x07, 0xC0, 0x1F, 0xE0,
  0x1E, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xF9, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF1, 0xF0, 0x03, 0xF1,
  0xF0, 0x03, 0xF3, 0xE0, 0x01, 0xF3, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFE, 0x1F, 0x0F, 0xFE, 0x3F, 0x1F, 0xBE, 0x3E, 0x3F, 0x3F,
  0x3E, 0x3E, 0x3F, 0x7C, 0x7C, 0x1F, 0x7C, 0x7C, 0x1F, 0xFC, 0xFC, 0x1F,
  0xF8, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xE0, 0xF8, 0x0F,
  0xE0, 0xFC, 0x1F, 0xE0, 0xFE, 0x7F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xF1, 0xF8, 0x1F, 0xE1, 0xFC, 0x03, 0x00, 0x00, 0x3F, 0x3E,
  0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF8, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x20, 0xF0, 0x0E, 0x3C, 0x07, 0xEF, 0x1D, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFE,
  0x03, 0xF7, 0xC1, 0xF8, 0xF8, 0x1E, 0x3F, 0x03, 0x0F, 0x80, 0x81, 0x80,
  0x00, 0x40, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC1,
  0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0xFD, 0xFF, 0xFF, 0xFF, 0x9F, 0x18, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0x3F, 0x07, 0xE1,
  0xF0, 0x7C, 0x1F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x1F, 0x81, 0xF1, 0xF8,
  0x1F, 0x1F, 0x01, 0xF3, 0xF0, 0x1F, 0x3F, 0x03, 0xF3, 0xE0, 0x3F, 0x3E,
  0x03, 0xF7, 0xE0, 0x3E, 0x7E, 0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xE7,
  0xC0, 0x7E, 0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC,
  0xF8, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x3F,
  0x0F, 0xC7, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x8F, 0xFF, 0x3F, 0xFC, 0xFE, 0xF8, 0xF9,
  0xF1, 0xC7, 0xE1, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0x1F, 0xC0, 0x38, 0x1F, 0x80, 0x60,
  0x3F, 0x00, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3C, 0x3F, 0xC0, 0x20, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x20, 0x03, 0xF0, 0x60, 0x0F, 0xE0, 0xFC, 0xFF, 0x81,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x77, 0xE0, 0x01,
  0xEF, 0x80, 0x07, 0x9F, 0x00, 0x0F, 0x3E, 0x00, 0x3C, 0xFC, 0x00, 0xF1,
  0xF8, 0x01, 0xE3, 0xE0, 0x07, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0x3F,
  0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0x81, 0xF0, 0x1E, 0x07, 0xE0,
  0x7C, 0x0F, 0xC0, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x41, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC2, 0x00, 0x7E,
  0x0C, 0x07, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xF0,
  0x20, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF3,
  0xF0, 0x0F, 0xDF, 0xE0, 0x3E, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFD, 0xFC,
  0x1F, 0xC1, 0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x3F,
  0x01, 0xF8, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x0F, 0xC0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x04, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xFC, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3F, 0x07,
  0xC0, 0xFC, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1,
  0xF8, 0x1F, 0x8F, 0xC0, 0x3F, 0x7E, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F,
  0x7E, 0x03, 0xF0, 0xFC, 0x1F, 0x81, 0xF0, 0x7E, 0x07, 0xE3, 0xF0, 0x1F,
  0x8F, 0xC0, 0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x0F,
  0xC0, 0x7C, 0x3F, 0x03, 0xF0, 0xFE, 0x1F, 0x81, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83,
  0xF9, 0xFC, 0x1F, 0x87, 0xE1, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07,
  0xC7, 0xE0, 0x3E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7C,
  0x07, 0xE3, 0xE0, 0x7F, 0x1F, 0x03, 0xF8, 0xFC, 0x3F, 0x87, 0xE3, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFD, 0xF0, 0x1F, 0xCF, 0x80, 0x7C,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0xF3, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x04,
  0x00, 0x00, 0x01, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF0, 0x7C, 0x02, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xF8, 0x70, 0xFC, 0x20, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x78,
  0x1E, 0x07, 0xF0, 0x70, 0x78, 0x1F, 0xF8, 0xE0, 0xF0, 0x7F, 0xE1, 0xE3,
  0xC1, 0xF3, 0xC3, 0x87, 0x87, 0x87, 0x87, 0x0E, 0x0F, 0x0F, 0x0E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78, 0xE1, 0xE0, 0xF0, 0xF3, 0xC3,
  0xC1, 0xE1, 0xE7, 0x87, 0x87, 0x83, 0x8F, 0x1E, 0x0F, 0x0F, 0x1E, 0x3C,
  0x1E, 0x1E, 0x38, 0x78, 0x7C, 0x38, 0xF0, 0xF0, 0xF0, 0xF1, 0xE1, 0xE1,
  0xE1, 0xC3, 0xC3, 0xC7, 0xC7, 0x87, 0x87, 0xDF, 0xDE, 0x0F, 0x0F, 0xF7,
  0xFC, 0x1E, 0x0F, 0xE7, 0xF0, 0x3C, 0x0F, 0x0F, 0x80, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x02, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x3E, 0x7C,
  0x00, 0xF9, 0xF0, 0x07, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0x7C, 0x03,
  0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0xC1,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC3, 0xF0, 0x1F, 0x1F, 0x80, 0x7C, 0x7E, 0x01, 0xF3, 0xF0,
  0x07, 0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xE0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0xFE, 0x03, 0xF0, 0x7F,
  0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0xFC,
  0x0F, 0xC3, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x1F, 0x87, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xF8,
  0x1F, 0x01, 0xF8, 0x1F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8,
  0x3E, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0,
  0x7E, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x87, 0x01,
  0xFC, 0x04, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x01, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x1F, 0x83, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F,
  0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3E, 0x01, 0xFC, 0x3F,
  0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x7F, 0x07,
  0xE0, 0x7F, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xF0, 0xF8, 0x1F, 0xE0, 0x08, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x03, 0xFF, 0x3F, 0x81, 0xFF, 0x9F, 0x81, 0xFF, 0x8F, 0xC0, 0xFF,
  0xC7, 0xE0, 0x7F, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x1F, 0x07, 0xE0, 0x1F, 0x83, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80,
  0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07,
  0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01,
  0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xF8,
  0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x0F, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x9F,
  0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xBF, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80,
  0x07, 0xE1, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0x3F, 0x00,
  0x7C, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07,
  0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xDE, 0x01, 0xFF, 0xC0,
  0x7D, 0xE0, 0x1F, 0xF8, 0x07, 0xDE, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x3E,
  0xF8, 0x0F, 0xDF, 0x07, 0xDF, 0x80, 0xF9, 0xF0, 0x7D, 0xF8, 0x0F, 0x9F,
  0x07, 0x9F, 0x00, 0xF9, 0xF0, 0xF9, 0xF0, 0x0F, 0x9F, 0x0F, 0x1F, 0x01,
  0xF9, 0xF1, 0xF3, 0xF0, 0x1F, 0x1F, 0x1F, 0x3F, 0x01, 0xF1, 0xF3, 0xE3,
  0xE0, 0x1F, 0x1F, 0x3E, 0x3E, 0x01, 0xF1, 0xF7, 0xC7, 0xE0, 0x3F, 0x1F,
  0x7C, 0x7E, 0x03, 0xE1, 0xF7, 0x87, 0xC0, 0x3E, 0x1F, 0xF8, 0x7C, 0x03,
  0xE1, 0xFF, 0x07, 0xC0, 0x3E, 0x1F, 0xF0, 0xFC, 0x07, 0xE1, 0xFF, 0x0F,
  0xC0, 0x7C, 0x1F, 0xE0, 0xF8, 0x07, 0xC1, 0xFE, 0x0F, 0x80, 0x7C, 0x1F,
  0xC0, 0xF8, 0x0F, 0xC1, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x81, 0xF8, 0x0F,
  0x80, 0xF8, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0,
  0x7F, 0x00, 0x7E, 0x03, 0xFC, 0x03, 0xE0, 0x1F, 0xE0, 0x1F, 0x01, 0xFF,
  0x00, 0xF8, 0x0F, 0xF8, 0x0F, 0xC0, 0x7F, 0xC0, 0x7C, 0x03, 0xFE, 0x03,
  0xE0, 0x1E, 0xF8, 0x1F, 0x01, 0xF7, 0xC0, 0xF8, 0x0F, 0xBE, 0x0F, 0xC0,
  0x7D, 0xF0, 0x7C, 0x03, 0xEF, 0x83, 0xE0, 0x3F, 0x3C, 0x1F, 0x01, 0xF1,
  0xF1, 0xF8, 0x0F, 0x8F, 0x8F, 0xC0, 0x7C, 0x7C, 0x7C, 0x03, 0xE3, 0xE3,
  0xE0, 0x3F, 0x1F, 0x1F, 0x01, 0xF0, 0x79, 0xF8, 0x0F, 0x83, 0xEF, 0xC0,
  0x7C, 0x1F, 0x7C, 0x03, 0xE0, 0xFB, 0xE0, 0x3F, 0x07, 0xDF, 0x01, 0xF0,
  0x3E, 0xF8, 0x0F, 0x80, 0xFF, 0x80, 0x7C, 0x07, 0xFC, 0x03, 0xE0, 0x3F,
  0xE0, 0x3F, 0x01, 0xFF, 0x01, 0xF0, 0x0F, 0xF8, 0x0F, 0x80, 0x7F, 0x80,
  0x7C, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3E, 0x00, 0x7F, 0x01, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0xFF, 0x07, 0xF0, 0x7F,
  0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0,
  0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3F,
  0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x03, 0xF8, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8,
  0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0x3F, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x03, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0,
  0xFC, 0x0F, 0xC7, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xE0, 0x7C,
  0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFE, 0x06, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x10, 0x03, 0xF0, 0x38, 0x1F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0xF8, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x00, 0x7C, 0x1F,
  0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x81,
  0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E,
  0x03, 0xF0, 0x7F, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7C,
  0x00, 0x7E, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x0F, 0xC7, 0xC0,
  0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x7C, 0x07,
  0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8,
  0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x00,
  0xF8, 0x7C, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0xC0, 0x0F,
  0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFB,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xFF,
  0x80, 0x3E, 0x00, 0xFB, 0xF0, 0x0F, 0xC0, 0x3F, 0x7E, 0x01, 0xF8, 0x07,
  0xEF, 0xC0, 0x7F, 0x00, 0xF9, 0xF8, 0x0F, 0xE0, 0x3F, 0x3F, 0x01, 0xFC,
  0x07, 0xC7, 0xE0, 0x7F, 0x81, 0xF8, 0xFC, 0x0F, 0xF0, 0x3F, 0x1F, 0x83,
  0xFE, 0x07, 0xC3, 0xF0, 0x7F, 0xC1, 0xF8, 0x7C, 0x0F, 0xF8, 0x3E, 0x0F,
  0x83, 0xFF, 0x0F, 0xC1, 0xF0, 0x7F, 0xE1, 0xF8, 0x3E, 0x0F, 0x7C, 0x3E,
  0x07, 0xC3, 0xEF, 0x8F, 0xC0, 0xF8, 0x79, 0xF1, 0xF0, 0x1F, 0x1F, 0x3E,
  0x3E, 0x03, 0xE3, 0xE7, 0xCF, 0xC0, 0x7C, 0x78, 0xF1, 0xF0, 0x0F, 0x9F,
  0x1E, 0x7E, 0x01, 0xF3, 0xC3, 0xCF, 0x80, 0x3E, 0xF8, 0x79, 0xF0, 0x07,
  0xDF, 0x0F, 0x7E, 0x00, 0xFB, 0xC1, 0xEF, 0x80, 0x1F, 0xF8, 0x3D, 0xF0,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F,
  0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03,
  0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00,
  0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x3F, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF0, 0x3F,
  0x00, 0x3F, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xFB, 0xE0, 0x1F, 0x9F, 0x01, 0xF8, 0xFC,
  0x0F, 0xC7, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0,
  0x3E, 0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x80, 0x7C, 0xF8, 0x03, 0xEF,
  0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xF3, 0xC0, 0x0F,
  0x9F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x1E, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x00, 0xF1, 0xF0, 0x07, 0xDF, 0x00,
  0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0x80, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x3F, 0x1F, 0x87, 0xE1, 0xF0, 0xF8, 0x3E,
  0x0F, 0x00, 0xFC, 0x7C, 0x07, 0xF9, 0xF0, 0x3F, 0xEF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0x0F, 0xE1, 0xF8, 0x3F, 0x87, 0xE0, 0xFE, 0x3F,
  0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03,
  0xE1, 0xF8, 0x0F, 0x87, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3,
  0xF0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0,
  0x7F, 0x0F, 0xC3, 0xF8, 0x3F, 0x9F, 0xE0, 0x7F, 0xEF, 0x81, 0xFF, 0xBE,
  0x03, 0xFC, 0xF0, 0x0F, 0xE3, 0xC0, 0x04, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF9, 0xF8, 0x07, 0xEF, 0xF0, 0x1F, 0x7F, 0xE0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xF0, 0xFC, 0x3F, 0x83, 0xF0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF0, 0x0F,
  0x87, 0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xE3, 0xF0, 0x1F, 0x8F,
  0xC0, 0x7C, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x1F, 0x81,
  0xF8, 0x7E, 0x07, 0xE1, 0xFC, 0x3F, 0x07, 0xF9, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFB, 0xFF, 0x03, 0xEF, 0xF8, 0x0F, 0x1F, 0xC0, 0x00, 0x08, 0x00, 0x00,
  0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xF0,
  0x41, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x81, 0xFC, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80,
  0x7F, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xC3, 0xF8, 0x1F, 0x83, 0xF8, 0x1F,
  0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0x7E, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0xFC,
  0x03, 0xE0, 0xFC, 0x07, 0xC0, 0xFC, 0x07, 0xC0, 0xFC, 0x07, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFE,
  0x7F, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xEF, 0x80, 0x3F, 0xCF, 0x00, 0x1F,
  0x8F, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0xF0, 0xFE, 0x7E, 0x1F, 0x87, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F,
  0x3F, 0x03, 0xE7, 0xC0, 0xFC, 0xF8, 0x3F, 0x3F, 0x0F, 0xC7, 0xFF, 0xF8,
  0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x83,
  0xF0, 0x30, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFC, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x7F, 0x9F,
  0x00, 0xFF, 0xDF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0xFE,
  0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0xF8,
  0x1F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xF0,
  0x3F, 0x0F, 0xE0, 0x3F, 0x9F, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xF7, 0xC0, 0x0F, 0xE7, 0xC0, 0x01, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0xC0, 0x3F, 0x00, 0xFD, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xCF, 0xC0, 0x7E, 0xFF, 0x03, 0xEF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x07, 0xF1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xF8,
  0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x03, 0xF0,
  0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03,
  0xF0, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0, 0x3E, 0x1F,
  0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0, 0x7E,
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x03,
  0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x3F, 0x01, 0xF0, 0x7E, 0x03, 0xE1, 0xF8,
  0x07, 0xC7, 0xE0, 0x1F, 0x8F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0xFC, 0x00,
  0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFD, 0xF0, 0x03, 0xF3,
  0xE0, 0x07, 0xC7, 0xE0, 0x0F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7C, 0x1F,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x00, 0x03, 0xC7, 0xE0, 0xFC, 0x07, 0xCF, 0xF1, 0xFE,
  0x07, 0xDF, 0xF3, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x07, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0x3E,
  0x1F, 0x81, 0xF0, 0x3E, 0x1F, 0x03, 0xF0, 0x7E, 0x1F, 0x03, 0xE0, 0x7E,
  0x1F, 0x03, 0xE0, 0x7C, 0x3F, 0x03, 0xE0, 0x7C, 0x3F, 0x07, 0xE0, 0x7C,
  0x3E, 0x07, 0xE0, 0xFC, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8,
  0x7E, 0x07, 0xC0, 0xF8, 0x7C, 0x0F, 0xC0, 0xF8, 0x7C, 0x0F, 0xC1, 0xF8,
  0x7C, 0x0F, 0x81, 0xF0, 0xFC, 0x0F, 0x81, 0xF0, 0xFC, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x83, 0xF0, 0xF8, 0x1F, 0x83, 0xF0, 0x03, 0xC7, 0xE0, 0x3E,
  0x7F, 0x81, 0xF7, 0xFE, 0x0F, 0x7F, 0xF0, 0x7F, 0xFF, 0x83, 0xF8, 0xFC,
  0x3F, 0x87, 0xE1, 0xF8, 0x1F, 0x0F, 0xC1, 0xF8, 0x7C, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC7,
  0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F,
  0xC7, 0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x7C,
  0x0F, 0xC7, 0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF0, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC,
  0x3E, 0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xE0, 0x3F, 0x7E,
  0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xEF,
  0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xCF, 0xC0, 0xFC,
  0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFC, 0x3F, 0x87, 0xF7, 0xF0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x78, 0x7C, 0x00, 0x7C, 0xFF, 0x00, 0x3E, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x87, 0xE0, 0x1F,
  0xE7, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xCF, 0xF0, 0x03,
  0xE3, 0xF0, 0x01, 0xF0, 0x40, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x7C, 0x07, 0xF9, 0xF0, 0x3F, 0xF7,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x0F, 0xE1, 0xF8, 0x3F, 0x87,
  0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3F, 0x1F, 0x80,
  0xFC, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3F, 0x01, 0xF8,
  0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3F, 0x03, 0xF0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x9F, 0xE0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0xFD, 0xF0, 0x0F, 0xE7, 0xC0, 0x04, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xC7, 0xC1, 0xF3, 0xF0, 0x7D,
  0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xEF, 0x87, 0xE0, 0x41, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x88, 0x0F,
  0xC3, 0xCF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80,
  0x06, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x7F, 0xC7, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC3, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF1, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x00, 0x40, 0x00, 0x07, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0,
  0x3E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x7E, 0x07, 0xC3,
  0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7E, 0x07,
  0xC3, 0xE0, 0x7E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7C,
  0x07, 0xC3, 0xE0, 0x7E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x0F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF0, 0xFE, 0x1F, 0xCF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xF7, 0xC0, 0x7F, 0x3E, 0x00, 0x40, 0x00, 0x00, 0xF8, 0x07,
  0xFF, 0x00, 0xFB, 0xE0, 0x3F, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3F,
  0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x80,
  0xF9, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFF, 0xC0, 0xFE, 0x07,
  0xFE, 0x07, 0xF0, 0x7F, 0xF0, 0x3F, 0x83, 0xEF, 0x83, 0xFC, 0x1F, 0x7C,
  0x1F, 0xE1, 0xF3, 0xE1, 0xFF, 0x0F, 0x9F, 0x0F, 0xF8, 0xFC, 0xF8, 0x7F,
  0x87, 0xC7, 0xC7, 0xFC, 0x3E, 0x3E, 0x3D, 0xE3, 0xE1, 0xF1, 0xEF, 0x1F,
  0x0F, 0x9E, 0x78, 0xF8, 0x7C, 0xF3, 0xCF, 0x83, 0xEF, 0x9E, 0x7C, 0x1F,
  0x78, 0xF7, 0xC0, 0xFB, 0xC7, 0xBE, 0x07, 0xFE, 0x3D, 0xF0, 0x3F, 0xE1,
  0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC,
  0x03, 0xFC, 0x3F, 0xE0, 0x1F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x03,
  0xE0, 0x3F, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x01,
  0xF1, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xF3, 0xF0, 0x01, 0xF3, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xDF, 0x00, 0x0F,
  0xDF, 0x00, 0x0F, 0x9F, 0x80, 0x1F, 0x9F, 0x80, 0x3F, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x7E, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x7E,
  0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x03, 0xE1,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE3, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x17, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x3F, 0xE8, 0x00, 0x78,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 14, 37, 12, 0, -36 },
  { 66, 16, 13, 19, 5, -36 },
  { 92, 25, 36, 23, 0, -36 },
  { 205, 22, 42, 21, 0, -39 },
  { 321, 30, 37, 34, 3, -37 },
  { 460, 24, 38, 25, 0, -37 },
  { 574, 8, 13, 11, 5, -36 },
  { 587, 16, 45, 14, 1, -37 },
  { 677, 17, 45, 14, -4, -37 },
  { 773, 18, 20, 20, 4, -39 },
  { 818, 20, 24, 23, 2, -30 },
  { 878, 11, 13, 11, -3, -6 },
  { 896, 12, 5, 14, 1, -16 },
  { 904, 7, 8, 11, 0, -7 },
  { 911, 25, 37, 18, -3, -37 },
  { 1027, 20, 38, 21, 1, -37 },
  { 1122, 15, 36, 21, 5, -36 },
  { 1190, 23, 37, 21, -2, -37 },
  { 1297, 23, 38, 21, -1, -37 },
  { 1407, 23, 37, 21, -1, -37 },
  { 1514, 22, 37, 21, 0, -36 },
  { 1616, 22, 38, 21, 1, -37 },
  { 1721, 23, 36, 21, 1, -36 },
  { 1825, 22, 38, 21, 0, -37 },
  { 1930, 21, 38, 21, 0, -37 },
  { 2030, 11, 29, 12, 0, -28 },
  { 2070, 15, 35, 12, -3, -28 },
  { 2136, 20, 24, 23, 2, -30 },
  { 2196, 20, 15, 23, 2, -25 },
  { 2234, 20, 24, 23, 2, -30 },
  { 2294, 17, 37, 16, 1, -37 },
  { 2373, 31, 41, 32, 1, -37 },
  { 2532, 22, 37, 23, -3, -37 },
  { 2634, 24, 36, 23, 0, -36 },
  { 2742, 23, 38, 21, 2, -37 },
  { 2852, 25, 36, 25, 0, -36 },
  { 2965, 22, 36, 20, 0, -36 },
  { 3064, 22, 36, 19, 0, -36 },
  { 3163, 25, 38, 26, 2, -37 },
  { 3282, 28, 36, 26, 0, -36 },
  { 3408, 21, 36, 15, -2, -36 },
  { 3503, 21, 46, 12, -8, -36 },
  { 3624, 27, 36, 22, 0, -36 },
  { 3746, 15, 36, 19, 0, -36 },
  { 3814, 36, 36, 35, 0, -36 },
  { 3976, 29, 36, 28, 0, -36 },
  { 4107, 24, 38, 27, 2, -37 },
  { 4221, 24, 36, 22, 0, -36 },
  { 4329, 24, 46, 27, 2, -37 },
  { 4467, 23, 36, 23, 0, -36 },
  { 4571, 23, 38, 20, -1, -37 },
  { 4681, 19, 36, 19, 4, -36 },
  { 4767, 25, 37, 25, 2, -36 },
  { 4883, 23, 36, 22, 4, -36 },
  { 4987, 35, 36, 35, 4, -36 },
  { 5145, 28, 36, 21, -3, -36 },
  { 5271, 21, 36, 20, 4, -36 },
  { 5366, 24, 36, 19, -2, -36 },
  { 5474, 20, 45, 14, -2, -37 },
  { 5587, 10, 37, 18, 5, -37 },
  { 5634, 20, 45, 14, -4, -37 },
  { 5747, 21, 21, 21, 0, -36 },
  { 5803, 17, 4, 16, -5, 4 },
  { 5812, 9, 8, 14, 7, -39 },
  { 5821, 22, 29, 23, 1, -28 },
  { 5901, 22, 40, 23, 0, -39 },
  { 6011, 18, 29, 18, 1, -28 },
  { 6077, 24, 40, 23, 1, -39 },
  { 6197, 19, 29, 21, 1, -28 },
  { 6266, 25, 51, 13, -6, -39 },
  { 6426, 24, 40, 23, -1, -28 },
  { 6546, 21, 39, 22, 0, -39 },
  { 6649, 13, 38, 11, 0, -38 },
  { 6711, 19, 50, 11, -6, -38 },
  { 6830, 23, 39, 20, 0, -39 },
  { 6943, 14, 39, 11, 0, -39 },
  { 7012, 32, 28, 33, 0, -28 },
  { 7124, 21, 28, 22, 0, -28 },
  { 7198, 20, 29, 22, 1, -28 },
  { 7271, 25, 40, 23, -3, -28 },
  { 7396, 22, 40, 23, 1, -28 },
  { 7506, 18, 28, 16, 0, -28 },
  { 7569, 18, 29, 18, 0, -28 },
  { 7635, 14, 35, 14, 1, -34 },
  { 7697, 21, 29, 22, 1, -28 },
  { 7774, 19, 28, 19, 3, -28 },
  { 7841, 29, 28, 30, 3, -28 },
  { 7943, 24, 28, 19, -2, -28 },
  { 8027, 26, 40, 19, -4, -28 },
  { 8157, 20, 28, 16, -2, -28 },
  { 8227, 20, 44, 17, 1, -36 },
  { 8337, 5, 51, 19, 7, -39 },
  { 8369, 19, 44, 17, -3, -36 },
  { 8474, 20, 8, 23, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC51PT7B_H_
