#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC23PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC6, 0x18, 0xE3, 0x8C, 0x30, 0xC7, 0x00, 0x01, 0x8E,
  0x38, 0x77, 0x66, 0x66, 0x6E, 0xCC, 0xCC, 0x06, 0x60, 0xD8, 0x33, 0x06,
  0x63, 0xFE, 0x7F, 0xC6, 0x60, 0xC8, 0x13, 0x1F, 0xFB, 0xFE, 0x13, 0x06,
  0x60, 0xC8, 0x1B, 0x06, 0x60, 0x03, 0x01, 0xC1, 0xFC, 0x7E, 0x3A, 0x0D,
  0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xB0, 0x2C, 0x8B, 0x33, 0xCF, 0xE1,
  0xF0, 0x10, 0x04, 0x00, 0x18, 0x00, 0xF0, 0xC6, 0xC6, 0x19, 0x18, 0x4C,
  0xC3, 0x33, 0x0C, 0xD8, 0x33, 0x6E, 0xDB, 0x7F, 0xE9, 0x36, 0x6C, 0xC3,
  0x33, 0x0C, 0x98, 0x66, 0x61, 0x99, 0x8C, 0x3C, 0x30, 0xE0, 0x03, 0x01,
  0xF0, 0x76, 0x0C, 0xC1, 0x98, 0x37, 0x06, 0xC0, 0xF0, 0x1C, 0x07, 0xDD,
  0xBB, 0x73, 0xEE, 0x79, 0x87, 0x39, 0xE7, 0xFC, 0x79, 0xC0, 0x76, 0x66,
  0xEC, 0x07, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60,
  0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x60, 0x06, 0x06, 0x06,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C,
  0x1C, 0x18, 0x38, 0x30, 0x60, 0xE0, 0x10, 0x1C, 0x58, 0xFB, 0x7F, 0x38,
  0x7C, 0xEE, 0x44, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC7, 0xFF, 0xFE, 0x38,
  0x1C, 0x0E, 0x07, 0x00, 0x39, 0x9C, 0xCE, 0x60, 0x7F, 0xF0, 0x7F, 0x80,
  0x00, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0E,
  0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0, 0x00,
  0x03, 0x03, 0xE1, 0xF8, 0x67, 0x39, 0xCC, 0x77, 0x19, 0xC6, 0x71, 0x98,
  0xE6, 0x39, 0x8C, 0xE3, 0x39, 0xC6, 0x61, 0xF8, 0x7C, 0x00, 0x0E, 0x3C,
  0xF7, 0x64, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xE1, 0xC3, 0x06, 0x1C, 0x38,
  0x03, 0x01, 0xF8, 0x7F, 0x04, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x03,
  0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x27, 0xF8, 0xFF, 0x00,
  0x07, 0x07, 0xE1, 0xFC, 0x47, 0x01, 0xC0, 0x60, 0x38, 0x3C, 0x1C, 0x07,
  0xC0, 0x70, 0x0C, 0x03, 0x01, 0xC8, 0xF3, 0xF8, 0xFC, 0x00, 0x01, 0xC0,
  0x70, 0x38, 0x1E, 0x05, 0x83, 0xE1, 0xB8, 0x6C, 0x33, 0x19, 0xC6, 0x73,
  0xFE, 0xFF, 0xBF, 0xE0, 0xE0, 0x38, 0x0C, 0x00, 0x1F, 0xC7, 0xE1, 0x80,
  0x60, 0x38, 0x0C, 0x03, 0xF1, 0xFC, 0x07, 0x00, 0xE0, 0x30, 0x0C, 0x07,
  0x23, 0xCF, 0xE3, 0xF0, 0x03, 0x87, 0xC7, 0xE7, 0x03, 0x03, 0x81, 0x91,
  0xFC, 0xFF, 0x73, 0xB1, 0xD8, 0xEC, 0x76, 0x33, 0x39, 0xF8, 0x78, 0x00,
  0x7F, 0xDF, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06,
  0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0x07, 0x07, 0xE1, 0xDC,
  0xE7, 0x31, 0xCE, 0x73, 0xB8, 0x7C, 0x1E, 0x0F, 0xC7, 0x73, 0x8C, 0xE3,
  0x30, 0xCE, 0x73, 0xF8, 0x7C, 0x00, 0x07, 0x07, 0xE1, 0xF8, 0xE7, 0x31,
  0xDC, 0x77, 0x19, 0xCE, 0x73, 0x8F, 0xE3, 0xB8, 0x0C, 0x07, 0x01, 0x80,
  0xE3, 0xF0, 0xF8, 0x00, 0x19, 0xCE, 0x60, 0x00, 0x00, 0x00, 0x19, 0xCE,
  0x00, 0x0C, 0x71, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x03, 0x1C, 0x71, 0x8E,
  0x30, 0x00, 0x80, 0xC1, 0xE3, 0xE7, 0x87, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xC0, 0x20, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x60, 0x3C,
  0x0F, 0x81, 0xF0, 0x3C, 0x1E, 0x3C, 0xF8, 0x70, 0x20, 0x00, 0x0C, 0x3F,
  0x3F, 0x03, 0x03, 0x07, 0x06, 0x0C, 0x18, 0x38, 0x30, 0x30, 0x00, 0x00,
  0x60, 0xE0, 0x60, 0x01, 0x80, 0x3F, 0x83, 0x0C, 0x30, 0x33, 0x01, 0xB1,
  0xE5, 0x9B, 0x29, 0x9B, 0xC8, 0x9E, 0xCC, 0xE6, 0x65, 0x33, 0x69, 0xBA,
  0x4F, 0xF2, 0x00, 0x18, 0x00, 0xC0, 0x83, 0xF8, 0x0F, 0x80, 0x03, 0xC0,
  0xF0, 0x6C, 0x1F, 0x0F, 0xC3, 0x70, 0xDC, 0x77, 0x19, 0xCF, 0xF3, 0xFD,
  0xC7, 0x71, 0xD8, 0x7E, 0x1F, 0x07, 0x1F, 0xC3, 0xF8, 0x63, 0x8C, 0x73,
  0x8E, 0x73, 0x8F, 0xE1, 0xF8, 0x37, 0x8E, 0x31, 0xC6, 0x30, 0xC6, 0x39,
  0xCF, 0x3F, 0xC7, 0xF0, 0x03, 0x83, 0xF1, 0xF8, 0xE0, 0x30, 0x1C, 0x07,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x21, 0xF8,
  0x7E, 0x00, 0x1F, 0xC3, 0xF8, 0x63, 0x8C, 0x73, 0x8E, 0x71, 0xCE, 0x39,
  0x87, 0x30, 0xEE, 0x19, 0xC7, 0x30, 0xE6, 0x39, 0xCE, 0x3F, 0x87, 0xE0,
  0x1F, 0xC7, 0xF1, 0x80, 0x60, 0x38, 0x0E, 0x03, 0xF0, 0xFC, 0x3F, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x38, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF1, 0x80,
  0x60, 0x38, 0x0E, 0x03, 0x80, 0xFC, 0x3F, 0x1C, 0x07, 0x01, 0xC0, 0x60,
  0x38, 0x0E, 0x03, 0x80, 0x03, 0x81, 0xFC, 0x7F, 0x9C, 0x13, 0x80, 0xE0,
  0x1C, 0x07, 0x00, 0xE3, 0xDC, 0xFB, 0x87, 0x70, 0xCE, 0x19, 0xC7, 0x38,
  0xE3, 0xFC, 0x3F, 0x00, 0x1C, 0x31, 0xC7, 0x18, 0x71, 0x87, 0x38, 0x63,
  0x86, 0x3F, 0xE3, 0xFE, 0x3F, 0xE7, 0x0C, 0x70, 0xC6, 0x1C, 0x61, 0xCE,
  0x1C, 0xE1, 0x8E, 0x38, 0x1F, 0x83, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x30,
  0x18, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC1, 0xF1, 0xF8, 0x03, 0x81,
  0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0,
  0xC0, 0x60, 0x70, 0x38, 0x18, 0x1C, 0x3E, 0x1E, 0x0E, 0x00, 0x1C, 0x71,
  0xCE, 0x19, 0xC1, 0x98, 0x3B, 0x83, 0xF0, 0x36, 0x03, 0xE0, 0x3E, 0x07,
  0x60, 0x77, 0x06, 0x70, 0x67, 0x06, 0x30, 0xE3, 0x0E, 0x38, 0x1C, 0x38,
  0x60, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x06, 0x1C, 0x3F, 0xFF,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x36,
  0x36, 0x3E, 0x36, 0x6E, 0x36, 0x6C, 0x76, 0xCC, 0x66, 0xDC, 0x67, 0xDC,
  0x67, 0x98, 0x67, 0x98, 0xE7, 0x18, 0xC7, 0x38, 0x1C, 0x18, 0xF1, 0xC7,
  0x8E, 0x3C, 0x63, 0xE3, 0x1B, 0x18, 0xD9, 0xC6, 0xEC, 0x33, 0x63, 0x9B,
  0x18, 0xD8, 0xC7, 0xC6, 0x3C, 0x31, 0xE3, 0x87, 0x18, 0x38, 0x03, 0x01,
  0xF8, 0x7F, 0x1C, 0x73, 0x0E, 0xE1, 0xD8, 0x3F, 0x07, 0xE0, 0xFC, 0x1B,
  0x87, 0x70, 0xEE, 0x19, 0xC7, 0x39, 0xC7, 0xF8, 0x7C, 0x00, 0x1F, 0xC3,
  0xF8, 0x63, 0x8C, 0x73, 0x8E, 0x71, 0xCE, 0x71, 0x9E, 0x3F, 0x8F, 0xC1,
  0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x03, 0x01, 0xF8, 0x7F,
  0x1C, 0x73, 0x0E, 0xE1, 0xD8, 0x3F, 0x07, 0xE0, 0xFC, 0x1B, 0x87, 0x70,
  0xEE, 0x19, 0xC7, 0x39, 0xC7, 0xF8, 0x7C, 0x01, 0x80, 0x38, 0x07, 0x00,
  0xF0, 0x1F, 0x87, 0xF1, 0x8C, 0x63, 0x38, 0xCE, 0x73, 0x1C, 0xFE, 0x3F,
  0x1D, 0x87, 0x71, 0x9C, 0x67, 0x18, 0xCE, 0x33, 0x8E, 0x07, 0x07, 0xF1,
  0xFC, 0xE2, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC8, 0xF3, 0xF8, 0xFC, 0x00, 0xFF, 0xFF, 0x38, 0x38, 0x38,
  0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xC0, 0x38,
  0xE7, 0x1C, 0xC3, 0x98, 0x67, 0x0C, 0xE3, 0x98, 0x73, 0x0E, 0xE1, 0x9C,
  0x33, 0x8E, 0x61, 0xCC, 0x31, 0xCE, 0x3F, 0x83, 0xE0, 0xE1, 0xF8, 0x6E,
  0x3B, 0x8C, 0xE7, 0x39, 0xCE, 0x63, 0x38, 0xCC, 0x37, 0x0D, 0x83, 0x60,
  0xF8, 0x3C, 0x0F, 0x03, 0x80, 0xC3, 0x87, 0xC3, 0x8E, 0xC3, 0x8C, 0xC7,
  0x8C, 0xC7, 0x9C, 0xCD, 0x98, 0xCD, 0xB8, 0xCD, 0xB8, 0xD9, 0xB0, 0xD9,
  0xF0, 0xFB, 0x60, 0xF3, 0x60, 0xF3, 0xE0, 0xE3, 0xC0, 0xE3, 0xC0, 0xE3,
  0x80, 0x1C, 0x70, 0xCE, 0x0C, 0xC0, 0xDC, 0x0F, 0x80, 0xF8, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x1B, 0x03, 0xB0, 0x33, 0x07, 0x38, 0x63, 0x8E,
  0x38, 0xE3, 0xF1, 0xB9, 0xDC, 0xC6, 0xE3, 0x61, 0xE0, 0xF0, 0x70, 0x38,
  0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0x1F, 0xE3, 0xFC, 0x07, 0x00,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x07,
  0x00, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0x87, 0xC3, 0x01, 0x80, 0xC0, 0xE0,
  0x70, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60,
  0x30, 0x18, 0x1F, 0x0F, 0x80, 0xE7, 0x18, 0xC6, 0x31, 0x8C, 0x73, 0x8C,
  0x63, 0x18, 0xC6, 0x38, 0x07, 0x87, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C,
  0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E,
  0x06, 0x0F, 0x0F, 0x80, 0x07, 0x01, 0xC0, 0xF0, 0x7C, 0x1B, 0x8C, 0x63,
  0x19, 0x86, 0xE1, 0xC0, 0xFE, 0xE6, 0x73, 0x0C, 0x07, 0xB3, 0xFC, 0xE7,
  0x71, 0xDC, 0x66, 0x19, 0x8E, 0x63, 0xB8, 0xC6, 0x71, 0xFC, 0x7B, 0x00,
  0x1C, 0x07, 0x01, 0x80, 0x60, 0x1B, 0x0F, 0xE3, 0xDC, 0xE7, 0x31, 0xDC,
  0x77, 0x1D, 0x86, 0x63, 0x98, 0xEE, 0x73, 0xFC, 0xDE, 0x00, 0x07, 0x0F,
  0xCF, 0x47, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x18, 0x8F, 0x83,
  0xC0, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0xCC, 0x3D, 0x8F, 0xF1, 0x8E,
  0x71, 0x8E, 0x31, 0x86, 0x30, 0xC6, 0x39, 0xC6, 0x19, 0xC3, 0xF8, 0x7B,
  0x00, 0x06, 0x0F, 0xCE, 0x66, 0x37, 0x1B, 0x39, 0xF8, 0xF0, 0x60, 0x70,
  0x18, 0x4F, 0xC3, 0xE0, 0x00, 0x40, 0x1F, 0x01, 0xE0, 0x38, 0x03, 0x00,
  0x30, 0x0F, 0xC0, 0xFC, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x0F,
  0x80, 0xF0, 0x04, 0x00, 0x07, 0x01, 0xEC, 0x7F, 0x8C, 0x73, 0x8E, 0x71,
  0x8C, 0x31, 0x8E, 0x31, 0xCE, 0x31, 0xCE, 0x1F, 0xC3, 0xF8, 0x07, 0x00,
  0xC4, 0x38, 0xFF, 0x1F, 0xC0, 0x40, 0x00, 0x1C, 0x07, 0x01, 0x80, 0x60,
  0x1B, 0x0F, 0xE3, 0xFC, 0xE7, 0x31, 0x9C, 0x67, 0x19, 0xCE, 0x63, 0x98,
  0xCE, 0x33, 0x9C, 0xC7, 0x00, 0x1C, 0x71, 0x80, 0x00, 0xE3, 0x8C, 0x31,
  0xC7, 0x1C, 0x61, 0x8E, 0x38, 0xC0, 0x03, 0x81, 0xC0, 0xC0, 0x00, 0x00,
  0x38, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38,
  0x18, 0x0C, 0x06, 0x07, 0x0F, 0x07, 0x81, 0x00, 0x1C, 0x07, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x73, 0x38, 0xCC, 0x36, 0x0F, 0x87, 0xE1, 0xF8, 0x76,
  0x19, 0x8E, 0x63, 0x9C, 0xC7, 0x00, 0x1C, 0x71, 0x86, 0x18, 0xE3, 0x8C,
  0x31, 0xC7, 0x1C, 0x61, 0x8E, 0x38, 0xC0, 0x03, 0x18, 0xDE, 0xF3, 0xFF,
  0xCE, 0x73, 0x31, 0x8D, 0xC6, 0x37, 0x39, 0xD8, 0xE7, 0x63, 0x19, 0x8C,
  0x6E, 0x31, 0xB9, 0xCE, 0xC6, 0x30, 0x03, 0x0D, 0xE3, 0xFC, 0xE7, 0x31,
  0x9C, 0x67, 0x19, 0xCE, 0x63, 0x98, 0xCE, 0x33, 0x9C, 0xC7, 0x00, 0x0C,
  0x3F, 0x7F, 0x63, 0xE3, 0xE3, 0xC3, 0xC3, 0xC7, 0xC6, 0xCE, 0xFC, 0x78,
  0x01, 0x83, 0x78, 0x7B, 0x8E, 0x71, 0x8E, 0x71, 0xCE, 0x39, 0x86, 0x31,
  0xC6, 0x39, 0xEE, 0x3F, 0xC6, 0xF0, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18,
  0x00, 0x0E, 0x07, 0xF3, 0xFC, 0xC7, 0x71, 0xDC, 0x66, 0x19, 0x86, 0x63,
  0xB8, 0xCE, 0x71, 0xFC, 0x7F, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80,
  0xE0, 0x03, 0x37, 0x3F, 0x38, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0,
  0xE0, 0xC0, 0x0E, 0x3F, 0x33, 0x70, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x0E,
  0x8E, 0xFC, 0xF8, 0x18, 0xC3, 0x3F, 0xFD, 0x86, 0x18, 0xE3, 0x8C, 0x30,
  0xC3, 0xCF, 0x00, 0x71, 0xB1, 0xD8, 0xCC, 0x6E, 0x37, 0x3B, 0x1D, 0x8C,
  0xC6, 0x67, 0x3F, 0x9E, 0xC0, 0xE3, 0xF1, 0xB9, 0xDC, 0xCE, 0xE3, 0x61,
  0xF0, 0xF0, 0x78, 0x38, 0x1C, 0x0C, 0x00, 0xE7, 0x1F, 0x9C, 0x6E, 0x73,
  0x3B, 0xCC, 0xEF, 0x73, 0xED, 0x8F, 0xB6, 0x36, 0xF0, 0xF3, 0xC3, 0xCF,
  0x0E, 0x38, 0x38, 0xE0, 0x18, 0xE3, 0xB8, 0x7E, 0x07, 0x80, 0xF0, 0x1C,
  0x07, 0x80, 0xF0, 0x3E, 0x0E, 0xE1, 0x9C, 0x71, 0x80, 0x1C, 0x70, 0xC6,
  0x0C, 0xE0, 0xCC, 0x0D, 0xC0, 0xD8, 0x0D, 0x80, 0xF0, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x0F, 0x80, 0xF0, 0x04, 0x00,
  0x1F, 0x8F, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x38, 0x3F,
  0x9F, 0xC0, 0x07, 0x83, 0xC3, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x78,
  0x30, 0x3C, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x3C, 0x0E, 0x01,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x1E, 0x06, 0x06, 0x0E,
  0x0E, 0x0E, 0x0C, 0x0E, 0x03, 0x0F, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x30,
  0xF0, 0xE0, 0x80, 0x70, 0xFF, 0xE7, 0xF0, 0x40,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 6, 16, 6, 0, -16 },
  { 13, 8, 6, 9, 2, -16 },
  { 19, 11, 16, 11, 0, -16 },
  { 41, 10, 18, 9, 0, -17 },
  { 64, 14, 17, 15, 1, -17 },
  { 94, 11, 17, 11, 0, -17 },
  { 118, 4, 6, 5, 2, -16 },
  { 121, 8, 20, 6, 0, -16 },
  { 141, 8, 21, 6, -2, -17 },
  { 162, 8, 9, 9, 2, -18 },
  { 171, 9, 11, 10, 1, -14 },
  { 184, 5, 6, 5, -1, -3 },
  { 188, 6, 2, 6, 0, -7 },
  { 190, 3, 3, 5, 0, -3 },
  { 192, 11, 17, 8, -1, -17 },
  { 216, 10, 17, 9, 0, -17 },
  { 238, 7, 16, 10, 2, -16 },
  { 252, 11, 17, 9, -1, -17 },
  { 276, 10, 17, 9, 0, -17 },
  { 298, 10, 17, 10, 0, -17 },
  { 320, 10, 16, 9, 0, -16 },
  { 340, 9, 17, 9, 1, -17 },
  { 360, 10, 16, 9, 1, -16 },
  { 380, 10, 17, 9, 0, -17 },
  { 402, 10, 17, 9, 0, -17 },
  { 424, 5, 13, 5, 0, -13 },
  { 433, 6, 16, 5, -1, -13 },
  { 445, 9, 11, 10, 1, -14 },
  { 458, 9, 6, 10, 1, -11 },
  { 465, 9, 11, 10, 1, -14 },
  { 478, 8, 17, 7, 0, -17 },
  { 495, 13, 19, 14, 1, -17 },
  { 526, 10, 16, 10, -1, -16 },
  { 546, 11, 16, 11, 0, -16 },
  { 568, 10, 17, 10, 1, -17 },
  { 590, 11, 16, 11, 0, -16 },
  { 612, 10, 16, 9, 0, -16 },
  { 632, 10, 16, 8, 0, -16 },
  { 652, 11, 17, 12, 1, -17 },
  { 676, 12, 16, 12, 0, -16 },
  { 700, 9, 16, 7, -1, -16 },
  { 718, 9, 21, 5, -3, -16 },
  { 742, 12, 16, 10, 0, -16 },
  { 766, 7, 16, 8, 0, -16 },
  { 780, 16, 16, 16, 0, -16 },
  { 812, 13, 16, 12, 0, -16 },
  { 838, 11, 17, 12, 1, -17 },
  { 862, 11, 16, 10, 0, -16 },
  { 884, 11, 21, 12, 1, -17 },
  { 913, 10, 16, 10, 0, -16 },
  { 933, 10, 17, 9, 0, -17 },
  { 955, 8, 16, 9, 2, -16 },
  { 971, 11, 16, 11, 1, -16 },
  { 993, 10, 16, 10, 2, -16 },
  { 1013, 16, 16, 16, 2, -16 },
  { 1045, 12, 16, 10, -1, -16 },
  { 1069, 9, 16, 9, 2, -16 },
  { 1087, 11, 16, 8, -1, -16 },
  { 1109, 9, 21, 7, -1, -17 },
  { 1133, 5, 17, 8, 2, -17 },
  { 1144, 9, 21, 7, -2, -17 },
  { 1168, 10, 9, 10, 0, -16 },
  { 1180, 7, 1, 7, -2, 2 },
  { 1181, 4, 4, 6, 3, -18 },
  { 1183, 10, 13, 10, 0, -13 },
  { 1200, 10, 17, 10, 0, -17 },
  { 1222, 9, 13, 8, 0, -13 },
  { 1237, 11, 17, 10, 0, -17 },
  { 1261, 9, 13, 9, 0, -13 },
  { 1276, 12, 24, 6, -3, -18 },
  { 1312, 11, 19, 10, -1, -13 },
  { 1339, 10, 17, 10, 0, -17 },
  { 1361, 6, 17, 5, 0, -17 },
  { 1374, 9, 23, 5, -3, -17 },
  { 1400, 10, 17, 9, 0, -17 },
  { 1422, 6, 17, 5, 0, -17 },
  { 1435, 14, 13, 15, 0, -13 },
  { 1458, 10, 13, 10, 0, -13 },
  { 1475, 8, 13, 10, 1, -13 },
  { 1488, 11, 18, 10, -1, -13 },
  { 1513, 10, 19, 10, 0, -13 },
  { 1537, 8, 13, 7, 0, -13 },
  { 1550, 8, 13, 8, 0, -13 },
  { 1563, 6, 15, 6, 1, -15 },
  { 1575, 9, 12, 10, 1, -12 },
  { 1589, 9, 12, 9, 1, -12 },
  { 1603, 14, 12, 14, 1, -12 },
  { 1624, 11, 12, 9, -1, -12 },
  { 1641, 12, 18, 9, -2, -12 },
  { 1668, 9, 12, 7, -1, -12 },
  { 1682, 9, 20, 8, 0, -16 },
  { 1705, 2, 23, 9, 3, -18 },
  { 1711, 8, 20, 8, -1, -16 },
  { 1731, 9, 4, 10, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC23PT7B_H_
