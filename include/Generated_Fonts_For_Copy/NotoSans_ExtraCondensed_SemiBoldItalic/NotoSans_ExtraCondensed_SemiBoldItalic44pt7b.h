#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC44PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x78, 0x00,
  0x3E, 0x7C, 0xF1, 0xF3, 0xC7, 0xDF, 0x1E, 0x7C, 0x79, 0xE1, 0xE7, 0x8F,
  0x9E, 0x3C, 0x78, 0xF3, 0xC3, 0xCF, 0x0E, 0x00, 0x00, 0x3C, 0x78, 0x01,
  0xC3, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x0E, 0x00, 0x78, 0xF0,
  0x03, 0xC7, 0x80, 0x1C, 0x38, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0x3C, 0x78, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00,
  0xF1, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x78, 0xF0, 0x03, 0x87, 0x00, 0x3C,
  0x78, 0x01, 0xE3, 0xC0, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x8F, 0x00,
  0x38, 0x70, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3E,
  0xDE, 0x0F, 0x98, 0x81, 0xE2, 0x00, 0x3C, 0xC0, 0x07, 0x98, 0x00, 0xFB,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x0D, 0xF0, 0x01, 0xBE, 0x00, 0x33,
  0xC0, 0x04, 0x78, 0x41, 0x9F, 0x08, 0x33, 0xE1, 0xE6, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF8, 0x07, 0x80, 0xFF, 0x01, 0xC0, 0x7B, 0xC0, 0xF0, 0x1C, 0x70, 0x38,
  0x0F, 0x1C, 0x1E, 0x03, 0x87, 0x0F, 0x01, 0xE3, 0xC3, 0xC0, 0x78, 0xF1,
  0xE0, 0x1C, 0x3C, 0x78, 0x07, 0x0F, 0x3C, 0x03, 0xC3, 0x8E, 0x00, 0xF1,
  0xE7, 0x80, 0x3C, 0x79, 0xC7, 0xCF, 0x1C, 0xF3, 0xFB, 0xCF, 0x39, 0xFF,
  0xFF, 0x9E, 0x7B, 0xDF, 0xE7, 0x3C, 0xF7, 0xF3, 0xCE, 0x1C, 0x70, 0xE7,
  0x8F, 0x00, 0x79, 0xE3, 0xC0, 0x3C, 0x70, 0xF0, 0x0F, 0x1C, 0x3C, 0x07,
  0x8F, 0x0E, 0x01, 0xE3, 0xC3, 0x80, 0xF0, 0xF1, 0xE0, 0x38, 0x3C, 0x78,
  0x1E, 0x0F, 0x3C, 0x07, 0x03, 0xCF, 0x03, 0xC0, 0xFF, 0x80, 0xE0, 0x1F,
  0xC0, 0x78, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x80, 0x3E, 0x7C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78,
  0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF3, 0xC0, 0x07, 0xBE, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0,
  0xF8, 0xFF, 0xC7, 0xC7, 0xBE, 0x3C, 0x7C, 0xF3, 0xE7, 0xC7, 0xDE, 0x3C,
  0x3F, 0xF3, 0xE0, 0xFF, 0x1F, 0x07, 0xF8, 0xF8, 0x3F, 0x87, 0xC0, 0xFC,
  0x3E, 0x0F, 0xC1, 0xF0, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF,
  0x9F, 0x07, 0xF8, 0xFC, 0x3E, 0x7C, 0xF1, 0xE7, 0xCF, 0x9E, 0x3C, 0x78,
  0xF3, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x06, 0x3C, 0x0F, 0x78, 0x7F, 0xEF, 0xFF, 0xFF, 0x3F,
  0xFE, 0x0F, 0xFC, 0x3F, 0x00, 0xFF, 0x07, 0xFE, 0x1F, 0x9E, 0x0E, 0x3E,
  0x08, 0x78, 0x10, 0x40, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x3C,
  0x3C, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3D, 0xFF, 0xFF, 0xFD,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x7E, 0x7C, 0x3E, 0x1E, 0x3E, 0x0F, 0x1F, 0x07, 0x8F, 0x03, 0xCF, 0x81,
  0xE7, 0xC1, 0xF3, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C,
  0x0F, 0x3C, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xE7, 0xC1, 0xF3,
  0xE0, 0xF9, 0xF0, 0x78, 0xF0, 0x7C, 0x78, 0x3E, 0x3E, 0x3E, 0x1F, 0x3F,
  0x0F, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x0F,
  0xC0, 0xFE, 0x0F, 0xE0, 0xFF, 0x1F, 0xF9, 0xFF, 0xDF, 0xBE, 0x79, 0xE1,
  0x9F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF,
  0xF0, 0x1C, 0x1F, 0x01, 0x81, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x18, 0x3F, 0x01,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x80, 0x3F, 0x0C, 0x07, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xBC,
  0x00, 0x3B, 0xC0, 0x07, 0x7C, 0x00, 0xF7, 0xC0, 0x0E, 0x78, 0x01, 0xE7,
  0x80, 0x3C, 0xF8, 0x03, 0x8F, 0x80, 0x78, 0xF8, 0x0F, 0x0F, 0x00, 0xE0,
  0xF0, 0x1E, 0x1F, 0x01, 0xC1, 0xF0, 0x3C, 0x1F, 0x07, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC8, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0xB8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x10,
  0x0F, 0xC3, 0x03, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xCC, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x7B, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0x3F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x7E,
  0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF0, 0xF8,
  0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x7E, 0x7E, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7C, 0x7E,
  0x0F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x78,
  0x3E, 0x1F, 0x07, 0xC7, 0xC0, 0x7D, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7C, 0xF8, 0x1F, 0x1F, 0x87,
  0xC1, 0xF0, 0xF8, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0x78, 0xF8, 0x1F, 0x1F,
  0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x0F,
  0xFF, 0x07, 0xFF, 0xC3, 0xF1, 0xF0, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x07,
  0xC7, 0xC1, 0xF1, 0xE0, 0x7C, 0x78, 0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xF3,
  0xE0, 0xFC, 0xFC, 0x7F, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F,
  0xBE, 0x07, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0x03, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x00, 0xE0,
  0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0,
  0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x01, 0xE0,
  0x00, 0x30, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x70, 0x00,
  0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x3C, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF,
  0xF1, 0xE7, 0xE2, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x00,
  0xE0, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3, 0x83,
  0xFC, 0x71, 0xE1, 0xFF, 0x1C, 0x70, 0xFF, 0xC7, 0x3C, 0x38, 0xF1, 0xCE,
  0x1C, 0x38, 0x73, 0x8F, 0x0E, 0x1D, 0xE3, 0x87, 0x8F, 0x70, 0xE1, 0xE3,
  0xDC, 0x78, 0x70, 0xE7, 0x1E, 0x1C, 0x3B, 0xC7, 0x0F, 0x0E, 0xF1, 0xC3,
  0xC7, 0x38, 0x70, 0xE1, 0xCE, 0x1C, 0x78, 0xE3, 0x87, 0x3E, 0x78, 0xE1,
  0xFD, 0xFC, 0x38, 0x7E, 0x7E, 0x0E, 0x0F, 0x0F, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x02,
  0x00, 0x3F, 0x9F, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3D,
  0xF0, 0x03, 0xDF, 0x00, 0x7D, 0xF0, 0x07, 0x9F, 0x00, 0xF9, 0xF0, 0x0F,
  0x9F, 0x00, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xE1, 0xF0, 0x3E, 0x1F, 0x03,
  0xE1, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0,
  0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x1F,
  0x3E, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3C, 0x1F, 0x03,
  0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x0F,
  0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xF8, 0x7E, 0x07, 0x81, 0xF0,
  0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x0F, 0x80,
  0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x0F, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x0F,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xC1, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x0C, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3E,
  0x3F, 0x83, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8,
  0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0,
  0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x87,
  0xC0, 0x7C, 0x7C, 0x07, 0xE3, 0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF8, 0x7C, 0x1F, 0x83, 0xE1, 0xFC, 0x1F, 0x7F, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x02, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0x80, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xF8, 0xF8, 0x1F,
  0xE3, 0xE0, 0xFF, 0x8F, 0x83, 0xFE, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3,
  0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0,
  0x3E, 0x0F, 0xC0, 0xF8, 0x3F, 0x83, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0x1F, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x7C,
  0x0F, 0x80, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0,
  0xF8, 0x0F, 0x80, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x37, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0,
  0x3C, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xE0, 0x07,
  0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x00, 0xFF,
  0xC0, 0x01, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xE3, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFF,
  0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0x78, 0x1F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0xF7, 0xC0, 0xF7, 0x83, 0xEF, 0x01,
  0xEF, 0x07, 0xBE, 0x07, 0xDE, 0x0F, 0x7C, 0x0F, 0xBE, 0x3C, 0xF8, 0x1F,
  0x7C, 0x79, 0xE0, 0x3C, 0x79, 0xE3, 0xC0, 0x78, 0xF3, 0xCF, 0x81, 0xF1,
  0xEF, 0x1F, 0x03, 0xE3, 0xDE, 0x3E, 0x07, 0x87, 0xFC, 0x78, 0x0F, 0x0F,
  0xF0, 0xF0, 0x1E, 0x1F, 0xE3, 0xE0, 0x7C, 0x3F, 0x87, 0xC0, 0xF8, 0x7F,
  0x0F, 0x81, 0xE0, 0xFC, 0x1E, 0x03, 0xC1, 0xF8, 0x7C, 0x0F, 0x83, 0xE0,
  0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xC0, 0x00, 0x03, 0xF0,
  0x0F, 0x81, 0xF8, 0x07, 0xC0, 0xFE, 0x03, 0xE0, 0x7F, 0x01, 0xE0, 0x3F,
  0x80, 0xF0, 0x3F, 0xC0, 0xF8, 0x1F, 0xE0, 0x7C, 0x0F, 0xF0, 0x3C, 0x07,
  0xFC, 0x1E, 0x07, 0xDE, 0x1F, 0x03, 0xEF, 0x0F, 0x81, 0xE7, 0x87, 0xC0,
  0xF3, 0xC3, 0xC0, 0x79, 0xE1, 0xE0, 0x7C, 0xF9, 0xF0, 0x3E, 0x3C, 0xF8,
  0x1E, 0x1E, 0x7C, 0x0F, 0x0F, 0x3C, 0x07, 0x87, 0x9E, 0x07, 0xC3, 0xDF,
  0x03, 0xE1, 0xFF, 0x81, 0xE0, 0x7F, 0xC0, 0xF0, 0x3F, 0xC0, 0x78, 0x1F,
  0xE0, 0x7C, 0x0F, 0xF0, 0x3E, 0x07, 0xF8, 0x1E, 0x03, 0xF8, 0x0F, 0x00,
  0xFC, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFF,
  0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x3F, 0x1F, 0x00, 0xF9, 0xF0,
  0x07, 0xCF, 0x80, 0x3E, 0xFC, 0x03, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xF9,
  0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00,
  0xFD, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x07, 0xC1, 0xF8, 0xFE,
  0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3C, 0x3F,
  0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x7C,
  0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF0,
  0x7C, 0x3F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xE0,
  0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x3F, 0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xCF,
  0x80, 0x3E, 0xFC, 0x03, 0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xF9, 0xF0, 0x07,
  0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0,
  0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8,
  0xF8, 0x0F, 0xC7, 0xC0, 0xFC, 0x3E, 0x07, 0xC1, 0xF8, 0xFE, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x0F, 0x87,
  0xE0, 0xF0, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF,
  0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x3C, 0x03, 0xE3, 0xE0, 0x3C,
  0x3E, 0x03, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x07,
  0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0x06, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x40, 0x3F, 0x07, 0x8F, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xDF, 0xFF, 0xE0, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x0F,
  0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80,
  0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0,
  0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8,
  0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x7C, 0x07,
  0xE3, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xCF,
  0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x3E, 0x1F,
  0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF1, 0xF0, 0x3E,
  0x3E, 0x07, 0xC7, 0x80, 0xF9, 0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x80, 0x7D,
  0xF0, 0x0F, 0x3C, 0x01, 0xEF, 0x80, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x7E, 0xF0, 0x0F, 0x80, 0xF9,
  0xE0, 0x1F, 0x01, 0xF3, 0xC0, 0x7E, 0x07, 0xC7, 0x80, 0xFC, 0x0F, 0x8F,
  0x03, 0xF8, 0x1E, 0x1E, 0x07, 0xF0, 0x7C, 0x3C, 0x0F, 0xE0, 0xF8, 0x78,
  0x3F, 0xC3, 0xE0, 0xF0, 0x7F, 0x87, 0xC1, 0xE1, 0xEE, 0x0F, 0x03, 0xC3,
  0xDC, 0x3E, 0x07, 0x87, 0xF8, 0x7C, 0x0F, 0x1E, 0xF1, 0xF0, 0x3E, 0x3D,
  0xE3, 0xE0, 0x7C, 0xFB, 0xC7, 0x80, 0xF9, 0xE7, 0x9F, 0x01, 0xF3, 0xCF,
  0x3E, 0x03, 0xEF, 0x1E, 0x78, 0x07, 0xDE, 0x3D, 0xF0, 0x0F, 0xBC, 0x7B,
  0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x78, 0xF8, 0x00,
  0x78, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xEF, 0x80, 0x07,
  0xCF, 0x80, 0x07, 0xCF, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x80, 0x1F,
  0x07, 0x80, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC,
  0x07, 0xC0, 0xF8, 0x0F, 0xFC, 0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xCF, 0x83,
  0xE3, 0xC3, 0xE1, 0xE1, 0xF0, 0xF1, 0xF0, 0x78, 0xF8, 0x3E, 0xF8, 0x1F,
  0x7C, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x40, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xF8, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x1F, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xF0, 0x0F, 0xBC, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0xF8, 0xF8, 0x3C, 0x1E,
  0x1F, 0x07, 0x87, 0x81, 0xE3, 0xC0, 0x7D, 0xF0, 0x0F, 0x78, 0x03, 0xFE,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x7C, 0x7C, 0x3E,
  0x3E, 0x1E, 0x0F, 0x01, 0xF1, 0xE0, 0xFF, 0x7C, 0x3F, 0xEF, 0x07, 0xFF,
  0xE1, 0xF8, 0xFC, 0x3E, 0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0x8F, 0x81, 0xF1, 0xF0, 0x3E,
  0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF8,
  0x7C, 0x3F, 0x0F, 0xFF, 0xE0, 0xFF, 0x78, 0x1F, 0xEF, 0x01, 0xF1, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF3, 0xE0,
  0x1E, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x8F, 0xC3, 0xE0, 0xF8,
  0xFC, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x78, 0x0F, 0x8F, 0x01, 0xE3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0x3E, 0x3C, 0x0F, 0x8F,
  0x81, 0xF1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xE3, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x07, 0xBF, 0xC0, 0xF3, 0xF0, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0x84, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x20, 0xFF,
  0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x0F, 0x9F, 0x01, 0xFE, 0xF8,
  0x1F, 0xF7, 0x80, 0xFF, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x3F, 0x07, 0xC1,
  0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07,
  0x80, 0xF0, 0x7C, 0x07, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x87, 0xE0, 0x7F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xF7, 0x80, 0x3F, 0x3C, 0x00, 0x01, 0xFC,
  0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x0F, 0x1E, 0x0F, 0x3E, 0x0F,
  0x3C, 0x0F, 0x7C, 0x1F, 0x7C, 0x3E, 0x7F, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0,
  0xFE, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x08, 0x7E, 0x78, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x7C, 0x78, 0x0F, 0xF7, 0xC0, 0xFF, 0xBC, 0x07, 0xFF,
  0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F,
  0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0x83, 0xE0, 0x7C,
  0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0,
  0x7C, 0x0F, 0x87, 0xE0, 0x7C, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0x7F, 0xFC, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x40, 0x3E, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE7, 0xE0, 0x7B, 0xF8, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC3, 0xF1, 0xF0, 0xF8, 0x7C, 0x7E, 0x1F, 0x1F, 0x07,
  0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x78, 0x1E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3,
  0xE0, 0xF8, 0xF8, 0x3E, 0x3C, 0x0F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0,
  0x7C, 0x7C, 0x1F, 0x1E, 0x07, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x06, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x3F, 0x07, 0x83,
  0xE0, 0xF8, 0x7C, 0x0F, 0x8F, 0x80, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF3,
  0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0x78, 0x07,
  0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0x87, 0xC0, 0x78, 0x7C, 0x07, 0x83, 0xC0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0x9F,
  0x0F, 0xC0, 0x73, 0xF9, 0xFE, 0x0F, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xC7, 0xF3, 0xF0, 0xF8, 0x7E, 0x1E, 0x0F, 0x87, 0xC1, 0xE1, 0xF0,
  0x7C, 0x1E, 0x1F, 0x07, 0x83, 0xE1, 0xE0, 0x78, 0x3E, 0x1E, 0x0F, 0x83,
  0xE3, 0xE0, 0xF8, 0x3C, 0x3E, 0x0F, 0x83, 0xC3, 0xE0, 0xF0, 0x7C, 0x3C,
  0x0F, 0x07, 0xC3, 0xC1, 0xF0, 0x78, 0x7C, 0x1F, 0x07, 0x87, 0xC1, 0xF0,
  0xF8, 0x7C, 0x1E, 0x0F, 0x87, 0x83, 0xE0, 0xF8, 0x78, 0x3E, 0x0F, 0x0F,
  0x83, 0xE0, 0xF0, 0xF8, 0x3C, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0x07, 0x1F,
  0x81, 0xCF, 0xE0, 0xF7, 0xFC, 0x3F, 0xFF, 0x0F, 0xC7, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xE0, 0x78, 0xF8,
  0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF0, 0x3C, 0x7C, 0x1F,
  0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x3E, 0x0F, 0x8F,
  0x83, 0xE3, 0xE0, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xFF,
  0xE1, 0xF0, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E, 0x78, 0x1F, 0x7C, 0x0F, 0xBE,
  0x07, 0xDF, 0x03, 0xEF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7B, 0xE0, 0x7D,
  0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x1F, 0x3E, 0x1F, 0x9F, 0x0F, 0x87, 0xFF,
  0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x01, 0xE7, 0xE0, 0x0E, 0x7F,
  0x00, 0xF7, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x1F, 0x81, 0xF0, 0x7C, 0x0F,
  0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xE0, 0x3C,
  0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xE0,
  0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x3F, 0x1F, 0x81,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFB, 0xF8, 0x07, 0xDF, 0x80, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xF1, 0xE0, 0xFF, 0x7C, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xF8,
  0xFC, 0x3E, 0x1F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81,
  0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0x8F, 0x80, 0xF1, 0xF0, 0x3E, 0x3E, 0x07,
  0xC7, 0xC0, 0xF8, 0xF8, 0x1E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x3F,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFB, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x9F, 0x07, 0x3E, 0x0F, 0x7E, 0x0F, 0x7E, 0x0F, 0xFC, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x03, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x04, 0x1E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x81, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0x80, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0xFF, 0x3F, 0xF3,
  0xFF, 0x7F, 0xF1, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0x03, 0xC3,
  0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xE0,
  0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x03, 0xC3, 0xC0, 0xF1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E,
  0x0F, 0x8F, 0x87, 0xC3, 0xE3, 0xF0, 0xFF, 0xFC, 0x3F, 0xEF, 0x07, 0xFB,
  0xC0, 0xF8, 0xE0, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0,
  0x7C, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xF0, 0xF1,
  0xE0, 0xF3, 0xE0, 0xF3, 0xC0, 0xF7, 0xC0, 0xF7, 0x80, 0xF7, 0x80, 0xFF,
  0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x78, 0x1F, 0x07, 0xDE, 0x0F, 0xC1, 0xF7, 0x83, 0xF0,
  0x79, 0xE1, 0xFC, 0x3E, 0x78, 0x7F, 0x0F, 0x1E, 0x1F, 0xC7, 0xC7, 0x8F,
  0xF1, 0xF1, 0xE3, 0xFC, 0x78, 0x78, 0xEF, 0x3E, 0x1E, 0x7B, 0xCF, 0x07,
  0x9E, 0xF3, 0xC1, 0xEF, 0x39, 0xF0, 0x7B, 0xCE, 0x78, 0x1E, 0xE3, 0xBE,
  0x0F, 0xF8, 0xEF, 0x03, 0xFE, 0x3B, 0xC0, 0xF7, 0x1F, 0xE0, 0x3F, 0xC7,
  0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F,
  0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC1, 0xF8,
  0x3E, 0x0F, 0x80, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x01, 0xF7,
  0xC0, 0x07, 0xBE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x7D, 0xE0, 0x07, 0xCF, 0x80, 0x3C,
  0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x0F, 0x01, 0xF0, 0x78, 0x1F, 0x03, 0xE0,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0x81, 0xF0, 0x0F, 0x03, 0xE0,
  0x1E, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF8, 0x01,
  0xE1, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x3E, 0x00, 0x1E,
  0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xEF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x00,
  0x1C, 0x00, 0xBF, 0xC0, 0x7F, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFC, 0x07,
  0xFA, 0x00, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 31, 11, 0, -31 },
  { 48, 14, 11, 16, 4, -31 },
  { 68, 21, 31, 20, 0, -31 },
  { 150, 19, 36, 18, 0, -33 },
  { 236, 26, 32, 29, 2, -32 },
  { 340, 21, 32, 21, 0, -32 },
  { 424, 7, 11, 10, 4, -31 },
  { 434, 14, 39, 12, 1, -32 },
  { 503, 14, 39, 12, -3, -32 },
  { 572, 15, 17, 17, 4, -34 },
  { 604, 17, 21, 20, 2, -26 },
  { 649, 9, 12, 10, -2, -6 },
  { 663, 10, 4, 12, 1, -14 },
  { 668, 6, 6, 10, 0, -6 },
  { 673, 21, 32, 16, -2, -32 },
  { 757, 17, 32, 18, 1, -32 },
  { 825, 13, 31, 18, 4, -31 },
  { 876, 20, 32, 18, -2, -32 },
  { 956, 20, 32, 18, -1, -32 },
  { 1036, 20, 32, 18, -1, -32 },
  { 1116, 19, 31, 18, 0, -31 },
  { 1190, 19, 32, 18, 1, -32 },
  { 1266, 20, 31, 18, 1, -31 },
  { 1344, 19, 32, 18, 0, -32 },
  { 1420, 18, 32, 18, 0, -32 },
  { 1492, 10, 24, 10, 0, -24 },
  { 1522, 12, 30, 10, -2, -24 },
  { 1567, 17, 21, 20, 2, -26 },
  { 1612, 17, 13, 20, 2, -22 },
  { 1640, 17, 21, 20, 2, -26 },
  { 1685, 15, 32, 14, 1, -32 },
  { 1745, 26, 36, 28, 1, -32 },
  { 1862, 20, 32, 20, -3, -32 },
  { 1942, 21, 31, 20, 0, -31 },
  { 2024, 19, 32, 18, 2, -32 },
  { 2100, 21, 31, 22, 0, -31 },
  { 2182, 19, 31, 17, 0, -31 },
  { 2256, 19, 31, 16, 0, -31 },
  { 2330, 22, 32, 23, 2, -32 },
  { 2418, 24, 31, 23, 0, -31 },
  { 2511, 18, 31, 13, -2, -31 },
  { 2581, 19, 40, 10, -7, -31 },
  { 2676, 23, 31, 19, 0, -31 },
  { 2766, 13, 31, 16, 0, -31 },
  { 2817, 31, 31, 30, 0, -31 },
  { 2938, 25, 31, 24, 0, -31 },
  { 3035, 21, 32, 23, 2, -32 },
  { 3119, 21, 31, 19, 0, -31 },
  { 3201, 21, 39, 23, 2, -32 },
  { 3304, 20, 31, 20, 0, -31 },
  { 3382, 20, 32, 18, -1, -32 },
  { 3462, 17, 31, 17, 3, -31 },
  { 3528, 22, 31, 22, 1, -31 },
  { 3614, 19, 31, 19, 4, -31 },
  { 3688, 31, 31, 30, 3, -31 },
  { 3809, 24, 31, 18, -3, -31 },
  { 3902, 17, 31, 18, 4, -31 },
  { 3968, 21, 31, 16, -2, -31 },
  { 4050, 18, 39, 12, -2, -32 },
  { 4138, 9, 32, 16, 4, -32 },
  { 4174, 17, 39, 12, -3, -32 },
  { 4257, 18, 18, 18, 0, -31 },
  { 4298, 14, 3, 14, -4, 4 },
  { 4304, 8, 7, 12, 6, -34 },
  { 4311, 19, 24, 20, 1, -24 },
  { 4368, 19, 33, 19, 0, -33 },
  { 4447, 16, 24, 15, 1, -24 },
  { 4495, 21, 33, 20, 1, -33 },
  { 4582, 16, 24, 18, 1, -24 },
  { 4630, 22, 45, 11, -5, -34 },
  { 4754, 21, 35, 20, -1, -24 },
  { 4846, 18, 33, 19, 0, -33 },
  { 4921, 11, 33, 9, 0, -33 },
  { 4967, 17, 44, 9, -6, -33 },
  { 5061, 20, 33, 18, 0, -33 },
  { 5144, 12, 33, 9, 0, -33 },
  { 5194, 28, 24, 29, 0, -24 },
  { 5278, 18, 24, 19, 0, -24 },
  { 5332, 17, 24, 19, 1, -24 },
  { 5383, 21, 34, 19, -2, -24 },
  { 5473, 19, 35, 20, 1, -24 },
  { 5557, 16, 24, 13, 0, -24 },
  { 5605, 16, 24, 15, 0, -24 },
  { 5653, 12, 29, 12, 1, -29 },
  { 5697, 18, 24, 19, 1, -24 },
  { 5751, 16, 24, 17, 3, -24 },
  { 5799, 26, 24, 26, 2, -24 },
  { 5877, 21, 24, 17, -2, -24 },
  { 5940, 23, 35, 17, -4, -24 },
  { 6041, 17, 24, 14, -2, -24 },
  { 6092, 17, 38, 15, 1, -31 },
  { 6173, 4, 44, 16, 6, -34 },
  { 6195, 17, 38, 15, -3, -31 },
  { 6276, 17, 7, 20, 2, -19 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC44PT7B_H_
