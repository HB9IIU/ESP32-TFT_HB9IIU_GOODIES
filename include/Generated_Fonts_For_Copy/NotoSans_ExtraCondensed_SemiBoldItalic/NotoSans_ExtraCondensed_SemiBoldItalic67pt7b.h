#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC67PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xF8,
  0x00, 0x18, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F,
  0xC7, 0xF0, 0xFE, 0x3F, 0xC3, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC1,
  0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xE6, 0x3E, 0x00, 0xFE, 0x30, 0x60, 0x0F, 0xE3, 0x80, 0x00, 0x7F, 0x1C,
  0x00, 0x03, 0xF8, 0xE0, 0x00, 0x1F, 0xC6, 0x00, 0x00, 0xFE, 0x30, 0x00,
  0x07, 0xF3, 0x80, 0x00, 0x3F, 0xDC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xDF, 0xE0, 0x00,
  0x06, 0x7F, 0x80, 0x00, 0x73, 0xFC, 0x00, 0x03, 0x9F, 0xE0, 0x00, 0x1C,
  0x7F, 0x00, 0x00, 0xC3, 0xF8, 0x00, 0x06, 0x3F, 0x81, 0x00, 0x71, 0xFC,
  0x0E, 0x03, 0x8F, 0xE0, 0x78, 0x1C, 0xFF, 0x03, 0xFC, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xC0,
  0x07, 0xFF, 0xC0, 0x0F, 0x80, 0x0F, 0xC7, 0xC0, 0x1F, 0x80, 0x0F, 0x87,
  0xE0, 0x1F, 0x00, 0x1F, 0x87, 0xE0, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x7E,
  0x00, 0x3F, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0xFC, 0x00, 0x3E,
  0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC1,
  0xF0, 0x00, 0x7E, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x0F, 0xC3, 0xE0, 0x00,
  0x7C, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x1F,
  0x8F, 0xC0, 0x00, 0xFC, 0x1F, 0x8F, 0x83, 0xF8, 0xFC, 0x1F, 0x1F, 0x87,
  0xFC, 0xFC, 0x3F, 0x1F, 0x0F, 0xFE, 0xFC, 0x3E, 0x3F, 0x1F, 0xFE, 0xFC,
  0x7E, 0x7E, 0x3F, 0xFE, 0x7F, 0xFC, 0x7E, 0x3E, 0x3F, 0x7F, 0xFC, 0xFC,
  0x7C, 0x3F, 0x7F, 0xF8, 0xF8, 0xFC, 0x3F, 0x3F, 0xF1, 0xF8, 0xF8, 0x3F,
  0x1F, 0xC1, 0xF0, 0xF8, 0x3F, 0x02, 0x03, 0xF1, 0xF8, 0x3F, 0x00, 0x03,
  0xE1, 0xF0, 0x3F, 0x00, 0x07, 0xE1, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF0,
  0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x3E, 0x00, 0x0F, 0x83, 0xF0, 0x7E, 0x00,
  0x1F, 0x83, 0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x3F, 0x03,
  0xE0, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x03, 0xE0, 0xF8,
  0x00, 0xFC, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x03, 0xE1, 0xF8, 0x01, 0xF8,
  0x03, 0xE3, 0xF0, 0x01, 0xF0, 0x03, 0xF7, 0xE0, 0x03, 0xF0, 0x03, 0xFF,
  0xE0, 0x03, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7E, 0x3F,
  0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x7F, 0x03, 0xFF, 0xE0, 0xFE, 0x07, 0xFF, 0xF0, 0xFE, 0x0F, 0xEF, 0xF0,
  0xFE, 0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0xC7, 0xF9, 0xFC, 0x3F, 0x83, 0xFB,
  0xF8, 0x7F, 0x03, 0xFB, 0xF8, 0x7F, 0x03, 0xFF, 0xF0, 0x7F, 0x01, 0xFF,
  0xF0, 0xFE, 0x01, 0xFF, 0xE0, 0xFE, 0x01, 0xFF, 0xE0, 0xFE, 0x00, 0xFF,
  0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xDF, 0xE0, 0x3F, 0xFF, 0x9F,
  0xE0, 0x1F, 0xFF, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF0, 0x01, 0xC0, 0x00,
  0x00, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x9F, 0xE7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x04, 0x0F,
  0xC0, 0x1E, 0x1F, 0x80, 0x3F, 0x3F, 0x02, 0x7F, 0xFE, 0x3D, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0x7F, 0x03, 0xFC, 0x7E, 0x03, 0xF0, 0xFE, 0x03, 0xE1, 0xFE, 0x03,
  0x81, 0xF8, 0x02, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFF,
  0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0x1F,
  0xDF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7E, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFC,
  0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03,
  0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x7F,
  0x80, 0x7F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x3F,
  0x8F, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0xC7, 0xF0,
  0x07, 0xF9, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF8,
  0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0xFF, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFF, 0x0F,
  0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x1F,
  0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x7F, 0xC0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF,
  0xFE, 0x7F, 0xDF, 0xCF, 0xF3, 0xF8, 0xFC, 0xFF, 0x1E, 0x1F, 0xC1, 0x83,
  0xF8, 0x20, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xE1, 0xFF, 0x00,
  0x7E, 0x03, 0xFC, 0x00, 0xF0, 0x0F, 0xF0, 0x03, 0x00, 0x3F, 0xC0, 0x08,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0x83, 0xFE, 0x00, 0x38, 0x07, 0xFC, 0x00, 0x80, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x80, 0x01, 0xFF, 0x03, 0x00, 0x0F, 0xF8, 0x0F, 0x00,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x1F, 0x3F, 0x80, 0x00, 0x7C,
  0xFC, 0x00, 0x03, 0xE7, 0xF0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x7C, 0x7F,
  0x00, 0x03, 0xE1, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7C, 0x3F, 0x80,
  0x03, 0xF0, 0xFE, 0x00, 0x0F, 0x83, 0xF8, 0x00, 0x7C, 0x0F, 0xE0, 0x03,
  0xF0, 0x7F, 0x00, 0x0F, 0x81, 0xFC, 0x00, 0x7C, 0x07, 0xF0, 0x03, 0xF0,
  0x1F, 0xC0, 0x0F, 0x80, 0xFF, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xEF, 0xFF, 0x00,
  0x10, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x10, 0x00, 0x7F, 0xC0, 0xC0, 0x07, 0xFC, 0x07, 0x80, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFE, 0x02, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC1, 0xE0, 0x01, 0xFC, 0xFF,
  0x80, 0x3F, 0x9F, 0xFC, 0x03, 0xFB, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE,
  0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE,
  0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xC1, 0xFF, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0,
  0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x8F,
  0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0x9F,
  0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFC,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x01,
  0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x07, 0xF0,
  0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF1, 0xFE, 0x01, 0xFE,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x7F,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F,
  0xF0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x03, 0xFE, 0x0F,
  0xE0, 0x3F, 0xE0, 0xFE, 0x07, 0xFE, 0x0F, 0xF0, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFD, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFB, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0x87, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x80, 0x3F, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x38, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x03, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xE0, 0xFF, 0x03, 0x00, 0xFE, 0x08, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x3F, 0x00, 0x10, 0x03, 0xE0, 0x7C, 0x03, 0xFF, 0x07, 0xC1,
  0xF0, 0x1F, 0xFF, 0x0F, 0x87, 0xE0, 0x7F, 0xFE, 0x1F, 0x0F, 0x81, 0xFF,
  0xFC, 0x3E, 0x1F, 0x03, 0xE1, 0xF8, 0x7C, 0x7C, 0x0F, 0x83, 0xE0, 0xF8,
  0xF8, 0x3F, 0x07, 0xC1, 0xF3, 0xE0, 0x7C, 0x0F, 0x83, 0xE7, 0xC1, 0xF0,
  0x3F, 0x07, 0xCF, 0x83, 0xE0, 0x7C, 0x0F, 0xBE, 0x07, 0xC0, 0xF8, 0x1F,
  0x7C, 0x1F, 0x03, 0xF0, 0x7C, 0xF8, 0x3E, 0x07, 0xE0, 0xF9, 0xF0, 0x7C,
  0x0F, 0x81, 0xF7, 0xE1, 0xF8, 0x1F, 0x03, 0xEF, 0x83, 0xE0, 0x7E, 0x0F,
  0x9F, 0x07, 0xC0, 0xFC, 0x1F, 0x3E, 0x0F, 0x81, 0xF0, 0x3C, 0x7C, 0x1F,
  0x07, 0xE0, 0xF8, 0xF8, 0x3E, 0x0F, 0xC1, 0xF1, 0xF0, 0x7C, 0x1F, 0x87,
  0xC3, 0xE0, 0xF8, 0x7F, 0x0F, 0x87, 0xC1, 0xF9, 0xFE, 0x3E, 0x0F, 0x83,
  0xFF, 0xBF, 0xF8, 0x1F, 0x07, 0xFE, 0x7F, 0xE0, 0x3E, 0x07, 0xF8, 0x7F,
  0x80, 0x7C, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0x00, 0x1F, 0xE0, 0x1F,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0x7E,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0x9F, 0x80,
  0x01, 0xFC, 0x7E, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F,
  0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x81,
  0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0xC0, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x03,
  0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF,
  0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xC3, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x00, 0xFF,
  0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F,
  0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC,
  0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xF8, 0x78, 0x00, 0xFF, 0xC0, 0x20, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x10, 0x00, 0xFF, 0xC1, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x74, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x03,
  0xFE, 0x03, 0xF8, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F,
  0xE0, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x07,
  0xF8, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x7F, 0x83, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xE1, 0xFC, 0x00, 0xFF, 0xC0, 0x0E, 0x00, 0x7F, 0xE0, 0x00, 0x80,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x20, 0xFF, 0x00, 0xFF, 0xF0, 0x7F,
  0x80, 0x7F, 0xFC, 0x1F, 0xE0, 0x1F, 0xFF, 0x07, 0xF8, 0x07, 0xFF, 0xC1,
  0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0x80, 0xFF, 0xF8, 0x1F, 0xE0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF8,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF8, 0x07, 0xF8, 0x03, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x41,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x0F,
  0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03,
  0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x03, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7,
  0xF0, 0x07, 0xF7, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0xBF,
  0x80, 0x1F, 0xDF, 0x80, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x00, 0xFC, 0xFE,
  0x00, 0x7E, 0x7E, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x07, 0xE7, 0xF8,
  0x03, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x3F, 0x1F, 0xC0,
  0x0F, 0xE7, 0xF0, 0x7E, 0x3F, 0x80, 0x3F, 0x8F, 0xE1, 0xF8, 0x7F, 0x00,
  0x7F, 0x1F, 0xC3, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0x01,
  0xFC, 0x3F, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0x7E, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFC, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFB, 0xF8, 0x7F, 0x00, 0x3F,
  0x83, 0xF7, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xEF, 0xC1, 0xFC, 0x00, 0xFC,
  0x0F, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xFE, 0x0F, 0xF0, 0x07, 0xF0,
  0x3F, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0xF0, 0x3F, 0x80, 0x1F, 0xC0,
  0xFF, 0xE0, 0x7F, 0x00, 0x3F, 0x01, 0xFF, 0x80, 0xFE, 0x00, 0xFE, 0x03,
  0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F,
  0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x07,
  0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0x00, 0x7F,
  0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0x80, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x01, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x1F, 0xFF,
  0x80, 0xFE, 0x00, 0x7E, 0x7E, 0x03, 0xF8, 0x01, 0xF9, 0xF8, 0x0F, 0xE0,
  0x0F, 0xE7, 0xE0, 0x3F, 0x80, 0x3F, 0x9F, 0x81, 0xFC, 0x00, 0xFE, 0x7F,
  0x07, 0xF0, 0x03, 0xF9, 0xFC, 0x1F, 0xC0, 0x0F, 0xC3, 0xF0, 0x7F, 0x00,
  0x7F, 0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0xFC,
  0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0xFE, 0x00, 0xFE, 0x0F, 0xE3, 0xF8, 0x03,
  0xF8, 0x1F, 0x8F, 0xE0, 0x0F, 0xE0, 0x7E, 0x7F, 0x00, 0x3F, 0x81, 0xF9,
  0xFC, 0x00, 0xFC, 0x07, 0xE7, 0xF0, 0x07, 0xF0, 0x1F, 0xDF, 0xC0, 0x1F,
  0xC0, 0x7F, 0x7E, 0x00, 0x7F, 0x00, 0xFD, 0xF8, 0x01, 0xFC, 0x03, 0xFF,
  0xE0, 0x07, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0xF0, 0x03, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xF8,
  0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC7, 0xFE,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x3F,
  0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x3F,
  0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x2F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0x81,
  0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFE,
  0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x3F, 0x80, 0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x07, 0xFE, 0x03,
  0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x80,
  0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x1F,
  0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE,
  0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xF3, 0xFF, 0xC0, 0x3F,
  0xC1, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x07,
  0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xFC,
  0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x03,
  0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0xC0, 0x7F, 0x8F, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x3F,
  0xC1, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F,
  0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE,
  0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0xF0, 0x03, 0xFE, 0x00, 0x40, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x20, 0x00, 0x7F, 0x80, 0x60, 0x01, 0xFE, 0x00, 0xF0,
  0x07, 0xFC, 0x03, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F,
  0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xF0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x3F,
  0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0,
  0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x1F, 0xC0,
  0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07,
  0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xE0,
  0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F, 0xF0,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xEF,
  0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x7F, 0x9F, 0xC0,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F,
  0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x83,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x80, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC,
  0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF9, 0xFC,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x3F, 0xBF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF7, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xC7, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xF8, 0x03,
  0xF8, 0x7F, 0x00, 0x7F, 0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0x87, 0xF0, 0x0F, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0xFF, 0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xFF, 0x00, 0xFE, 0x07,
  0xF0, 0x1F, 0xFC, 0x07, 0xF8, 0x1F, 0x80, 0xFF, 0xF0, 0x1F, 0xC0, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xFF, 0x03, 0xFC, 0x0F, 0xE0,
  0x7E, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFB, 0xF0, 0x7F, 0x80, 0xFE, 0x0F,
  0xEF, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0xFC,
  0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xE3, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0x8F,
  0xC3, 0xF8, 0x03, 0xF8, 0x7E, 0x3F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF0, 0xFC,
  0x7F, 0x00, 0x3F, 0x8F, 0xC3, 0xF3, 0xFC, 0x00, 0xFE, 0x7F, 0x0F, 0xCF,
  0xE0, 0x03, 0xF9, 0xF8, 0x3F, 0x3F, 0x80, 0x0F, 0xE7, 0xE0, 0xFD, 0xFC,
  0x00, 0x3F, 0xBF, 0x03, 0xF7, 0xF0, 0x00, 0xFE, 0xFC, 0x0F, 0xDF, 0xC0,
  0x03, 0xFF, 0xF0, 0x3E, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0xFB, 0xF8, 0x00,
  0x3F, 0x7E, 0x03, 0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xFC, 0x7F,
  0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0,
  0x07, 0xF1, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0,
  0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x83,
  0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01,
  0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x01, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x03, 0xF0, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x3F,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x01,
  0xFC, 0x1F, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1,
  0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0x7F, 0x7E, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F,
  0x87, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF,
  0x0F, 0xC0, 0x1F, 0xFC, 0xFE, 0x01, 0xFF, 0xF7, 0xF0, 0x1F, 0xFF, 0xBF,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFD, 0xFF, 0xC0, 0xFF, 0x87, 0xFE, 0x07,
  0xF8, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xC0,
  0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F,
  0x07, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFE, 0x1F,
  0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x3F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F,
  0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFE, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x01, 0xFE, 0x1F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFE, 0xFC, 0x03, 0xFF, 0xF7, 0xE0, 0x0F, 0xFF, 0x3F,
  0x00, 0x3F, 0xF1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x3F, 0x00, 0x1F, 0xC7, 0xF8, 0x01, 0xFD, 0xFF, 0xC0,
  0x1F, 0xDF, 0xFE, 0x01, 0xFB, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0x9F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x7F, 0xC0, 0x7F,
  0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0xFE, 0x1F,
  0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xE1, 0xFC, 0x01,
  0xFC, 0x3F, 0xC0, 0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x83,
  0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0xE1,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0xFC, 0xFF, 0xF8, 0x0F, 0xC7, 0xFE, 0x00, 0xFC, 0x3F, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0x3C, 0x07,
  0xFC, 0x04, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x40, 0x7F, 0x81, 0xC0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x83, 0xF8, 0x00, 0x3F, 0xE3, 0xF8,
  0x00, 0x7F, 0xF3, 0xF8, 0x00, 0xFF, 0xFB, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x7F, 0xF0, 0x07, 0xF8, 0x3F, 0xF0,
  0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0,
  0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80,
  0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0xDF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0xFC, 0x00, 0x3F, 0xFC, 0xFC, 0x00,
  0x1F, 0xF8, 0xFC, 0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0,
  0x3F, 0x07, 0xF0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE3, 0xF8,
  0x07, 0xF1, 0xFC, 0x03, 0xF9, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0x7F,
  0x07, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0xC0, 0xFF, 0x81, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0x08, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0C, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0x00, 0x0F, 0xFE, 0x7F,
  0x00, 0x1F, 0xFF, 0x7F, 0x00, 0x3F, 0xFF, 0x7E, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xEF, 0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x03, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xF8,
  0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF8,
  0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0,
  0x0F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xBF, 0x80, 0x03, 0xFF, 0x3F, 0x80,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x60, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x80, 0x03, 0xFC, 0x00,
  0xE0, 0x03, 0xFC, 0x00, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x3F,
  0x00, 0x1F, 0xCF, 0xFC, 0x01, 0xFD, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFB, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xF0,
  0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFC,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xC1, 0xFC,
  0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x3F,
  0x83, 0xF8, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x7F,
  0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7C,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xBF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x3F,
  0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0xC0,
  0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07,
  0xF1, 0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFD,
  0xFC, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xF7, 0xF0, 0x00,
  0x7F, 0x9F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0xC0,
  0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7E, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F,
  0x9F, 0xFC, 0x7F, 0xF8, 0x07, 0xEF, 0xFF, 0xBF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFB, 0xFF, 0xE7,
  0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xC0,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x01,
  0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x87, 0xF8, 0x01, 0xF9,
  0xFF, 0xC0, 0x1F, 0xBF, 0xFE, 0x01, 0xF3, 0xFF, 0xE0, 0x3F, 0x7F, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x81,
  0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF8, 0x3F, 0x80,
  0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xF0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xF3, 0xFE, 0x1F,
  0xE0, 0xFF, 0x1F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE7,
  0xF8, 0x07, 0xF3, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0xFE,
  0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFB, 0xF8, 0x01,
  0xFD, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80,
  0x7F, 0x9F, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F, 0xC7, 0xF0, 0x3F, 0xC3, 0xFC,
  0x3F, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x87, 0xFC, 0x00, 0x1F, 0x9F, 0xFC,
  0x00, 0x1F, 0x9F, 0xFE, 0x00, 0x1F, 0xBF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8,
  0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF0,
  0x07, 0xFE, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xEF, 0xFF, 0x80, 0x0F, 0xEF, 0xFF, 0x80, 0x0F, 0xE7, 0xFF, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x0F, 0xE0, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0x8F, 0xC0, 0x1F, 0xFC, 0xFE, 0x01, 0xFF, 0xF7, 0xF0, 0x1F,
  0xFF, 0xBF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF9, 0xFF, 0xC0, 0xFF, 0x07,
  0xFE, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x03, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF,
  0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8,
  0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF,
  0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x01, 0xFE, 0x1F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0x7F, 0x00, 0x3F, 0xF3, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xC1,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0xFE, 0x01, 0xF9, 0xFE, 0x01, 0xFB, 0xFE, 0x01, 0xFB, 0xFE,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xF0, 0x78, 0x0F, 0xF0,
  0x08, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x06, 0x00, 0x7F, 0x83, 0xC0, 0x7F,
  0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xC0, 0x07, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03,
  0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F,
  0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0,
  0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x0F, 0xF0,
  0x7F, 0x03, 0xFE, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x7E, 0x01,
  0xFF, 0xCF, 0xC0, 0x1F, 0xE1, 0xF8, 0x00, 0x70, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0,
  0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F,
  0xE0, 0xFE, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80,
  0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xC0, 0x1F, 0xCF, 0xE0,
  0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x00,
  0xFE, 0x7F, 0x01, 0xFF, 0x00, 0xFE, 0x7F, 0x01, 0xFF, 0x01, 0xFC, 0x7F,
  0x01, 0xFF, 0x01, 0xFC, 0x7F, 0x03, 0xFF, 0x01, 0xF8, 0x7F, 0x03, 0xFF,
  0x03, 0xF8, 0x7F, 0x07, 0xFF, 0x03, 0xF8, 0x7F, 0x07, 0xFF, 0x07, 0xF0,
  0x7F, 0x07, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xFF, 0x07, 0xE0, 0x7F, 0x0F,
  0xFF, 0x0F, 0xE0, 0x7F, 0x1F, 0xBF, 0x0F, 0xE0, 0x7F, 0x1F, 0xBF, 0x1F,
  0xC0, 0x7F, 0x1F, 0x3F, 0x1F, 0xC0, 0x7F, 0x3F, 0x3F, 0x1F, 0x80, 0x7E,
  0x3F, 0x3F, 0x3F, 0x80, 0x7E, 0x3E, 0x3F, 0x3F, 0x80, 0x7E, 0x7E, 0x3F,
  0x3F, 0x00, 0x7E, 0x7E, 0x3F, 0x7F, 0x00, 0x7E, 0xFC, 0x3E, 0x7E, 0x00,
  0x7E, 0xFC, 0x3E, 0x7E, 0x00, 0x7E, 0xF8, 0x3E, 0xFE, 0x00, 0x7F, 0xF8,
  0x3E, 0xFC, 0x00, 0x7F, 0xF8, 0x3E, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF8,
  0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x7F,
  0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x03,
  0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x07,
  0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFF,
  0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0xC0, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x87, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xBF, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x4F, 0xFC, 0x00, 0x17, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xA0, 0x00, 0x7F, 0x88,
  0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 18, 49, 16, 0, -48 },
  { 112, 22, 17, 25, 6, -48 },
  { 159, 32, 48, 31, 0, -48 },
  { 351, 29, 55, 28, 0, -51 },
  { 551, 40, 50, 45, 3, -49 },
  { 801, 32, 49, 32, 0, -48 },
  { 997, 10, 17, 15, 7, -48 },
  { 1019, 22, 59, 18, 1, -48 },
  { 1182, 21, 60, 18, -5, -49 },
  { 1340, 23, 25, 26, 6, -51 },
  { 1412, 26, 32, 30, 3, -40 },
  { 1516, 13, 17, 15, -3, -8 },
  { 1544, 16, 7, 19, 1, -22 },
  { 1558, 9, 10, 15, 0, -9 },
  { 1570, 32, 48, 24, -3, -48 },
  { 1762, 27, 50, 28, 1, -49 },
  { 1931, 19, 48, 28, 7, -48 },
  { 2045, 30, 49, 28, -2, -49 },
  { 2229, 30, 50, 28, -1, -49 },
  { 2417, 30, 48, 28, -1, -48 },
  { 2597, 29, 49, 28, 0, -48 },
  { 2775, 28, 50, 28, 2, -49 },
  { 2950, 29, 48, 28, 2, -48 },
  { 3124, 29, 50, 28, 0, -49 },
  { 3306, 28, 50, 28, 0, -49 },
  { 3481, 15, 38, 15, 0, -37 },
  { 3553, 19, 46, 15, -4, -37 },
  { 3663, 26, 31, 30, 3, -39 },
  { 3764, 26, 19, 30, 3, -33 },
  { 3826, 26, 31, 30, 3, -39 },
  { 3927, 23, 50, 21, 1, -49 },
  { 4071, 39, 54, 42, 2, -48 },
  { 4335, 30, 48, 30, -4, -48 },
  { 4515, 31, 48, 31, 0, -48 },
  { 4701, 31, 50, 28, 2, -49 },
  { 4895, 33, 48, 33, 0, -48 },
  { 5093, 29, 48, 26, 0, -48 },
  { 5267, 29, 48, 25, 0, -48 },
  { 5441, 34, 50, 34, 2, -49 },
  { 5654, 36, 48, 34, 0, -48 },
  { 5870, 28, 48, 20, -3, -48 },
  { 6038, 28, 62, 15, -10, -48 },
  { 6255, 35, 48, 29, 0, -48 },
  { 6465, 20, 48, 25, 0, -48 },
  { 6585, 47, 48, 45, 0, -48 },
  { 6867, 38, 48, 36, 0, -48 },
  { 7095, 33, 50, 35, 2, -49 },
  { 7302, 31, 48, 29, 0, -48 },
  { 7488, 33, 60, 35, 2, -49 },
  { 7736, 30, 48, 30, 0, -48 },
  { 7916, 31, 50, 27, -1, -49 },
  { 8110, 25, 48, 25, 5, -48 },
  { 8260, 34, 49, 33, 2, -48 },
  { 8469, 29, 48, 30, 6, -48 },
  { 8643, 46, 48, 46, 5, -48 },
  { 8919, 37, 48, 28, -4, -48 },
  { 9141, 27, 48, 27, 6, -48 },
  { 9303, 32, 48, 25, -3, -48 },
  { 9495, 26, 59, 19, -2, -48 },
  { 9687, 12, 48, 24, 7, -48 },
  { 9759, 26, 59, 19, -5, -48 },
  { 9951, 28, 28, 28, 0, -48 },
  { 10049, 22, 4, 21, -6, 6 },
  { 10060, 11, 10, 19, 10, -51 },
  { 10074, 29, 38, 30, 1, -37 },
  { 10212, 28, 52, 30, 0, -51 },
  { 10394, 24, 38, 23, 1, -37 },
  { 10508, 32, 52, 30, 1, -51 },
  { 10716, 25, 38, 27, 1, -37 },
  { 10835, 33, 67, 17, -8, -51 },
  { 11112, 32, 53, 30, -2, -37 },
  { 11324, 28, 51, 30, 0, -51 },
  { 11503, 17, 50, 14, 0, -50 },
  { 11610, 26, 66, 14, -9, -50 },
  { 11825, 30, 51, 27, 0, -51 },
  { 12017, 18, 51, 14, 0, -51 },
  { 12132, 42, 37, 43, 0, -37 },
  { 12327, 28, 37, 30, 0, -37 },
  { 12457, 25, 38, 29, 2, -37 },
  { 12576, 32, 53, 30, -4, -37 },
  { 12788, 29, 53, 30, 1, -37 },
  { 12981, 24, 37, 20, 0, -37 },
  { 13092, 25, 38, 23, -1, -37 },
  { 13211, 18, 45, 18, 2, -44 },
  { 13313, 27, 37, 29, 2, -36 },
  { 13438, 25, 36, 25, 4, -36 },
  { 13551, 40, 36, 39, 3, -36 },
  { 13731, 31, 36, 26, -3, -36 },
  { 13871, 35, 52, 25, -6, -36 },
  { 14099, 26, 36, 21, -3, -36 },
  { 14216, 26, 59, 22, 1, -48 },
  { 14408, 6, 66, 25, 9, -51 },
  { 14458, 25, 59, 22, -4, -48 },
  { 14643, 26, 11, 30, 3, -29 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC67PT7B_H_
