#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC7PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x58, 0x80, 0xF0, 0x7D, 0xFC, 0x79, 0x3C, 0x5E, 0xF7, 0x50, 0x6D,
  0xDE, 0xC0, 0x5A, 0xA0, 0x24, 0x95, 0x80, 0xF0, 0x5D, 0x00, 0xC0, 0xC0,
  0x80, 0x29, 0x48, 0x76, 0xDC, 0x6A, 0x80, 0x65, 0x2C, 0x65, 0x1C, 0x2E,
  0xF4, 0x6B, 0x9C, 0x6A, 0xDC, 0x65, 0x28, 0x6D, 0x5C, 0x77, 0x9C, 0x42,
  0x42, 0x80, 0x39, 0x80, 0xE3, 0x80, 0xC7, 0x00, 0x45, 0x48, 0x7B, 0xFF,
  0x86, 0x6E, 0xFA, 0x6D, 0xDC, 0x6A, 0x4C, 0x6E, 0xDC, 0x69, 0xCC, 0x69,
  0x48, 0x74, 0xAA, 0xE0, 0x55, 0x6A, 0xA0, 0x69, 0x4C, 0x25, 0x25, 0x80,
  0x76, 0x4C, 0xA0, 0x5A, 0xC0, 0x4A, 0xF5, 0x6B, 0x00, 0x55, 0xDA, 0xA0,
  0x65, 0x9A, 0xE0, 0x6D, 0xC8, 0x65, 0x9A, 0xE6, 0x6D, 0xEA, 0x71, 0x1C,
  0x69, 0x28, 0x56, 0xAA, 0xE0, 0xBB, 0x48, 0xAD, 0x7A, 0xAD, 0x00, 0x6D,
  0x6C, 0xFA, 0x80, 0x69, 0x4C, 0x5A, 0xA0, 0xF8, 0x55, 0xA0, 0x4E, 0x80,
  0xE0, 0x80, 0x76, 0xE0, 0x4E, 0xDC, 0x72, 0x60, 0x2E, 0xDC, 0x77, 0x60,
  0x36, 0x44, 0x44, 0x80, 0x76, 0xE5, 0x80, 0x4E, 0xDA, 0x5A, 0x80, 0x25,
  0x24, 0xA0, 0x4D, 0x6C, 0x5A, 0x80, 0x7B, 0xBD, 0x76, 0xD0, 0x76, 0xE0,
  0x76, 0xE9, 0x00, 0x76, 0xE4, 0x80, 0x6A, 0x71, 0x60, 0x7A, 0x80, 0x76,
  0xE0, 0xB7, 0x20, 0xBB, 0xFA, 0xA9, 0x60, 0x55, 0x22, 0x48, 0xDB, 0x69,
  0x49, 0x80, 0xFE, 0x55, 0xA0, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 2, 2, 3, 1, -5 },
  { 4, 3, 5, 3, 0, -5 },
  { 6, 3, 5, 3, 0, -5 },
  { 8, 4, 5, 5, 0, -5 },
  { 11, 3, 5, 3, 0, -5 },
  { 13, 1, 2, 2, 1, -5 },
  { 14, 2, 6, 2, 0, -5 },
  { 16, 3, 6, 2, -1, -5 },
  { 19, 2, 2, 3, 1, -5 },
  { 20, 3, 3, 3, 0, -4 },
  { 22, 1, 2, 2, 0, -1 },
  { 23, 2, 1, 2, 0, -2 },
  { 24, 1, 1, 2, 0, -1 },
  { 25, 3, 5, 3, 0, -5 },
  { 27, 3, 5, 3, 0, -5 },
  { 29, 2, 5, 3, 1, -5 },
  { 31, 3, 5, 3, 0, -5 },
  { 33, 3, 5, 3, 0, -5 },
  { 35, 3, 5, 3, 0, -5 },
  { 37, 3, 5, 3, 0, -5 },
  { 39, 3, 5, 3, 0, -5 },
  { 41, 3, 5, 3, 0, -5 },
  { 43, 3, 5, 3, 0, -5 },
  { 45, 3, 5, 3, 0, -5 },
  { 47, 2, 4, 2, 0, -4 },
  { 48, 2, 5, 2, 0, -4 },
  { 50, 3, 3, 3, 0, -4 },
  { 52, 3, 3, 3, 0, -4 },
  { 54, 3, 3, 3, 0, -4 },
  { 56, 3, 5, 2, 0, -5 },
  { 58, 4, 6, 4, 0, -5 },
  { 61, 3, 5, 3, 0, -5 },
  { 63, 3, 5, 3, 0, -5 },
  { 65, 3, 5, 3, 0, -5 },
  { 67, 3, 5, 3, 0, -5 },
  { 69, 3, 5, 3, 0, -5 },
  { 71, 3, 5, 3, 0, -5 },
  { 73, 4, 5, 4, 0, -5 },
  { 76, 4, 5, 4, 0, -5 },
  { 79, 3, 5, 2, 0, -5 },
  { 81, 3, 6, 2, -1, -5 },
  { 84, 4, 5, 3, 0, -5 },
  { 87, 2, 5, 3, 0, -5 },
  { 89, 5, 5, 5, 0, -5 },
  { 93, 4, 5, 4, 0, -5 },
  { 96, 4, 5, 4, 0, -5 },
  { 99, 3, 5, 3, 0, -5 },
  { 101, 4, 6, 4, 0, -5 },
  { 104, 3, 5, 3, 0, -5 },
  { 106, 3, 5, 3, 0, -5 },
  { 108, 3, 5, 3, 0, -5 },
  { 110, 4, 5, 4, 0, -5 },
  { 113, 3, 5, 3, 1, -5 },
  { 115, 5, 5, 5, 0, -5 },
  { 119, 3, 5, 3, 0, -5 },
  { 121, 2, 5, 3, 1, -5 },
  { 123, 3, 5, 3, 0, -5 },
  { 125, 2, 6, 2, 0, -5 },
  { 127, 1, 5, 3, 1, -5 },
  { 128, 2, 6, 2, 0, -5 },
  { 130, 3, 3, 3, 0, -5 },
  { 132, 3, 1, 2, -1, 0 },
  { 133, 1, 1, 2, 1, -5 },
  { 134, 3, 4, 3, 0, -4 },
  { 136, 3, 5, 3, 0, -5 },
  { 138, 3, 4, 2, 0, -4 },
  { 140, 3, 5, 3, 0, -5 },
  { 142, 3, 4, 3, 0, -4 },
  { 144, 4, 7, 2, -1, -5 },
  { 148, 3, 6, 3, 0, -4 },
  { 151, 3, 5, 3, 0, -5 },
  { 153, 2, 5, 2, 0, -5 },
  { 155, 3, 7, 2, -1, -5 },
  { 158, 3, 5, 3, 0, -5 },
  { 160, 2, 5, 1, 0, -5 },
  { 162, 4, 4, 5, 0, -4 },
  { 164, 3, 4, 3, 0, -4 },
  { 166, 3, 4, 3, 0, -4 },
  { 168, 3, 6, 3, 0, -4 },
  { 171, 3, 6, 3, 0, -4 },
  { 174, 2, 4, 2, 0, -4 },
  { 175, 3, 4, 2, 0, -4 },
  { 177, 2, 5, 2, 0, -5 },
  { 179, 3, 4, 3, 0, -4 },
  { 181, 3, 4, 3, 0, -4 },
  { 183, 4, 4, 4, 0, -4 },
  { 185, 3, 4, 3, 0, -4 },
  { 187, 4, 6, 3, -1, -4 },
  { 190, 2, 4, 2, 0, -4 },
  { 191, 3, 6, 2, 0, -5 },
  { 194, 1, 7, 3, 1, -5 },
  { 195, 2, 6, 2, 0, -5 },
  { 197, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic7pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC7PT7B_H_
