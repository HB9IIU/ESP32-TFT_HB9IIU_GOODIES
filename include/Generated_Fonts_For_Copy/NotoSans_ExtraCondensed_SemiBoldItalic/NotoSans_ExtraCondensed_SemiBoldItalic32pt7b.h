#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC32PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0E,
  0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x0F,
  0x07, 0x83, 0xC0, 0x79, 0xDE, 0x77, 0x3D, 0xCF, 0x73, 0x9C, 0xEE, 0x3B,
  0x8C, 0x01, 0xCE, 0x03, 0x9C, 0x06, 0x30, 0x1C, 0xE0, 0x39, 0xC0, 0x63,
  0x07, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x0C, 0x60, 0x39, 0xC0, 0x63, 0x80,
  0xC6, 0x03, 0x9C, 0x3F, 0xFE, 0x7F, 0xFC, 0x39, 0xC0, 0x73, 0x80, 0xC6,
  0x03, 0x9C, 0x07, 0x38, 0x0C, 0x60, 0x39, 0xC0, 0x00, 0x00, 0x60, 0x01,
  0x00, 0x1F, 0x01, 0xFF, 0x0F, 0xF8, 0x7E, 0xE1, 0xC8, 0x87, 0x20, 0x1D,
  0x80, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0xBC, 0x02, 0xF0, 0x0B, 0xC4, 0x6F, 0x3F, 0xF8, 0xFF, 0xC3, 0xFE, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x1E, 0x03, 0x0F, 0xC1, 0xC3,
  0x70, 0xE1, 0xCC, 0x38, 0x63, 0x1C, 0x38, 0xC7, 0x0E, 0x73, 0x83, 0x1C,
  0xC0, 0xC7, 0x70, 0x31, 0x98, 0xEC, 0xEE, 0xFF, 0xF3, 0x3F, 0xFD, 0xDC,
  0xDE, 0x66, 0x30, 0x3B, 0x8C, 0x0C, 0xE3, 0x07, 0x39, 0xC3, 0x8C, 0x70,
  0xE3, 0x18, 0x70, 0xCE, 0x1C, 0x33, 0x8E, 0x0F, 0xC3, 0x01, 0xE0, 0x01,
  0xF0, 0x07, 0xF0, 0x1D, 0xE0, 0x79, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x9C,
  0x07, 0x38, 0x0F, 0xE0, 0x1F, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0xF8, 0xE7,
  0x7B, 0xDC, 0xF7, 0x78, 0xFE, 0xF1, 0xF9, 0xC3, 0xF3, 0x83, 0xC7, 0x8F,
  0x8F, 0xFF, 0x8F, 0xFF, 0x1F, 0x9F, 0x00, 0x7B, 0xDE, 0xE7, 0x3B, 0x9C,
  0x03, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x1E,
  0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x3C,
  0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0x80, 0x08, 0x01,
  0xE0, 0x38, 0x27, 0x0F, 0xE7, 0xFF, 0xCF, 0xF8, 0xF0, 0x3F, 0x0F, 0xE3,
  0xCE, 0x11, 0xC0, 0x20, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x38, 0x71, 0xE3, 0x8F, 0x1C, 0x78,
  0x7F, 0x7F, 0xFF, 0x77, 0xFD, 0xE0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF1, 0xE7, 0x1C, 0x73,
  0xC7, 0x38, 0x77, 0x87, 0x78, 0x77, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE,
  0x0E, 0xE1, 0xEE, 0x1E, 0xE1, 0xCE, 0x3C, 0xE3, 0xCE, 0x78, 0xFF, 0x0F,
  0xF0, 0x7C, 0x00, 0x03, 0xC1, 0xE0, 0xF8, 0x7E, 0x3F, 0xBF, 0xC7, 0x71,
  0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C,
  0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x80, 0x01, 0xF0, 0x1F, 0xF0,
  0xFF, 0xC3, 0x8F, 0x04, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0,
  0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE,
  0x00, 0x03, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0x1F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x07, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x20, 0xF8,
  0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x37, 0x01, 0xDC, 0x06, 0xF0, 0x3B, 0xC1,
  0xCE, 0x06, 0x38, 0x38, 0xE1, 0xC7, 0x86, 0x1E, 0x3F, 0xFE, 0xFF, 0xF3,
  0xFF, 0xC0, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x00, 0x07,
  0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x20, 0xF8, 0xFF, 0xC3,
  0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x1E, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x79, 0x83, 0xBE, 0x1F, 0xF9, 0xFB, 0xCF,
  0x0E, 0x78, 0x73, 0xC3, 0x9C, 0x1C, 0xE1, 0xE7, 0x0F, 0x38, 0x71, 0xE7,
  0x8F, 0xF8, 0x3F, 0xC0, 0xF8, 0x00, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x03,
  0xF0, 0x1F, 0xE0, 0xFF, 0x87, 0x8F, 0x1C, 0x3C, 0x70, 0xF1, 0xC3, 0x87,
  0x1E, 0x1E, 0x70, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0xF7, 0x87,
  0x8E, 0x3C, 0x3C, 0xF0, 0xF3, 0x83, 0xCE, 0x0F, 0x3C, 0x38, 0xFF, 0xE1,
  0xFF, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0xFE, 0x3C, 0xF1, 0xC3,
  0x9E, 0x1C, 0xF0, 0xE7, 0x07, 0x38, 0x79, 0xC3, 0xCE, 0x3E, 0x79, 0xF3,
  0xFF, 0x0F, 0xB8, 0x3B, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x8F, 0xF8, 0x7F, 0x83, 0xF0, 0x00, 0x04, 0x3C, 0x78, 0xF1, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x78, 0xF1, 0xE0, 0x01, 0x01,
  0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x38, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x07, 0x80, 0x00,
  0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x1E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1C, 0x00, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00, 0x3E, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x80,
  0x70, 0x02, 0x00, 0x00, 0x1F, 0x87, 0xF8, 0xFF, 0x10, 0xF0, 0x1E, 0x03,
  0x80, 0x70, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x0C,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0x0E, 0x03, 0x80, 0xE0, 0xE0, 0x0C,
  0x38, 0x01, 0xC6, 0x1F, 0x39, 0xC7, 0xE7, 0x31, 0xCC, 0xEE, 0x73, 0x9D,
  0x8C, 0x73, 0xB3, 0x8C, 0x6E, 0x71, 0x8D, 0xCC, 0x71, 0xB1, 0x8E, 0x66,
  0x31, 0x8C, 0xC6, 0x73, 0x18, 0xFF, 0xE3, 0x1E, 0x78, 0x60, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x04, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0xE0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07,
  0x70, 0x1D, 0xC0, 0xF7, 0x03, 0x9C, 0x0E, 0x70, 0x79, 0xC1, 0xC7, 0x0F,
  0x1C, 0x3C, 0x70, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0xF0, 0x73, 0xC1, 0xDE,
  0x07, 0x78, 0x1D, 0xC0, 0x7F, 0x01, 0xC0, 0x07, 0xF0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x79, 0xF0, 0xE1, 0xE1, 0xC3, 0xC7, 0x87, 0x8F, 0x0E, 0x1E, 0x3C,
  0x38, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0x07, 0x0F, 0x0E, 0x1E, 0x1C,
  0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xC1, 0xE3, 0x87, 0x8F, 0xFE, 0x1F, 0xF8,
  0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x7C, 0x41, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC2, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0x7E, 0x0F, 0x1E, 0x0E, 0x1E, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0E, 0x1C, 0x0E, 0x1C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x38, 0x3C, 0x38, 0x3C, 0x78, 0x3C, 0x78, 0x78, 0x78,
  0xF8, 0x73, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x3F,
  0xF0, 0xFF, 0x83, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xFF, 0xC3, 0xFE, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0x07,
  0xFF, 0x0F, 0x86, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0xFE, 0x70, 0xFC, 0xF0, 0xFC, 0xF0, 0xFC, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0x78, 0x78, 0x78, 0x7F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x07, 0x03, 0x87, 0x83, 0xC3, 0xC1, 0xE1,
  0xE0, 0xF0, 0xE0, 0x70, 0x70, 0x38, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F,
  0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xE0, 0xF0, 0xE0,
  0x70, 0x70, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0E, 0x0E, 0x07, 0x0F,
  0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE0, 0x0F, 0xF8, 0x7F, 0xC1, 0xF8, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x10, 0x00, 0x07, 0x07, 0x83,
  0x87, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0xE3, 0xC0, 0x73, 0xC0, 0x79, 0xE0,
  0x3D, 0xE0, 0x1D, 0xE0, 0x0E, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xEE, 0x00, 0xE7, 0x00, 0x73, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1C,
  0x38, 0x0E, 0x1C, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0xC0, 0x07, 0x03,
  0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xFF,
  0xFF, 0xEF, 0xF8, 0x07, 0x80, 0x7E, 0x0F, 0x00, 0xF8, 0x3F, 0x01, 0xF0,
  0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0E,
  0xE1, 0xDC, 0x1D, 0xC3, 0xF8, 0x3B, 0x8F, 0xF0, 0x77, 0x1D, 0xC1, 0xEE,
  0x3B, 0x83, 0x9C, 0xE7, 0x07, 0x39, 0xDE, 0x0E, 0x77, 0x3C, 0x1C, 0xEE,
  0x70, 0x79, 0xF8, 0xE0, 0xE3, 0xF3, 0xC1, 0xC7, 0xC7, 0x83, 0x8F, 0x8E,
  0x0F, 0x1F, 0x1C, 0x1E, 0x3C, 0x38, 0x38, 0x78, 0xF0, 0x00, 0x07, 0x81,
  0xC1, 0xE0, 0x70, 0xF8, 0x3C, 0x3E, 0x0F, 0x0F, 0x83, 0x83, 0xF0, 0xE1,
  0xFC, 0x38, 0x77, 0x1E, 0x1D, 0xC7, 0x87, 0x71, 0xC1, 0xDC, 0x70, 0xF3,
  0x9C, 0x38, 0xEF, 0x0E, 0x3B, 0x83, 0x8E, 0xE0, 0xE3, 0xB8, 0x78, 0xFE,
  0x1C, 0x1F, 0x87, 0x07, 0xC1, 0xC1, 0xF0, 0xF0, 0x7C, 0x3C, 0x1F, 0x0E,
  0x07, 0xC0, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0x1E, 0x1E, 0x1E,
  0x1C, 0x0E, 0x3C, 0x0F, 0x38, 0x0F, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x1E,
  0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x78, 0xF0, 0x78, 0xF8, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0x80,
  0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x79, 0xF0, 0xE1, 0xE1, 0xC3, 0xC7,
  0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x38, 0x78, 0x70, 0xF1, 0xFF, 0xC3, 0xFF,
  0x07, 0xFC, 0x0F, 0xE0, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFC,
  0x07, 0xFE, 0x0F, 0x1E, 0x1E, 0x1E, 0x1C, 0x0E, 0x3C, 0x0F, 0x38, 0x0F,
  0x78, 0x0E, 0x78, 0x0E, 0x78, 0x1E, 0x70, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF8, 0xF0,
  0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0x79, 0xE0,
  0xE1, 0xC1, 0xC3, 0xC7, 0x87, 0x0F, 0x0E, 0x1E, 0x3C, 0x38, 0x78, 0x71,
  0xE1, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x0E, 0x70, 0x1C, 0xF0, 0x79, 0xE0,
  0xF3, 0xC1, 0xC3, 0x83, 0x87, 0x0F, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x00,
  0x01, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x7C, 0x60, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE1, 0x03, 0xC3,
  0x0F, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xFB, 0xFF, 0x9F,
  0xFC, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x0E, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0E, 0x1C, 0x1E, 0x1C, 0x1E, 0x3C, 0x1E,
  0x3C, 0x1C, 0x3C, 0x1C, 0x38, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x38,
  0x70, 0x38, 0x70, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0xF0, 0xF0,
  0xF1, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0xE0, 0x3F, 0x80, 0xEE,
  0x07, 0xB8, 0x1C, 0xE0, 0xF3, 0x83, 0xCE, 0x0E, 0x38, 0x78, 0xE1, 0xC3,
  0x8F, 0x0E, 0x38, 0x38, 0xE0, 0xE7, 0x83, 0x9C, 0x0E, 0xF0, 0x3B, 0x80,
  0xEE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x00, 0x70, 0x38, 0x1E, 0xE0, 0x70, 0x79, 0xC1, 0xE0, 0xF3, 0x83, 0xC1,
  0xC7, 0x0F, 0x87, 0x8E, 0x1F, 0x0E, 0x1C, 0x3E, 0x1C, 0x38, 0xFC, 0x78,
  0x71, 0xF8, 0xE0, 0xE7, 0x73, 0xC1, 0xCE, 0xE7, 0x03, 0x9D, 0xCE, 0x0F,
  0x73, 0xBC, 0x1E, 0xE7, 0x70, 0x3D, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE,
  0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0x83,
  0xE0, 0x1F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0xE1,
  0xE0, 0x38, 0x70, 0x0E, 0x3C, 0x03, 0x8E, 0x00, 0xF7, 0x00, 0x3F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1D, 0xC0, 0x0F, 0x70, 0x07, 0x9C,
  0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x38, 0x78, 0x1E, 0x1E, 0x0F, 0x07, 0x80,
  0xE0, 0x7F, 0x87, 0xBC, 0x39, 0xE3, 0xCF, 0x1C, 0x79, 0xE1, 0xCE, 0x0E,
  0xF0, 0x77, 0x03, 0xF8, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x03, 0xF0,
  0x3F, 0x07, 0xF0, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0xE3, 0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xF1, 0xC7, 0x1C, 0x71, 0xC0, 0x03, 0xF0,
  0x7F, 0x07, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x78, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x39, 0xC1, 0xCE, 0x1C, 0x71, 0xE3, 0x8E, 0x0E, 0xE0, 0x7F,
  0x03, 0x80, 0xFF, 0xFF, 0xF8, 0xF3, 0x9C, 0x73, 0x80, 0x06, 0x00, 0x7D,
  0xC7, 0xEE, 0x7D, 0xF3, 0xCF, 0xBC, 0x39, 0xC1, 0xDE, 0x1E, 0xF0, 0xF7,
  0x87, 0xB8, 0x39, 0xC1, 0xCE, 0x1E, 0x70, 0xF3, 0x8F, 0x9F, 0xF8, 0xFD,
  0xC3, 0xCE, 0x00, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE6, 0x07, 0xFE, 0x1D, 0xF8, 0x7D, 0xE1, 0xE3, 0xCF, 0x0F,
  0x3C, 0x3C, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x78, 0x79, 0xE1, 0xE7, 0x87,
  0x1E, 0x3C, 0x78, 0xE3, 0xFF, 0x8E, 0xFC, 0x3B, 0xE0, 0x03, 0x81, 0xFC,
  0x7F, 0x1F, 0x63, 0xC0, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x47, 0xF8, 0x7F, 0x0F, 0xC0, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x8E, 0x07,
  0xDC, 0x1F, 0xF8, 0x79, 0xF0, 0xE1, 0xE3, 0xC3, 0x87, 0x07, 0x0E, 0x1E,
  0x3C, 0x3C, 0x78, 0x78, 0xE0, 0xE1, 0xC1, 0xC3, 0x87, 0x87, 0x0F, 0x0E,
  0x3C, 0x1F, 0xF8, 0x3F, 0xF0, 0x3E, 0xE0, 0x03, 0x00, 0xFE, 0x1F, 0xE3,
  0xCF, 0x38, 0x77, 0x8F, 0x70, 0xEF, 0x1E, 0xFF, 0xCF, 0xF0, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x4F, 0xB8, 0x7F, 0x83, 0xF0, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0xBC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x07, 0xDC, 0x1F, 0xF8, 0x7D, 0xF0, 0xE1, 0xE3,
  0xC3, 0x87, 0x07, 0x0E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xE0, 0xE1, 0xC1,
  0xC3, 0x87, 0x87, 0x0F, 0x0E, 0x3E, 0x1F, 0xF8, 0x3F, 0x70, 0x3D, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x10, 0x3C, 0x38, 0xF0, 0x7F, 0xE0, 0xFF,
  0x80, 0x78, 0x00, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x39, 0x83, 0xFF, 0x1F, 0xF8, 0xFB, 0xC7, 0x8E, 0x78, 0x73, 0xC3,
  0x9E, 0x3C, 0xE1, 0xE7, 0x0E, 0x78, 0x73, 0xC3, 0x9C, 0x3C, 0xE1, 0xE7,
  0x0E, 0x78, 0x73, 0xC7, 0x9C, 0x3C, 0x07, 0x0F, 0x0F, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78,
  0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0xBC, 0x0F, 0xC0, 0xF8, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x8F, 0x1C, 0x78, 0x71, 0xC1,
  0xCE, 0x07, 0x78, 0x3F, 0xC0, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81,
  0xEF, 0x07, 0x3C, 0x1C, 0x70, 0x71, 0xC3, 0xC7, 0x8E, 0x1E, 0x38, 0x78,
  0x07, 0x83, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07,
  0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x07,
  0x83, 0xC1, 0xC0, 0x00, 0x60, 0xC1, 0xDF, 0xBE, 0x1F, 0xFF, 0xF1, 0xF7,
  0xEF, 0x1E, 0x3C, 0x73, 0xC3, 0x8F, 0x3C, 0x78, 0xF3, 0x87, 0x8E, 0x38,
  0x70, 0xE3, 0x87, 0x0E, 0x78, 0x71, 0xE7, 0x8F, 0x1E, 0x70, 0xE1, 0xC7,
  0x0E, 0x1C, 0x70, 0xE1, 0xCF, 0x1E, 0x3C, 0xF1, 0xE3, 0xCE, 0x1C, 0x38,
  0x00, 0x60, 0xEF, 0xC7, 0xFE, 0x3E, 0xF1, 0xE3, 0x8E, 0x1C, 0xF0, 0xE7,
  0x8F, 0x38, 0x79, 0xC3, 0x9E, 0x1C, 0xF0, 0xE7, 0x0F, 0x38, 0x79, 0xC3,
  0x9E, 0x1C, 0xF0, 0xE7, 0x0F, 0x00, 0x03, 0x80, 0xFE, 0x1F, 0xE3, 0xFF,
  0x38, 0xF7, 0x87, 0x70, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E,
  0xE1, 0xEE, 0x1E, 0xE3, 0xCF, 0xFC, 0x7F, 0x83, 0xE0, 0x00, 0x18, 0x07,
  0x7E, 0x07, 0x7E, 0x07, 0xDE, 0x07, 0x8F, 0x07, 0x0F, 0x0F, 0x0F, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1E,
  0x3C, 0x1E, 0x38, 0x3F, 0xF8, 0x3F, 0xF0, 0x39, 0xE0, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x03, 0x00, 0x7D, 0xC7, 0xFE, 0x79, 0xF3, 0x87, 0xBC, 0x39, 0xC1,
  0xCE, 0x0E, 0xF0, 0xF7, 0x87, 0xB8, 0x39, 0xC1, 0xCE, 0x1E, 0x70, 0xF3,
  0x8F, 0x1F, 0xF8, 0xFD, 0xC3, 0xDE, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x00, 0x00, 0x63, 0xBC, 0x77,
  0x8F, 0xE1, 0xF0, 0x7C, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x00, 0x03, 0x01, 0xFC,
  0x7F, 0x9E, 0x23, 0x80, 0x70, 0x0F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E,
  0x03, 0xC0, 0x38, 0x07, 0x21, 0xE7, 0xFC, 0xFF, 0x1F, 0xC0, 0x0E, 0x07,
  0x07, 0x03, 0x87, 0xFB, 0xF8, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07,
  0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x3F, 0x1F, 0x87, 0xC0, 0x3C, 0x39,
  0xC3, 0xCE, 0x1C, 0x70, 0xE7, 0x87, 0x3C, 0x79, 0xC3, 0xCE, 0x1C, 0x70,
  0xE7, 0x87, 0x3C, 0x79, 0xC3, 0xCE, 0x1C, 0x71, 0xE3, 0xFF, 0x1F, 0xB8,
  0x79, 0xC0, 0xE0, 0xFE, 0x1E, 0xE1, 0xCE, 0x1C, 0xE3, 0xCE, 0x38, 0xE7,
  0x8E, 0x70, 0xE7, 0x0E, 0xE0, 0xEE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF0, 0x00, 0xE1, 0xE1, 0xF8, 0x78, 0xFE, 0x3E, 0x3B, 0x8F,
  0x8E, 0xE7, 0xE7, 0x39, 0xF9, 0xCE, 0x6E, 0xF3, 0xBB, 0xB8, 0xEE, 0xEE,
  0x3B, 0x3F, 0x0F, 0xCF, 0xC3, 0xE3, 0xF0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F,
  0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x00, 0x0F, 0x1F, 0x07, 0x1C, 0x07,
  0x3C, 0x07, 0x38, 0x07, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C,
  0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0x07, 0x07, 0x83, 0x83, 0x81, 0xC3, 0xC0,
  0xE1, 0xC0, 0x71, 0xE0, 0x38, 0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x07, 0x38,
  0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x04, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0xF1, 0xFF, 0x1F, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xFF, 0x8F, 0xF8, 0xFF,
  0x80, 0x00, 0xF0, 0x3F, 0x03, 0xE0, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0xFC, 0x0F, 0x80, 0xF0, 0x0F,
  0x80, 0x38, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x7C, 0x07, 0xC0,
  0x3E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x3F, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x3E, 0x0F, 0xC0, 0xF8, 0x0F,
  0x00, 0x18, 0x0B, 0xF0, 0x7F, 0xFF, 0xCF, 0xF8, 0x1F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 9, 23, 8, 0, -23 },
  { 27, 10, 8, 12, 3, -23 },
  { 37, 15, 23, 15, 0, -23 },
  { 81, 14, 26, 13, 0, -24 },
  { 127, 18, 23, 21, 2, -23 },
  { 179, 15, 23, 15, 0, -23 },
  { 223, 5, 8, 7, 3, -23 },
  { 228, 10, 28, 8, 1, -23 },
  { 263, 10, 28, 9, -2, -23 },
  { 298, 11, 13, 13, 3, -25 },
  { 316, 13, 15, 14, 1, -19 },
  { 341, 7, 8, 7, -2, -4 },
  { 348, 8, 3, 9, 0, -10 },
  { 351, 5, 4, 7, 0, -4 },
  { 354, 16, 23, 11, -2, -23 },
  { 400, 12, 23, 13, 1, -23 },
  { 435, 10, 23, 13, 3, -23 },
  { 464, 14, 23, 13, -1, -23 },
  { 505, 14, 23, 13, 0, -23 },
  { 546, 14, 23, 13, 0, -23 },
  { 587, 14, 23, 13, 0, -23 },
  { 628, 13, 23, 13, 1, -23 },
  { 666, 14, 23, 13, 1, -23 },
  { 707, 14, 23, 13, 0, -23 },
  { 748, 13, 23, 13, 0, -23 },
  { 786, 7, 18, 7, 0, -18 },
  { 802, 9, 22, 7, -2, -18 },
  { 827, 13, 15, 14, 1, -19 },
  { 852, 13, 9, 14, 1, -16 },
  { 867, 13, 15, 14, 1, -19 },
  { 892, 11, 23, 10, 1, -23 },
  { 924, 19, 26, 20, 1, -23 },
  { 986, 14, 23, 14, -2, -23 },
  { 1027, 15, 23, 15, 0, -23 },
  { 1071, 15, 23, 13, 1, -23 },
  { 1115, 16, 23, 16, 0, -23 },
  { 1161, 14, 23, 12, 0, -23 },
  { 1202, 14, 23, 12, 0, -23 },
  { 1243, 16, 23, 16, 1, -23 },
  { 1289, 17, 23, 16, 0, -23 },
  { 1338, 13, 23, 9, -1, -23 },
  { 1376, 13, 30, 7, -5, -23 },
  { 1425, 17, 23, 14, 0, -23 },
  { 1474, 10, 23, 12, 0, -23 },
  { 1503, 23, 23, 22, 0, -23 },
  { 1570, 18, 23, 17, 0, -23 },
  { 1622, 16, 23, 17, 1, -23 },
  { 1668, 15, 23, 14, 0, -23 },
  { 1712, 16, 28, 17, 1, -23 },
  { 1768, 15, 23, 14, 0, -23 },
  { 1812, 15, 23, 13, -1, -23 },
  { 1856, 13, 23, 12, 2, -23 },
  { 1894, 16, 23, 16, 1, -23 },
  { 1940, 14, 23, 14, 3, -23 },
  { 1981, 23, 23, 22, 2, -23 },
  { 2048, 18, 23, 13, -2, -23 },
  { 2100, 13, 23, 13, 3, -23 },
  { 2138, 15, 23, 12, -1, -23 },
  { 2182, 12, 28, 9, -1, -23 },
  { 2224, 6, 23, 12, 3, -23 },
  { 2242, 12, 28, 9, -2, -23 },
  { 2284, 13, 13, 13, 0, -23 },
  { 2306, 11, 2, 10, -3, 3 },
  { 2309, 5, 5, 9, 5, -24 },
  { 2313, 13, 18, 14, 1, -18 },
  { 2343, 14, 24, 14, 0, -24 },
  { 2385, 11, 18, 11, 1, -18 },
  { 2410, 15, 24, 14, 1, -24 },
  { 2455, 12, 18, 13, 1, -18 },
  { 2482, 16, 32, 8, -4, -24 },
  { 2546, 15, 26, 14, -1, -18 },
  { 2595, 13, 24, 14, 0, -24 },
  { 2634, 8, 24, 7, 0, -24 },
  { 2658, 12, 32, 7, -4, -24 },
  { 2706, 14, 24, 13, 0, -24 },
  { 2748, 9, 24, 7, 0, -24 },
  { 2775, 20, 18, 21, 0, -18 },
  { 2820, 13, 18, 14, 0, -18 },
  { 2850, 12, 18, 14, 1, -18 },
  { 2877, 16, 26, 14, -2, -18 },
  { 2929, 13, 26, 14, 1, -18 },
  { 2972, 11, 18, 10, 0, -18 },
  { 2997, 11, 18, 11, 0, -18 },
  { 3022, 9, 21, 9, 1, -21 },
  { 3046, 13, 17, 14, 1, -17 },
  { 3074, 12, 17, 12, 2, -17 },
  { 3100, 18, 17, 19, 2, -17 },
  { 3139, 16, 17, 12, -2, -17 },
  { 3173, 17, 25, 12, -3, -17 },
  { 3227, 12, 17, 10, -1, -17 },
  { 3253, 12, 28, 11, 1, -23 },
  { 3295, 3, 32, 12, 4, -25 },
  { 3307, 12, 28, 11, -2, -23 },
  { 3349, 13, 5, 14, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC32PT7B_H_
