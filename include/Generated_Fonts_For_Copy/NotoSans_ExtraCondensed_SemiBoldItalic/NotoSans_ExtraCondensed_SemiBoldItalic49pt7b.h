#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC49PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x1E, 0x00, 0x3E, 0x3F,
  0x7E, 0x3E, 0x7E, 0x3E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C,
  0x78, 0x7C, 0xF8, 0x78, 0xF8, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0,
  0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x70, 0x00, 0xF0, 0xF0, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x01, 0xE1, 0xE0, 0x01, 0xC3, 0xC0,
  0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x87, 0x80,
  0x07, 0x87, 0x80, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFD, 0xF0, 0x3E, 0x63, 0x01,
  0xF3, 0x00, 0x1F, 0x18, 0x00, 0xF9, 0x80, 0x07, 0xCC, 0x00, 0x3F, 0x60,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0D, 0xF8,
  0x00, 0x67, 0xC0, 0x03, 0x3E, 0x00, 0x19, 0xF0, 0x81, 0x8F, 0x86, 0x0C,
  0xFC, 0x38, 0x6F, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03,
  0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0xF0, 0x03, 0xC0, 0x3F, 0xC0,
  0x3C, 0x03, 0xFE, 0x01, 0xE0, 0x3E, 0xF8, 0x1E, 0x01, 0xE3, 0xC0, 0xF0,
  0x1E, 0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x78, 0x07, 0x87, 0x87, 0x80, 0x78,
  0x3C, 0x3C, 0x03, 0xC3, 0xC3, 0xC0, 0x1E, 0x1E, 0x3E, 0x00, 0xF0, 0xF1,
  0xE0, 0x07, 0x87, 0x9F, 0x00, 0x38, 0x78, 0xF0, 0x43, 0xC3, 0xCF, 0x0F,
  0xDE, 0x1E, 0x79, 0xFE, 0xF1, 0xE7, 0x8F, 0xFB, 0xDF, 0x3C, 0xF3, 0xDF,
  0xF3, 0xCF, 0x1E, 0xFF, 0x1E, 0x78, 0xF3, 0xF1, 0xE3, 0xC7, 0x80, 0x0F,
  0x3C, 0x3C, 0x00, 0xF1, 0xE1, 0xE0, 0x07, 0x8F, 0x0F, 0x00, 0x78, 0xF0,
  0x78, 0x07, 0xC7, 0x83, 0xC0, 0x3C, 0x3C, 0x3C, 0x03, 0xE1, 0xE1, 0xE0,
  0x1E, 0x0F, 0x0F, 0x01, 0xE0, 0x78, 0xF0, 0x0F, 0x03, 0xC7, 0x80, 0xF0,
  0x1E, 0x78, 0x07, 0x80, 0xFF, 0xC0, 0x78, 0x03, 0xFC, 0x07, 0xC0, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xDF,
  0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8,
  0x03, 0xE1, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0xFF, 0xE3, 0xF3, 0xF7,
  0xE7, 0xC7, 0xC7, 0xCF, 0x9F, 0x0F, 0xBE, 0x3E, 0x1F, 0xFC, 0xFC, 0x1F,
  0xF1, 0xF0, 0x3F, 0xE3, 0xE0, 0x7F, 0x87, 0xC0, 0x7F, 0x0F, 0x80, 0xFC,
  0x1F, 0x83, 0xF8, 0x3F, 0x1F, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFB, 0xF0,
  0xFF, 0xE7, 0xE0, 0x7F, 0x0F, 0xE0, 0x3E, 0x7D, 0xFB, 0xF7, 0xCF, 0x9F,
  0x3C, 0x79, 0xF3, 0xE7, 0x8F, 0x00, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x01, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x02, 0x1F, 0x03, 0x8F,
  0x01, 0xF7, 0x86, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xF9, 0xE0, 0xFC, 0xF8, 0x3C, 0x3E,
  0x0C, 0x1E, 0x02, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F,
  0x0F, 0x83, 0xC0, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF,
  0xE0, 0x1C, 0xFD, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x7E, 0x0F, 0xC7,
  0xC1, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE3, 0xF0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xF3, 0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xFB, 0xF0, 0x3F,
  0x7E, 0x07, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xEF, 0xC0, 0xFD,
  0xF8, 0x1F, 0xBE, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x1F, 0x9F, 0x03, 0xE3,
  0xE0, 0xFC, 0x7C, 0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x3F, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C,
  0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x7F, 0xE3, 0xFF, 0x9F, 0xBE,
  0xFD, 0xF3, 0xE7, 0xC7, 0x1F, 0x08, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x1F, 0x9F, 0xC0, 0x3C, 0x1F, 0x80, 0x30, 0x1F, 0x80, 0x40, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xF3, 0xFC, 0x06, 0x03, 0xF0, 0x10, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x7F,
  0xE0, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x8F, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC3, 0x00, 0x7E, 0x0F, 0x8F, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1D, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0x9F,
  0x00, 0x1E, 0xF8, 0x00, 0xF3, 0xE0, 0x03, 0x8F, 0x80, 0x1E, 0x3E, 0x00,
  0xF1, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x1F, 0x00, 0xF0, 0x7C, 0x03, 0xC1,
  0xF0, 0x1E, 0x0F, 0xC0, 0xF8, 0x3E, 0x03, 0xC0, 0xF8, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x02, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x08, 0x03, 0xF8, 0x40,
  0x3F, 0x83, 0xC7, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0x08, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFD, 0xFC, 0x07, 0xDF, 0xF0, 0x3F, 0xFF, 0x83,
  0xFF, 0xFE, 0x1F, 0xE7, 0xF0, 0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x03,
  0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C, 0x3E,
  0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0xFC,
  0x0F, 0xDF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F,
  0x0F, 0xC0, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x0F, 0x87, 0xE0, 0x7E,
  0x7E, 0x03, 0xF7, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xF9, 0xF8, 0x1F, 0x07,
  0xC1, 0xF8, 0x3F, 0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0xFC, 0x7E, 0x07, 0xC3, 0xF8, 0x7E,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00,
  0x06, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0,
  0x7F, 0x7F, 0x07, 0xE1, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x03,
  0xF1, 0xF0, 0x3F, 0x1F, 0x07, 0xF1, 0xF0, 0x7F, 0x1F, 0x9F, 0xE1, 0xFF,
  0xFE, 0x1F, 0xFB, 0xE0, 0xFF, 0x7E, 0x07, 0xE7, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x0C, 0x3F, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x01, 0xC0, 0xFC, 0x1F, 0x87, 0xF0, 0xFE,
  0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0xF8, 0x1F,
  0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0x00, 0x00, 0x38, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F,
  0x80, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0xC3, 0xFF, 0xE0, 0xE3, 0xF8, 0x40, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0x07,
  0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x0F, 0xC1, 0xC3, 0xC1,
  0xFF, 0x8E, 0x1C, 0x1F, 0xF8, 0x71, 0xE1, 0xF3, 0xC3, 0x8E, 0x0F, 0x1E,
  0x1C, 0xF0, 0xF0, 0xF1, 0xE7, 0x87, 0x07, 0x0F, 0x38, 0x78, 0x78, 0x7B,
  0xC3, 0xC3, 0xC3, 0xDE, 0x3C, 0x1E, 0x1C, 0xF1, 0xE1, 0xE0, 0xE7, 0x0F,
  0x0F, 0x0F, 0x38, 0x78, 0x78, 0x73, 0xC3, 0x83, 0xC3, 0x9E, 0x1C, 0x3C,
  0x3C, 0xF0, 0xE1, 0xE1, 0xC7, 0x87, 0x9F, 0x1E, 0x3C, 0x3F, 0xFF, 0xE1,
  0xE1, 0xFC, 0xFE, 0x0F, 0x07, 0xC7, 0xE0, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x18, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x79, 0xE0,
  0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07,
  0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x07,
  0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0,
  0x3F, 0x1F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x3F,
  0x7E, 0x00, 0xFD, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F,
  0xC0, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8,
  0x3F, 0x03, 0xF1, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0xFC, 0x3F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x7E,
  0x07, 0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xE0,
  0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x07, 0xE0, 0x7E, 0x0F, 0x81, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFB, 0xC0, 0x7F, 0x02, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x20, 0x1F, 0xEF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xF0, 0xFE, 0x03,
  0xF0, 0x7E, 0x03, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07,
  0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7E, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0xFC, 0x1F,
  0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3E, 0x03, 0xF8, 0x3E,
  0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0x7E, 0x3F, 0xC0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0x7E,
  0x07, 0xF8, 0x0C, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x0F, 0xFC,
  0xFC, 0x0F, 0xFC, 0xFC, 0x0F, 0xF8, 0xFC, 0x0F, 0xF8, 0xFC, 0x1F, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x01, 0xF0,
  0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0xFC, 0x03, 0xE0,
  0xFE, 0x07, 0xE0, 0x7F, 0xDF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xC0,
  0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x01, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x1F, 0x03, 0xF0,
  0x07, 0xC0, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x7C,
  0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF7, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xEF,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x0F,
  0x87, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80,
  0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFB,
  0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x7D, 0xF0, 0x1F,
  0x7C, 0x0F, 0xBE, 0x03, 0xEF, 0x83, 0xEF, 0xC0, 0x7D, 0xF0, 0x7D, 0xF0,
  0x0F, 0xBE, 0x0F, 0x3E, 0x01, 0xF7, 0xC3, 0xE7, 0xC0, 0x7C, 0x78, 0x79,
  0xF8, 0x0F, 0x8F, 0x1F, 0x3E, 0x01, 0xF1, 0xE3, 0xC7, 0xC0, 0x3E, 0x3C,
  0xF8, 0xF8, 0x07, 0xC7, 0x9F, 0x1F, 0x01, 0xF0, 0xF7, 0xC7, 0xE0, 0x3E,
  0x1E, 0xF8, 0xF8, 0x07, 0xC3, 0xDE, 0x1F, 0x00, 0xF8, 0x7F, 0xC3, 0xE0,
  0x1F, 0x0F, 0xF0, 0x7C, 0x07, 0xC1, 0xFE, 0x1F, 0x80, 0xF8, 0x3F, 0x83,
  0xE0, 0x1F, 0x07, 0xF0, 0x7C, 0x03, 0xE0, 0xFE, 0x0F, 0x80, 0xF8, 0x1F,
  0x83, 0xF0, 0x1F, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x01, 0xF0, 0x1F, 0xC0, 0x1F, 0x01, 0xFC, 0x03, 0xF0, 0x1F,
  0xC0, 0x3E, 0x03, 0xFC, 0x03, 0xE0, 0x3F, 0xC0, 0x3E, 0x03, 0xFC, 0x03,
  0xE0, 0x3F, 0xE0, 0x7C, 0x03, 0xFE, 0x07, 0xC0, 0x7F, 0xE0, 0x7C, 0x07,
  0xDE, 0x07, 0xC0, 0x7D, 0xE0, 0xFC, 0x07, 0xDE, 0x0F, 0x80, 0xF9, 0xF0,
  0xF8, 0x0F, 0x9F, 0x0F, 0x80, 0xF9, 0xF0, 0xF8, 0x0F, 0x8F, 0x1F, 0x80,
  0xF8, 0xF1, 0xF0, 0x1F, 0x0F, 0x9F, 0x01, 0xF0, 0xF9, 0xF0, 0x1F, 0x0F,
  0x9F, 0x01, 0xF0, 0xFB, 0xE0, 0x1F, 0x07, 0xBE, 0x03, 0xE0, 0x7B, 0xE0,
  0x3E, 0x07, 0xFE, 0x03, 0xE0, 0x7F, 0xE0, 0x3E, 0x07, 0xFC, 0x03, 0xE0,
  0x7F, 0xC0, 0x7C, 0x03, 0xFC, 0x07, 0xC0, 0x3F, 0xC0, 0x7C, 0x03, 0xFC,
  0x07, 0xC0, 0x3F, 0x80, 0xF8, 0x03, 0xF8, 0x0F, 0x80, 0x3F, 0x80, 0xF8,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xDF, 0xC0, 0xFE, 0x0F, 0xC3, 0xF8, 0x1F, 0x87,
  0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF8,
  0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00,
  0x3F, 0x7C, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xF7, 0xE0, 0x07,
  0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x0F,
  0xC0, 0xFE, 0x1F, 0xC3, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7E,
  0x1F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xC1, 0xF8, 0x1F,
  0x83, 0xF0, 0x3F, 0x07, 0xC0, 0xFC, 0x0F, 0x83, 0xF8, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xDF, 0xC0, 0xFE, 0x0F, 0xC3, 0xF8, 0x1F, 0x87, 0xE0, 0x3F,
  0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF8, 0x03, 0xF3,
  0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7C,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xF7, 0xE0, 0x07, 0xEF, 0xC0,
  0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01,
  0xF9, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0x83, 0xF0, 0x3E, 0x0F,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x81, 0xF0, 0x7C, 0x0F, 0xC1,
  0xF0, 0x3F, 0x07, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x7C, 0xFC, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E,
  0x1F, 0x00, 0xF8, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0x07, 0x01,
  0xFC, 0x02, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x04, 0x01, 0xF8, 0x0E, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F,
  0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7C, 0x1F,
  0x80, 0x7C, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x3F,
  0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3F, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x3E,
  0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7C,
  0x03, 0xF0, 0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0xF8,
  0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8,
  0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7C, 0xFC, 0x03, 0xF3, 0xF0, 0x0F,
  0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xC3, 0xF0, 0x3F, 0x0F,
  0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0xC3,
  0xF0, 0x3F, 0x0F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0,
  0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xE7, 0xE0, 0x07, 0x9F, 0x00, 0x1E,
  0x7C, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xF0,
  0x07, 0xEF, 0x80, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xC0, 0x3F, 0x3E, 0x01,
  0xF8, 0x07, 0xC7, 0xC0, 0x3F, 0x01, 0xF8, 0xF8, 0x0F, 0xE0, 0x3E, 0x1F,
  0x01, 0xFC, 0x07, 0xC3, 0xE0, 0x3F, 0x81, 0xF8, 0x7C, 0x0F, 0xF0, 0x3E,
  0x0F, 0x81, 0xFE, 0x0F, 0xC1, 0xF0, 0x7F, 0xC1, 0xF0, 0x3E, 0x0F, 0x78,
  0x3E, 0x07, 0xC1, 0xEF, 0x0F, 0xC0, 0xF8, 0x7F, 0xE1, 0xF0, 0x1F, 0x0F,
  0x7C, 0x3E, 0x03, 0xE1, 0xEF, 0x8F, 0x80, 0x7C, 0x7D, 0xF1, 0xF0, 0x0F,
  0x8F, 0x3E, 0x7E, 0x01, 0xF3, 0xE7, 0xCF, 0x80, 0x3E, 0x78, 0xF9, 0xF0,
  0x07, 0xCF, 0x1E, 0x7E, 0x00, 0xFB, 0xE3, 0xCF, 0x80, 0x1F, 0x78, 0x79,
  0xF0, 0x03, 0xFF, 0x0F, 0x7C, 0x00, 0x7F, 0xE1, 0xEF, 0x80, 0x0F, 0x78,
  0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x81, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC1, 0xF0,
  0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x3E,
  0x7C, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F,
  0x9F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xC0,
  0x07, 0xC0, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0x7C,
  0x07, 0xE7, 0xC0, 0xFC, 0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F, 0x07,
  0xC3, 0xF0, 0x7C, 0x3E, 0x07, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xEF, 0xC0,
  0x3E, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0xF8, 0x7C,
  0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83,
  0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x78, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0x3E, 0x00,
  0xF9, 0xF0, 0x0F, 0x87, 0x80, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F,
  0x83, 0xE0, 0x3C, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0x7D, 0xF0,
  0x01, 0xF0, 0x7F, 0xFF, 0xBF, 0xFF, 0xBF, 0xFF, 0xC0, 0xFC, 0x7E, 0x7E,
  0x3E, 0x1F, 0x1F, 0x0F, 0x00, 0xF8, 0xF8, 0x1F, 0xE7, 0xC1, 0xFF, 0xBE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xE3, 0xF8, 0x7E, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x0F, 0xC7,
  0xC0, 0x7E, 0x3E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x0F,
  0xC7, 0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E,
  0x1F, 0xC3, 0xF1, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xDF, 0x03, 0xFE, 0xF8,
  0x0F, 0xC7, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF9, 0xF0, 0x0F, 0x9F, 0xC0, 0x7D,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC3, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF0, 0x1F, 0x8F, 0x80,
  0xFC, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x8F,
  0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF8, 0x7F, 0x1F, 0x87, 0xFF, 0xF8, 0x3E, 0xFF, 0xC1, 0xF7,
  0xFC, 0x0F, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xF0, 0x41, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x02, 0x0F, 0xE3, 0x81, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x03,
  0xE3, 0xE0, 0x1F, 0xE7, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F,
  0x81, 0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF0,
  0x3E, 0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x7E,
  0x1F, 0xC0, 0xFC, 0x7F, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFE,
  0xF8, 0x03, 0xF9, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x1F, 0xFF, 0x0F, 0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0x3C, 0xFC, 0x1F, 0x3E,
  0x07, 0xCF, 0x81, 0xF7, 0xC1, 0xF9, 0xF1, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF,
  0x0F, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x41, 0xFF, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xE2, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0xFE, 0x7C, 0x07, 0xFE, 0xF8, 0x0F, 0xFD, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFE, 0x3F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F,
  0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xFC, 0x0F, 0xC1, 0xF0, 0x1F, 0x83, 0xE0,
  0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07,
  0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE1, 0xFC,
  0x0F, 0xC7, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xEF, 0x80,
  0x3F, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x80, 0x3F, 0x01, 0x80, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE7, 0xC0, 0x7D, 0xFE, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFE, 0x1F, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F,
  0x81, 0xF1, 0xF8, 0x1F, 0x1F, 0x83, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1,
  0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C,
  0x3E, 0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F,
  0x8F, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x00, 0x00,
  0x70, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0xC0,
  0x7C, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x7E, 0x00, 0xFB,
  0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x1F, 0x0F,
  0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0,
  0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC7, 0xC1, 0xF0, 0x0F, 0x3F, 0xC7, 0xF8,
  0x1E, 0xFF, 0xDF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE1,
  0xFC, 0x7F, 0x8F, 0xC3, 0xF0, 0x7E, 0x1F, 0x87, 0xC0, 0xF8, 0x3E, 0x0F,
  0x83, 0xF0, 0x7C, 0x3F, 0x07, 0xE0, 0xF8, 0x7C, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x1F, 0x0F, 0xC1,
  0xF0, 0x3E, 0x1F, 0x03, 0xE0, 0x7C, 0x3E, 0x07, 0xC0, 0xF8, 0x7C, 0x0F,
  0x83, 0xE0, 0xF8, 0x3F, 0x07, 0xC3, 0xF0, 0x7C, 0x0F, 0x87, 0xC0, 0xF8,
  0x1F, 0x0F, 0x81, 0xF0, 0x7E, 0x1F, 0x03, 0xE0, 0xF8, 0x7E, 0x0F, 0x81,
  0xF0, 0xF8, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x1F,
  0x00, 0x07, 0x87, 0xC0, 0x79, 0xFE, 0x07, 0xBF, 0xF0, 0x7B, 0xFF, 0x07,
  0xFF, 0xF0, 0xFE, 0x1F, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x1F, 0x83, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E,
  0x3F, 0x03, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07,
  0xC7, 0xE0, 0x7C, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0,
  0xF8, 0xFC, 0x0F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x0F, 0xC7,
  0xC0, 0xF9, 0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7D, 0xF8, 0x0F, 0xBE,
  0x01, 0xF7, 0xC0, 0x7E, 0xF8, 0x0F, 0xFF, 0x01, 0xF7, 0xE0, 0x3E, 0xF8,
  0x07, 0xDF, 0x01, 0xFB, 0xE0, 0x3E, 0x7C, 0x0F, 0xCF, 0x81, 0xF9, 0xF8,
  0x7E, 0x1F, 0x9F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0xF1, 0xFC, 0x00, 0xF3, 0xFE, 0x00,
  0xF7, 0xFE, 0x00, 0xFF, 0x7F, 0x01, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x01,
  0xF8, 0x3F, 0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3F, 0x03,
  0xE0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07,
  0xC0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F,
  0xC0, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0x7F, 0xE0, 0x1F, 0x7F, 0xC0, 0x1F, 0x3F, 0x80, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x78, 0x0F, 0xE7, 0xC0, 0xFF, 0xBE, 0x0F, 0xFD, 0xE0, 0xFF, 0xFF,
  0x07, 0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF0,
  0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE1,
  0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03,
  0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0x7E, 0x1F, 0xC3, 0xF1, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFE, 0xF8, 0x0F, 0xCF, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC7, 0x83, 0xCF, 0xC1, 0xE7,
  0xE0, 0xF7, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x1F, 0xCF, 0x07, 0xE0, 0x41, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x20, 0x3F, 0x0E, 0x1F, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0xF1, 0xFF, 0xCF, 0xFE, 0x3F, 0xF9, 0xFF, 0xE0, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x10, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x0F,
  0xE0, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE0,
  0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03,
  0xE1, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F,
  0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C,
  0x1F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF1,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xDE, 0x03, 0xFE, 0xF0, 0x0F, 0xC7, 0x80,
  0xF8, 0x07, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7E, 0xF8, 0x1F, 0x3E,
  0x0F, 0xCF, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F,
  0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xEF, 0x80,
  0xFB, 0xE0, 0x3E, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x00, 0xF8, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x3F, 0x83, 0xEF,
  0x83, 0xF8, 0x3E, 0xF8, 0x3F, 0x83, 0xEF, 0x87, 0xF8, 0x7C, 0xF8, 0x7F,
  0x87, 0xCF, 0x8F, 0xF8, 0xF8, 0xF8, 0xF7, 0x8F, 0x8F, 0x8F, 0x78, 0xF8,
  0xF9, 0xFF, 0x9F, 0x0F, 0x9E, 0xF9, 0xF0, 0xF9, 0xEF, 0x9E, 0x0F, 0xBC,
  0xF3, 0xE0, 0xFB, 0xCF, 0x3E, 0x0F, 0x7C, 0xF7, 0xC0, 0xF7, 0x8F, 0x7C,
  0x0F, 0x78, 0xF7, 0x80, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF,
  0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x7E, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0xC0,
  0x3F, 0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xE0, 0x01,
  0xF7, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF0,
  0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F, 0xC0, 0x7E, 0x0F, 0x80,
  0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x81,
  0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8,
  0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x07,
  0x9F, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xF7, 0xC0, 0x00,
  0x7B, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x0E, 0x00, 0x00, 0x1F, 0x00, 0x2F, 0xF8, 0x07, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 13, 35, 12, 0, -35 },
  { 58, 16, 13, 18, 5, -35 },
  { 84, 24, 35, 22, 0, -35 },
  { 189, 21, 40, 20, 0, -37 },
  { 294, 29, 35, 33, 2, -35 },
  { 421, 23, 35, 24, 0, -35 },
  { 522, 7, 13, 11, 5, -35 },
  { 534, 16, 43, 13, 1, -35 },
  { 620, 16, 44, 13, -4, -36 },
  { 708, 17, 19, 19, 4, -38 },
  { 749, 19, 23, 22, 2, -29 },
  { 804, 10, 13, 11, -2, -6 },
  { 821, 12, 5, 14, 1, -16 },
  { 829, 7, 7, 11, 0, -7 },
  { 836, 25, 35, 18, -3, -35 },
  { 946, 19, 35, 20, 1, -35 },
  { 1030, 14, 35, 20, 5, -35 },
  { 1092, 23, 35, 20, -2, -35 },
  { 1193, 22, 35, 20, -1, -35 },
  { 1290, 22, 35, 20, -1, -35 },
  { 1387, 21, 35, 20, 0, -35 },
  { 1479, 21, 36, 20, 1, -36 },
  { 1574, 22, 35, 20, 1, -35 },
  { 1671, 21, 35, 20, 0, -35 },
  { 1763, 20, 36, 20, 0, -36 },
  { 1853, 11, 27, 11, 0, -27 },
  { 1891, 14, 34, 11, -3, -27 },
  { 1951, 19, 23, 22, 2, -29 },
  { 2006, 19, 14, 22, 2, -24 },
  { 2040, 19, 23, 22, 2, -29 },
  { 2095, 17, 35, 16, 1, -35 },
  { 2170, 29, 39, 31, 1, -35 },
  { 2312, 22, 35, 22, -3, -35 },
  { 2409, 23, 35, 22, 0, -35 },
  { 2510, 22, 36, 20, 2, -36 },
  { 2609, 24, 35, 24, 0, -35 },
  { 2714, 21, 35, 19, 0, -35 },
  { 2806, 21, 35, 18, 0, -35 },
  { 2898, 24, 36, 25, 2, -36 },
  { 3006, 27, 35, 25, 0, -35 },
  { 3125, 20, 35, 15, -2, -35 },
  { 3213, 20, 45, 11, -7, -35 },
  { 3326, 26, 35, 22, 0, -35 },
  { 3440, 15, 35, 18, 0, -35 },
  { 3506, 35, 35, 33, 0, -35 },
  { 3660, 28, 35, 27, 0, -35 },
  { 3783, 23, 35, 26, 2, -35 },
  { 3884, 23, 35, 22, 0, -35 },
  { 3985, 23, 43, 26, 2, -35 },
  { 4109, 22, 35, 22, 0, -35 },
  { 4206, 23, 35, 20, -1, -35 },
  { 4307, 19, 35, 18, 3, -35 },
  { 4391, 24, 35, 24, 2, -35 },
  { 4496, 22, 35, 22, 4, -35 },
  { 4593, 35, 35, 33, 3, -35 },
  { 4747, 27, 35, 20, -3, -35 },
  { 4866, 20, 35, 20, 4, -35 },
  { 4954, 23, 35, 18, -2, -35 },
  { 5055, 19, 43, 14, -2, -35 },
  { 5158, 9, 35, 18, 5, -35 },
  { 5198, 19, 43, 14, -3, -35 },
  { 5301, 21, 20, 21, 0, -35 },
  { 5354, 17, 3, 15, -5, 4 },
  { 5361, 8, 7, 14, 7, -37 },
  { 5368, 21, 27, 22, 1, -27 },
  { 5439, 21, 37, 22, 0, -37 },
  { 5537, 18, 27, 17, 1, -27 },
  { 5598, 23, 37, 22, 1, -37 },
  { 5705, 18, 27, 20, 1, -27 },
  { 5766, 24, 49, 13, -6, -37 },
  { 5913, 23, 39, 22, -1, -27 },
  { 6026, 20, 37, 22, 0, -37 },
  { 6119, 13, 37, 11, 0, -37 },
  { 6180, 19, 49, 11, -6, -37 },
  { 6297, 22, 37, 20, 0, -37 },
  { 6399, 13, 37, 10, 0, -37 },
  { 6460, 31, 27, 32, 0, -27 },
  { 6565, 20, 27, 22, 0, -27 },
  { 6633, 19, 27, 21, 1, -27 },
  { 6698, 24, 39, 22, -3, -27 },
  { 6815, 21, 39, 22, 1, -27 },
  { 6918, 17, 27, 15, 0, -27 },
  { 6976, 18, 27, 17, 0, -27 },
  { 7037, 14, 32, 13, 1, -32 },
  { 7093, 21, 27, 21, 1, -27 },
  { 7164, 18, 27, 18, 3, -27 },
  { 7225, 28, 27, 29, 3, -27 },
  { 7320, 23, 27, 19, -2, -27 },
  { 7398, 25, 39, 19, -4, -27 },
  { 7520, 19, 27, 16, -2, -27 },
  { 7585, 19, 43, 16, 1, -35 },
  { 7688, 5, 49, 18, 6, -38 },
  { 7719, 18, 43, 16, -3, -35 },
  { 7816, 19, 7, 22, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC49PT7B_H_
