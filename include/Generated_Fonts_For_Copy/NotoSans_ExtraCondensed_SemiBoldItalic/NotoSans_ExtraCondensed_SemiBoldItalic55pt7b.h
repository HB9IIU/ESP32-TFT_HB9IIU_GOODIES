#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC55PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x3E, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0x00, 0x18, 0x00, 0x3F, 0x8F, 0xCF, 0xC3, 0xF3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3E, 0x1F, 0x8F, 0x87, 0xE7, 0xE1, 0xF1, 0xF8, 0x7C, 0x7C, 0x3F,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3E, 0x3E, 0x0F, 0x00,
  0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07,
  0x87, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0xC0,
  0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0,
  0xF8, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x1E,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0xF0, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x00, 0xF0,
  0x78, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x1F,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xF3, 0x3C, 0x07, 0xE3, 0x08,
  0x07, 0xE7, 0x00, 0x07, 0xC6, 0x00, 0x07, 0xC6, 0x00, 0x07, 0xE6, 0x00,
  0x07, 0xEE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x33, 0xF0,
  0x00, 0x33, 0xF0, 0x00, 0x33, 0xF0, 0x00, 0x33, 0xF0, 0x40, 0x73, 0xF0,
  0x60, 0x63, 0xF0, 0x78, 0x67, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x03, 0xF8, 0x00, 0xF0, 0x07,
  0xFC, 0x01, 0xF0, 0x0F, 0xFC, 0x01, 0xE0, 0x1F, 0x3C, 0x03, 0xE0, 0x1E,
  0x3E, 0x03, 0xC0, 0x3E, 0x3E, 0x07, 0xC0, 0x3C, 0x3E, 0x0F, 0x80, 0x7C,
  0x3E, 0x0F, 0x00, 0x7C, 0x3E, 0x1F, 0x00, 0x78, 0x3C, 0x1E, 0x00, 0x78,
  0x3C, 0x3E, 0x00, 0xF8, 0x3C, 0x3C, 0x00, 0xF8, 0x7C, 0x7C, 0x00, 0xF0,
  0x7C, 0x78, 0x00, 0xF0, 0x78, 0xF8, 0x00, 0xF0, 0x78, 0xF0, 0xFC, 0xF0,
  0xF9, 0xF1, 0xFE, 0xF0, 0xF1, 0xE3, 0xFE, 0xF1, 0xF3, 0xE7, 0xFF, 0xFB,
  0xE7, 0xC7, 0x9F, 0xFF, 0xE7, 0xCF, 0x0F, 0x7F, 0xCF, 0x8F, 0x0F, 0x7F,
  0x8F, 0x1E, 0x0F, 0x1E, 0x1F, 0x1E, 0x0F, 0x00, 0x1E, 0x3E, 0x1F, 0x00,
  0x3E, 0x3E, 0x1F, 0x00, 0x3C, 0x3C, 0x1F, 0x00, 0x7C, 0x3C, 0x1E, 0x00,
  0x78, 0x7C, 0x1E, 0x00, 0xF8, 0x7C, 0x3E, 0x00, 0xF0, 0x7C, 0x3E, 0x01,
  0xF0, 0x7C, 0x3C, 0x01, 0xE0, 0x7C, 0x7C, 0x03, 0xE0, 0x7C, 0x7C, 0x07,
  0xC0, 0x7C, 0xF8, 0x07, 0xC0, 0x7F, 0xF0, 0x0F, 0x80, 0x3F, 0xF0, 0x0F,
  0x00, 0x3F, 0xE0, 0x1F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE1,
  0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x07,
  0xC3, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0xBF, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x0F, 0xC1, 0xFF, 0xC3, 0xF0, 0xFF,
  0xF0, 0xF8, 0x7E, 0xFE, 0x7E, 0x3F, 0x1F, 0x9F, 0x8F, 0x87, 0xEF, 0xC7,
  0xE1, 0xFF, 0xF1, 0xF8, 0x3F, 0xF8, 0xFC, 0x0F, 0xFE, 0x3F, 0x03, 0xFF,
  0x0F, 0xC0, 0x7F, 0xC3, 0xF0, 0x1F, 0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0x03,
  0xFE, 0x0F, 0xE1, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xBF, 0x03, 0xFF, 0x8F, 0xE0, 0x7F, 0xC3, 0xF8, 0x01, 0x00, 0x00,
  0x00, 0x1F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0xFC, 0x7E, 0x3E,
  0x1F, 0x0F, 0x87, 0xC7, 0xC0, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x04, 0x0F, 0x00, 0xE1, 0xE0, 0x1F, 0x3C,
  0x17, 0xFF, 0xBE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF,
  0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFF, 0x03, 0xFB, 0xE0, 0x7E, 0x3E,
  0x07, 0xC7, 0xE0, 0x70, 0xFC, 0x04, 0x0E, 0x00, 0x01, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x00, 0x7F, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x08, 0x3E, 0x7F, 0x7F, 0xFF,
  0xFE, 0xFE, 0x7C, 0x30, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F,
  0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x9F,
  0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x1F, 0x80,
  0xFC, 0x7E, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8,
  0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xE7, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0x7E, 0x7F, 0x3F, 0x1F, 0x1F, 0x07,
  0x1F, 0x81, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xE0, 0xFE, 0x01, 0xE0, 0x7F,
  0x00, 0x40, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xE0,
  0x7F, 0x00, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x80, 0x0F, 0xE0, 0xE0, 0x1F,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0x7C, 0x00, 0x1E, 0xFC, 0x00, 0x1E, 0xFC, 0x00, 0x3C, 0xFC, 0x00, 0x7C,
  0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF1, 0xF8, 0x01, 0xF1, 0xF8, 0x01, 0xE1,
  0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0x83, 0xF0, 0x0F, 0x83,
  0xF0, 0x1F, 0x03, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x3C, 0x07,
  0xE2, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xCC,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x04, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x80, 0x1F, 0xC0, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFB, 0x80, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xCF, 0xC0, 0x1F, 0x3F, 0xC0, 0x7E, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x87, 0xFC, 0x7F, 0x0F, 0xF0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x81,
  0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F,
  0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF0,
  0x7F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x03, 0xF1,
  0xFC, 0x03, 0xF3, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xCF, 0xE0, 0x3F, 0x87, 0xE0, 0x7F, 0x03, 0xF0, 0x7E, 0x03,
  0xF0, 0xFE, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFF, 0xBF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFC, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0xFC,
  0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x3F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0x7E,
  0x07, 0xF0, 0xFE, 0x1F, 0xE1, 0xFE, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xFE, 0xFC, 0x07, 0xF9, 0xF8, 0x07, 0xC7, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x02, 0x03, 0xFC, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x04, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x03, 0xE0, 0x7E, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x07, 0xC0, 0x10, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x3F, 0xC3, 0x81, 0xF8, 0x40, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x01, 0xE0, 0xF8, 0x1F, 0xE0, 0xF0, 0x78, 0x1F, 0xFC, 0x78,
  0x78, 0x1F, 0xFC, 0x3C, 0x3C, 0x1F, 0xBE, 0x1E, 0x3E, 0x1F, 0x1F, 0x0F,
  0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x0F, 0x07, 0x83, 0xCF, 0x07, 0x83, 0xC1,
  0xE7, 0x87, 0xC3, 0xE1, 0xE3, 0xC3, 0xC1, 0xF0, 0xF3, 0xE1, 0xE0, 0xF0,
  0x79, 0xE1, 0xF0, 0x78, 0x3C, 0xF0, 0xF0, 0x7C, 0x3C, 0x78, 0x78, 0x3E,
  0x1E, 0x3C, 0x3C, 0x1E, 0x0F, 0x1E, 0x1E, 0x1F, 0x0F, 0x1F, 0x0F, 0x0F,
  0x87, 0x8F, 0x07, 0x8F, 0xC7, 0x87, 0x83, 0xC7, 0xE7, 0xC3, 0xC1, 0xFF,
  0x7F, 0xC1, 0xE0, 0xFF, 0x3F, 0xC0, 0xF0, 0x3F, 0x1F, 0xC0, 0x7C, 0x07,
  0x03, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x30, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xDF, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xBF, 0x00, 0x1F, 0xBF,
  0x00, 0x1F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F,
  0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x7F, 0x03,
  0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0x83,
  0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xF0, 0xFF, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x0F,
  0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x83, 0xFC, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xF0, 0x30, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x40, 0x1F, 0xE0, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xF1, 0xFF, 0x80, 0x7E, 0x0F,
  0xF0, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x0F,
  0xC0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xC1, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC,
  0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80,
  0x3F, 0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83,
  0xF0, 0x0F, 0xE0, 0x7E, 0x03, 0xFC, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0x7E, 0x0F, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFE, 0x03, 0xC0, 0x3F, 0xC0, 0x08, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x03,
  0xFF, 0x87, 0xE0, 0x3F, 0xF8, 0x7E, 0x03, 0xFF, 0x0F, 0xE0, 0x7F, 0xF0,
  0xFE, 0x07, 0xFF, 0x0F, 0xE0, 0x7F, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFE,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xF8,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x80,
  0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x00,
  0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x04, 0x7F, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x3F,
  0x01, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3E,
  0x3F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFD, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xBF, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x7E,
  0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x07, 0xFF, 0x00, 0xFD, 0xF0, 0x1F, 0x7E, 0x01, 0xFB, 0xE0, 0x3E,
  0xFC, 0x03, 0xF7, 0xC0, 0xF9, 0xF0, 0x07, 0xCF, 0x81, 0xF7, 0xE0, 0x1F,
  0x9F, 0x07, 0xEF, 0xC0, 0x3F, 0x3E, 0x0F, 0x9F, 0x80, 0x7E, 0x7C, 0x3F,
  0x3F, 0x00, 0xF8, 0xF8, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0xF9, 0xF8, 0x07,
  0xE3, 0xE3, 0xE3, 0xF0, 0x0F, 0xC7, 0xC7, 0xC7, 0xE0, 0x1F, 0x8F, 0x9F,
  0x0F, 0xC0, 0x3E, 0x1F, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0xFC, 0x7E, 0x01,
  0xF8, 0x7D, 0xF0, 0xFC, 0x03, 0xF0, 0xFF, 0xE1, 0xF8, 0x07, 0xE1, 0xFF,
  0x83, 0xF0, 0x0F, 0x83, 0xFF, 0x0F, 0xC0, 0x1F, 0x07, 0xFC, 0x1F, 0x80,
  0x7E, 0x0F, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0xE0, 0x7E, 0x01, 0xF8, 0x3F,
  0xC0, 0xF8, 0x03, 0xE0, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xE0,
  0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x0F,
  0xF8, 0x03, 0xF0, 0x1F, 0xF0, 0x07, 0xC0, 0x3F, 0xE0, 0x0F, 0x80, 0x7F,
  0xC0, 0x3F, 0x00, 0xFF, 0x80, 0x7E, 0x03, 0xFF, 0x80, 0xFC, 0x07, 0xFF,
  0x01, 0xF0, 0x0F, 0xBE, 0x07, 0xE0, 0x1F, 0x7C, 0x0F, 0xC0, 0x3E, 0xF8,
  0x1F, 0x80, 0xFD, 0xF0, 0x3F, 0x01, 0xFB, 0xF0, 0x7C, 0x03, 0xE7, 0xE1,
  0xF8, 0x07, 0xC7, 0xC3, 0xF0, 0x1F, 0x8F, 0x87, 0xE0, 0x3F, 0x1F, 0x0F,
  0x80, 0x7E, 0x3E, 0x1F, 0x00, 0xF8, 0x7E, 0x7E, 0x01, 0xF0, 0xFC, 0xFC,
  0x07, 0xE0, 0xF9, 0xF8, 0x0F, 0xC1, 0xF3, 0xE0, 0x1F, 0x83, 0xE7, 0xC0,
  0x3E, 0x07, 0xDF, 0x80, 0x7C, 0x0F, 0xFF, 0x01, 0xF8, 0x1F, 0xFE, 0x03,
  0xF0, 0x1F, 0xF8, 0x07, 0xE0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x1F,
  0x00, 0xFF, 0xC0, 0x7E, 0x01, 0xFF, 0x00, 0xFC, 0x03, 0xFE, 0x01, 0xF8,
  0x03, 0xFC, 0x03, 0xE0, 0x07, 0xF8, 0x0F, 0xC0, 0x0F, 0xF0, 0x1F, 0x80,
  0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x0F,
  0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xC7, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F,
  0x00, 0x0F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7F,
  0x7E, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00,
  0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xCF, 0xE0, 0x07, 0xF3, 0xF0,
  0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xC3,
  0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7E, 0x1F, 0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x7F,
  0x07, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80,
  0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x1F, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF0, 0x0F, 0xC3, 0xF8, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0,
  0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF,
  0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x0F, 0xCF, 0xE0, 0x07, 0xF3, 0xF0, 0x01, 0xFC, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xC3, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x3E, 0x03,
  0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0,
  0xFE, 0x07, 0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x1F, 0x00, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03,
  0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xF8, 0x38, 0x07, 0xF0, 0x04, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x40, 0x07, 0xF0, 0x30, 0x07, 0xF0, 0x3F, 0x1F, 0xF8, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x3F,
  0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x03, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x00,
  0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x7F, 0x07,
  0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xF0, 0x7E, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xE3, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x04, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0xFD,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFB, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFD, 0xF8, 0x03, 0xF0, 0x07, 0xE7,
  0xE0, 0x0F, 0xC0, 0x1F, 0x9F, 0x80, 0x7F, 0x00, 0x7E, 0x7E, 0x01, 0xFC,
  0x03, 0xF1, 0xF0, 0x07, 0xF0, 0x0F, 0xC7, 0xC0, 0x3F, 0xC0, 0x7E, 0x1F,
  0x00, 0xFF, 0x01, 0xF8, 0x7C, 0x07, 0xFC, 0x07, 0xE1, 0xF0, 0x1F, 0xF0,
  0x3F, 0x07, 0xC0, 0x7F, 0xC0, 0xFC, 0x1F, 0x03, 0xFF, 0x03, 0xF0, 0x7C,
  0x0F, 0xFC, 0x1F, 0x83, 0xF0, 0x7D, 0xF0, 0x7E, 0x0F, 0xC1, 0xF7, 0xC3,
  0xF0, 0x3F, 0x07, 0xDF, 0x0F, 0xC0, 0xFC, 0x3E, 0x78, 0x3F, 0x03, 0xF0,
  0xF9, 0xE1, 0xF8, 0x0F, 0xC3, 0xE7, 0x87, 0xE0, 0x3F, 0x1F, 0x3E, 0x3F,
  0x00, 0xFC, 0x7C, 0xF8, 0xFC, 0x03, 0xF3, 0xE3, 0xE3, 0xF0, 0x0F, 0xCF,
  0x8F, 0x9F, 0x80, 0x3F, 0x3E, 0x3E, 0x7E, 0x00, 0xFD, 0xF0, 0xF9, 0xF0,
  0x03, 0xF7, 0xC3, 0xEF, 0xC0, 0x0F, 0xFE, 0x0F, 0xBF, 0x00, 0x3F, 0xF8,
  0x3F, 0xF8, 0x00, 0xFB, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xFC,
  0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xC7, 0xC0,
  0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x7F,
  0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x07,
  0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x81,
  0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0x80, 0x7E, 0x7E, 0x01, 0xF9,
  0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x41, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xF3, 0xE0,
  0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x1F, 0x80, 0xFC, 0x1F, 0x01,
  0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0xFC, 0x3E, 0x00, 0xF8, 0xFC,
  0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x7F, 0x1F, 0x87, 0xE3, 0xF0,
  0xF8, 0x7E, 0x1F, 0x07, 0x80, 0x00, 0x7E, 0x1F, 0x01, 0xFF, 0x3F, 0x03,
  0xFF, 0xBE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F,
  0xC1, 0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xF7, 0xC0, 0x7F, 0xF7, 0xC0, 0x3F, 0xE7, 0xC0, 0x1F, 0x87, 0xC0, 0x02,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x3F, 0x00, 0x7E, 0xFF, 0x80, 0xFB, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFC, 0x1F, 0xC1, 0xF8, 0x7F, 0x03, 0xF0,
  0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x3F, 0x1F,
  0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xF8, 0x07, 0xF1, 0xF0,
  0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x01,
  0xF8, 0x7E, 0x03, 0xF1, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x87, 0xF8, 0x7E,
  0x0F, 0xFB, 0xFC, 0x3F, 0xFF, 0xF0, 0x7D, 0xFF, 0xC0, 0xF9, 0xFF, 0x01,
  0xF1, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0x0C, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x20, 0x7E, 0x06, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0xCF, 0x80, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xF8, 0x7F, 0x80, 0xFC,
  0x1F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x03,
  0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0x80, 0x7E,
  0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x3F, 0x80,
  0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x1F, 0xE0,
  0x3F, 0xDF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xDF, 0x00, 0x3F, 0xE7,
  0xC0, 0x07, 0xF1, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x3F, 0x07, 0xF0, 0xFC,
  0x3F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF1, 0xF8, 0x0F, 0x8F, 0xC0,
  0xFC, 0x7C, 0x0F, 0xC7, 0xE3, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x01, 0x03, 0xF8, 0x78, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xF1, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x13, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x11, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x87, 0xC0, 0x1F, 0xF3, 0xF0, 0x0F, 0xFE, 0xF8, 0x07, 0xFF,
  0xBE, 0x01, 0xFF, 0xFF, 0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0x07, 0xF0, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xF0,
  0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07,
  0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0,
  0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x3F, 0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFB, 0xF0, 0x01, 0xFC,
  0xFC, 0x00, 0x10, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x80, 0x1F, 0xC0,
  0x38, 0x0F, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x7E, 0xFF,
  0x80, 0xFB, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF1, 0xFC,
  0x1F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xF8, 0x0F, 0x83,
  0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E,
  0x03, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0,
  0x7E, 0x1F, 0x80, 0xF8, 0x3F, 0x03, 0xF0, 0x7C, 0x07, 0xE1, 0xF8, 0x0F,
  0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x8F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF8,
  0x1F, 0x83, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xF8,
  0x03, 0xF1, 0xFC, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3E,
  0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0xFC, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80,
  0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x3F, 0x00, 0xFB, 0xFE, 0x3F, 0xE0, 0x3D,
  0xFF, 0xDF, 0xFC, 0x1F, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFE, 0x3F, 0xE3, 0xF0, 0x7F, 0x0F, 0xF0, 0xFC, 0x1F, 0x83, 0xF8, 0x3F,
  0x0F, 0xC0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x3E, 0x03, 0xF0, 0x3F, 0x1F, 0x80, 0xF8, 0x0F, 0x87, 0xE0, 0x7E,
  0x07, 0xE1, 0xF8, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE0, 0x7E, 0x1F, 0x01,
  0xF8, 0x1F, 0x0F, 0xC0, 0x7C, 0x07, 0xC3, 0xF0, 0x3F, 0x03, 0xF0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x3F, 0x0F, 0x80, 0xF8, 0x0F, 0x87,
  0xE0, 0x3E, 0x07, 0xE1, 0xF8, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE0, 0x7E,
  0x1F, 0x01, 0xF8, 0x1F, 0x8F, 0xC0, 0x7C, 0x07, 0xC3, 0xF0, 0x3F, 0x03,
  0xF0, 0xFC, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xE3,
  0xF0, 0x07, 0x8F, 0xF8, 0x0F, 0x3F, 0xF0, 0x3E, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFF, 0x1F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E,
  0x1F, 0x80, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0x83, 0xF0, 0x3F, 0x07, 0xC0,
  0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xFC, 0x0F,
  0xC1, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7C, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x80, 0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x7E, 0x01,
  0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7C, 0x01, 0xFB,
  0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xF3, 0xF0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF0, 0x7E, 0x1F, 0xC1, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x7C, 0x7F, 0x00, 0x1F, 0x3F, 0xE0, 0x07, 0xDF,
  0xF8, 0x03, 0xEF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xC3, 0xF0, 0x0F,
  0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x1F, 0x81, 0xF8,
  0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xF1, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7E, 0xFF, 0xC0, 0x1F, 0xBF,
  0xE0, 0x07, 0xE7, 0xF0, 0x01, 0xF8, 0x20, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x1F, 0x01, 0xFF, 0x3E, 0x03, 0xFF, 0xBE, 0x03, 0xFF, 0xBE, 0x07,
  0xFF, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x80, 0xFC, 0x1F,
  0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E,
  0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC,
  0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFE,
  0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xEF, 0xC0, 0x1F, 0xCF, 0xC0, 0x04, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x7C,
  0xFC, 0x0F, 0xBF, 0x83, 0xEF, 0xE0, 0x7D, 0xFC, 0x0F, 0xFF, 0x81, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x0C, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x08, 0x07, 0xF0, 0xC0, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x02,
  0x00, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xFF, 0x9F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x00, 0x80, 0x00,
  0x07, 0xE0, 0x7E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF8, 0x7E, 0x03, 0xE0,
  0xFC, 0x07, 0xC1, 0xF8, 0x1F, 0x83, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x80, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xF8, 0x0F, 0xC3, 0xF0,
  0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3E, 0x03,
  0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xC0, 0x7E,
  0x0F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x3F, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xDF, 0x03, 0xFF, 0xFC, 0x07, 0xFE, 0xF8, 0x07,
  0xF1, 0xF0, 0x01, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF,
  0xC1, 0xF8, 0xFC, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F, 0x07, 0xC3, 0xE0,
  0x7C, 0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xCF, 0xC0, 0x7C, 0xF8,
  0x07, 0xDF, 0x80, 0x7D, 0xF0, 0x07, 0xDF, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0xFC, 0x0F, 0xE0, 0x3F, 0xFC, 0x0F, 0xE0, 0x7E, 0xFC, 0x0F, 0xE0,
  0x7E, 0xFC, 0x1F, 0xE0, 0x7C, 0xFC, 0x1F, 0xE0, 0xFC, 0xFC, 0x1F, 0xE0,
  0xFC, 0xFC, 0x3F, 0xE0, 0xF8, 0xFC, 0x3D, 0xE1, 0xF8, 0xFC, 0x7F, 0xE1,
  0xF0, 0xFC, 0x7F, 0xE3, 0xF0, 0xFC, 0x7B, 0xE3, 0xF0, 0xFC, 0xFB, 0xE3,
  0xE0, 0xFC, 0xFB, 0xE7, 0xE0, 0xFD, 0xF3, 0xE7, 0xC0, 0xFD, 0xF3, 0xE7,
  0xC0, 0xF9, 0xE3, 0xEF, 0xC0, 0xFB, 0xE3, 0xEF, 0x80, 0xFB, 0xE3, 0xFF,
  0x80, 0xFB, 0xC3, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFC,
  0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x01, 0xF3, 0xF0, 0x00,
  0x7D, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x3F,
  0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x00, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x00, 0xF8,
  0x0F, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x3F,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E,
  0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7C, 0xF8,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x06, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x04, 0xFF, 0x00, 0x17, 0xFF, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xA0, 0x07, 0xFC, 0x80, 0x01, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 15, 40, 13, 0, -39 },
  { 76, 18, 14, 21, 5, -39 },
  { 108, 27, 39, 25, 0, -39 },
  { 240, 24, 45, 23, 0, -42 },
  { 375, 32, 41, 37, 3, -40 },
  { 539, 26, 41, 27, 0, -40 },
  { 673, 9, 14, 12, 5, -39 },
  { 689, 18, 48, 15, 1, -39 },
  { 797, 18, 49, 15, -4, -40 },
  { 908, 19, 21, 22, 5, -42 },
  { 958, 22, 27, 25, 2, -33 },
  { 1033, 11, 14, 12, -3, -7 },
  { 1053, 13, 6, 15, 1, -18 },
  { 1063, 8, 9, 12, 0, -8 },
  { 1072, 27, 40, 20, -3, -40 },
  { 1207, 22, 41, 23, 1, -40 },
  { 1320, 17, 39, 23, 5, -39 },
  { 1403, 25, 40, 23, -2, -40 },
  { 1528, 24, 41, 23, -1, -40 },
  { 1651, 24, 39, 23, -1, -39 },
  { 1768, 24, 40, 23, 0, -39 },
  { 1888, 23, 41, 23, 1, -40 },
  { 2006, 25, 39, 23, 1, -39 },
  { 2128, 24, 41, 23, 0, -40 },
  { 2251, 23, 41, 23, 0, -40 },
  { 2369, 12, 31, 13, 0, -30 },
  { 2416, 15, 37, 13, -3, -30 },
  { 2486, 22, 25, 25, 2, -32 },
  { 2555, 22, 16, 25, 2, -27 },
  { 2599, 22, 25, 25, 2, -32 },
  { 2668, 19, 41, 17, 1, -40 },
  { 2766, 33, 45, 34, 1, -40 },
  { 2952, 24, 39, 24, -3, -39 },
  { 3069, 26, 39, 25, 0, -39 },
  { 3196, 25, 41, 23, 2, -40 },
  { 3325, 27, 39, 27, 0, -39 },
  { 3457, 24, 39, 21, 0, -39 },
  { 3574, 24, 39, 20, 0, -39 },
  { 3691, 28, 41, 28, 2, -40 },
  { 3835, 30, 39, 28, 0, -39 },
  { 3982, 23, 39, 16, -3, -39 },
  { 4095, 23, 50, 13, -8, -39 },
  { 4239, 29, 39, 24, 0, -39 },
  { 4381, 17, 39, 20, 0, -39 },
  { 4464, 39, 39, 37, 0, -39 },
  { 4655, 31, 39, 30, 0, -39 },
  { 4807, 26, 41, 29, 2, -40 },
  { 4941, 26, 39, 24, 0, -39 },
  { 5068, 26, 49, 29, 2, -40 },
  { 5228, 25, 39, 25, 0, -39 },
  { 5350, 25, 41, 22, -1, -40 },
  { 5479, 21, 39, 21, 4, -39 },
  { 5582, 27, 40, 27, 2, -39 },
  { 5717, 24, 39, 24, 5, -39 },
  { 5834, 38, 39, 38, 4, -39 },
  { 6020, 30, 39, 23, -3, -39 },
  { 6167, 22, 39, 22, 5, -39 },
  { 6275, 26, 39, 20, -2, -39 },
  { 6402, 21, 48, 16, -2, -39 },
  { 6528, 11, 40, 20, 5, -40 },
  { 6583, 22, 48, 16, -4, -39 },
  { 6715, 23, 22, 23, 0, -39 },
  { 6779, 18, 3, 17, -5, 5 },
  { 6786, 9, 9, 15, 8, -42 },
  { 6797, 24, 31, 25, 1, -30 },
  { 6890, 23, 43, 24, 0, -42 },
  { 7014, 20, 31, 19, 1, -30 },
  { 7092, 26, 43, 25, 1, -42 },
  { 7232, 21, 31, 22, 1, -30 },
  { 7314, 27, 55, 14, -6, -42 },
  { 7500, 26, 43, 25, -1, -30 },
  { 7640, 23, 42, 24, 0, -42 },
  { 7761, 14, 41, 12, 0, -41 },
  { 7833, 21, 54, 12, -7, -41 },
  { 7975, 25, 42, 22, 0, -42 },
  { 8107, 15, 42, 12, 0, -42 },
  { 8186, 34, 30, 36, 0, -30 },
  { 8314, 23, 30, 24, 0, -30 },
  { 8401, 22, 31, 24, 1, -30 },
  { 8487, 26, 43, 24, -3, -30 },
  { 8627, 24, 43, 24, 1, -30 },
  { 8756, 19, 30, 17, 0, -30 },
  { 8828, 20, 31, 19, 0, -30 },
  { 8906, 15, 37, 15, 2, -36 },
  { 8976, 23, 31, 24, 1, -30 },
  { 9066, 20, 30, 21, 3, -30 },
  { 9141, 32, 30, 32, 3, -30 },
  { 9261, 26, 30, 21, -3, -30 },
  { 9359, 29, 43, 21, -5, -30 },
  { 9515, 21, 30, 17, -2, -30 },
  { 9594, 21, 48, 18, 1, -39 },
  { 9720, 5, 55, 20, 7, -42 },
  { 9755, 20, 48, 18, -3, -39 },
  { 9875, 22, 9, 25, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC55PT7B_H_
