#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC43PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x78, 0x00,
  0x3E, 0x7C, 0xF1, 0xF3, 0xC7, 0x9F, 0x1E, 0x7C, 0xF9, 0xE3, 0xE7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF3, 0xC3, 0xCF, 0x1E, 0x00, 0x00, 0x38, 0x70, 0x01,
  0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x78, 0xF0,
  0x03, 0x87, 0x00, 0x1C, 0x38, 0x01, 0xE3, 0xC0, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE0, 0x3C, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x3C, 0x00,
  0xF1, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0xF0, 0x03, 0xC7, 0x81, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x3C,
  0x78, 0x01, 0xE3, 0x80, 0x0E, 0x1C, 0x00, 0x71, 0xE0, 0x07, 0x8E, 0x00,
  0x38, 0x70, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFE, 0x0F, 0x91, 0x81, 0xE6, 0x10, 0x3C, 0xC0, 0x07, 0x98, 0x00, 0xF3,
  0x00, 0x1F, 0x40, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xBE, 0x00, 0x37,
  0xC0, 0x04, 0xF8, 0x81, 0x9F, 0x08, 0x33, 0xC1, 0xC6, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x1E, 0x07,
  0xF0, 0x1E, 0x07, 0xF8, 0x0F, 0x03, 0xDE, 0x0F, 0x03, 0xCF, 0x07, 0x01,
  0xC7, 0x87, 0x81, 0xE3, 0xC3, 0x80, 0xF1, 0xE3, 0xC0, 0x70, 0xF1, 0xC0,
  0x38, 0x71, 0xE0, 0x3C, 0x38, 0xE0, 0x1E, 0x3C, 0xF0, 0x0F, 0x1E, 0x70,
  0xE7, 0x8E, 0x79, 0xFB, 0xCF, 0x39, 0xFF, 0xE7, 0x3C, 0xFF, 0x7F, 0xBC,
  0xE3, 0xBF, 0x9E, 0x71, 0xCF, 0x9E, 0x78, 0xE0, 0x0E, 0x38, 0x70, 0x0F,
  0x3C, 0x38, 0x07, 0x1E, 0x1C, 0x07, 0x8F, 0x1E, 0x03, 0x87, 0x0F, 0x03,
  0xC3, 0x87, 0x01, 0xC1, 0xC7, 0x81, 0xE0, 0xE3, 0xC0, 0xE0, 0x73, 0xC0,
  0xF0, 0x3F, 0xC0, 0x70, 0x1F, 0xE0, 0x78, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1E, 0x78, 0x03, 0xC7, 0xC0, 0x3C, 0x7C,
  0x03, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0xC7, 0x80, 0x7C, 0xF0, 0x03, 0xDF,
  0x00, 0x3D, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0xF1, 0xFF, 0x9F, 0x3E, 0xF9, 0xE7, 0xC7, 0xBE, 0x78,
  0x7F, 0xEF, 0x87, 0xFC, 0xF8, 0x3F, 0x8F, 0x83, 0xF8, 0xF8, 0x3F, 0x0F,
  0x83, 0xF0, 0xF8, 0x7F, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFE, 0xFC,
  0x3F, 0x87, 0xC0, 0x3E, 0x7C, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0xF3,
  0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x02, 0x1E, 0x06, 0x38,
  0x1F, 0x71, 0xBF, 0xFF, 0x7F, 0xFE, 0x1F, 0xFE, 0x1F, 0x00, 0x7F, 0x01,
  0xFF, 0x0F, 0xDE, 0x0F, 0x1E, 0x0E, 0x3E, 0x08, 0x70, 0x00, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x8F, 0x87, 0xC3, 0xC3, 0xE1,
  0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x39, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7C, 0xF8, 0x7C, 0x7C, 0x3C, 0x3E, 0x3E, 0x1F, 0x1E, 0x0F,
  0x9F, 0x07, 0xCF, 0x83, 0xE7, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x79, 0xF0,
  0x3C, 0xF0, 0x3E, 0x78, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0x9F, 0x07, 0xCF,
  0x83, 0xE7, 0xC1, 0xF3, 0xC1, 0xF1, 0xE0, 0xF8, 0xF0, 0x78, 0x78, 0x7C,
  0x3E, 0x7C, 0x1F, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x78, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFF, 0x0F, 0xF8, 0xFF, 0xCF, 0xBC,
  0xF9, 0xE3, 0x9F, 0x08, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFF,
  0x03, 0xE3, 0xF0, 0x1C, 0x1F, 0x01, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3C, 0x7E, 0x02, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x10, 0x07, 0xE3, 0x01, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x77, 0xC0, 0x0E, 0xF0, 0x03, 0x9E,
  0x00, 0xF7, 0xC0, 0x1C, 0xF8, 0x07, 0x1E, 0x01, 0xE3, 0xC0, 0x38, 0x78,
  0x0E, 0x1F, 0x03, 0xC3, 0xE0, 0x70, 0x78, 0x1E, 0x0F, 0x07, 0x83, 0xE0,
  0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8,
  0x08, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x20, 0x1F, 0x8C, 0x0F,
  0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF9,
  0xE0, 0x3C, 0xFC, 0x0F, 0x7F, 0x87, 0xFF, 0xE1, 0xFE, 0xF8, 0x7E, 0x1F,
  0x1F, 0x07, 0xCF, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x3E, 0x0F, 0x8F,
  0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3C, 0x3E, 0x1F, 0x0F, 0x8F, 0xC1, 0xFF,
  0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7C, 0x7C, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xF0, 0xF8, 0x3E, 0x3E,
  0x07, 0xCF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0x81, 0xF1,
  0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xC3,
  0xE0, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xCF, 0xC3,
  0xE1, 0xF0, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0x81, 0xF1, 0xE0,
  0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0xCF, 0x83, 0xE3, 0xE1, 0xF8, 0xFC, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFE, 0xF0, 0x1E, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0x01,
  0xE0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xF0, 0xFC,
  0x3F, 0x0F, 0x83, 0xE0, 0x00, 0x40, 0x1E, 0x03, 0xF0, 0x3F, 0x03, 0xE0,
  0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F,
  0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x7C, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF,
  0xE1, 0x87, 0xC2, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x01, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x07, 0x00, 0xF0, 0x01, 0xE0,
  0x78, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0E, 0x07, 0xC3, 0x87, 0x87, 0xFC,
  0xF1, 0xC3, 0xFE, 0x3C, 0x70, 0xE3, 0x8F, 0x38, 0x70, 0xE3, 0x8E, 0x3C,
  0x78, 0xE7, 0x8E, 0x1C, 0x39, 0xC3, 0x87, 0x0E, 0x71, 0xE1, 0xC3, 0x9C,
  0x70, 0xF1, 0xCF, 0x1C, 0x3C, 0x73, 0xC7, 0x0E, 0x1C, 0xE1, 0xC7, 0x8E,
  0x38, 0x71, 0xE3, 0x8E, 0x1C, 0xF9, 0xC3, 0x87, 0xFF, 0xF0, 0xE1, 0xF9,
  0xF8, 0x38, 0x3C, 0x7C, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x10, 0x00, 0xFE, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x0F, 0xBC, 0x01, 0xE7,
  0x80, 0x7C, 0xF0, 0x0F, 0x9E, 0x01, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x0F,
  0x03, 0xE1, 0xE0, 0x7C, 0x3C, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xC3, 0xE0, 0x78, 0xF8, 0x0F, 0x1F, 0x01, 0xE3, 0xE0, 0x3C,
  0xF8, 0x07, 0x9F, 0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xFF, 0x00, 0x78,
  0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xC3,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xE0, 0xF8, 0x1E, 0x0F, 0x83,
  0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3C, 0x07, 0x87, 0xC0, 0xF8,
  0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0x7C, 0x3F, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xF0, 0xC0, 0x7E, 0x04, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x0C, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F,
  0xFF, 0x03, 0xE1, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8,
  0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0x80,
  0xFC, 0x7C, 0x07, 0xE3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87,
  0x80, 0xFC, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF8, 0x7C, 0x1F, 0x83, 0xE1, 0xF8, 0x1F, 0x3F, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0x0F, 0x07, 0xE0, 0x10, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x7F, 0x9F, 0x07, 0xFC, 0xF8, 0x3F, 0xC7, 0xC1,
  0xFE, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xC3,
  0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3F, 0x07,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0,
  0x3C, 0x03, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8,
  0x0F, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3E, 0x03, 0xE0, 0x78, 0x07, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x3E, 0x01, 0xE0, 0x7C, 0x07, 0xC0,
  0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xBF,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x1E, 0x0F, 0xC0, 0x3C, 0x1F,
  0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0x8F, 0x80,
  0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xC0, 0x01,
  0xEF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xC7,
  0x80, 0x0F, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0x7C, 0x03, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x0F,
  0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x03, 0xF8,
  0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x03,
  0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xEF,
  0x03, 0xDE, 0x07, 0xFC, 0x0F, 0x78, 0x3D, 0xF0, 0x3D, 0xE0, 0xF7, 0xC1,
  0xF7, 0x87, 0x9E, 0x07, 0xDE, 0x1E, 0x78, 0x1E, 0x78, 0xFB, 0xE0, 0x79,
  0xE3, 0xCF, 0x81, 0xE7, 0x8F, 0x3C, 0x0F, 0x9E, 0x78, 0xF0, 0x3E, 0x79,
  0xE7, 0xC0, 0xF1, 0xEF, 0x1F, 0x03, 0xC7, 0xBC, 0x7C, 0x0F, 0x1F, 0xE1,
  0xE0, 0x7C, 0x3F, 0x87, 0x81, 0xF0, 0xFC, 0x3E, 0x07, 0x83, 0xF0, 0xF8,
  0x1E, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0x80, 0xFC,
  0x03, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x3F, 0xC0, 0xF0, 0x1F,
  0xE0, 0x78, 0x0F, 0xF0, 0x3C, 0x07, 0xF8, 0x3E, 0x07, 0xFC, 0x1F, 0x03,
  0xFE, 0x0F, 0x01, 0xE7, 0x87, 0x80, 0xF3, 0xC3, 0xC0, 0x79, 0xE3, 0xE0,
  0x7C, 0xF1, 0xF0, 0x3E, 0x78, 0xF0, 0x1E, 0x3C, 0x78, 0x0F, 0x0F, 0x3C,
  0x07, 0x87, 0xBE, 0x07, 0xC3, 0xDF, 0x03, 0xE1, 0xEF, 0x01, 0xE0, 0xF7,
  0x80, 0xF0, 0x7F, 0xC0, 0x78, 0x1F, 0xE0, 0x7C, 0x0F, 0xE0, 0x3E, 0x07,
  0xF0, 0x1E, 0x03, 0xF8, 0x0F, 0x01, 0xFC, 0x0F, 0x80, 0xFE, 0x07, 0xC0,
  0x3E, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x1F, 0x83, 0xE0, 0xFC, 0x3F, 0x03, 0xE1,
  0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x7C, 0x01,
  0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0x7C,
  0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xC0, 0x3E,
  0x7E, 0x01, 0xF3, 0xF0, 0x1F, 0x8F, 0x80, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0,
  0xFC, 0x1F, 0x8F, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xE0,
  0xF0, 0x3E, 0x1F, 0x07, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0,
  0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x1F, 0x83, 0xE0,
  0xFC, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xCF,
  0xC0, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7D, 0xF8, 0x03,
  0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8,
  0x07, 0xE7, 0xC0, 0x3E, 0x7E, 0x01, 0xF3, 0xF0, 0x1F, 0x8F, 0x80, 0xF8,
  0x7C, 0x0F, 0xC3, 0xE0, 0xFC, 0x1F, 0x8F, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03,
  0xC7, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0x81, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0xF0, 0x7C,
  0x1F, 0x1F, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x3C, 0x03, 0xC3,
  0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFB, 0xE0, 0x7E, 0x04, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x04, 0x03, 0xE0,
  0x70, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF0,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x1F, 0x01,
  0xF0, 0x7C, 0x07, 0x81, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0,
  0xF8, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0,
  0x1F, 0x07, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E,
  0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xC0, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F,
  0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF8, 0x3E, 0x03,
  0xE0, 0xF8, 0x1F, 0x03, 0xF0, 0x7C, 0x07, 0xC3, 0xF0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xF8, 0x03, 0xFF,
  0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1E, 0x3E,
  0x07, 0xC7, 0x80, 0xF8, 0xF0, 0x3E, 0x1E, 0x07, 0xC3, 0xC1, 0xF0, 0x78,
  0x3E, 0x0F, 0x07, 0x81, 0xE1, 0xF0, 0x3C, 0x3E, 0x07, 0x8F, 0x80, 0xF1,
  0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x7C, 0x01, 0xEF,
  0x80, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x7D, 0xE0, 0x1E, 0x01, 0xE7, 0x80, 0xF8, 0x0F, 0x9E, 0x03,
  0xE0, 0x3E, 0x78, 0x0F, 0x80, 0xF1, 0xE0, 0x7E, 0x07, 0xC7, 0x81, 0xF8,
  0x1F, 0x1E, 0x07, 0xE0, 0xF8, 0x78, 0x3F, 0x83, 0xE1, 0xE0, 0xFE, 0x0F,
  0x07, 0x87, 0xF8, 0x7C, 0x1E, 0x1F, 0xE1, 0xF0, 0xF8, 0x77, 0x8F, 0x83,
  0xE3, 0xDE, 0x3E, 0x0F, 0x8F, 0x78, 0xF0, 0x3E, 0x79, 0xE7, 0xC0, 0xF9,
  0xE7, 0x9F, 0x03, 0xE7, 0x9E, 0x78, 0x0F, 0xBC, 0x7B, 0xE0, 0x3E, 0xF1,
  0xEF, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xDE, 0x1F, 0xF0, 0x0F, 0x78, 0x7F,
  0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03,
  0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x78, 0x00,
  0xF8, 0xF8, 0x00, 0x78, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0x79, 0xE0, 0x00,
  0x7B, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xEF, 0x00, 0x03,
  0xEF, 0x00, 0x03, 0xCF, 0x00, 0x07, 0xCF, 0x80, 0x0F, 0x8F, 0x80, 0x0F,
  0x8F, 0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x07, 0x80, 0x7C,
  0x07, 0xC0, 0xFC, 0x07, 0xC0, 0xF8, 0x0F, 0xFC, 0x0F, 0xBE, 0x07, 0xDF,
  0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF1, 0xF0, 0x78, 0xF8,
  0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x7C, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3C,
  0x3C, 0x1F, 0x07, 0x87, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x78, 0x03,
  0xFE, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0xF9, 0xF1, 0xE3, 0xE3,
  0xC3, 0x80, 0x00, 0xC0, 0x00, 0xFC, 0xF0, 0x7F, 0xBC, 0x3F, 0xFF, 0x1F,
  0x9F, 0xC7, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x7C, 0x0F, 0x9F, 0x03,
  0xE7, 0xC0, 0xF1, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xE3,
  0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xE3, 0xF0, 0xFF,
  0xFC, 0x3F, 0xEF, 0x07, 0xF3, 0xC0, 0xF8, 0xF0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE3, 0x80, 0x7B, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC3, 0xF9, 0xF0, 0xF8, 0x7C, 0x7E, 0x1F, 0x1F, 0x03, 0xC7, 0xC1,
  0xF1, 0xE0, 0x7C, 0x78, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x78,
  0xF0, 0x3E, 0x3C, 0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7E,
  0x3E, 0x1F, 0xFF, 0x8F, 0x7F, 0xC3, 0xDF, 0xE0, 0xF3, 0xF0, 0x00, 0x00,
  0x78, 0x07, 0xFC, 0x1F, 0xF8, 0x7F, 0xE1, 0xFC, 0xC3, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC1,
  0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x0C, 0x3C, 0x03, 0xF3, 0xC0,
  0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xF9, 0xFC, 0x1F, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x07, 0xC0, 0xF0, 0x78, 0x0F,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0x1E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0xF8, 0x7C, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFB, 0xC0, 0x3F, 0x38, 0x00, 0x00, 0x70, 0x03, 0xFC, 0x07,
  0xFE, 0x0F, 0xFF, 0x1F, 0x1F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3C, 0x1F, 0x7C,
  0x1E, 0x7C, 0x3E, 0x7B, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0x80, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x08, 0xFC,
  0x78, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xF9, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x0F, 0xCF, 0x01, 0xFE, 0xF0, 0x3F, 0xFF, 0x07, 0xE7,
  0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x03, 0xE1, 0xF0,
  0x3E, 0x1F, 0x03, 0xC1, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E,
  0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x83,
  0xE3, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xF9, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x0C, 0x0F, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE3, 0x80,
  0x7B, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xF8, 0x7C, 0x7E,
  0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xE1, 0xF0, 0x78, 0x78, 0x3E, 0x3E, 0x0F,
  0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1F, 0x1F, 0x07, 0xC7,
  0xC1, 0xF1, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0,
  0xF8, 0xF8, 0x3C, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0xF8, 0x1E, 0x1E, 0x03, 0xC7, 0xC0,
  0x79, 0xF0, 0x1F, 0x7C, 0x03, 0xCF, 0x00, 0x7B, 0xE0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3E, 0xF8, 0x0F,
  0x8F, 0x01, 0xF1, 0xE0, 0x3C, 0x3E, 0x07, 0x87, 0xC0, 0xF0, 0xF8, 0x3E,
  0x0F, 0x07, 0xC1, 0xF0, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x0E, 0x07, 0x00, 0xE7, 0xF3, 0xF8,
  0x3D, 0xFE, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFC, 0xFF, 0x7E, 0x1F, 0x0F,
  0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x3C, 0x1F, 0x1F, 0x07, 0x83, 0xC3,
  0xC1, 0xF0, 0x78, 0x78, 0x3E, 0x0F, 0x1F, 0x07, 0x83, 0xE3, 0xE0, 0xF0,
  0x7C, 0x7C, 0x1E, 0x0F, 0x0F, 0x07, 0xC1, 0xE1, 0xE0, 0xF8, 0x7C, 0x7C,
  0x1E, 0x0F, 0x8F, 0x83, 0xC1, 0xF1, 0xE0, 0xF8, 0x3C, 0x3C, 0x1F, 0x07,
  0x87, 0x83, 0xE1, 0xF1, 0xF0, 0x78, 0x3E, 0x3E, 0x0F, 0x07, 0x87, 0x83,
  0xE0, 0xF0, 0x00, 0x0C, 0x01, 0xCF, 0xE0, 0xF7, 0xF8, 0x3F, 0xFF, 0x0F,
  0xEF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0x87, 0xC1,
  0xE1, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xC3, 0xC0, 0xF0,
  0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xE1, 0xE0, 0x78, 0x78,
  0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0x00, 0xF0, 0x01, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFB, 0xF0, 0xF8, 0x78, 0xF8, 0x3E, 0x78,
  0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDE, 0x03, 0xCF, 0x01, 0xEF, 0x80, 0xF7,
  0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x1F,
  0x1F, 0x0F, 0x87, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0x80, 0x00,
  0x01, 0x80, 0x1C, 0xFE, 0x03, 0xDF, 0xE0, 0x3D, 0xFF, 0x03, 0xF1, 0xF0,
  0x3E, 0x1F, 0x03, 0xE0, 0xF0, 0x7C, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x1F,
  0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x03,
  0xE0, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8,
  0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xCF, 0xC0, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0xFC, 0xF0, 0x7F, 0xBC, 0x3F, 0xFF, 0x1F, 0x9F, 0xC7,
  0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3C, 0x0F, 0x9F, 0x03, 0xC7, 0xC0,
  0xF1, 0xE0, 0x3C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0x78,
  0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xE1, 0xF0, 0xFF, 0xFC, 0x3F,
  0xEF, 0x07, 0xFF, 0xC0, 0xF9, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x0E, 0x7C, 0x3D, 0xF8, 0x7B,
  0xE0, 0xFF, 0xC1, 0xFC, 0x87, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0xFF, 0xF1, 0xF0, 0xC3,
  0xC0, 0x8F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x07, 0xC4, 0x0F, 0x8F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC0, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0x78, 0x0F, 0x81, 0xFF, 0x3F, 0xF7, 0xFE, 0x1F,
  0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF,
  0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x0F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x78,
  0x78, 0x1E, 0x1E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF8, 0x3C, 0x3C,
  0x0F, 0x0F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x0F,
  0x87, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F, 0xC3,
  0xFF, 0xF0, 0xFF, 0xBC, 0x1F, 0xDE, 0x07, 0xE7, 0x80, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xF7, 0x83, 0xEF, 0x07, 0x9E, 0x1F, 0x3C, 0x3C, 0x78, 0xF8,
  0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x87, 0x9E, 0x0F, 0x7C, 0x1E, 0xF0, 0x3D,
  0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x00, 0x78, 0x3F, 0x07, 0xBC, 0x1F, 0x07, 0xDE,
  0x1F, 0x83, 0xCF, 0x0F, 0xC3, 0xE7, 0x87, 0xE1, 0xE3, 0xC7, 0xF0, 0xF1,
  0xE3, 0xB8, 0xF8, 0xF3, 0xDC, 0x78, 0x79, 0xEE, 0x3C, 0x3C, 0xEF, 0x3C,
  0x3E, 0xF7, 0x9E, 0x1F, 0x7B, 0xDF, 0x0F, 0xB9, 0xEF, 0x07, 0xFC, 0xF7,
  0x83, 0xDC, 0x7F, 0x81, 0xEE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0xFC, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x3C, 0x3E, 0x03, 0xC3,
  0xC0, 0x3C, 0x7C, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x7B, 0xC0, 0x0F, 0xBC, 0x01,
  0xF3, 0xC0, 0x1E, 0x3E, 0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0,
  0xF8, 0x1F, 0x00, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0xF8, 0x07, 0x81, 0xE0,
  0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x7C, 0x00,
  0xF0, 0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0x9F, 0x00, 0x0F,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xC3, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01,
  0xFC, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0xFF, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x1F, 0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0x80, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xF4, 0x03, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 12, 31, 10, 0, -31 },
  { 48, 14, 11, 16, 4, -31 },
  { 68, 21, 31, 20, 0, -31 },
  { 150, 19, 36, 18, 0, -33 },
  { 236, 25, 31, 29, 2, -31 },
  { 333, 20, 31, 21, 0, -31 },
  { 411, 7, 11, 10, 4, -31 },
  { 421, 14, 38, 11, 1, -31 },
  { 488, 14, 38, 11, -3, -31 },
  { 555, 15, 17, 17, 4, -33 },
  { 587, 17, 20, 19, 2, -25 },
  { 630, 9, 11, 10, -2, -5 },
  { 643, 10, 5, 12, 1, -14 },
  { 650, 6, 6, 10, 0, -6 },
  { 655, 21, 31, 15, -2, -31 },
  { 737, 17, 31, 18, 1, -31 },
  { 803, 13, 31, 18, 4, -31 },
  { 854, 20, 31, 18, -2, -31 },
  { 932, 19, 31, 18, -1, -31 },
  { 1006, 19, 31, 18, -1, -31 },
  { 1080, 18, 31, 18, 0, -31 },
  { 1150, 18, 31, 18, 1, -31 },
  { 1220, 19, 31, 18, 1, -31 },
  { 1294, 19, 31, 18, 0, -31 },
  { 1368, 18, 31, 18, 0, -31 },
  { 1438, 10, 24, 10, 0, -24 },
  { 1468, 12, 30, 10, -2, -24 },
  { 1513, 17, 20, 19, 2, -25 },
  { 1556, 17, 12, 19, 2, -21 },
  { 1582, 17, 20, 19, 2, -25 },
  { 1625, 15, 31, 14, 1, -31 },
  { 1684, 26, 35, 27, 1, -31 },
  { 1798, 19, 31, 19, -3, -31 },
  { 1872, 20, 31, 20, 0, -31 },
  { 1950, 20, 31, 18, 1, -31 },
  { 2028, 21, 31, 21, 0, -31 },
  { 2110, 19, 31, 17, 0, -31 },
  { 2184, 19, 31, 16, 0, -31 },
  { 2258, 21, 31, 22, 2, -31 },
  { 2340, 23, 31, 22, 0, -31 },
  { 2430, 18, 31, 13, -2, -31 },
  { 2500, 18, 40, 10, -7, -31 },
  { 2590, 23, 31, 19, 0, -31 },
  { 2680, 13, 31, 16, 0, -31 },
  { 2731, 30, 31, 29, 0, -31 },
  { 2848, 25, 31, 23, 0, -31 },
  { 2945, 21, 31, 23, 1, -31 },
  { 3027, 20, 31, 19, 0, -31 },
  { 3105, 21, 38, 23, 1, -31 },
  { 3205, 20, 31, 19, 0, -31 },
  { 3283, 20, 31, 17, -1, -31 },
  { 3361, 17, 31, 16, 3, -31 },
  { 3427, 22, 31, 21, 1, -31 },
  { 3513, 19, 31, 19, 4, -31 },
  { 3587, 30, 31, 29, 3, -31 },
  { 3704, 24, 31, 18, -3, -31 },
  { 3797, 17, 31, 17, 4, -31 },
  { 3863, 21, 31, 16, -2, -31 },
  { 3945, 17, 38, 12, -2, -31 },
  { 4026, 8, 31, 16, 4, -31 },
  { 4057, 17, 38, 12, -3, -31 },
  { 4138, 18, 18, 18, 0, -31 },
  { 4179, 14, 2, 14, -4, 4 },
  { 4183, 7, 7, 12, 6, -33 },
  { 4190, 18, 24, 19, 1, -24 },
  { 4244, 18, 33, 19, 0, -33 },
  { 4319, 15, 24, 15, 1, -24 },
  { 4364, 20, 33, 19, 1, -33 },
  { 4447, 16, 24, 18, 1, -24 },
  { 4495, 21, 43, 11, -5, -33 },
  { 4608, 20, 34, 19, -1, -24 },
  { 4693, 18, 33, 19, 0, -33 },
  { 4768, 11, 32, 9, 0, -32 },
  { 4812, 16, 42, 9, -5, -32 },
  { 4896, 19, 33, 17, 0, -33 },
  { 4975, 11, 33, 9, 0, -33 },
  { 5021, 27, 24, 28, 0, -24 },
  { 5102, 18, 24, 19, 0, -24 },
  { 5156, 17, 24, 19, 1, -24 },
  { 5207, 20, 34, 19, -2, -24 },
  { 5292, 18, 34, 19, 1, -24 },
  { 5369, 15, 24, 13, 0, -24 },
  { 5414, 15, 24, 15, 0, -24 },
  { 5459, 12, 28, 12, 1, -28 },
  { 5501, 18, 23, 19, 1, -23 },
  { 5553, 15, 23, 16, 3, -23 },
  { 5597, 25, 23, 25, 2, -23 },
  { 5669, 20, 23, 16, -2, -23 },
  { 5727, 23, 33, 16, -4, -23 },
  { 5822, 17, 23, 14, -2, -23 },
  { 5871, 16, 38, 14, 1, -31 },
  { 5947, 4, 43, 16, 6, -33 },
  { 5969, 17, 38, 14, -3, -31 },
  { 6050, 17, 6, 19, 2, -18 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC43PT7B_H_
