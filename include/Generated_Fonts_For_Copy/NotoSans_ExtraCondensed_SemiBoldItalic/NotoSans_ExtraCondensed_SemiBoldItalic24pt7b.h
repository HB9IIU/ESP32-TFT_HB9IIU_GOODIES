#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC24PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x70, 0xE1, 0x83, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x80,
  0x00, 0x18, 0x70, 0xE0, 0x77, 0x77, 0x66, 0x66, 0x66, 0xCE, 0x06, 0x60,
  0x66, 0x06, 0x40, 0xCC, 0x0C, 0xD3, 0xFE, 0x3F, 0xE1, 0x98, 0x19, 0x81,
  0x30, 0xFF, 0xCF, 0xFC, 0x36, 0x06, 0x60, 0x66, 0x06, 0x40, 0xCC, 0x00,
  0x01, 0x00, 0x40, 0xFC, 0x7F, 0x3A, 0x8E, 0x83, 0xA0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x2E, 0x0B, 0xA2, 0xEE, 0xF3, 0xFC, 0x7C, 0x04, 0x01, 0x00,
  0x1C, 0x38, 0xF8, 0xC6, 0x66, 0x19, 0x98, 0x66, 0xC3, 0x33, 0x0C, 0xD8,
  0xB3, 0x6F, 0xFB, 0x6D, 0xCD, 0xB0, 0x6C, 0xC1, 0xB3, 0x0C, 0xCC, 0x33,
  0x31, 0x8D, 0x8C, 0x3E, 0x30, 0xF0, 0x07, 0x81, 0xF8, 0x77, 0x0C, 0xE1,
  0x98, 0x3F, 0x07, 0xC0, 0x70, 0x3E, 0x6F, 0xCD, 0x9B, 0xF3, 0xEE, 0x7D,
  0xC7, 0x39, 0xE7, 0xFE, 0x7D, 0xC0, 0x77, 0x66, 0x6E, 0x07, 0x06, 0x0C,
  0x1C, 0x18, 0x38, 0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0,
  0xE0, 0xE0, 0x60, 0x60, 0x60, 0x70, 0x06, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x1C, 0x18, 0x38,
  0x30, 0x60, 0xE0, 0x0C, 0x8C, 0xF9, 0xFF, 0x1F, 0x3C, 0xFE, 0x66, 0x04,
  0x0C, 0x06, 0x03, 0x01, 0x8F, 0xFF, 0xFF, 0xFE, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0x39, 0x9C, 0xCE, 0x60, 0x7D, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x70,
  0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x00,
  0x07, 0x83, 0xF1, 0xDC, 0xE7, 0x39, 0xCC, 0x77, 0x1D, 0xC7, 0x71, 0xD8,
  0x66, 0x39, 0x8E, 0xE3, 0x39, 0xC6, 0x61, 0xF8, 0x7C, 0x00, 0x0E, 0x3C,
  0xFB, 0xFE, 0xC9, 0x87, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0C, 0x18,
  0x70, 0x07, 0xC3, 0xFC, 0x33, 0x84, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xFC, 0xFF,
  0x00, 0x1F, 0x87, 0xF1, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x7C, 0x1E,
  0x01, 0xC0, 0x38, 0x0E, 0x03, 0x81, 0xC8, 0xF3, 0xF8, 0xFC, 0x00, 0x01,
  0xC0, 0xF0, 0x3C, 0x1E, 0x05, 0x83, 0x61, 0xB8, 0x6E, 0x33, 0x18, 0xC6,
  0x73, 0xFE, 0xFF, 0x81, 0x80, 0x60, 0x38, 0x0E, 0x00, 0x0F, 0xC7, 0xF1,
  0x80, 0x60, 0x38, 0x0E, 0x03, 0xC0, 0xFC, 0x3F, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x81, 0xC8, 0xF3, 0xF8, 0xFC, 0x00, 0x07, 0xC3, 0xE1, 0xC0, 0xE0,
  0x30, 0x1C, 0x06, 0xE3, 0xFC, 0xF7, 0x38, 0xCC, 0x33, 0x1C, 0xC7, 0x31,
  0xCE, 0xE3, 0xF8, 0x78, 0x00, 0x3F, 0xDF, 0xF0, 0x18, 0x0E, 0x03, 0x01,
  0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03,
  0x80, 0xE0, 0x00, 0x0F, 0x87, 0xF3, 0x8C, 0xE3, 0x38, 0xCE, 0x71, 0xF8,
  0x7C, 0x1E, 0x0F, 0xC7, 0x3B, 0x8E, 0xE3, 0xB8, 0xEE, 0x73, 0xFC, 0x7E,
  0x00, 0x0F, 0x87, 0xF3, 0x9C, 0xE7, 0x31, 0xDC, 0x77, 0x1D, 0xCF, 0x7F,
  0x8F, 0x61, 0xB8, 0x0E, 0x07, 0x01, 0xC0, 0xE3, 0xF0, 0xF8, 0x00, 0x19,
  0xCE, 0x00, 0x00, 0x00, 0x00, 0x39, 0xCE, 0x00, 0x0C, 0x71, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x9C, 0x71, 0x8E, 0x30, 0x00, 0x81, 0xC3, 0xE7,
  0xCF, 0x87, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xC0, 0x20, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x80, 0x70, 0x3E, 0x07, 0xC0, 0xF8, 0x1C,
  0x3E, 0x7C, 0xF8, 0x70, 0x20, 0x00, 0x1F, 0x1F, 0x88, 0xE0, 0x70, 0x30,
  0x38, 0x38, 0x18, 0x18, 0x1C, 0x0C, 0x06, 0x00, 0x00, 0x01, 0xC1, 0xE0,
  0x60, 0x00, 0x03, 0xF0, 0x38, 0xE1, 0xC1, 0x8C, 0x03, 0x31, 0xED, 0x9F,
  0x36, 0x6C, 0xF3, 0x33, 0xCC, 0xCB, 0x62, 0x6D, 0x99, 0xB6, 0x64, 0x9F,
  0xB2, 0x3B, 0x88, 0x00, 0x30, 0x00, 0xE0, 0x81, 0xFE, 0x03, 0xF0, 0x00,
  0x01, 0xE0, 0x3C, 0x07, 0x81, 0xB0, 0x36, 0x0E, 0xC1, 0x98, 0x73, 0x0E,
  0x61, 0x8C, 0x7F, 0x8F, 0xF3, 0x8E, 0x71, 0xCC, 0x3B, 0x87, 0xF0, 0xE0,
  0x1F, 0xC3, 0xFC, 0x73, 0x8C, 0x71, 0x8E, 0x71, 0xCE, 0x71, 0xFC, 0x3F,
  0x86, 0x71, 0xC7, 0x38, 0xE7, 0x1C, 0xC3, 0x39, 0xE7, 0xF8, 0xFE, 0x00,
  0x07, 0xE3, 0xF8, 0x71, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x83, 0xF0, 0x3E, 0x00,
  0x1F, 0xC1, 0xFE, 0x1C, 0xE1, 0xCE, 0x18, 0x73, 0x87, 0x38, 0x73, 0x86,
  0x30, 0xE3, 0x0E, 0x70, 0xE7, 0x0C, 0x71, 0xC6, 0x38, 0xEF, 0x8F, 0xF0,
  0xFC, 0x00, 0x1F, 0xC7, 0xF1, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xFE,
  0x3F, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0xF8, 0xFE, 0x00,
  0x1F, 0xC7, 0xF1, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0x0F,
  0xC7, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x07, 0xF0,
  0xFF, 0x1C, 0x23, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE3, 0xEE,
  0x3C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x18, 0xF1, 0x87, 0xF8, 0x3F, 0x80,
  0x1C, 0x38, 0xE1, 0xC7, 0x0C, 0x38, 0x61, 0x87, 0x1C, 0x38, 0xE1, 0xC7,
  0xFC, 0x3F, 0xE1, 0x87, 0x1C, 0x38, 0xE1, 0xC7, 0x0C, 0x30, 0xE3, 0x87,
  0x1C, 0x38, 0xE1, 0xC0, 0x1F, 0xC3, 0xE0, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x81, 0xF8,
  0xFC, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03,
  0x81, 0xC1, 0xF0, 0x78, 0x3C, 0x00, 0x1C, 0x78, 0xE3, 0x87, 0x38, 0x33,
  0x81, 0x9C, 0x1D, 0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x1D, 0xC0,
  0xEE, 0x07, 0x30, 0x31, 0x83, 0x8E, 0x1C, 0x70, 0xE3, 0x80, 0x1C, 0x38,
  0x70, 0xE1, 0x87, 0x0E, 0x1C, 0x30, 0x61, 0xC3, 0x87, 0x0C, 0x38, 0x7F,
  0xFE, 0x1E, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xC3, 0xC1, 0xE1, 0xE1, 0xF1,
  0xF0, 0xF8, 0xF8, 0xFC, 0x6C, 0x6C, 0x36, 0x76, 0x1B, 0x37, 0x1D, 0xBB,
  0x8E, 0xD9, 0x86, 0x7C, 0xC3, 0x3C, 0xE3, 0x9E, 0x71, 0xCE, 0x38, 0xE7,
  0x18, 0x00, 0x1E, 0x1C, 0x78, 0x61, 0xE1, 0x87, 0x8E, 0x1E, 0x38, 0xFC,
  0xE3, 0xF3, 0x0C, 0xCC, 0x33, 0x70, 0xCD, 0xC7, 0x36, 0x1C, 0xF8, 0x63,
  0xE1, 0x87, 0x8E, 0x1E, 0x38, 0x70, 0xE1, 0xC0, 0x0F, 0xC3, 0xFC, 0xF3,
  0x9C, 0x77, 0x06, 0xE0, 0xD8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0xEE, 0x1D, 0xC7, 0x39, 0xE3, 0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xFC, 0x73,
  0x8E, 0x71, 0x8E, 0x71, 0xCE, 0x39, 0xCE, 0x3F, 0xC7, 0xF1, 0xF8, 0x38,
  0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x0F, 0xC3, 0xFC, 0xF3,
  0x9C, 0x77, 0x06, 0xE0, 0xD8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0xEE, 0x1D, 0xC7, 0x39, 0xE3, 0xF8, 0x7E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x70, 0x1F, 0x83, 0xF8, 0x73, 0x8C, 0x71, 0x8E, 0x71, 0xCE, 0x31, 0xCE,
  0x3F, 0x87, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xC6, 0x38, 0xE7, 0x1C, 0xE3,
  0x80, 0x07, 0xF0, 0xFE, 0x1E, 0x61, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x38, 0x01, 0x80, 0x38, 0x67, 0x87,
  0xF0, 0xFE, 0x00, 0xFF, 0xFF, 0xC6, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60,
  0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x00, 0x38,
  0x73, 0x86, 0x38, 0xE3, 0x0E, 0x30, 0xE7, 0x0E, 0x70, 0xC7, 0x1C, 0x61,
  0xCE, 0x1C, 0xE1, 0xCE, 0x18, 0xE3, 0x8E, 0x38, 0xE7, 0x0F, 0xF0, 0x7E,
  0x00, 0xE0, 0xFC, 0x3B, 0x87, 0x71, 0xCE, 0x39, 0xC6, 0x39, 0xC7, 0x30,
  0xEE, 0x1D, 0xC3, 0xB0, 0x7E, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x00, 0xE1, 0x87, 0xE3, 0x87, 0xE3, 0x86, 0xE3, 0x8E, 0xE7, 0x8E, 0xC7,
  0x8C, 0xC7, 0x9C, 0xCD, 0x98, 0xCD, 0xB8, 0xDD, 0xB8, 0xD9, 0xB0, 0xD9,
  0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF1, 0xE0, 0xE1, 0xC0, 0xE1, 0xC0, 0x0C,
  0x38, 0x63, 0x83, 0xB8, 0x1D, 0xC0, 0xFC, 0x07, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x07, 0xC0, 0x36, 0x03, 0xB8, 0x19, 0xC1, 0xCE, 0x1C,
  0x70, 0xE3, 0x80, 0xE1, 0xF8, 0xEE, 0x31, 0x9C, 0x66, 0x1B, 0x86, 0xC1,
  0xF0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0,
  0x00, 0x0F, 0xE3, 0xFC, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0xF8, 0xFF,
  0x00, 0x0F, 0xC3, 0xE0, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18,
  0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0x03, 0xE0, 0xF8, 0x00, 0xE3, 0x18, 0xC6, 0x31, 0xCE, 0x31, 0x8C, 0x63,
  0x18, 0xE7, 0x18, 0x07, 0xC3, 0xE0, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30,
  0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C,
  0x07, 0x01, 0xC1, 0xE0, 0xF8, 0x00, 0x03, 0x01, 0xC0, 0xF0, 0x3E, 0x1F,
  0x86, 0x63, 0x19, 0xC7, 0x61, 0xF8, 0x30, 0xFF, 0xFE, 0xF7, 0x30, 0x0E,
  0xE3, 0xFC, 0xE7, 0x1C, 0xE7, 0x1C, 0xE3, 0x98, 0x63, 0x0C, 0x63, 0x9C,
  0x71, 0x9E, 0x3F, 0x87, 0xB0, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06,
  0xE3, 0xFC, 0xE7, 0x38, 0xCC, 0x37, 0x1D, 0xC7, 0x71, 0xD8, 0x66, 0x3B,
  0xCC, 0xFF, 0x37, 0x80, 0x1F, 0x3F, 0x72, 0x60, 0xE0, 0xE0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xE4, 0xFC, 0x7C, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0xEE, 0x1F, 0xC3, 0x9C, 0x31, 0xC7, 0x1C, 0x71, 0xC6, 0x18, 0x61,
  0x86, 0x38, 0xE3, 0x86, 0x78, 0x7F, 0x07, 0xB0, 0x1F, 0x3F, 0x73, 0x63,
  0xE3, 0xFE, 0xFC, 0xC0, 0xC0, 0xC0, 0xC2, 0xFE, 0x7C, 0x00, 0xF0, 0x1E,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x7C, 0x0F, 0xC0, 0x70, 0x07, 0x00, 0x70,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x38, 0x0F, 0x80, 0xF0, 0x0E, 0x00, 0x07, 0xF0, 0xFF,
  0x1C, 0xE1, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xC3, 0x0C, 0x31, 0xC7, 0x1C,
  0x33, 0xC3, 0xF8, 0x3D, 0x80, 0x38, 0x03, 0x80, 0x30, 0xEF, 0x0F, 0xE0,
  0x38, 0x00, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0xE3, 0xFC, 0xE7,
  0x39, 0xCC, 0x77, 0x1D, 0xC6, 0x71, 0x98, 0xE6, 0x3B, 0x8C, 0xE3, 0x39,
  0xC0, 0x0C, 0x71, 0xC0, 0x00, 0x63, 0x8E, 0x38, 0xC7, 0x1C, 0x71, 0x86,
  0x38, 0xE3, 0x80, 0x01, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x18, 0x1C, 0x0E,
  0x07, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06,
  0x03, 0x03, 0x87, 0xC3, 0xC1, 0xC0, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x31, 0xCE, 0x71, 0xDC, 0x37, 0x06, 0xC1, 0xF8, 0x3F, 0x07, 0x60,
  0xCC, 0x19, 0xC7, 0x38, 0xE7, 0x18, 0xE0, 0x0C, 0x71, 0xC7, 0x18, 0x63,
  0x8E, 0x38, 0xC7, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x80, 0x1F, 0x9C, 0x7F,
  0xFC, 0xE7, 0xB9, 0xCE, 0x73, 0x1C, 0xEE, 0x31, 0xDC, 0x63, 0x39, 0xC6,
  0x63, 0x9C, 0xC6, 0x3B, 0x8C, 0x67, 0x18, 0xCE, 0x73, 0x80, 0x1B, 0x8D,
  0xF3, 0x9C, 0xE7, 0x31, 0xDC, 0x77, 0x19, 0xC6, 0x63, 0x98, 0xEE, 0x33,
  0x8C, 0xE7, 0x00, 0x1F, 0x1F, 0x9C, 0xEC, 0x7E, 0x3F, 0x1F, 0x0F, 0x86,
  0xC7, 0x63, 0xB3, 0x9F, 0xC7, 0xC0, 0x0D, 0xC3, 0xFC, 0x73, 0x8E, 0x31,
  0x86, 0x71, 0xCE, 0x39, 0xC7, 0x30, 0xC6, 0x39, 0xE7, 0x3F, 0xC7, 0xF0,
  0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x00, 0x0F, 0xE3, 0xF8,
  0xE7, 0x18, 0xE7, 0x1C, 0xE3, 0x98, 0x63, 0x0C, 0x63, 0x9C, 0x71, 0x9E,
  0x3F, 0x87, 0xB0, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x00,
  0x1B, 0x3F, 0x3F, 0x38, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0,
  0xE0, 0x1F, 0x9F, 0x9C, 0x4E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x07,
  0x23, 0x9F, 0x8F, 0x80, 0x18, 0x63, 0x1F, 0xFD, 0xC7, 0x18, 0x63, 0x8E,
  0x38, 0xC3, 0x0F, 0x3C, 0x31, 0xDC, 0x67, 0x19, 0x8E, 0x63, 0xB8, 0xCE,
  0x33, 0x9C, 0xC7, 0x31, 0xCC, 0xE3, 0xF8, 0xF6, 0x00, 0xE3, 0xF1, 0xF8,
  0xCC, 0xE6, 0x63, 0x71, 0xB0, 0xD8, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x00,
  0x63, 0x8F, 0x9E, 0x7E, 0x79, 0xB9, 0xEE, 0xED, 0xB3, 0xB6, 0xCF, 0xFF,
  0x3E, 0xD8, 0xFB, 0x63, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xE3, 0x80, 0x1C,
  0xE3, 0x98, 0x77, 0x0F, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1F, 0x07,
  0xE1, 0xDC, 0x31, 0x8E, 0x38, 0x0C, 0x30, 0xC7, 0x0C, 0x60, 0xCE, 0x0C,
  0xC0, 0xDC, 0x0D, 0x80, 0xD8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0xF8, 0x0F, 0x00, 0xE0, 0x00, 0x1F, 0x8F,
  0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x38, 0x38, 0x18, 0x1C, 0x1F, 0xCF,
  0xE0, 0x03, 0xC1, 0xE0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C,
  0x1E, 0x06, 0x03, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07,
  0x80, 0xF0, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x0F,
  0x01, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x03, 0xC1, 0xC1, 0xE1,
  0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x3C, 0x1E, 0x0C, 0x00, 0xF8, 0xFF,
  0xE3, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 7, 17, 6, 0, -17 },
  { 16, 8, 6, 9, 2, -17 },
  { 22, 12, 17, 11, 0, -17 },
  { 48, 10, 19, 10, 0, -18 },
  { 72, 14, 17, 16, 1, -17 },
  { 102, 11, 17, 12, 0, -17 },
  { 126, 4, 6, 5, 2, -17 },
  { 129, 8, 21, 6, 0, -17 },
  { 150, 8, 21, 6, -2, -17 },
  { 171, 8, 9, 9, 2, -18 },
  { 180, 9, 11, 11, 1, -14 },
  { 193, 5, 6, 5, -1, -3 },
  { 197, 6, 3, 7, 0, -8 },
  { 200, 3, 3, 5, 0, -3 },
  { 202, 12, 17, 9, -1, -17 },
  { 228, 10, 17, 10, 0, -17 },
  { 250, 7, 17, 10, 2, -17 },
  { 265, 11, 17, 10, -1, -17 },
  { 289, 10, 17, 10, 0, -17 },
  { 311, 10, 17, 10, 0, -17 },
  { 333, 10, 17, 10, 0, -17 },
  { 355, 10, 17, 10, 1, -17 },
  { 377, 10, 17, 10, 1, -17 },
  { 399, 10, 17, 10, 0, -17 },
  { 421, 10, 17, 10, 0, -17 },
  { 443, 5, 13, 5, 0, -13 },
  { 452, 6, 16, 5, -1, -13 },
  { 464, 9, 11, 11, 1, -14 },
  { 477, 9, 7, 11, 1, -12 },
  { 485, 9, 11, 11, 1, -14 },
  { 498, 9, 17, 8, 0, -17 },
  { 518, 14, 19, 15, 1, -17 },
  { 552, 11, 17, 11, -2, -17 },
  { 576, 11, 17, 11, 0, -17 },
  { 600, 11, 17, 10, 1, -17 },
  { 624, 12, 17, 12, 0, -17 },
  { 650, 10, 17, 9, 0, -17 },
  { 672, 10, 17, 9, 0, -17 },
  { 694, 12, 17, 12, 1, -17 },
  { 720, 13, 17, 12, 0, -17 },
  { 748, 10, 17, 7, -1, -17 },
  { 770, 10, 22, 6, -4, -17 },
  { 798, 13, 17, 11, 0, -17 },
  { 826, 7, 17, 9, 0, -17 },
  { 841, 17, 17, 16, 0, -17 },
  { 878, 14, 17, 13, 0, -17 },
  { 908, 11, 17, 13, 1, -17 },
  { 932, 11, 17, 11, 0, -17 },
  { 956, 11, 21, 13, 1, -17 },
  { 985, 11, 17, 11, 0, -17 },
  { 1009, 12, 17, 10, -1, -17 },
  { 1035, 9, 17, 9, 2, -17 },
  { 1055, 12, 17, 12, 1, -17 },
  { 1081, 11, 17, 11, 2, -17 },
  { 1105, 16, 17, 16, 2, -17 },
  { 1139, 13, 17, 10, -1, -17 },
  { 1167, 10, 17, 10, 2, -17 },
  { 1189, 11, 17, 9, -1, -17 },
  { 1213, 10, 21, 7, -1, -17 },
  { 1240, 5, 17, 9, 2, -17 },
  { 1251, 10, 21, 7, -2, -17 },
  { 1278, 10, 10, 10, 0, -17 },
  { 1291, 8, 2, 8, -2, 2 },
  { 1293, 4, 3, 7, 3, -18 },
  { 1295, 11, 13, 11, 0, -13 },
  { 1313, 10, 18, 11, 0, -18 },
  { 1336, 8, 13, 8, 1, -13 },
  { 1349, 12, 18, 11, 0, -18 },
  { 1376, 8, 13, 10, 1, -13 },
  { 1389, 12, 24, 6, -3, -18 },
  { 1425, 12, 19, 11, -1, -13 },
  { 1454, 10, 18, 11, 0, -18 },
  { 1477, 6, 18, 5, 0, -18 },
  { 1491, 9, 24, 5, -3, -18 },
  { 1518, 11, 18, 10, 0, -18 },
  { 1543, 6, 18, 5, 0, -18 },
  { 1557, 15, 13, 16, 0, -13 },
  { 1582, 10, 13, 11, 0, -13 },
  { 1599, 9, 13, 10, 1, -13 },
  { 1614, 11, 19, 11, -1, -13 },
  { 1641, 11, 19, 11, 0, -13 },
  { 1668, 8, 13, 7, 0, -13 },
  { 1681, 9, 13, 8, 0, -13 },
  { 1696, 6, 16, 7, 1, -16 },
  { 1708, 10, 13, 10, 1, -13 },
  { 1725, 9, 13, 9, 1, -13 },
  { 1740, 14, 13, 14, 1, -13 },
  { 1763, 11, 13, 9, -1, -13 },
  { 1781, 12, 19, 9, -2, -13 },
  { 1810, 9, 13, 8, -1, -13 },
  { 1825, 10, 21, 8, 0, -17 },
  { 1852, 2, 24, 9, 3, -18 },
  { 1858, 9, 21, 8, -1, -17 },
  { 1882, 9, 3, 11, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC24PT7B_H_
