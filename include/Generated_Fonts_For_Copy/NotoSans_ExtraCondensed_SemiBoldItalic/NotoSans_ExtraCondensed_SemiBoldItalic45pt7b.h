#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC45PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07,
  0x80, 0x3E, 0x3E, 0x7C, 0x78, 0xF9, 0xF1, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F,
  0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0xF8, 0xF1, 0xE3, 0xC3, 0xC0, 0x00, 0x3C,
  0x78, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0,
  0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xC0, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x01, 0xC3, 0x80, 0x0F, 0x1E,
  0x00, 0x3C, 0x78, 0x00, 0xE1, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00,
  0x70, 0xE0, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x07, 0x8F, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC7, 0x80,
  0x0E, 0x1E, 0x00, 0x38, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x0F, 0x00, 0x3C,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0xF0,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xD8,
  0xC0, 0xF9, 0x80, 0x0F, 0x98, 0x00, 0xF1, 0x00, 0x0F, 0xB0, 0x00, 0xFB,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0D, 0xF0, 0x00, 0xCF, 0x80,
  0x0C, 0xF8, 0x00, 0xCF, 0x84, 0x08, 0xF0, 0x61, 0x9F, 0x07, 0x9F, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xFC, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF8, 0x0E,
  0x01, 0xE7, 0x03, 0xC0, 0x78, 0xE0, 0x70, 0x0F, 0x1C, 0x1E, 0x01, 0xC3,
  0x83, 0x80, 0x78, 0x70, 0xF0, 0x0F, 0x1E, 0x1C, 0x01, 0xC3, 0xC7, 0x80,
  0x38, 0x79, 0xE0, 0x0F, 0x0F, 0x3C, 0x01, 0xE1, 0xCF, 0x0E, 0x3C, 0x79,
  0xE7, 0xE7, 0x8E, 0x79, 0xFE, 0xF3, 0xCF, 0x3F, 0xCF, 0xF3, 0xCF, 0x3D,
  0xFE, 0x71, 0xC7, 0x9F, 0x9E, 0x78, 0xF0, 0x83, 0x8E, 0x1E, 0x00, 0xF3,
  0xC3, 0xC0, 0x1C, 0x78, 0x70, 0x07, 0x8F, 0x0E, 0x00, 0xE1, 0xC3, 0xC0,
  0x3C, 0x38, 0x78, 0x0F, 0x07, 0x0E, 0x01, 0xE0, 0xE3, 0xC0, 0x78, 0x1C,
  0x78, 0x0F, 0x03, 0x9E, 0x03, 0xC0, 0x7F, 0x80, 0x78, 0x0F, 0xF0, 0x1E,
  0x00, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x80, 0x1E, 0x7C, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78,
  0x03, 0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0x9E, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xC7, 0xC7, 0xFE, 0x3E, 0x7D, 0xF9, 0xF3, 0xE7, 0xDF, 0x3E, 0x3E,
  0xF9, 0xE0, 0xFF, 0x9F, 0x07, 0xFC, 0xF8, 0x3F, 0xC7, 0xC0, 0xFC, 0x3E,
  0x07, 0xE1, 0xF0, 0x7F, 0x0F, 0x87, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x0F, 0xFC, 0xF8, 0x3F, 0xC7, 0xE0, 0x3E, 0x7C, 0xF9, 0xE3, 0xCF, 0x9F,
  0x3C, 0x78, 0xF3, 0xE0, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x82, 0x1E, 0x07, 0x3C, 0x1F, 0xF9, 0xFF, 0xFF,
  0xBF, 0xFF, 0x0F, 0xFE, 0x1F, 0x80, 0x7F, 0x81, 0xFF, 0x07, 0xCF, 0x0F,
  0x9F, 0x0E, 0x1E, 0x08, 0x38, 0x00, 0x40, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xE1,
  0xF0, 0xF8, 0xF8, 0x7C, 0x3C, 0x3E, 0x1E, 0x00, 0xFF, 0xFF, 0xFB, 0xFF,
  0x7F, 0xE0, 0x3D, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xF1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xE0, 0x7C,
  0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0x81, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C,
  0x0F, 0x9F, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07,
  0xCF, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE3, 0xE0, 0xF9, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xF8, 0x7F,
  0xE3, 0xFF, 0x3F, 0xFC, 0x79, 0xF0, 0xC7, 0xC2, 0x1E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0xF0, 0xFC, 0x07, 0x03, 0xE0, 0x10, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x08, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x00, 0x00, 0x0C, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x18, 0x3F, 0x01, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x88, 0x03, 0xF0, 0xE0,
  0x7F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xBE, 0x00, 0x3B, 0xC0, 0x07,
  0x7C, 0x00, 0xF7, 0xC0, 0x0E, 0x7C, 0x01, 0xC7, 0x80, 0x3C, 0x78, 0x03,
  0x8F, 0x80, 0x78, 0xF8, 0x0F, 0x0F, 0x80, 0xE0, 0xF0, 0x1E, 0x1F, 0x03,
  0xC1, 0xF0, 0x3C, 0x1F, 0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0C, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE2, 0x01, 0xF8,
  0x60, 0x7F, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE1, 0x00, 0x7D, 0xFC, 0x0F, 0x7F, 0x83,
  0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x8F,
  0xC1, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F,
  0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F, 0xCF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF,
  0xF0, 0x7F, 0xFE, 0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE0, 0x7C, 0xF8, 0x0F, 0xBF,
  0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF8,
  0x1F, 0x9F, 0x03, 0xE1, 0xF0, 0xF8, 0x3E, 0x3E, 0x03, 0xC7, 0xC0, 0x7C,
  0xF8, 0x0F, 0x9F, 0x01, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0xC3, 0xE1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x0C,
  0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0x8F,
  0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xF1, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7E,
  0x1F, 0x1F, 0xC3, 0xFF, 0xF8, 0x7F, 0xDE, 0x07, 0xFF, 0xC0, 0xFC, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x08, 0x1F, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x00, 0x01, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8,
  0x00, 0x00, 0x60, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03,
  0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x80,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0xF0, 0x7F, 0xF0,
  0xFF, 0xF1, 0xFF, 0xE3, 0x07, 0xC4, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7C, 0x03, 0xC0, 0x1F, 0x00,
  0x3C, 0x07, 0x80, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x0F, 0x0F,
  0x03, 0xE1, 0xE1, 0xC1, 0xFF, 0x3C, 0x78, 0x7F, 0xC7, 0x8E, 0x1E, 0x38,
  0xF3, 0xC7, 0x8F, 0x1E, 0x70, 0xE1, 0xE3, 0xCE, 0x3C, 0x38, 0x73, 0xC7,
  0x87, 0x0E, 0x70, 0xE1, 0xE1, 0xCE, 0x3C, 0x3C, 0x39, 0xC7, 0x87, 0x0E,
  0x78, 0xF0, 0xE1, 0xCF, 0x1C, 0x3C, 0x39, 0xE3, 0x87, 0x8E, 0x38, 0x71,
  0xF1, 0xC7, 0x0F, 0x7E, 0x70, 0xE1, 0xFD, 0xFC, 0x1C, 0x1F, 0x3F, 0x03,
  0xC1, 0xC3, 0xC0, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x04, 0x00, 0x3F, 0x9F, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00,
  0x7C, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0xF1, 0xF0,
  0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xF8, 0x1F, 0x1F, 0x81,
  0xF1, 0xF0, 0x1F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0,
  0x1F, 0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3E, 0x1F, 0x81, 0xE0, 0x7C, 0x1F, 0x03,
  0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0xC3, 0xE0, 0x7C, 0x1F,
  0x07, 0xE0, 0xF8, 0x7E, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0xF8, 0xFE, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x83, 0xE0,
  0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x7C, 0x07, 0xC3,
  0xE0, 0x7E, 0x1F, 0x03, 0xE0, 0xF8, 0x7F, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0x0C, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x18, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xE7, 0xF8, 0x0F, 0x87, 0xE0, 0x7C, 0x0F,
  0xC1, 0xF0, 0x3F, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3,
  0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0xC7, 0xC0,
  0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x81, 0xF8, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xC3, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0xE0, 0xFE, 0x01,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x07,
  0xFC, 0xFC, 0x1F, 0xF3, 0xE0, 0x7F, 0x8F, 0x81, 0xFE, 0x3E, 0x0F, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x3F, 0x03, 0xE0, 0xFE, 0x0F,
  0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0x7C,
  0x0F, 0x80, 0x7C, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xE0,
  0x7E, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0xFC, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xC0,
  0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x04, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x7E,
  0x03, 0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE1, 0xF8, 0x03, 0xC1, 0xF0,
  0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xC7, 0xC0, 0x07, 0xCF, 0x80,
  0x0F, 0x9F, 0x80, 0x0F, 0xBF, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3F, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x1F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x01, 0x7F, 0xFB, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0x01, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8,
  0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0x7C, 0x0F, 0xFC,
  0x0F, 0x78, 0x0F, 0xBC, 0x1E, 0xF8, 0x0F, 0x3C, 0x1E, 0xF8, 0x0F, 0x3C,
  0x3E, 0xF8, 0x1F, 0x3C, 0x3C, 0xF0, 0x1F, 0x3C, 0x7D, 0xF0, 0x1F, 0x3C,
  0x79, 0xF0, 0x1E, 0x3C, 0xF9, 0xF0, 0x1E, 0x3C, 0xF1, 0xF0, 0x3E, 0x3C,
  0xF1, 0xE0, 0x3E, 0x3D, 0xE3, 0xE0, 0x3E, 0x3D, 0xE3, 0xE0, 0x3C, 0x3F,
  0xC3, 0xE0, 0x3C, 0x3F, 0xC3, 0xE0, 0x7C, 0x3F, 0xC3, 0xC0, 0x7C, 0x3F,
  0x87, 0xC0, 0x7C, 0x3F, 0x87, 0xC0, 0x78, 0x3F, 0x07, 0xC0, 0xF8, 0x3F,
  0x07, 0x80, 0xF8, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x0F, 0x80, 0x01, 0xF0,
  0x07, 0xC0, 0xFE, 0x01, 0xE0, 0x3F, 0x80, 0x78, 0x0F, 0xE0, 0x3E, 0x03,
  0xF8, 0x0F, 0x80, 0xFE, 0x03, 0xE0, 0x7F, 0x80, 0xF0, 0x1F, 0xF0, 0x7C,
  0x07, 0xFC, 0x1F, 0x01, 0xEF, 0x07, 0xC0, 0xFB, 0xC1, 0xE0, 0x3E, 0xF0,
  0x78, 0x0F, 0xBC, 0x3E, 0x03, 0xCF, 0x8F, 0x80, 0xF3, 0xE3, 0xE0, 0x7C,
  0x78, 0xF0, 0x1F, 0x1E, 0x3C, 0x07, 0xC7, 0x9F, 0x01, 0xE1, 0xE7, 0xC0,
  0x78, 0x7D, 0xF0, 0x3E, 0x1F, 0x78, 0x0F, 0x83, 0xDE, 0x03, 0xE0, 0xFF,
  0x80, 0xF0, 0x3F, 0xE0, 0x3C, 0x0F, 0xF8, 0x1F, 0x03, 0xFC, 0x07, 0xC0,
  0xFF, 0x01, 0xF0, 0x1F, 0xC0, 0x78, 0x07, 0xF0, 0x3E, 0x01, 0xF8, 0x0F,
  0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x04, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xF0, 0xFC, 0x3F, 0x07,
  0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C,
  0x01, 0xF7, 0xE0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80,
  0x3F, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xC7,
  0xC0, 0x7E, 0x3E, 0x03, 0xE1, 0xF8, 0x3F, 0x0F, 0xE7, 0xF0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3E, 0x3F, 0x81, 0xF0,
  0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC3,
  0xF0, 0x3E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x1F,
  0x83, 0xE3, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F,
  0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xF0,
  0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF,
  0x80, 0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0,
  0x03, 0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xFC,
  0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xE1, 0xF8, 0x3F, 0x0F, 0xE7,
  0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xE3, 0xF0, 0x3C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x0F, 0x8F, 0xC1, 0xFF,
  0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xE7, 0xC0, 0x3E,
  0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3C, 0x3E, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x81, 0xF8,
  0xF8, 0x1F, 0x8F, 0x80, 0xF8, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x70, 0x1F, 0x80, 0x80,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0xC0, 0x7E, 0x07, 0x8F, 0xF0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x3E, 0x03, 0xF0, 0xF8, 0x0F,
  0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x87,
  0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80,
  0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x01, 0xF8,
  0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8,
  0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x1F,
  0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x3F, 0x1F, 0x80, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xF8, 0x03, 0xFF, 0x80,
  0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0xF8,
  0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x78, 0x0F, 0x8F, 0x80,
  0xF8, 0xF8, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0xBE, 0x00, 0xFB, 0xE0,
  0x0F, 0xBC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xF7, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x3E, 0xF8, 0x0F, 0x80, 0x7D,
  0xF0, 0x1F, 0x01, 0xF3, 0xE0, 0x3E, 0x03, 0xE7, 0xC0, 0xFC, 0x07, 0xCF,
  0x81, 0xF8, 0x1F, 0x1F, 0x07, 0xF0, 0x3E, 0x3C, 0x0F, 0xE0, 0x78, 0x78,
  0x1F, 0xC1, 0xF0, 0xF0, 0x7F, 0x83, 0xE1, 0xE0, 0xFF, 0x0F, 0x83, 0xC1,
  0xFE, 0x1F, 0x07, 0x87, 0xBC, 0x3E, 0x0F, 0x0F, 0x78, 0xF8, 0x1E, 0x3C,
  0xF1, 0xF0, 0x3C, 0x79, 0xE7, 0xC0, 0x78, 0xF3, 0xCF, 0x81, 0xF3, 0xC7,
  0x9F, 0x03, 0xE7, 0x8F, 0x7C, 0x07, 0xDF, 0x1E, 0xF8, 0x0F, 0xBC, 0x3D,
  0xE0, 0x1F, 0x78, 0x77, 0xC0, 0x3F, 0xE0, 0xEF, 0x80, 0x7F, 0xC1, 0xDE,
  0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0,
  0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x80,
  0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0x87, 0xC0,
  0x03, 0xC3, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xE0, 0x00, 0x7D, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xCF, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x03,
  0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0,
  0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0x81, 0xFB, 0xE0, 0x7C, 0xF8, 0x3E, 0x1E,
  0x0F, 0x87, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xDF,
  0x01, 0xF7, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xF8, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0,
  0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0x78, 0x03, 0xCF, 0x00, 0xF9, 0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xC0,
  0xF0, 0x78, 0x3C, 0x0F, 0x8F, 0x80, 0xF1, 0xE0, 0x1E, 0x7C, 0x03, 0xDF,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0xF9, 0xF9, 0xF3, 0xE3,
  0xC3, 0xC7, 0x80, 0x00, 0xE0, 0x00, 0x7F, 0x3C, 0x1F, 0xEF, 0x87, 0xFF,
  0xF1, 0xFD, 0xFC, 0x3F, 0x1F, 0x8F, 0xC3, 0xF1, 0xF0, 0x3E, 0x3E, 0x07,
  0xCF, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF9, 0xF0, 0x1F,
  0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x07, 0xE3, 0xE0, 0xFC,
  0x7C, 0x3F, 0x0F, 0x87, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFD, 0xE0,
  0x3F, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF9, 0xE0, 0x1E, 0x7E, 0x03, 0xDF, 0xE0, 0xFF, 0xFE, 0x1F, 0xCF,
  0xC3, 0xF0, 0xF8, 0x7C, 0x1F, 0x1F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x01, 0xF1, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x81, 0xF1, 0xF0, 0x3E,
  0x3E, 0x07, 0xC7, 0xC0, 0xF9, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xE1, 0xF0,
  0xFC, 0x7E, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xF7, 0xFC, 0x1E, 0x7E, 0x00,
  0x00, 0x7C, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xEE, 0x1F, 0x80,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x30, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x07, 0x1F, 0x00, 0xFE, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0xEF, 0xE0, 0x7C, 0x3F, 0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0,
  0x3E, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC3,
  0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07,
  0xC1, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x3F, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xBC, 0x01, 0xF9, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C,
  0x1F, 0x3C, 0x0F, 0x3E, 0x0F, 0x9F, 0x1F, 0x8F, 0xFF, 0x8F, 0xFF, 0x87,
  0xFF, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x83, 0xFB, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xF3, 0xC0,
  0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0x7F, 0x03, 0xE1, 0xF8, 0x3F, 0x07,
  0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E,
  0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7C, 0x3F, 0x03, 0xF3,
  0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFD, 0xE0, 0x0F, 0xDF, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x02, 0x01, 0xF8, 0x1F, 0x3F, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF9, 0xE0, 0x1E, 0x7F, 0x03, 0xDF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC3, 0xF1, 0xF8, 0x7C, 0x1F, 0x1F, 0x83, 0xE3, 0xE0, 0x78,
  0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xE1,
  0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3C, 0x3E, 0x0F, 0x87,
  0xC1, 0xF0, 0xF8, 0x3E, 0x1E, 0x07, 0xC7, 0xC0, 0xF0, 0xF8, 0x3E, 0x1F,
  0x07, 0xC0, 0x00, 0xE0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x83, 0xF0, 0x78, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x0F, 0x9F,
  0x80, 0xF1, 0xF0, 0x0F, 0x3E, 0x01, 0xF7, 0xC0, 0x1F, 0xFC, 0x01, 0xEF,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07,
  0x83, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x03, 0xC0, 0x7B, 0xF8, 0xFE, 0x07, 0xFF,
  0xDF, 0xF0, 0xF7, 0xFF, 0xFF, 0x0F, 0xEF, 0xFB, 0xF0, 0xFC, 0x7F, 0x1F,
  0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x7C, 0x1F, 0x1F, 0x07, 0xC1, 0xF1, 0xF0,
  0x7C, 0x1F, 0x1F, 0x07, 0xC1, 0xE1, 0xE0, 0x78, 0x3E, 0x3E, 0x0F, 0x83,
  0xE3, 0xE0, 0xF8, 0x3E, 0x3E, 0x0F, 0x83, 0xC3, 0xE0, 0xF0, 0x3C, 0x3C,
  0x0F, 0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x7C, 0x1F, 0x07, 0xC7, 0xC1, 0xF0,
  0x78, 0x78, 0x1E, 0x07, 0x87, 0x83, 0xE0, 0xF8, 0xF8, 0x3E, 0x0F, 0x8F,
  0x83, 0xE0, 0xF8, 0xF8, 0x3E, 0x0F, 0x00, 0x00, 0x07, 0x00, 0xF3, 0xF0,
  0x1C, 0xFF, 0x07, 0xBF, 0xE0, 0xFF, 0xFE, 0x1F, 0x87, 0xC3, 0xE0, 0xF8,
  0x7C, 0x1E, 0x1F, 0x03, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x03, 0xE3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x8F,
  0x81, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF0, 0x3E, 0x3E,
  0x07, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xE1, 0xFD, 0xF8, 0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x0F,
  0x3C, 0x07, 0xBE, 0x03, 0xDF, 0x03, 0xEF, 0x81, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F, 0x9F,
  0x07, 0xCF, 0xC7, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x0F, 0x3F, 0x80, 0x7B, 0xFC, 0x07, 0xFF, 0xF0,
  0x3F, 0x9F, 0x81, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xC0,
  0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x01, 0xF0, 0xF8, 0x0F, 0x87,
  0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0xFC, 0x1F,
  0x07, 0xC0, 0xF8, 0x3F, 0x0F, 0x81, 0xF8, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xDF, 0xE0, 0x3E, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x7F, 0x3C, 0x1F, 0xF7, 0x87, 0xFF, 0xF0, 0xFD, 0xFC,
  0x3E, 0x1F, 0x87, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xCF, 0x81, 0xF1,
  0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xC7,
  0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F,
  0x87, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFD, 0xE0, 0x3F, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x07, 0x9F, 0x07, 0xBE, 0x0F, 0xFE, 0x0F, 0xFE,
  0x0F, 0xF2, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE,
  0x1F, 0x8E, 0x1F, 0x04, 0x1E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x80, 0xF8, 0xC1, 0xF8, 0xFF, 0xF0,
  0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC4, 0x7F, 0xC7, 0xFE, 0x7F, 0xF3, 0xFF, 0x87, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0x83, 0xE1, 0xE0, 0x78,
  0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x8F, 0x81, 0xE1,
  0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF0, 0x3C, 0x3E, 0x07, 0x87,
  0xC1, 0xF0, 0xF8, 0x3E, 0x1E, 0x07, 0xC3, 0xC0, 0xF0, 0xF8, 0x3E, 0x1F,
  0x07, 0xC3, 0xE1, 0xF8, 0x7C, 0x7F, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F,
  0xEF, 0x01, 0xF9, 0xE0, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3E,
  0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0xF8, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xF0,
  0xF1, 0xE0, 0xF3, 0xE0, 0xF3, 0xC0, 0xF3, 0xC0, 0xF7, 0xC0, 0xF7, 0x80,
  0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x78, 0x1F, 0x03, 0xEF, 0x07, 0xE0, 0xF9, 0xE0,
  0xFC, 0x1F, 0x3C, 0x1F, 0x87, 0xC7, 0x87, 0xF0, 0xF8, 0xF0, 0xFE, 0x1E,
  0x1E, 0x3F, 0xC7, 0xC3, 0xC7, 0xF8, 0xF8, 0x78, 0xEF, 0x1E, 0x0F, 0x3D,
  0xE7, 0xC1, 0xE7, 0xBC, 0xF0, 0x3D, 0xE7, 0xBE, 0x07, 0xBC, 0xF7, 0xC0,
  0xF7, 0x9E, 0xF0, 0x1F, 0xE3, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x0F,
  0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F,
  0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFC,
  0x00, 0x07, 0xC1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x7C, 0x00, 0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xBE, 0x00, 0x7D, 0xF0,
  0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xE1, 0xE0, 0x3E, 0x0F, 0x81, 0xF0,
  0x7C, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC1,
  0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3C,
  0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80,
  0x0F, 0x9E, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0xEF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x17, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF,
  0x83, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x0F, 0xE0, 0x07,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xA0, 0x1F,
  0xC8, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 12, 32, 11, 0, -32 },
  { 49, 15, 11, 17, 4, -32 },
  { 70, 22, 32, 21, 0, -32 },
  { 158, 20, 37, 19, 0, -34 },
  { 251, 27, 33, 30, 2, -33 },
  { 363, 21, 33, 22, 0, -33 },
  { 450, 7, 11, 10, 4, -32 },
  { 460, 14, 39, 12, 1, -32 },
  { 529, 14, 40, 12, -3, -33 },
  { 599, 15, 17, 18, 4, -34 },
  { 631, 17, 22, 20, 2, -27 },
  { 678, 9, 12, 10, -2, -6 },
  { 692, 11, 4, 12, 1, -14 },
  { 698, 6, 6, 10, 0, -6 },
  { 703, 22, 32, 16, -2, -32 },
  { 791, 18, 33, 19, 1, -33 },
  { 866, 14, 32, 19, 4, -32 },
  { 922, 21, 33, 19, -2, -33 },
  { 1009, 20, 33, 19, -1, -33 },
  { 1092, 20, 32, 19, -1, -32 },
  { 1172, 19, 32, 19, 0, -32 },
  { 1248, 19, 33, 19, 1, -33 },
  { 1327, 20, 32, 19, 1, -32 },
  { 1407, 19, 33, 19, 0, -33 },
  { 1486, 19, 33, 19, 0, -33 },
  { 1565, 10, 25, 10, 0, -25 },
  { 1597, 12, 31, 10, -2, -25 },
  { 1644, 18, 21, 20, 2, -27 },
  { 1692, 18, 13, 20, 2, -22 },
  { 1722, 18, 21, 20, 2, -27 },
  { 1770, 15, 33, 14, 1, -33 },
  { 1832, 27, 36, 28, 1, -32 },
  { 1954, 20, 32, 20, -3, -32 },
  { 2034, 21, 32, 21, 0, -32 },
  { 2118, 20, 33, 19, 2, -33 },
  { 2201, 22, 32, 22, 0, -32 },
  { 2289, 19, 32, 17, 0, -32 },
  { 2365, 19, 32, 17, 0, -32 },
  { 2441, 22, 33, 23, 2, -33 },
  { 2532, 24, 32, 23, 0, -32 },
  { 2628, 19, 32, 13, -2, -32 },
  { 2704, 19, 41, 10, -7, -32 },
  { 2802, 24, 32, 20, 0, -32 },
  { 2898, 14, 32, 17, 0, -32 },
  { 2954, 32, 32, 31, 0, -32 },
  { 3082, 26, 32, 24, 0, -32 },
  { 3186, 21, 33, 24, 2, -33 },
  { 3273, 21, 32, 20, 0, -32 },
  { 3357, 21, 41, 24, 2, -33 },
  { 3465, 20, 32, 20, 0, -32 },
  { 3545, 21, 33, 18, -1, -33 },
  { 3632, 17, 32, 17, 3, -32 },
  { 3700, 22, 32, 22, 2, -32 },
  { 3788, 20, 32, 20, 4, -32 },
  { 3868, 31, 32, 31, 3, -32 },
  { 3992, 25, 32, 19, -3, -32 },
  { 4092, 18, 32, 18, 4, -32 },
  { 4164, 22, 32, 17, -2, -32 },
  { 4252, 18, 39, 13, -2, -32 },
  { 4340, 9, 32, 16, 4, -32 },
  { 4376, 17, 39, 13, -3, -32 },
  { 4459, 19, 18, 19, 0, -32 },
  { 4502, 15, 3, 14, -4, 4 },
  { 4508, 7, 7, 13, 7, -34 },
  { 4515, 19, 25, 20, 1, -25 },
  { 4575, 19, 34, 20, 0, -34 },
  { 4656, 16, 25, 16, 1, -25 },
  { 4706, 21, 34, 20, 1, -34 },
  { 4796, 17, 25, 18, 1, -25 },
  { 4850, 22, 45, 12, -5, -34 },
  { 4974, 21, 36, 20, -1, -25 },
  { 5069, 19, 34, 20, 0, -34 },
  { 5150, 12, 34, 10, 0, -34 },
  { 5201, 18, 45, 10, -6, -34 },
  { 5303, 20, 34, 18, 0, -34 },
  { 5388, 12, 34, 10, 0, -34 },
  { 5439, 28, 25, 29, 0, -25 },
  { 5527, 19, 25, 20, 0, -25 },
  { 5587, 17, 25, 19, 1, -25 },
  { 5641, 21, 36, 20, -2, -25 },
  { 5736, 19, 36, 20, 1, -25 },
  { 5822, 16, 25, 14, 0, -25 },
  { 5872, 16, 25, 15, 0, -25 },
  { 5922, 13, 30, 12, 1, -30 },
  { 5971, 19, 24, 20, 1, -24 },
  { 6028, 16, 24, 17, 3, -24 },
  { 6076, 27, 24, 26, 2, -24 },
  { 6157, 21, 24, 17, -2, -24 },
  { 6220, 23, 35, 17, -4, -24 },
  { 6321, 18, 24, 14, -2, -24 },
  { 6375, 17, 39, 15, 1, -32 },
  { 6458, 4, 44, 17, 6, -34 },
  { 6480, 17, 39, 15, -3, -32 },
  { 6563, 18, 7, 20, 2, -19 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC45PT7B_H_
