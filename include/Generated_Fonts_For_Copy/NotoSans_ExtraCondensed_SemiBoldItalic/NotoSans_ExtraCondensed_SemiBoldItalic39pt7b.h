#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC39PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0x78, 0x00, 0x7C, 0xF7, 0x8F, 0x78, 0xF7, 0x9E, 0x79, 0xEF,
  0x1E, 0xF1, 0xEF, 0x1C, 0xE1, 0xCE, 0x3C, 0x00, 0x71, 0xC0, 0x0E, 0x38,
  0x03, 0x87, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x71, 0xC0,
  0x0E, 0x38, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x01, 0xC7, 0x00,
  0x71, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x71, 0xE0, 0x0E, 0x38, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x81, 0xC7, 0x00, 0x70, 0xE0, 0x0E,
  0x38, 0x01, 0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x78,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x07, 0x00, 0x1F,
  0xF0, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x5E, 0x0F, 0x22, 0x07, 0x30, 0x07,
  0x98, 0x03, 0xEC, 0x00, 0xF4, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x37, 0x80, 0x1B, 0xC0, 0x09,
  0xE2, 0x04, 0xF0, 0x86, 0x78, 0xFB, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F,
  0xF8, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x07, 0x80,
  0x70, 0x3F, 0x81, 0xE0, 0x7F, 0x03, 0x81, 0xCF, 0x0F, 0x03, 0x9E, 0x1C,
  0x0E, 0x3C, 0x78, 0x1C, 0x70, 0xE0, 0x38, 0xE3, 0xC0, 0xF1, 0xC7, 0x01,
  0xC3, 0x9C, 0x03, 0x8F, 0x38, 0x07, 0x1C, 0xE3, 0xCE, 0x39, 0xCF, 0xDC,
  0xE7, 0x3F, 0xFF, 0xCE, 0xF3, 0xBF, 0x39, 0xC7, 0x7C, 0xF3, 0x8E, 0x01,
  0xCE, 0x1C, 0x07, 0x9C, 0x78, 0x0E, 0x38, 0xF0, 0x3C, 0x71, 0xC0, 0x71,
  0xE3, 0x81, 0xE3, 0x87, 0x03, 0x87, 0x1C, 0x0E, 0x0E, 0x38, 0x1C, 0x0F,
  0xE0, 0x70, 0x1F, 0xC1, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xC0,
  0x0F, 0xFC, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0,
  0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0xF8, 0xFF, 0x1E, 0x3D, 0xF3, 0xCF,
  0x1E, 0xF1, 0xE3, 0xDE, 0x78, 0x7F, 0x8F, 0x07, 0xF1, 0xE0, 0xFC, 0x3C,
  0x1F, 0x87, 0x83, 0xF0, 0xF9, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0x7C, 0x1F,
  0xCF, 0xC0, 0x7D, 0xF7, 0x9E, 0x79, 0xEF, 0x3C, 0xF3, 0x80, 0x00, 0xF0,
  0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x00, 0x03, 0x80, 0x0F,
  0x00, 0x3C, 0x10, 0xE0, 0x73, 0x81, 0xFE, 0xFF, 0xFF, 0xC7, 0xFF, 0x0F,
  0xFC, 0x7F, 0x03, 0xFC, 0x1F, 0x78, 0x38, 0xF0, 0x63, 0x81, 0x0C, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x1F,
  0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0x70, 0xF0, 0x7F, 0xDF, 0xF7, 0xFD,
  0xFF, 0xFF, 0x80, 0x79, 0xFF, 0xBE, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0xF1, 0xE3,
  0xE3, 0xC7, 0x87, 0x9F, 0x0F, 0x3C, 0x1E, 0x78, 0x3D, 0xF0, 0x7B, 0xC0,
  0xF7, 0x83, 0xEF, 0x07, 0xFE, 0x0F, 0x7C, 0x1E, 0xF0, 0x3D, 0xE0, 0xFB,
  0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x9E, 0x1E, 0x3C, 0x7C, 0x78, 0xF0, 0xFF,
  0xE1, 0xFF, 0x81, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x87,
  0xF1, 0xFC, 0x7F, 0x9E, 0xF7, 0x9E, 0x67, 0xC8, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x70, 0xF8, 0x10, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x17, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC2, 0x01, 0xF0, 0xFB, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x73, 0xC0,
  0x1D, 0xE0, 0x0E, 0x78, 0x07, 0x1E, 0x01, 0xC7, 0x80, 0xE3, 0xE0, 0x70,
  0xF0, 0x1C, 0x3C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x3F, 0xFF, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0x63, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xE1, 0x01, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0xF0, 0x7F, 0xF8, 0x7B, 0xF8, 0x7F, 0xFC, 0x7C, 0x7C, 0xF8, 0x3C,
  0xF8, 0x3C, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x78,
  0xF0, 0xF8, 0xF8, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0x80,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFB, 0xF0, 0xF0, 0xF8, 0x78,
  0x3C, 0x3C, 0x1E, 0x1E, 0x1F, 0x0F, 0x0F, 0x07, 0x8F, 0x83, 0xEF, 0x80,
  0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x3E, 0x7C,
  0x3E, 0x3E, 0x1E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0,
  0xF1, 0xF0, 0xF8, 0xF8, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0x0F, 0x1F, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3E, 0x0F, 0x3C, 0x1F, 0x3C, 0x1F,
  0x3C, 0x3F, 0x3E, 0x3F, 0x3F, 0xFE, 0x1F, 0xFE, 0x1F, 0xDE, 0x0F, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0xC7, 0xE0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0x07, 0xC3, 0xE3,
  0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x00, 0x01, 0xE0, 0x7C, 0x0F,
  0x81, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03,
  0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x00, 0x00, 0x01, 0x00, 0x07,
  0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80,
  0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFC,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0xE0,
  0x01, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0x8F, 0xFE, 0x3F, 0xF1, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0x01,
  0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x07, 0x87,
  0x1C, 0x3F, 0xCE, 0x38, 0xFF, 0x9C, 0xE3, 0xCE, 0x39, 0xC7, 0x1C, 0x77,
  0x1C, 0x38, 0xEE, 0x38, 0xF1, 0xDC, 0x71, 0xC3, 0x31, 0xC3, 0x8E, 0xE3,
  0x87, 0x1D, 0xC7, 0x1E, 0x3B, 0x8E, 0x38, 0xE7, 0x1C, 0x71, 0xCE, 0x39,
  0xE7, 0x1C, 0x7E, 0xFC, 0x38, 0x79, 0xF0, 0x70, 0x60, 0x80, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x10, 0x03, 0xF7, 0xE0,
  0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xDE, 0x01, 0xEF,
  0x00, 0xF7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x7C, 0xF0, 0x3C, 0x78, 0x1E,
  0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE3,
  0xFF, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x1E, 0xF8, 0x1F, 0x7C, 0x0F,
  0xBC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0x87, 0xC1, 0xE0, 0xF0, 0xF8, 0x3C, 0x3E,
  0x0F, 0x0F, 0x07, 0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x7C, 0x7C, 0x1F, 0xFE,
  0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x78, 0xF8, 0x3E, 0x1F, 0x0F, 0x03, 0xC3,
  0xC0, 0xF0, 0xF0, 0x3C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0x81, 0xE1, 0xE0,
  0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xC1, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x20, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x78,
  0xFC, 0x0F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x03, 0xE1, 0xE0,
  0x7C, 0x3C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0xC7, 0x80,
  0xF0, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF0, 0x3E, 0x1E, 0x07,
  0xC7, 0xC1, 0xF0, 0xF8, 0x3E, 0x1E, 0x0F, 0x83, 0xC7, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xE0, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7F,
  0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xE0, 0x40, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC3, 0xFC, 0x78, 0x3F, 0xC7, 0x83, 0xF8,
  0x78, 0x3F, 0x8F, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F,
  0x07, 0x80, 0xF0, 0x7C, 0x0F, 0x07, 0xC1, 0xF0, 0x7F, 0xFF, 0x03, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0xC1,
  0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x3E, 0x07,
  0xC1, 0xF0, 0x3E, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xC0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x07, 0xC0,
  0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xE0, 0x3C, 0x00, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x7F, 0x80, 0x7F, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0xF8, 0x1E, 0x0F, 0x81, 0xF0, 0xF8,
  0x0F, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xF3,
  0xE0, 0x0F, 0x3E, 0x00, 0x79, 0xE0, 0x03, 0xDF, 0x00, 0x3F, 0xF0, 0x01,
  0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xF7, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3E,
  0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0x78, 0x3C, 0x07, 0xC1, 0xE0,
  0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE,
  0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x1F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3B, 0xC0, 0xFF, 0x07, 0xFC, 0x0F,
  0xF0, 0x7F, 0x81, 0xEF, 0x0F, 0x78, 0x1E, 0xF0, 0xF7, 0x81, 0xEF, 0x0E,
  0x78, 0x1E, 0xF1, 0xEF, 0x01, 0xEF, 0x1C, 0xF0, 0x3C, 0xF3, 0xCF, 0x03,
  0xCF, 0x38, 0xF0, 0x3C, 0x77, 0x9F, 0x03, 0xC7, 0x79, 0xE0, 0x3C, 0x7F,
  0x1E, 0x07, 0x87, 0xF1, 0xE0, 0x78, 0x7E, 0x1E, 0x07, 0x87, 0xE3, 0xE0,
  0x78, 0x7C, 0x3C, 0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x07,
  0x87, 0xC0, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x7E, 0x03, 0xC1, 0xF8,
  0x0F, 0x07, 0xE0, 0x78, 0x1F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1E,
  0x0F, 0xF0, 0xF8, 0x3D, 0xC3, 0xC0, 0xF7, 0x0F, 0x07, 0x9E, 0x3C, 0x1E,
  0x78, 0xF0, 0x79, 0xE7, 0x81, 0xE7, 0x9E, 0x07, 0x8E, 0x78, 0x3C, 0x39,
  0xE0, 0xF0, 0xF7, 0x83, 0xC3, 0xFC, 0x0F, 0x0F, 0xF0, 0x3C, 0x3F, 0xC1,
  0xE0, 0x7F, 0x07, 0x81, 0xFC, 0x1E, 0x07, 0xE0, 0x78, 0x1F, 0x83, 0xC0,
  0x7E, 0x0F, 0x01, 0xF8, 0x3C, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xF0,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7C, 0x3E, 0x1F, 0x07, 0xC7, 0xC0, 0xF8,
  0xF8, 0x0F, 0x3E, 0x01, 0xE7, 0xC0, 0x7C, 0xF0, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0xDF,
  0x00, 0xFB, 0xE0, 0x1E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3E, 0x1E,
  0x07, 0xC3, 0xE1, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07,
  0x87, 0xC1, 0xE0, 0xF0, 0xF8, 0x3C, 0x3E, 0x0F, 0x0F, 0x03, 0xC3, 0xC0,
  0xF0, 0xF0, 0x7C, 0x7C, 0x1E, 0x1F, 0x0F, 0x87, 0x8F, 0xC1, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7C, 0x3E, 0x1F, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x0F,
  0x3E, 0x01, 0xE7, 0xC0, 0x7C, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E,
  0xF8, 0x07, 0xDF, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0xDF, 0x00, 0xFB,
  0xE0, 0x1E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3E, 0x1E, 0x07, 0xC3,
  0xE1, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x1F, 0xFE, 0x07, 0x8F, 0x81, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x07, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x1F, 0x07, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0x3E, 0x03, 0xCF, 0x80,
  0xF1, 0xE0, 0x3C, 0x78, 0x1F, 0x1E, 0x07, 0x87, 0xC1, 0xE1, 0xF0, 0x78,
  0x3C, 0x3E, 0x0F, 0x0F, 0x83, 0xC3, 0xC0, 0xF8, 0x00, 0x7F, 0x00, 0x7F,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xC1, 0x83, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x04, 0x07, 0xC1,
  0x81, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0xFE, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0x07, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x81, 0xE0,
  0xF0, 0x1E, 0x0F, 0x03, 0xE0, 0xF0, 0x3E, 0x1F, 0x03, 0xC1, 0xF0, 0x3C,
  0x1E, 0x03, 0xC1, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x78, 0x3C, 0x07,
  0x83, 0xC0, 0xF8, 0x3C, 0x0F, 0x87, 0xC0, 0xF0, 0x7C, 0x0F, 0x07, 0x80,
  0xF0, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x81, 0xE0, 0xF8,
  0x3E, 0x0F, 0x87, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01,
  0xFE, 0x00, 0xF8, 0x07, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3C, 0xF8,
  0x1F, 0x1E, 0x07, 0x87, 0x83, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F,
  0x07, 0x87, 0x81, 0xE3, 0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x9E, 0x01,
  0xE7, 0x80, 0x7B, 0xE0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xDE, 0x00, 0x77,
  0x80, 0x1D, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x0E, 0x03, 0xFF, 0x03, 0xC0, 0x7B,
  0xC0, 0x78, 0x0F, 0x78, 0x1F, 0x03, 0xEF, 0x03, 0xE0, 0x79, 0xE0, 0x7C,
  0x0F, 0x3C, 0x1F, 0x83, 0xC7, 0x83, 0xF0, 0x78, 0xF0, 0x7E, 0x1F, 0x1E,
  0x1F, 0xC3, 0xC3, 0xC3, 0xB8, 0x78, 0x78, 0xF7, 0x1E, 0x0F, 0x1E, 0xE3,
  0xC1, 0xE3, 0x9C, 0xF8, 0x3C, 0xF3, 0x9E, 0x07, 0x9C, 0xF3, 0xC0, 0xF7,
  0x9E, 0xF0, 0x1E, 0xF3, 0xDE, 0x03, 0xDC, 0x7B, 0xC0, 0x7F, 0x8F, 0xF0,
  0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xE0,
  0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0x7E, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0x78, 0x7C,
  0x03, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x9E, 0x00, 0x3C,
  0xF0, 0x01, 0xEF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xF3, 0xC0, 0x07,
  0x9E, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0xF0,
  0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x00, 0xF8, 0x1F, 0x78, 0x1E, 0x78, 0x3E,
  0x78, 0x3C, 0x78, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0x78, 0xF0, 0x79, 0xE0,
  0x3D, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x00, 0xF1, 0xE3, 0xC7, 0x8F, 0x0E, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x87, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x3C,
  0x78, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xBC, 0x07, 0x9C,
  0x0F, 0x1E, 0x0E, 0x1E, 0x1E, 0x1E, 0x3C, 0x0E, 0x3C, 0x0F, 0x78, 0x0F,
  0xF0, 0x0F, 0x7F, 0xFB, 0xFF, 0xFF, 0xFE, 0xFB, 0xE7, 0x9E, 0x3C, 0x70,
  0x00, 0x80, 0x03, 0xF3, 0xC3, 0xFF, 0xC3, 0xFF, 0xE1, 0xF3, 0xF1, 0xF0,
  0xF8, 0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3E, 0x0F, 0x9F,
  0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xF0, 0xF0, 0xF8,
  0x78, 0x7C, 0x3E, 0x7E, 0x1F, 0xEF, 0x07, 0xF7, 0x01, 0xF3, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x88, 0x07, 0xBF, 0x03, 0xFF, 0xC1, 0xFF,
  0xE1, 0xF8, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x3C, 0x1F, 0x1E, 0x0F, 0x1E,
  0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xF9, 0xF0, 0x78,
  0xF8, 0x3C, 0x7C, 0x3C, 0x3E, 0x3E, 0x1F, 0x3E, 0x1F, 0xFF, 0x0F, 0x7F,
  0x07, 0x3F, 0x00, 0x00, 0x40, 0x0F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0x10,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE1, 0x0F, 0xDC,
  0x1F, 0xF0, 0x7F, 0xC0, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x8F, 0x81, 0xFB, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0x3F, 0x0F,
  0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x83,
  0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x3E, 0x0F, 0x9F, 0x83, 0xFF, 0xE0, 0x7F, 0x70, 0x0F,
  0x9C, 0x00, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0xC7, 0x8F, 0x3C, 0x1C, 0xF0,
  0xF7, 0x83, 0xDE, 0x1F, 0x79, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xC0, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x87, 0xFE, 0x1F,
  0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x09, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3F, 0x3C, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7C, 0xFC, 0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x3C,
  0x1E, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3E, 0x1F, 0x07, 0x83, 0xE0, 0xF0,
  0x78, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0xC0,
  0xF9, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x02, 0x03, 0xE0, 0x70, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x88, 0x0F, 0x7E, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0x9F, 0x1F, 0x0F, 0x1F,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3E, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78,
  0x7C, 0xF8, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0x03, 0xC1, 0xF0, 0x7C, 0x1F,
  0x03, 0x80, 0x00, 0x00, 0x02, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07,
  0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x02,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x43, 0xC1, 0xE0, 0xF0, 0xF0, 0x3C, 0x7C, 0x0F,
  0x3E, 0x07, 0x8F, 0x01, 0xE7, 0x80, 0x7B, 0xE0, 0x1F, 0xF0, 0x0F, 0x78,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xCF, 0x01,
  0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3E, 0x07, 0x8F, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xE0,
  0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78,
  0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x00, 0x00, 0x08, 0x08, 0x0F, 0x7E, 0x3E,
  0x0E, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0x9F, 0xDF, 0x1F, 0x0F, 0x8F,
  0x1F, 0x0F, 0x0F, 0x1E, 0x1F, 0x0F, 0x1E, 0x1E, 0x0F, 0x3E, 0x1E, 0x0F,
  0x3C, 0x1E, 0x1E, 0x3C, 0x1E, 0x1E, 0x3C, 0x3E, 0x1E, 0x3C, 0x3C, 0x1E,
  0x7C, 0x3C, 0x1E, 0x78, 0x3C, 0x3C, 0x78, 0x3C, 0x3C, 0x78, 0x78, 0x3C,
  0x78, 0x78, 0x3C, 0xF0, 0x78, 0x7C, 0xF0, 0x78, 0x78, 0xF0, 0xF8, 0x78,
  0x00, 0x08, 0x0E, 0x7E, 0x0E, 0xFF, 0x0E, 0xFF, 0x0F, 0x9F, 0x1F, 0x0F,
  0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3E, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C,
  0x78, 0x7C, 0xF8, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0x00, 0xC0, 0x07, 0xF0,
  0x3F, 0xF0, 0xFF, 0xE1, 0xF3, 0xE7, 0xC3, 0xCF, 0x07, 0xBE, 0x0F, 0x78,
  0x1E, 0xF0, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xDE, 0x07, 0xBC, 0x0F,
  0x78, 0x3E, 0xF0, 0x79, 0xE1, 0xF3, 0xE7, 0xC3, 0xFF, 0x07, 0xFC, 0x07,
  0xF0, 0x00, 0x00, 0x02, 0x00, 0x7B, 0xF0, 0x0E, 0xFF, 0x01, 0xDF, 0xE0,
  0x3E, 0x3C, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3C, 0x1F, 0x07, 0x83, 0xC1,
  0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x87,
  0xC1, 0xE0, 0xF8, 0x3C, 0x1F, 0x0F, 0x83, 0xE3, 0xE0, 0x7E, 0xFC, 0x1F,
  0xFF, 0x03, 0xDF, 0xC0, 0x79, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x80, 0x83, 0xF3, 0x83, 0xFF, 0xC3, 0xFF,
  0xE1, 0xF3, 0xF1, 0xF0, 0xF8, 0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x1E, 0x3C,
  0x0F, 0x1E, 0x0F, 0x9F, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1,
  0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x7C, 0x3E, 0x7E, 0x1F, 0xFF, 0x07, 0xFF,
  0x03, 0xF7, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x08,
  0x3D, 0xF0, 0xEF, 0x83, 0xBE, 0x0F, 0xF8, 0x7E, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x00, 0x80, 0x1F, 0xE0, 0xFF, 0xC7, 0xFE, 0x3E, 0x18, 0xF8, 0x03,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE2, 0x0F, 0x8E, 0x7E, 0x3F, 0xF0,
  0xFF, 0xC3, 0xFC, 0x00, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x3F,
  0xDF, 0xF3, 0xFE, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3E, 0x47,
  0xF0, 0xFE, 0x0F, 0xC0, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3E, 0x1E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x78, 0x3C, 0x78, 0x3C,
  0x78, 0x3C, 0x78, 0x3C, 0x78, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8,
  0xF0, 0xF8, 0xF9, 0xF0, 0xFF, 0x70, 0xFF, 0x70, 0x7E, 0xF0, 0xF0, 0x3F,
  0xE0, 0x7B, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x9E, 0x1E, 0x3C, 0x3C, 0x38,
  0xF0, 0x71, 0xE0, 0xE7, 0x81, 0xCF, 0x03, 0x9C, 0x07, 0x78, 0x0E, 0xF0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x00, 0xF0, 0x7C, 0x1F, 0xE0, 0xF8, 0x7B, 0xC3, 0xF0, 0xF7, 0x87,
  0xE3, 0xCF, 0x0F, 0xC7, 0x9E, 0x3F, 0x8F, 0x3C, 0x7F, 0x3C, 0x79, 0xFE,
  0x78, 0xF3, 0xBC, 0xE1, 0xE7, 0x7B, 0xC3, 0xDE, 0xE7, 0x87, 0xB9, 0xDE,
  0x0F, 0xF3, 0xBC, 0x1F, 0xC7, 0x70, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0,
  0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F,
  0x83, 0xE0, 0x00, 0x07, 0x83, 0xE0, 0xF0, 0xF8, 0x1F, 0x3E, 0x01, 0xE7,
  0x80, 0x3D, 0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x00, 0xF0, 0xF0,
  0x3C, 0x1E, 0x0F, 0x83, 0xC0, 0x07, 0xC1, 0xF0, 0x3C, 0x1E, 0x03, 0xC3,
  0xE0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C,
  0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xDE, 0x00, 0x3D, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xB8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x9F, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFE, 0x1F, 0xF8,
  0x3F, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x00,
  0x00, 0x1E, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x07, 0xC0, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x1F, 0xC0, 0xF8, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xC0, 0x00,
  0x1C, 0x01, 0x7F, 0x81, 0xFF, 0xF7, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 11, 28, 10, 0, -28 },
  { 40, 12, 10, 15, 4, -28 },
  { 55, 19, 28, 18, 0, -28 },
  { 122, 17, 32, 16, 0, -30 },
  { 190, 23, 28, 26, 2, -28 },
  { 271, 19, 28, 19, 0, -28 },
  { 338, 6, 10, 9, 4, -28 },
  { 346, 12, 34, 10, 1, -28 },
  { 397, 13, 34, 10, -3, -28 },
  { 453, 14, 15, 15, 3, -30 },
  { 480, 15, 18, 18, 2, -23 },
  { 514, 8, 10, 9, -2, -5 },
  { 524, 10, 5, 11, 0, -13 },
  { 531, 6, 5, 9, 0, -5 },
  { 535, 19, 28, 14, -2, -28 },
  { 602, 15, 28, 16, 1, -28 },
  { 655, 11, 28, 16, 4, -28 },
  { 694, 17, 28, 16, -1, -28 },
  { 754, 18, 28, 16, -1, -28 },
  { 817, 18, 28, 16, -1, -28 },
  { 880, 17, 28, 16, 0, -28 },
  { 940, 16, 28, 16, 1, -28 },
  { 996, 17, 28, 16, 1, -28 },
  { 1056, 17, 28, 16, 0, -28 },
  { 1116, 16, 28, 16, 0, -28 },
  { 1172, 9, 21, 9, 0, -21 },
  { 1196, 11, 26, 9, -2, -21 },
  { 1232, 16, 18, 18, 1, -23 },
  { 1268, 15, 11, 18, 2, -19 },
  { 1289, 15, 18, 18, 2, -23 },
  { 1323, 13, 28, 12, 1, -28 },
  { 1369, 23, 31, 24, 1, -28 },
  { 1459, 17, 28, 17, -2, -28 },
  { 1519, 18, 28, 18, 0, -28 },
  { 1582, 18, 28, 16, 1, -28 },
  { 1645, 19, 28, 19, 0, -28 },
  { 1712, 17, 28, 15, 0, -28 },
  { 1772, 17, 28, 14, 0, -28 },
  { 1832, 20, 28, 20, 1, -28 },
  { 1902, 21, 28, 20, 0, -28 },
  { 1976, 16, 28, 12, -2, -28 },
  { 2032, 16, 36, 9, -6, -28 },
  { 2104, 21, 28, 17, 0, -28 },
  { 2178, 12, 28, 14, 0, -28 },
  { 2220, 28, 28, 26, 0, -28 },
  { 2318, 22, 28, 21, 0, -28 },
  { 2395, 19, 28, 21, 1, -28 },
  { 2462, 18, 28, 17, 0, -28 },
  { 2525, 19, 35, 21, 1, -28 },
  { 2609, 18, 28, 17, 0, -28 },
  { 2672, 18, 28, 16, -1, -28 },
  { 2735, 15, 28, 15, 3, -28 },
  { 2788, 20, 28, 19, 1, -28 },
  { 2858, 18, 28, 17, 3, -28 },
  { 2921, 27, 28, 27, 3, -28 },
  { 3016, 21, 28, 16, -2, -28 },
  { 3090, 16, 28, 16, 3, -28 },
  { 3146, 19, 28, 14, -2, -28 },
  { 3213, 15, 34, 11, -1, -28 },
  { 3277, 7, 28, 14, 4, -28 },
  { 3302, 15, 34, 11, -3, -28 },
  { 3366, 16, 16, 16, 0, -28 },
  { 3398, 13, 3, 12, -4, 3 },
  { 3403, 6, 6, 11, 6, -30 },
  { 3408, 17, 22, 17, 1, -22 },
  { 3455, 17, 30, 17, 0, -30 },
  { 3519, 14, 22, 14, 1, -22 },
  { 3558, 18, 30, 17, 1, -30 },
  { 3626, 14, 21, 16, 1, -21 },
  { 3663, 20, 39, 10, -5, -30 },
  { 3761, 19, 31, 17, -1, -22 },
  { 3835, 16, 30, 17, 0, -30 },
  { 3895, 10, 29, 8, 0, -29 },
  { 3932, 15, 38, 8, -5, -29 },
  { 4004, 18, 30, 16, 0, -30 },
  { 4072, 10, 30, 8, 0, -30 },
  { 4110, 24, 22, 25, 0, -22 },
  { 4176, 16, 22, 17, 0, -22 },
  { 4220, 15, 22, 17, 1, -22 },
  { 4262, 19, 31, 17, -2, -22 },
  { 4336, 17, 31, 17, 1, -22 },
  { 4402, 14, 22, 12, 0, -22 },
  { 4441, 14, 22, 13, 0, -22 },
  { 4480, 11, 26, 11, 1, -26 },
  { 4516, 16, 21, 17, 1, -21 },
  { 4558, 15, 21, 15, 2, -21 },
  { 4598, 23, 21, 23, 2, -21 },
  { 4659, 19, 21, 15, -2, -21 },
  { 4709, 20, 30, 15, -3, -21 },
  { 4784, 15, 21, 12, -1, -21 },
  { 4824, 15, 34, 13, 1, -28 },
  { 4888, 4, 39, 14, 5, -30 },
  { 4908, 14, 34, 13, -2, -28 },
  { 4968, 16, 6, 18, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC39PT7B_H_
