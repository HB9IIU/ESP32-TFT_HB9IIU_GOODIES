#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC35PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E,
  0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x00, 0x3C, 0xF3, 0x9E,
  0x79, 0xE7, 0x9E, 0x79, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xE3, 0x80, 0x00,
  0xE3, 0x00, 0x63, 0x80, 0x71, 0xC0, 0x38, 0xC0, 0x1C, 0xE0, 0x1C, 0x70,
  0x0E, 0x30, 0x3F, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0x81, 0xCE, 0x00, 0xC7,
  0x00, 0xE3, 0x80, 0x73, 0x80, 0x31, 0xC1, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F,
  0xFE, 0x0E, 0x38, 0x07, 0x18, 0x03, 0x9C, 0x03, 0x8E, 0x01, 0xC6, 0x00,
  0xE7, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x07,
  0xC0, 0x3F, 0xE1, 0xFF, 0xC3, 0xFF, 0x0F, 0x22, 0x1E, 0xC0, 0x3D, 0x80,
  0x7A, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xF8, 0x01,
  0xF8, 0x02, 0xF0, 0x0D, 0xE0, 0x1B, 0xC8, 0x27, 0x9C, 0x5E, 0x3F, 0xFC,
  0x7F, 0xF0, 0x7F, 0xC0, 0x18, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0x0F, 0x01, 0xC1, 0xF8, 0x38, 0x3B, 0x83, 0x87, 0x38, 0x70, 0x73, 0x87,
  0x06, 0x38, 0xE0, 0xE3, 0x8E, 0x0E, 0x39, 0xC0, 0xE3, 0x9C, 0x0E, 0x73,
  0x80, 0xE7, 0x39, 0xEE, 0x77, 0x3F, 0xEE, 0x67, 0x7F, 0xCE, 0xE3, 0x79,
  0xCE, 0x70, 0x1C, 0xE7, 0x03, 0x9C, 0x70, 0x39, 0xC7, 0x07, 0x1C, 0x70,
  0x71, 0xC6, 0x0E, 0x1C, 0xE0, 0xE1, 0xCE, 0x1C, 0x1D, 0xC1, 0xC1, 0xF8,
  0x38, 0x0F, 0x00, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xE3, 0x80,
  0x71, 0xC0, 0x78, 0xE0, 0x3C, 0xF0, 0x1E, 0x70, 0x07, 0x78, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x78, 0xFE, 0x38, 0xF7, 0xBC, 0xF3,
  0xDE, 0x71, 0xFE, 0x78, 0x7F, 0x3C, 0x3F, 0x1E, 0x1F, 0x0F, 0x0F, 0x87,
  0x8F, 0xC3, 0xFF, 0xF0, 0xFF, 0x78, 0x3F, 0x3E, 0x00, 0x3C, 0xF7, 0x9E,
  0x79, 0xC7, 0x1C, 0xF0, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xF0, 0x1C,
  0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x00, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F,
  0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x00,
  0x78, 0x07, 0x04, 0x70, 0x77, 0x1F, 0xFF, 0x7F, 0xF0, 0xFF, 0x1F, 0x03,
  0xF8, 0x7B, 0xC7, 0x1C, 0x31, 0x80, 0x10, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x3C, 0x71, 0xE3, 0xCF, 0x1E, 0x38, 0xE0, 0x7F, 0xBF, 0xFF,
  0xE0, 0x33, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x1F, 0xE0, 0xFF, 0x83, 0xDE, 0x1E, 0x38, 0x70, 0xF3, 0xC3, 0xCF,
  0x0F, 0x78, 0x39, 0xE0, 0xE7, 0x87, 0x9C, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF,
  0x07, 0x3C, 0x3C, 0xF0, 0xF3, 0x83, 0xCE, 0x1E, 0x38, 0x78, 0xE3, 0xC3,
  0xDF, 0x0F, 0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xE0, 0x78, 0x1F, 0x07,
  0xE3, 0xFC, 0xFF, 0xBE, 0xE3, 0xBC, 0x27, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xFC, 0x03, 0xFE, 0x0F, 0xFE,
  0x07, 0x1F, 0x06, 0x0F, 0x04, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x01, 0xFC, 0x07, 0xFE,
  0x07, 0xFF, 0x07, 0x1F, 0x04, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x80, 0xF8, 0xC1, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xDE,
  0x01, 0xDC, 0x03, 0xBC, 0x03, 0xBC, 0x07, 0x3C, 0x06, 0x38, 0x0E, 0x38,
  0x1C, 0x78, 0x18, 0x78, 0x38, 0x78, 0x70, 0x72, 0x7F, 0xFC, 0x7F, 0xFC,
  0xFF, 0xFC, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3B, 0x00, 0x7F, 0x81, 0xFF, 0x81, 0xFF,
  0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x88, 0x1F, 0x18, 0x7C, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF3, 0xC1, 0xFF, 0xC3, 0xFF, 0x87, 0xCF, 0x1F,
  0x0F, 0x3C, 0x1E, 0x78, 0x38, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87,
  0x8F, 0x1E, 0x1E, 0x7C, 0x3F, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x1F, 0xFE,
  0x3F, 0xFC, 0x7F, 0xF9, 0xFF, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x0F,
  0xF8, 0x3F, 0xF8, 0x78, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0E,
  0x1E, 0x3C, 0x1E, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xFC, 0x0F,
  0x3C, 0x3C, 0x7C, 0x70, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07,
  0x1E, 0x1E, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xF0,
  0x3F, 0xF0, 0x79, 0xE1, 0xE1, 0xC3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x3C,
  0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE3, 0xE3, 0xEF, 0xC7, 0xFF, 0x87, 0xEE,
  0x07, 0xBC, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x10,
  0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0x0E, 0x1F, 0x1F, 0x1E, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x78, 0xF8,
  0xF8, 0xF0, 0x03, 0xC0, 0xF0, 0x7C, 0x1E, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x0F,
  0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0x80, 0x00, 0x04, 0x00, 0x30,
  0x03, 0xC0, 0x3F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xC0, 0x03,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x80, 0x0F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3C,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0x80, 0x38, 0x00,
  0x80, 0x00, 0x0F, 0xC3, 0xFE, 0x3F, 0xE3, 0x1F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x04, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0xF8, 0x78,
  0x0F, 0x00, 0xE0, 0x70, 0x07, 0x07, 0x00, 0x18, 0x70, 0x20, 0xE3, 0x0F,
  0xE7, 0x38, 0xFF, 0x39, 0x8E, 0x31, 0xDC, 0x73, 0x8C, 0xE7, 0x1C, 0x66,
  0x38, 0xE3, 0x71, 0x86, 0x3B, 0x9C, 0x71, 0xDC, 0xE3, 0x8C, 0xE7, 0x1C,
  0xE6, 0x39, 0xE6, 0x31, 0xFF, 0x71, 0x87, 0xDF, 0x0E, 0x3C, 0xF0, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x08, 0x01, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0xF7, 0x01, 0xCE, 0x07,
  0x9C, 0x0F, 0x38, 0x3C, 0x70, 0x78, 0xE0, 0xE1, 0xC3, 0xC3, 0x87, 0xFF,
  0x1F, 0xFE, 0x3F, 0xFC, 0x78, 0x79, 0xE0, 0xF3, 0xC1, 0xEF, 0x03, 0xDE,
  0x07, 0xFC, 0x0F, 0xF0, 0x1E, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x0F,
  0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0F, 0x1E, 0x0F, 0x1E,
  0x1E, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x38, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x70,
  0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0xFE, 0x03, 0xFF, 0x07,
  0xFE, 0x0F, 0xC6, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x60, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x1E,
  0x1E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0,
  0xF9, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x1E, 0x1C, 0x0F, 0x1E,
  0x0F, 0x8F, 0x0F, 0x87, 0x8F, 0x83, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0x80,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xE0,
  0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF,
  0x81, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0x0E, 0x0F, 0x80,
  0x87, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xE1, 0xFC, 0x78, 0x7F, 0x1E, 0x1F, 0xCF, 0x87, 0xE3, 0xC0,
  0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xE0, 0xF0, 0x78, 0x3C,
  0x1F, 0x0F, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x07, 0x81,
  0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07,
  0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0x03, 0xC1, 0xE0, 0x78,
  0x3C, 0x0F, 0x07, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0,
  0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x00, 0x03, 0xFE,
  0x0F, 0xFC, 0x07, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x9F, 0x03,
  0xF8, 0x0F, 0xE0, 0x3E, 0x00, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0x78, 0x78,
  0x1C, 0x3C, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x39, 0xE0, 0x1E,
  0x78, 0x07, 0xBC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xF3, 0x80, 0x3C, 0xF0, 0x0E, 0x3C, 0x07, 0x8F, 0x01,
  0xE3, 0xC0, 0x78, 0xF0, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x00, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x7F, 0xF7, 0xFE, 0xFF,
  0xC0, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0xF8,
  0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x83, 0xF8, 0x1F,
  0xC1, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xEF, 0x07, 0xF8, 0x77, 0x03,
  0xBC, 0x73, 0x81, 0xDE, 0x3B, 0xC1, 0xE7, 0x3D, 0xE0, 0xF3, 0x9C, 0xF0,
  0x79, 0xDE, 0x70, 0x38, 0xEE, 0x78, 0x1C, 0x7F, 0x3C, 0x1E, 0x3F, 0x1E,
  0x0F, 0x1F, 0x8F, 0x07, 0x0F, 0x87, 0x03, 0x87, 0xC7, 0x83, 0xC3, 0xE3,
  0xC1, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x7C,
  0x0F, 0x07, 0xC0, 0xE0, 0x7C, 0x0E, 0x0F, 0xC1, 0xE0, 0xFC, 0x1E, 0x0F,
  0xE1, 0xE0, 0xFE, 0x1C, 0x1E, 0xE1, 0xC1, 0xEE, 0x3C, 0x1E, 0xE3, 0xC1,
  0xCF, 0x3C, 0x1C, 0xF3, 0x83, 0xC7, 0x38, 0x3C, 0x77, 0x83, 0xC7, 0x78,
  0x38, 0x77, 0x83, 0x87, 0xF0, 0x78, 0x7F, 0x07, 0x83, 0xF0, 0x70, 0x3F,
  0x07, 0x03, 0xE0, 0xF0, 0x3E, 0x0F, 0x03, 0xE0, 0xF0, 0x3E, 0x00, 0x00,
  0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xF1, 0xF0, 0xF0, 0x78, 0xF0, 0x3C,
  0x78, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0xBE, 0x03, 0xDE, 0x01, 0xEF, 0x00,
  0xF7, 0x80, 0xFB, 0xC0, 0x7B, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x1F, 0x78,
  0x0F, 0x3C, 0x0F, 0x9E, 0x07, 0x8F, 0x87, 0xC3, 0xE7, 0xC1, 0xFF, 0xC0,
  0x7F, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x0F,
  0x3F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x0F, 0x1E,
  0x0F, 0x1E, 0x1F, 0x1E, 0x3E, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F,
  0xC0, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x81,
  0xFF, 0xC1, 0xF1, 0xF0, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x78, 0x0F,
  0x3C, 0x07, 0xBE, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0xFB, 0xC0,
  0x7B, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x1F, 0x78, 0x0F, 0x3C, 0x0F, 0x9E,
  0x07, 0x8F, 0x87, 0xC3, 0xE7, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0x3F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x1E, 0x3E, 0x1E,
  0x7C, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x3D, 0xE0, 0x3C, 0xE0, 0x38,
  0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0xF8, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0x78, 0x01, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xEE, 0x0F,
  0x82, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x40, 0xF8, 0x7B, 0xF0, 0x7F,
  0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0x9F, 0xFE,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x00, 0x0F, 0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x07,
  0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3,
  0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0,
  0xF0, 0x78, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0x78,
  0x3E, 0x7C, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x0F, 0x3C, 0x1E, 0x78,
  0x78, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x3C, 0x1E, 0x78,
  0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x78, 0x1E, 0x07,
  0xBC, 0x0F, 0x07, 0x9E, 0x0F, 0x83, 0xCF, 0x07, 0x81, 0xC7, 0x83, 0xC1,
  0xE3, 0xC3, 0xE0, 0xF1, 0xE1, 0xF0, 0xF0, 0xF1, 0xF8, 0x78, 0x78, 0xFC,
  0x3C, 0x38, 0x7E, 0x3C, 0x1C, 0x77, 0x1E, 0x0E, 0x3B, 0x8E, 0x07, 0x3D,
  0xCF, 0x03, 0x9C, 0xE7, 0x81, 0xCE, 0x77, 0x80, 0xEE, 0x3B, 0xC0, 0x77,
  0x1D, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF0, 0x07,
  0xE1, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x78, 0x78, 0x0F, 0x0F, 0x01,
  0xE3, 0xC0, 0x3C, 0x70, 0x03, 0x9E, 0x00, 0x73, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x01, 0xEF, 0x00, 0x3D,
  0xE0, 0x0F, 0x3C, 0x01, 0xE3, 0x80, 0x78, 0x70, 0x1E, 0x0F, 0x03, 0xC1,
  0xE0, 0xF0, 0x3C, 0x00, 0xF0, 0x3F, 0xC1, 0xEF, 0x07, 0xBC, 0x3C, 0x70,
  0xF1, 0xC7, 0x87, 0x1E, 0x1E, 0xF0, 0x7B, 0x81, 0xFE, 0x07, 0xF0, 0x1F,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x08, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE2, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x00, 0xF0, 0xE1, 0xC3, 0x87, 0x0F, 0x1E, 0x3C,
  0x38, 0x70, 0xE1, 0xC3, 0xC7, 0x8F, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xE3,
  0xC7, 0x8F, 0x0E, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x60, 0x01, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xDE, 0x07, 0x9C, 0x0E, 0x38, 0x38,
  0x70, 0xF0, 0xF1, 0xC0, 0xE7, 0x81, 0xDE, 0x03, 0xC0, 0xFF, 0xFF, 0xFC,
  0xF1, 0xE7, 0x8E, 0x3C, 0x70, 0x07, 0xDE, 0x1F, 0xB8, 0x7F, 0xF1, 0xF3,
  0xE3, 0xC7, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0x3C, 0xF0, 0x79, 0xE0, 0xF3,
  0xC1, 0xE7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x7C, 0x79, 0xF8, 0xFF,
  0xE1, 0xFD, 0xC1, 0xF3, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x78, 0x1D, 0xF8,
  0x7F, 0xF8, 0xF8, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x3C,
  0x1E, 0x70, 0x38, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x1E, 0x1E,
  0x3C, 0x78, 0xFF, 0xF1, 0xDF, 0xC3, 0x9F, 0x00, 0x07, 0xF0, 0xFF, 0x1F,
  0xE3, 0xE2, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x08, 0xFF, 0x87, 0xF8, 0x3F,
  0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x07, 0xDE, 0x0F, 0xDC, 0x1F, 0xFC, 0x3E,
  0x7C, 0x3C, 0x7C, 0x78, 0x3C, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF1, 0xF0, 0xF1,
  0xE0, 0xFF, 0xE0, 0xFE, 0xE0, 0x7C, 0xE0, 0x07, 0xE0, 0x7F, 0x87, 0xFE,
  0x78, 0xF3, 0xC7, 0xBC, 0x3D, 0xE1, 0xCE, 0x3E, 0xFF, 0xE7, 0xFE, 0x3F,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x08, 0xFF, 0xC3, 0xFE,
  0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF7, 0x81, 0xFB, 0x81, 0xFF, 0xC1,
  0xF3, 0xE0, 0xF1, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x1E,
  0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF1,
  0xF0, 0x79, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xDE, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0xC1, 0x83, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x1F, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x78, 0x1F, 0xF8, 0x7F, 0xF0,
  0xF9, 0xF1, 0xE1, 0xE3, 0xC3, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78,
  0x78, 0xE0, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x38, 0x38,
  0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC0, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x00,
  0x00, 0x00, 0x1E, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x1F, 0x0E, 0x1E, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0xF0, 0x1C, 0xF0,
  0x1D, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7D, 0xE0,
  0x79, 0xE0, 0x79, 0xE0, 0x71, 0xE0, 0x71, 0xE0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x00, 0x0E, 0xF8, 0xF8,
  0x3F, 0xF7, 0xF1, 0xFF, 0xFF, 0xC7, 0xCF, 0xCF, 0x1E, 0x3E, 0x3C, 0x78,
  0xF0, 0xF3, 0xC3, 0xC3, 0x8F, 0x0F, 0x0E, 0x3C, 0x38, 0x78, 0xF0, 0xE1,
  0xE3, 0x87, 0x87, 0x9E, 0x1E, 0x1C, 0x78, 0x78, 0x71, 0xE1, 0xC3, 0xC7,
  0x07, 0x0F, 0x1C, 0x3C, 0x3C, 0xF0, 0xF0, 0xE3, 0xC3, 0xC3, 0x8F, 0x0E,
  0x1E, 0x00, 0x0E, 0x78, 0x1D, 0xF8, 0x77, 0xF0, 0xF9, 0xF1, 0xE1, 0xC3,
  0xC3, 0x87, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xE0, 0xE3, 0xC3,
  0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x38, 0x38, 0xF0, 0xF1, 0xE1, 0xE3,
  0xC3, 0xC0, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x7C, 0xF3, 0xC7, 0xBC, 0x1D,
  0xE0, 0xEE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0x78,
  0x7B, 0xC7, 0xDE, 0x3C, 0xFF, 0xC3, 0xFC, 0x0F, 0xC0, 0x03, 0x9E, 0x01,
  0xDF, 0x81, 0xFF, 0xE0, 0xF8, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x1E,
  0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x03, 0x83, 0x83, 0xC3, 0xC1, 0xE1, 0xE0,
  0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x3E, 0x78, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F,
  0x7C, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xDE, 0x1F, 0xB8, 0x7F,
  0xF1, 0xF3, 0xE3, 0xC7, 0xCF, 0x07, 0x9E, 0x1E, 0x38, 0x3C, 0xF0, 0x79,
  0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x7C, 0x78,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC1, 0xF7, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x0E, 0xF0,
  0xEF, 0x1F, 0xF1, 0xFE, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0xC7, 0xFC, 0x78, 0x43, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x10, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0x80, 0x07, 0x03,
  0x80, 0xE0, 0x38, 0x1F, 0xDF, 0xE7, 0xF8, 0xF0, 0x3C, 0x0F, 0x03, 0x80,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFC,
  0x3F, 0x07, 0xC0, 0x1C, 0x1C, 0x70, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x38,
  0xE0, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x79, 0xC1, 0xC7, 0x0F, 0x3C, 0x3C,
  0xF0, 0xF3, 0xC3, 0xCF, 0x1E, 0x3C, 0xF8, 0xFF, 0xE3, 0xFB, 0x87, 0xDE,
  0x00, 0xF0, 0x7F, 0x83, 0xBC, 0x3D, 0xE1, 0xCF, 0x1E, 0x78, 0xF3, 0xCF,
  0x1E, 0x78, 0xF3, 0x87, 0xBC, 0x3D, 0xC1, 0xFE, 0x0F, 0xE0, 0x77, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0xF0, 0xFF, 0x0F,
  0x0F, 0xF1, 0xF0, 0xEF, 0x1F, 0x1E, 0xF3, 0xF1, 0xEF, 0x3F, 0x1C, 0xF3,
  0xF3, 0xCF, 0x77, 0x38, 0xE7, 0x77, 0x8E, 0x77, 0x78, 0xEE, 0x77, 0x0E,
  0xE7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xC0,
  0xF8, 0x7C, 0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x00, 0x07, 0x8F, 0x83, 0xC7,
  0x81, 0xE7, 0x80, 0xF3, 0xC0, 0x7B, 0xC0, 0x1D, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x77, 0x80, 0x7B, 0xC0, 0x78, 0xE0, 0x3C, 0x70, 0x3C, 0x3C, 0x3E, 0x1E,
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x8F,
  0x01, 0xE3, 0xC0, 0x78, 0xE0, 0x0E, 0x78, 0x03, 0x9C, 0x00, 0xEF, 0x00,
  0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xF8, 0x7F, 0xC7, 0xFE, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0xFF, 0xC7, 0xFE, 0x3F, 0xF0, 0x00, 0x78, 0x0F,
  0xC0, 0xFE, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x1E, 0x00, 0xF8,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0x08, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0x80, 0x1F, 0x01, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0xE0, 0x0F, 0x03, 0xF0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x81, 0xFC, 0x0F,
  0xC0, 0x7C, 0x02, 0x00, 0x00, 0x3C, 0x05, 0xFE, 0x1F, 0xFF, 0xF9, 0xFF,
  0x81, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 10, 25, 9, 0, -25 },
  { 33, 12, 9, 13, 3, -25 },
  { 47, 17, 25, 16, 0, -25 },
  { 101, 15, 29, 14, 0, -27 },
  { 156, 20, 25, 23, 2, -25 },
  { 219, 17, 25, 17, 0, -25 },
  { 273, 6, 9, 8, 3, -25 },
  { 280, 11, 31, 9, 1, -25 },
  { 323, 12, 31, 9, -3, -25 },
  { 370, 12, 14, 14, 3, -27 },
  { 391, 14, 17, 16, 1, -21 },
  { 421, 7, 9, 8, -2, -4 },
  { 429, 9, 3, 10, 0, -11 },
  { 433, 5, 5, 8, 0, -5 },
  { 437, 17, 25, 13, -2, -25 },
  { 491, 14, 25, 14, 1, -25 },
  { 535, 11, 25, 15, 3, -25 },
  { 570, 16, 25, 14, -1, -25 },
  { 620, 16, 25, 14, -1, -25 },
  { 670, 16, 25, 15, -1, -25 },
  { 720, 15, 25, 14, 0, -25 },
  { 767, 15, 25, 14, 1, -25 },
  { 814, 15, 25, 14, 1, -25 },
  { 861, 15, 25, 14, 0, -25 },
  { 908, 15, 25, 14, 0, -25 },
  { 955, 8, 19, 8, 0, -19 },
  { 974, 10, 24, 8, -2, -19 },
  { 1004, 14, 17, 16, 1, -21 },
  { 1034, 14, 10, 16, 1, -17 },
  { 1052, 14, 17, 16, 1, -21 },
  { 1082, 12, 25, 11, 1, -25 },
  { 1120, 21, 28, 22, 1, -25 },
  { 1194, 15, 25, 16, -2, -25 },
  { 1241, 16, 25, 16, 0, -25 },
  { 1291, 16, 25, 15, 1, -25 },
  { 1341, 17, 25, 17, 0, -25 },
  { 1395, 15, 25, 14, 0, -25 },
  { 1442, 15, 25, 13, 0, -25 },
  { 1489, 18, 25, 18, 1, -25 },
  { 1546, 19, 25, 18, 0, -25 },
  { 1606, 15, 25, 10, -2, -25 },
  { 1653, 14, 32, 8, -5, -25 },
  { 1709, 18, 25, 15, 0, -25 },
  { 1766, 11, 25, 13, 0, -25 },
  { 1801, 25, 25, 24, 0, -25 },
  { 1880, 20, 25, 19, 0, -25 },
  { 1943, 17, 25, 18, 1, -25 },
  { 1997, 16, 25, 15, 0, -25 },
  { 2047, 17, 31, 18, 1, -25 },
  { 2113, 16, 25, 16, 0, -25 },
  { 2163, 16, 25, 14, -1, -25 },
  { 2213, 14, 25, 13, 2, -25 },
  { 2257, 18, 25, 17, 1, -25 },
  { 2314, 15, 25, 15, 3, -25 },
  { 2361, 25, 25, 24, 2, -25 },
  { 2440, 19, 25, 14, -2, -25 },
  { 2500, 14, 25, 14, 3, -25 },
  { 2544, 16, 25, 13, -1, -25 },
  { 2594, 13, 31, 10, -1, -25 },
  { 2645, 7, 25, 13, 3, -25 },
  { 2667, 13, 31, 10, -2, -25 },
  { 2718, 15, 14, 15, 0, -25 },
  { 2745, 11, 2, 11, -3, 3 },
  { 2748, 6, 6, 10, 5, -27 },
  { 2753, 15, 19, 16, 1, -19 },
  { 2789, 15, 27, 16, 0, -27 },
  { 2840, 12, 19, 12, 1, -19 },
  { 2869, 16, 27, 16, 1, -27 },
  { 2923, 13, 19, 14, 1, -19 },
  { 2954, 17, 35, 9, -4, -27 },
  { 3029, 17, 27, 16, -1, -19 },
  { 3087, 15, 27, 15, 0, -27 },
  { 3138, 9, 26, 8, 0, -26 },
  { 3168, 13, 34, 8, -4, -26 },
  { 3224, 16, 27, 14, 0, -27 },
  { 3278, 9, 27, 7, 0, -27 },
  { 3309, 22, 19, 23, 0, -19 },
  { 3362, 15, 19, 15, 0, -19 },
  { 3398, 13, 19, 15, 1, -19 },
  { 3429, 17, 27, 16, -2, -19 },
  { 3487, 15, 27, 16, 1, -19 },
  { 3538, 12, 19, 11, 0, -19 },
  { 3567, 13, 19, 12, 0, -19 },
  { 3598, 10, 23, 10, 1, -23 },
  { 3627, 14, 19, 15, 1, -19 },
  { 3661, 13, 19, 13, 2, -19 },
  { 3692, 20, 19, 21, 2, -19 },
  { 3740, 17, 19, 13, -2, -19 },
  { 3781, 18, 27, 13, -3, -19 },
  { 3842, 13, 19, 11, -1, -19 },
  { 3873, 13, 31, 12, 1, -25 },
  { 3924, 3, 35, 13, 5, -27 },
  { 3938, 13, 31, 12, -2, -25 },
  { 3989, 14, 5, 16, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC35PT7B_H_
