#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC52PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x80, 0x7E, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0xC0, 0x00, 0x3F, 0x1F, 0x9F, 0x8F,
  0x8F, 0x8F, 0xC7, 0xC7, 0xE7, 0xE3, 0xF3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8,
  0x7C, 0x7C, 0x3C, 0x3C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0x80,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC3,
  0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x3C, 0x03, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x03, 0xC3, 0xC0, 0x03,
  0xC1, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x1E, 0x01, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x03, 0xC3, 0xC0,
  0x03, 0xE1, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0x98, 0xE0, 0x3E, 0x30, 0x80, 0x7C, 0xE0, 0x00, 0xF9, 0x80,
  0x01, 0xF3, 0x00, 0x03, 0xE6, 0x00, 0x07, 0xEC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x6F, 0xC0, 0x00,
  0xDF, 0x80, 0x03, 0x1F, 0x00, 0x06, 0x3E, 0x00, 0x0C, 0x7C, 0x10, 0x19,
  0xF8, 0x30, 0x33, 0xF0, 0x7C, 0xDF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0xFF, 0x80, 0x3C, 0x03,
  0xFE, 0x01, 0xF0, 0x1F, 0x7C, 0x07, 0x80, 0xF9, 0xF0, 0x3C, 0x03, 0xC3,
  0xC0, 0xF0, 0x1F, 0x0F, 0x07, 0x80, 0x78, 0x7C, 0x3E, 0x01, 0xE1, 0xF0,
  0xF0, 0x07, 0x87, 0x87, 0xC0, 0x3C, 0x1E, 0x1E, 0x00, 0xF0, 0x78, 0xF8,
  0x03, 0xC1, 0xE3, 0xC0, 0x0F, 0x0F, 0x9F, 0x00, 0x3C, 0x3C, 0x78, 0x78,
  0xF0, 0xF3, 0xE3, 0xFB, 0xC7, 0xCF, 0x1F, 0xEF, 0x1E, 0x7C, 0xFF, 0xFC,
  0xF9, 0xE7, 0xDF, 0xFF, 0xCF, 0x1E, 0x3F, 0xFE, 0x3C, 0xF0, 0xF7, 0xF1,
  0xE3, 0xC3, 0xC2, 0x0F, 0x9F, 0x0F, 0x00, 0x3C, 0x78, 0x3C, 0x01, 0xF1,
  0xE0, 0xF0, 0x07, 0x87, 0x87, 0xC0, 0x3E, 0x3E, 0x1F, 0x00, 0xF0, 0xF8,
  0x78, 0x07, 0xC3, 0xC1, 0xE0, 0x1E, 0x0F, 0x0F, 0x80, 0xF8, 0x3C, 0x3C,
  0x03, 0xC0, 0xF0, 0xF0, 0x1F, 0x03, 0xC7, 0x80, 0x78, 0x0F, 0xBE, 0x03,
  0xC0, 0x1F, 0xF0, 0x0F, 0x00, 0x7F, 0x80, 0x78, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0xC3, 0xF0, 0xFF, 0xE1, 0xF0, 0xFF, 0xF0, 0xF8, 0x7C, 0xFC, 0xFC, 0x7E,
  0x7E, 0x7C, 0x7E, 0x1F, 0x7E, 0x3E, 0x0F, 0xFE, 0x1F, 0x07, 0xFF, 0x1F,
  0x81, 0xFF, 0x0F, 0xC0, 0xFF, 0x87, 0xC0, 0x7F, 0x83, 0xE0, 0x1F, 0x81,
  0xF8, 0x1F, 0xC0, 0xFC, 0x1F, 0xF0, 0x7F, 0xBF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xBF, 0x03, 0xFF, 0x9F, 0x80, 0xFF, 0x0F, 0xE0, 0x0C, 0x00,
  0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78,
  0xF8, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x02, 0x0F, 0x80, 0x71, 0xE0, 0x1F, 0xBC, 0x33, 0xFF, 0xFE, 0x7F,
  0xFF, 0xD7, 0xFF, 0xF8, 0x0F, 0xFF, 0x01, 0xF8, 0x10, 0x7F, 0x80, 0x1F,
  0xF0, 0x07, 0xFF, 0x03, 0xF9, 0xF0, 0x3E, 0x3E, 0x03, 0x87, 0xE0, 0x30,
  0x70, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC0,
  0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xBF, 0xFD, 0xFF,
  0xEF, 0xFF, 0x7F, 0xF0, 0x3E, 0xFD, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xC7, 0xC0, 0xFC, 0x3F, 0x07, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC3, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0x80,
  0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F,
  0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F,
  0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8,
  0x1F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0xFC, 0x1F, 0x87, 0xE0,
  0xFC, 0x7E, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03,
  0xF8, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0x7E, 0xFD,
  0xF9, 0xF1, 0xE3, 0xE1, 0x8F, 0xC2, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0xF0, 0x7F, 0x00, 0xE0, 0x3F, 0x00, 0x40, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x30, 0x3F, 0x80, 0x40, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x40, 0x07, 0xF0, 0xC0, 0x1F, 0xC1, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0xF7, 0xE0,
  0x01, 0xEF, 0xC0, 0x07, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3C, 0x7C, 0x00,
  0xF1, 0xF8, 0x01, 0xE3, 0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x0F, 0x80, 0x3C,
  0x3F, 0x00, 0xF0, 0x7E, 0x03, 0xE0, 0xFC, 0x07, 0x81, 0xF0, 0x1E, 0x03,
  0xE0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x08, 0x01, 0xFC, 0x30, 0x0F, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFC, 0x60, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x0F, 0xCF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFB,
  0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xF3, 0xF8, 0x7F, 0x07, 0xE1, 0xFC, 0x1F,
  0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F,
  0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0,
  0xFC, 0x3F, 0x07, 0xE0, 0x7E, 0x3F, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF,
  0xFC, 0x0F, 0xC7, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x07, 0xC0, 0x7C,
  0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xC0, 0xF8, 0x1F,
  0x87, 0xE0, 0x7E, 0x3F, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01,
  0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0,
  0x3E, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0x80, 0x7E,
  0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF8, 0x7E, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x3E, 0x0F, 0xC0, 0xFC,
  0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E,
  0x03, 0xE1, 0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x1F, 0x03, 0xF8, 0x7E, 0x0F,
  0xE1, 0xF8, 0x7F, 0x87, 0xF3, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xBF, 0x01, 0xFC, 0xF8, 0x01, 0xC7, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x80, 0x3E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x7C, 0x02, 0x00, 0x00, 0x08, 0x00, 0xF8,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0x80, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFF,
  0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xC7, 0xF0, 0xC0, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFC,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x07, 0x80, 0x7C, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x60,
  0x3C, 0x1E, 0x07, 0xFC, 0x78, 0x78, 0x3F, 0xF8, 0xF0, 0xF0, 0xFF, 0xF1,
  0xE3, 0xC1, 0xE3, 0xC3, 0xC7, 0x87, 0x87, 0x87, 0x9E, 0x0F, 0x0F, 0x0F,
  0x3C, 0x3C, 0x1E, 0x1E, 0x78, 0x78, 0x78, 0x3C, 0xE1, 0xE0, 0xF0, 0x73,
  0xC3, 0xC1, 0xE1, 0xE7, 0x87, 0x83, 0xC3, 0xCF, 0x0F, 0x0F, 0x07, 0x9E,
  0x3C, 0x1E, 0x0E, 0x38, 0x78, 0x3C, 0x3C, 0xF0, 0xF0, 0xF8, 0x71, 0xE1,
  0xE1, 0xF1, 0xE3, 0xC3, 0xC7, 0xE3, 0x87, 0x87, 0xDF, 0xDF, 0x0F, 0x07,
  0xFB, 0xFC, 0x1E, 0x0F, 0xE7, 0xF0, 0x3C, 0x0F, 0x87, 0xC0, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x03, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xEF, 0x80, 0x07, 0xDF,
  0x00, 0x0F, 0xBE, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF9, 0xF0,
  0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x9F, 0x80, 0x3E, 0x3F, 0x00,
  0xFC, 0x7E, 0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7E, 0x03, 0xF1, 0xF8, 0x07,
  0xE3, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E,
  0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xE0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x01, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC1, 0xFC, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF8,
  0x1F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8,
  0x3E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x0F, 0xE0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFE, 0x06, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x03, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x0F, 0x87, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF0, 0x07, 0xE1, 0xF8,
  0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x1F,
  0x00, 0x7E, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x83,
  0xF0, 0x3F, 0x83, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0xC0, 0xFC, 0x7F, 0xC0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xC0,
  0x70, 0x1F, 0xE0, 0x04, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x7F, 0xE3, 0xF8, 0x1F, 0xF8, 0xFC, 0x07, 0xFE, 0x3F, 0x03,
  0xFF, 0x8F, 0xC0, 0xFF, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xC0, 0x7F, 0x03,
  0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0,
  0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7E,
  0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F,
  0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F,
  0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xC0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF8, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F,
  0x03, 0xF0, 0x03, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xE0,
  0x03, 0xF1, 0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xF3,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xF7, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xE1, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7C,
  0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0,
  0x0F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x1F,
  0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xEF, 0x80,
  0x7D, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x1F, 0x7C, 0x0F,
  0xBF, 0x01, 0xFB, 0xE0, 0x7D, 0xF0, 0x0F, 0xDF, 0x07, 0xCF, 0x80, 0x7C,
  0xF8, 0x3E, 0xFC, 0x03, 0xE7, 0xC3, 0xE7, 0xE0, 0x1F, 0x3E, 0x1F, 0x3F,
  0x01, 0xF9, 0xF1, 0xF1, 0xF0, 0x0F, 0xCF, 0x8F, 0x8F, 0x80, 0x7C, 0x7C,
  0x78, 0xFC, 0x03, 0xE3, 0xE7, 0xC7, 0xE0, 0x1F, 0x1F, 0x3E, 0x3E, 0x01,
  0xF8, 0xFB, 0xE1, 0xF0, 0x0F, 0x87, 0xDF, 0x0F, 0x80, 0x7C, 0x3F, 0xF0,
  0xFC, 0x03, 0xE1, 0xFF, 0x87, 0xE0, 0x1F, 0x07, 0xF8, 0x3E, 0x01, 0xF8,
  0x3F, 0xC1, 0xF0, 0x0F, 0x81, 0xFC, 0x1F, 0x80, 0x7C, 0x0F, 0xE0, 0xFC,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x1F,
  0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x07, 0xF0, 0x03, 0xE0, 0x1F, 0xE0, 0x0F, 0x80, 0x7F, 0x80, 0x3E, 0x01,
  0xFE, 0x01, 0xF8, 0x07, 0xF8, 0x07, 0xE0, 0x3F, 0xE0, 0x1F, 0x00, 0xFF,
  0xC0, 0x7C, 0x03, 0xFF, 0x01, 0xF0, 0x0F, 0xFC, 0x0F, 0xC0, 0x3F, 0xF0,
  0x3E, 0x01, 0xF7, 0xC0, 0xF8, 0x07, 0xDF, 0x03, 0xE0, 0x1F, 0x3E, 0x1F,
  0x80, 0x7C, 0xF8, 0x7E, 0x03, 0xF3, 0xE1, 0xF0, 0x0F, 0xCF, 0x87, 0xC0,
  0x3E, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0xFC, 0x03, 0xE1, 0xF3, 0xF0, 0x1F,
  0x87, 0xCF, 0x80, 0x7E, 0x1F, 0x3E, 0x01, 0xF0, 0x7C, 0xF8, 0x07, 0xC1,
  0xF7, 0xE0, 0x1F, 0x07, 0xDF, 0x80, 0xFC, 0x0F, 0xFC, 0x03, 0xE0, 0x3F,
  0xF0, 0x0F, 0x80, 0xFF, 0xC0, 0x3E, 0x03, 0xFF, 0x00, 0xF8, 0x0F, 0xF8,
  0x07, 0xE0, 0x3F, 0xE0, 0x1F, 0x00, 0x7F, 0x80, 0x7C, 0x01, 0xFE, 0x01,
  0xF0, 0x07, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xE1,
  0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x0F, 0xC7, 0xF0,
  0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0x7E, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0x9F,
  0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xE0, 0x03, 0xFB,
  0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F,
  0xC3, 0xF0, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xF0, 0x7F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07,
  0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07,
  0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0xC3, 0xFC, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x3F,
  0x87, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF8, 0x01,
  0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0x7E, 0x00,
  0x3F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xEF, 0xE0,
  0x03, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x8F,
  0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x01, 0xF0, 0xFE, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC3, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x1F, 0x80, 0x1F,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x3E,
  0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7C, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC,
  0x07, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFC, 0x1C, 0x03,
  0xF8, 0x04, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x60,
  0x0F, 0xC0, 0x78, 0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC1,
  0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xC0, 0x1F,
  0x83, 0xF0, 0x07, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x3F, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F,
  0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x03,
  0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF0,
  0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03,
  0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE,
  0x03, 0xF8, 0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xBE, 0x00, 0x7E, 0xF8,
  0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x3E, 0x01, 0xF8, 0xF8, 0x07,
  0xE3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x83,
  0xE0, 0x7E, 0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x3E, 0x03, 0xE1,
  0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xE0,
  0x0F, 0x9F, 0x80, 0x3E, 0x7C, 0x00, 0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F,
  0xBE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF7, 0xC0,
  0x1F, 0x80, 0x7E, 0x7C, 0x01, 0xF8, 0x07, 0xE7, 0xC0, 0x3F, 0x80, 0x7C,
  0xFC, 0x03, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xF0,
  0x0F, 0x8F, 0xC0, 0x7F, 0x01, 0xF8, 0xFC, 0x0F, 0xF0, 0x1F, 0x0F, 0xC0,
  0xFF, 0x03, 0xF0, 0xFC, 0x0F, 0xF0, 0x3F, 0x0F, 0xC1, 0xFF, 0x03, 0xE0,
  0xFC, 0x1E, 0xF0, 0x7E, 0x0F, 0xC3, 0xEF, 0x07, 0xC0, 0xFC, 0x3E, 0xF0,
  0xFC, 0x0F, 0xC3, 0xDF, 0x0F, 0xC0, 0xFC, 0x7D, 0xF0, 0xF8, 0x0F, 0x87,
  0xDF, 0x1F, 0x80, 0xF8, 0xF9, 0xF1, 0xF8, 0x0F, 0x8F, 0x9F, 0x1F, 0x00,
  0xF8, 0xF1, 0xF3, 0xF0, 0x0F, 0x9F, 0x1F, 0x3E, 0x00, 0xF9, 0xF1, 0xF7,
  0xE0, 0x0F, 0xBE, 0x1F, 0x7E, 0x00, 0xFB, 0xE1, 0xF7, 0xC0, 0x0F, 0xBE,
  0x1F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0x3E, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0,
  0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x01, 0xF8, 0x00, 0x7C, 0x01, 0xFB, 0xF0, 0x0F, 0x9F, 0x80, 0xFC, 0xFC,
  0x07, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0,
  0x3E, 0x1F, 0x81, 0xF0, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xE7,
  0xE0, 0x1F, 0x3E, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xF8,
  0xF8, 0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0xFC,
  0x00, 0x7C, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0xFC, 0xFE, 0x7E, 0x3E, 0x3E, 0x1F, 0x0F, 0x00, 0x30, 0x00, 0x07, 0xF9,
  0xF0, 0x3F, 0xE7, 0xC1, 0xFF, 0xDF, 0x07, 0xFF, 0xFC, 0x3F, 0x9F, 0xE1,
  0xFC, 0x3F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xE3, 0xF0,
  0x1F, 0x0F, 0x80, 0x7C, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F,
  0x1F, 0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F,
  0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xFC, 0x3F, 0x0F,
  0xF0, 0xFE, 0x7F, 0x81, 0xFF, 0xFE, 0x07, 0xFE, 0xF8, 0x0F, 0xF3, 0xE0,
  0x1F, 0x8F, 0x80, 0x10, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x70, 0x03, 0xE7, 0xF0, 0x1F, 0xBF, 0xE0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFF, 0x07, 0xF9, 0xFC, 0x3F, 0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0,
  0x3F, 0x0F, 0xC0, 0xFC, 0x3E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F,
  0x1F, 0x00, 0xFC, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F,
  0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x7E, 0x07,
  0xE1, 0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0xE7, 0xF0, 0xFF, 0xFF, 0x83,
  0xEF, 0xFC, 0x0F, 0xBF, 0xE0, 0x3C, 0x7F, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x1E, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xE3, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x60, 0x7F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x06, 0x0F,
  0x80, 0x0F, 0xE7, 0xC0, 0x1F, 0xFB, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x0F, 0xE7, 0xF8, 0x07, 0xE1, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x1F,
  0x80, 0x7C, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x01,
  0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xF0,
  0x1F, 0xCF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0x7C, 0x00, 0xFF, 0x3E,
  0x00, 0x3F, 0x1F, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x87, 0xC3, 0xE0,
  0xF8, 0xFC, 0x1F, 0x1F, 0x03, 0xE7, 0xE0, 0x7C, 0xF8, 0x1F, 0xBF, 0x07,
  0xE7, 0xE3, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x08, 0x7E, 0x06, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFC, 0x40, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3F, 0x9F, 0x00, 0xFF, 0xDF, 0x01, 0xFF, 0xDF, 0x01, 0xFF, 0xFF,
  0x03, 0xF9, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0xFC, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xF8, 0x3F, 0x01, 0xF8,
  0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x0F, 0xF0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xF7, 0xE0, 0x0F, 0xE7, 0xE0,
  0x01, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x80, 0x3F, 0x80, 0xF8, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x70, 0x03, 0xE7, 0xF0,
  0x1F, 0xBF, 0xE0, 0x7D, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFB, 0xFC, 0x1F,
  0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x3E, 0x03,
  0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7C, 0x07, 0xC1,
  0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0x83, 0xE0,
  0x3E, 0x0F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7C,
  0x1F, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3E,
  0x03, 0xE0, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xE0, 0xFC,
  0x07, 0xC3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0x7C, 0x7E, 0x00,
  0xF9, 0xF8, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFB,
  0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x7E, 0x1F,
  0x00, 0xF8, 0x3F, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF8,
  0x1F, 0x81, 0xF0, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x01,
  0xE7, 0xF8, 0x7F, 0x01, 0xF7, 0xFE, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0x8F, 0xF9, 0xFC, 0x1F, 0x87, 0xF8, 0x7E,
  0x1F, 0x81, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x0F,
  0x83, 0xE0, 0x7E, 0x0F, 0xC3, 0xF0, 0x3E, 0x07, 0xE1, 0xF8, 0x1F, 0x03,
  0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0xC0, 0xF8, 0x3E, 0x07, 0xE0,
  0xFC, 0x3F, 0x03, 0xE0, 0x7E, 0x1F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF8,
  0x1F, 0x07, 0xC0, 0xFC, 0x0F, 0x83, 0xE0, 0x7E, 0x0F, 0xC3, 0xF0, 0x3E,
  0x07, 0xE1, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x81, 0xF0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x7E, 0x07, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0x7E, 0x1F, 0x81,
  0xF0, 0x3E, 0x0F, 0x81, 0xF8, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x1F,
  0xC0, 0x7C, 0xFF, 0x81, 0xF7, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xE7, 0xF0,
  0x7E, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC0, 0xF8, 0x3F, 0x03, 0xE0, 0xF8,
  0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xC1, 0xF0, 0x1F,
  0x07, 0xC0, 0x7C, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F,
  0x80, 0xF8, 0x3E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x01,
  0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xE0,
  0xF8, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0x7F, 0x1F, 0xC3, 0xF1, 0xF8, 0x3F, 0x3F,
  0x01, 0xF3, 0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0x7E, 0x01, 0xF7,
  0xE0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3E,
  0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0xFC, 0x1F,
  0xCF, 0xC1, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x7F,
  0x00, 0x3E, 0x7F, 0xC0, 0x1F, 0x7F, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xF0,
  0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC,
  0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F,
  0x00, 0xFC, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x3F, 0x03,
  0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xF7, 0xF8,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xF7, 0xFC, 0x01, 0xF1, 0xF8,
  0x00, 0xF8, 0x20, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xF9, 0xF0, 0x1F, 0xF7, 0xC0,
  0xFF, 0xDF, 0x07, 0xFF, 0xFC, 0x3F, 0x9F, 0xE0, 0xFC, 0x3F, 0x87, 0xE0,
  0x7E, 0x1F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x0F, 0x80, 0x7C,
  0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0xFC,
  0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0xFC, 0x0F,
  0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xFC, 0x3F, 0x07, 0xF0, 0xFF, 0x7F, 0x81,
  0xFF, 0xFE, 0x07, 0xFE, 0xF8, 0x0F, 0xF7, 0xE0, 0x3F, 0x9F, 0x80, 0x10,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xC0, 0xF1,
  0xF0, 0x7C, 0xFC, 0x1F, 0x7F, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0x88,
  0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0x87, 0x07, 0xE0, 0x20, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x84, 0x07, 0xF0, 0xFB,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x04,
  0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x01, 0xFF, 0xDF, 0xFE, 0x7F, 0xF9, 0xFF, 0xE1, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF2, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81,
  0xFE, 0x01, 0x80, 0x00, 0x07, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0xFC, 0x0F,
  0x83, 0xE0, 0x3E, 0x0F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x07,
  0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0,
  0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x7E, 0x1F, 0x81, 0xF8,
  0x7E, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xF0, 0xFC,
  0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x3F, 0xBF, 0xE0, 0xFF, 0xFF,
  0x81, 0xFF, 0xBC, 0x07, 0xFC, 0xF0, 0x0F, 0xE3, 0xC0, 0x04, 0x00, 0x00,
  0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0, 0x3F, 0x7C, 0x07, 0xEF, 0x80, 0xF9,
  0xF0, 0x3F, 0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC3,
  0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3E, 0x7E, 0x07,
  0xCF, 0x80, 0x79, 0xF0, 0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0,
  0x7F, 0x03, 0xEF, 0x81, 0xFC, 0x0F, 0xBE, 0x07, 0xF0, 0x7E, 0xF8, 0x3F,
  0xC1, 0xF3, 0xE0, 0xFF, 0x07, 0xCF, 0x83, 0xFC, 0x3E, 0x3E, 0x1E, 0xF0,
  0xF8, 0xF8, 0x7B, 0xC7, 0xE3, 0xE3, 0xFF, 0x1F, 0x0F, 0x8F, 0x7C, 0x7C,
  0x3E, 0x3D, 0xF3, 0xE0, 0xF9, 0xF7, 0xCF, 0x83, 0xE7, 0x9F, 0x3E, 0x0F,
  0xBE, 0x7D, 0xF0, 0x3E, 0xF9, 0xF7, 0xC0, 0xFB, 0xC7, 0xFE, 0x03, 0xFF,
  0x1E, 0xF8, 0x0F, 0xF8, 0x7B, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87,
  0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x81, 0xFE,
  0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x03,
  0xF7, 0xE0, 0x01, 0xFB, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0x3E,
  0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F,
  0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8,
  0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE3, 0xE0, 0x00,
  0xF9, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x03, 0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x0B, 0xFF, 0x00, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFA, 0x00, 0x7F, 0x90,
  0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 14, 38, 13, 0, -37 },
  { 68, 17, 13, 19, 5, -37 },
  { 96, 25, 37, 24, 0, -37 },
  { 212, 23, 43, 21, 0, -40 },
  { 336, 30, 38, 35, 3, -38 },
  { 479, 25, 39, 25, 0, -38 },
  { 601, 8, 13, 12, 5, -37 },
  { 614, 17, 45, 14, 1, -37 },
  { 710, 17, 46, 14, -4, -38 },
  { 808, 19, 20, 20, 4, -40 },
  { 856, 21, 25, 23, 2, -31 },
  { 922, 11, 14, 12, -3, -7 },
  { 942, 13, 6, 14, 1, -17 },
  { 952, 7, 8, 12, 0, -7 },
  { 959, 26, 37, 19, -3, -37 },
  { 1080, 21, 39, 21, 1, -38 },
  { 1183, 15, 37, 22, 5, -37 },
  { 1253, 24, 38, 21, -2, -38 },
  { 1367, 23, 39, 21, -1, -38 },
  { 1480, 23, 37, 22, -1, -37 },
  { 1587, 22, 38, 21, 0, -37 },
  { 1692, 22, 39, 21, 1, -38 },
  { 1800, 23, 37, 21, 1, -37 },
  { 1907, 22, 39, 21, 0, -38 },
  { 2015, 22, 39, 21, 0, -38 },
  { 2123, 12, 30, 12, 0, -29 },
  { 2168, 15, 36, 12, -3, -29 },
  { 2236, 21, 25, 23, 2, -31 },
  { 2302, 21, 15, 23, 2, -26 },
  { 2342, 21, 25, 23, 2, -31 },
  { 2408, 18, 38, 16, 1, -38 },
  { 2494, 31, 41, 33, 1, -37 },
  { 2653, 23, 37, 23, -3, -37 },
  { 2760, 24, 37, 24, 0, -37 },
  { 2871, 23, 39, 22, 2, -38 },
  { 2984, 25, 37, 26, 0, -37 },
  { 3100, 23, 37, 20, 0, -37 },
  { 3207, 23, 37, 19, 0, -37 },
  { 3314, 26, 39, 27, 2, -38 },
  { 3441, 28, 37, 27, 0, -37 },
  { 3571, 21, 37, 15, -2, -37 },
  { 3669, 22, 48, 12, -8, -37 },
  { 3801, 27, 37, 23, 0, -37 },
  { 3926, 16, 37, 19, 0, -37 },
  { 4000, 37, 37, 35, 0, -37 },
  { 4172, 30, 37, 28, 0, -37 },
  { 4311, 25, 39, 27, 2, -38 },
  { 4433, 24, 37, 23, 0, -37 },
  { 4544, 25, 47, 27, 2, -38 },
  { 4691, 24, 37, 23, 0, -37 },
  { 4802, 24, 39, 21, -1, -38 },
  { 4919, 20, 37, 20, 4, -37 },
  { 5012, 26, 38, 26, 2, -37 },
  { 5136, 22, 37, 23, 5, -37 },
  { 5238, 36, 37, 35, 4, -37 },
  { 5405, 28, 37, 21, -3, -37 },
  { 5535, 21, 37, 21, 4, -37 },
  { 5633, 25, 37, 19, -2, -37 },
  { 5749, 20, 45, 15, -2, -37 },
  { 5862, 10, 37, 19, 5, -37 },
  { 5909, 21, 45, 15, -4, -37 },
  { 6028, 22, 21, 22, 0, -37 },
  { 6086, 17, 4, 16, -5, 4 },
  { 6095, 8, 8, 15, 8, -40 },
  { 6103, 22, 30, 23, 1, -29 },
  { 6186, 22, 41, 23, 0, -40 },
  { 6299, 19, 30, 18, 1, -29 },
  { 6371, 25, 41, 23, 1, -40 },
  { 6500, 19, 30, 21, 1, -29 },
  { 6572, 26, 52, 14, -6, -40 },
  { 6741, 24, 41, 23, -1, -29 },
  { 6864, 22, 40, 23, 0, -40 },
  { 6974, 13, 39, 11, 0, -39 },
  { 7038, 20, 51, 11, -7, -39 },
  { 7166, 23, 40, 21, 0, -40 },
  { 7281, 14, 40, 11, 0, -40 },
  { 7351, 33, 29, 34, 0, -29 },
  { 7471, 22, 29, 23, 0, -29 },
  { 7551, 20, 30, 22, 1, -29 },
  { 7626, 25, 41, 23, -3, -29 },
  { 7755, 22, 41, 23, 1, -29 },
  { 7868, 18, 29, 16, 0, -29 },
  { 7934, 19, 30, 18, 0, -29 },
  { 8006, 14, 35, 14, 2, -34 },
  { 8068, 22, 29, 23, 1, -28 },
  { 8148, 19, 28, 20, 3, -28 },
  { 8215, 30, 28, 31, 3, -28 },
  { 8320, 25, 28, 20, -3, -28 },
  { 8408, 26, 40, 20, -4, -28 },
  { 8538, 20, 28, 17, -2, -28 },
  { 8608, 20, 45, 17, 1, -37 },
  { 8721, 5, 52, 19, 7, -40 },
  { 8754, 19, 45, 17, -3, -37 },
  { 8861, 21, 8, 23, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic52pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC52PT7B_H_
