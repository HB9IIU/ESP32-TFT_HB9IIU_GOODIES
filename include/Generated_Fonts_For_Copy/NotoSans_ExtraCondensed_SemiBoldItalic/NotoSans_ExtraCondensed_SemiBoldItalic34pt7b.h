#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC34PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x00, 0x00, 0x06, 0x07,
  0x87, 0xC3, 0xE1, 0xE0, 0x79, 0xEF, 0x3D, 0xE7, 0xB8, 0xE7, 0x1C, 0xE7,
  0x9C, 0xE7, 0x1C, 0xE3, 0x80, 0x00, 0xE7, 0x01, 0xC6, 0x01, 0xCE, 0x01,
  0x8E, 0x03, 0x8E, 0x03, 0x8C, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x07,
  0x38, 0x06, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x0C, 0x70, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0x38, 0xC0, 0x39, 0xC0, 0x31, 0xC0, 0x71, 0xC0, 0x71,
  0x80, 0x73, 0x80, 0xE3, 0x80, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x1F,
  0xE0, 0x7F, 0xE1, 0xFF, 0x87, 0xF7, 0x0F, 0x60, 0x1C, 0x80, 0x39, 0x00,
  0x7A, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x03,
  0xF0, 0x06, 0xF0, 0x09, 0xE4, 0x13, 0x8C, 0x2F, 0x1F, 0xFE, 0x3F, 0xF8,
  0x7F, 0xE0, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x04, 0x00,
  0x41, 0xF0, 0x38, 0x3F, 0x83, 0x83, 0x38, 0x70, 0x73, 0x87, 0x07, 0x38,
  0xE0, 0xE3, 0x8C, 0x0E, 0x39, 0xC0, 0xE3, 0x18, 0x0E, 0x73, 0x80, 0xC7,
  0x71, 0xCC, 0x77, 0x3E, 0xEE, 0xE7, 0xFF, 0xCE, 0xE7, 0xFD, 0xCC, 0x73,
  0x1D, 0xC7, 0x03, 0x9C, 0x70, 0x39, 0xC6, 0x07, 0x18, 0xE0, 0x71, 0x8E,
  0x0E, 0x38, 0xE0, 0xC3, 0x9C, 0x1C, 0x1D, 0xC1, 0x81, 0xF8, 0x38, 0x0F,
  0x00, 0x00, 0x40, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xBC, 0x07, 0x3C, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x78, 0x0F, 0xF0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0xCF, 0x3F, 0xCF, 0x79, 0xCE, 0x71, 0xFE, 0xF1,
  0xFC, 0xF0, 0xFC, 0xF0, 0xF8, 0xF0, 0xF8, 0xF1, 0xF8, 0xFF, 0xF8, 0x7F,
  0xBC, 0x3F, 0x3C, 0x3D, 0xE7, 0x9E, 0x71, 0xC7, 0x1C, 0xE0, 0x01, 0xC0,
  0xE0, 0x78, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81,
  0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x00, 0x01,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38,
  0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x70,
  0x1E, 0x03, 0x81, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x07, 0x06, 0x70, 0xFE,
  0x6F, 0xFF, 0x3F, 0xF1, 0xF0, 0x3F, 0x07, 0xB8, 0xF3, 0xC3, 0x1C, 0x21,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x1E, 0x3C, 0x71, 0xE3, 0x8F, 0x1C, 0x38,
  0xE0, 0x7F, 0xBF, 0xDF, 0xDF, 0xE0, 0x33, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0x00, 0xC0, 0x1F, 0x81, 0xFC, 0x1F, 0xF1, 0xE7, 0x8E, 0x1C, 0xF0,
  0xE7, 0x87, 0x38, 0x7B, 0xC3, 0xDE, 0x1E, 0xE0, 0xFF, 0x07, 0xF8, 0x3B,
  0xC3, 0xDE, 0x1E, 0xE0, 0xF7, 0x07, 0x38, 0x79, 0xC3, 0xCE, 0x3C, 0x7B,
  0xE3, 0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x3F,
  0xBE, 0xE7, 0x78, 0x9E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0,
  0x00, 0x70, 0x07, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x61, 0xE0, 0x83, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE0, 0x00,
  0x30, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x06, 0x1E, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x07, 0xF0, 0x07,
  0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0xC1, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1B,
  0x80, 0x77, 0x00, 0xDE, 0x03, 0xBC, 0x0E, 0x70, 0x18, 0xE0, 0x73, 0xC1,
  0xC7, 0x83, 0x8F, 0x0E, 0x1C, 0x38, 0x38, 0x7F, 0xFC, 0xFF, 0xFB, 0xFF,
  0xF0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x07, 0xFE,
  0x0F, 0xF8, 0x1F, 0xF0, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x3F, 0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC4, 0x0F, 0x8C,
  0x3E, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x38, 0x07, 0xF0, 0x3F,
  0xC1, 0xFF, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE2,
  0x07, 0xBE, 0x1F, 0xFC, 0x7F, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0,
  0xF3, 0xC3, 0xCE, 0x0F, 0x38, 0x78, 0xF1, 0xE3, 0xCF, 0x8F, 0xFC, 0x1F,
  0xE0, 0x3F, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xE1, 0xE1, 0xE3, 0xC3, 0xC7,
  0x87, 0x8F, 0x0E, 0x1E, 0x3C, 0x1C, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x7C,
  0x03, 0xFC, 0x0F, 0xFC, 0x3C, 0x78, 0x70, 0x71, 0xE0, 0xF3, 0xC1, 0xE7,
  0x83, 0x8F, 0x0F, 0x1E, 0x1E, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x00,
  0xE0, 0x0F, 0xE0, 0x7F, 0x83, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0xCF,
  0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1F, 0x3C, 0xFC, 0xFF, 0xE3,
  0xFF, 0x87, 0xDE, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0,
  0x1F, 0x0F, 0xF8, 0x3F, 0xC0, 0xFE, 0x00, 0x06, 0x0F, 0x1F, 0x1E, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x78, 0xF8,
  0xF0, 0xF0, 0x00, 0x80, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x0F,
  0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0x80, 0x00, 0x04, 0x00, 0x70,
  0x07, 0xC0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x03, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x03, 0x03,
  0xF8, 0xFF, 0x9F, 0xF2, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x00,
  0x00, 0x02, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x04, 0x00,
  0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x3C, 0x1E, 0x07, 0x00, 0xE0, 0xE0, 0x07,
  0x1C, 0x00, 0x71, 0xC3, 0xE7, 0x38, 0xFE, 0x73, 0x1C, 0xE7, 0x71, 0xCE,
  0x77, 0x38, 0xE7, 0x63, 0x8C, 0x7E, 0x31, 0xC6, 0xE7, 0x1C, 0x6E, 0x71,
  0xCE, 0xC7, 0x38, 0xCC, 0x73, 0x9C, 0xC7, 0x79, 0x8C, 0x7D, 0xF8, 0xC3,
  0xCF, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x08, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0x0E, 0xE0, 0x1D, 0xC0, 0x7B, 0x80, 0xE7, 0x03, 0xDE,
  0x07, 0x3C, 0x0E, 0x78, 0x3C, 0xF0, 0x71, 0xE1, 0xE3, 0xC3, 0xFF, 0x8F,
  0xFF, 0x1F, 0xFE, 0x38, 0x3C, 0xF0, 0x79, 0xE0, 0xF7, 0x81, 0xEF, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0x1F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C,
  0x1F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF8, 0x3C, 0x78, 0x3C, 0x3C, 0x38, 0x3C,
  0x38, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x78, 0x70, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x78, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFE,
  0x0F, 0x84, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x60,
  0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0x81, 0xE3, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x38, 0x3E, 0x3C, 0x1F, 0x1E,
  0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78,
  0xF0, 0x78, 0x78, 0x3C, 0x38, 0x3E, 0x3C, 0x1E, 0x1E, 0x1F, 0x0F, 0x1F,
  0x07, 0xBF, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x0F,
  0xF8, 0x3F, 0xF0, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xF8, 0x30, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x27, 0x87, 0xE3, 0xC3, 0xF3, 0xC3, 0xF9, 0xE0,
  0x3C, 0xF0, 0x1E, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x87, 0x83, 0xC3,
  0xE1, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x00, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x0F, 0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1E, 0x1E,
  0x07, 0x87, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x0F, 0x0F, 0x03,
  0xC3, 0xC1, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x17,
  0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0x87, 0xC1, 0xC1, 0xE0,
  0xF0, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xCF, 0x00, 0xE7, 0x80, 0x79,
  0xE0, 0x1E, 0xF0, 0x07, 0xF8, 0x01, 0xDE, 0x00, 0x7F, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xDE, 0x00, 0xE7, 0x80, 0x38, 0xE0, 0x1E, 0x3C, 0x07,
  0x8F, 0x01, 0xE3, 0xC0, 0x70, 0xF0, 0x3C, 0x3C, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07,
  0x81, 0xE0, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x3F, 0x07, 0xC0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0,
  0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xDC, 0x1F, 0xC3,
  0xFC, 0x1D, 0xC3, 0xBC, 0x1D, 0xC7, 0xBC, 0x3D, 0xC7, 0x38, 0x3D, 0xE7,
  0x78, 0x39, 0xEE, 0x78, 0x39, 0xEE, 0x78, 0x39, 0xFC, 0x70, 0x79, 0xFC,
  0x70, 0x78, 0xFC, 0xF0, 0x70, 0xF8, 0xF0, 0x70, 0xF8, 0xF0, 0xF0, 0xF0,
  0xE0, 0xF0, 0xF0, 0xE0, 0xF0, 0xE1, 0xE0, 0x07, 0x80, 0xE0, 0xF8, 0x1C,
  0x3F, 0x07, 0x87, 0xE0, 0xF0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0, 0xF0,
  0xFF, 0x1E, 0x1E, 0xE3, 0xC3, 0x9C, 0x70, 0x73, 0x8E, 0x0E, 0x73, 0xC3,
  0xCE, 0x78, 0x79, 0xEF, 0x0E, 0x1D, 0xC1, 0xC3, 0xB8, 0x38, 0x7F, 0x0F,
  0x0F, 0xE1, 0xE1, 0xF8, 0x38, 0x3F, 0x07, 0x03, 0xE1, 0xE0, 0x7C, 0x3C,
  0x0F, 0x87, 0x81, 0xE0, 0x00, 0x20, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0xE0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x78, 0x0F, 0x3C, 0x07, 0xBE,
  0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x7B, 0xC0, 0x3D,
  0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x87,
  0x83, 0xC7, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xFC,
  0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x1E, 0x3E, 0x1C, 0x7C, 0x3F, 0xF8,
  0x3F, 0xF0, 0x3F, 0xE0, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x20,
  0x00, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xF0, 0xF0, 0xF0, 0x78, 0x78,
  0x3C, 0x78, 0x0F, 0x3C, 0x07, 0xBE, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7,
  0x80, 0xF3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F,
  0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x87, 0x83, 0xC7, 0xC1, 0xFF, 0xC0, 0x7F,
  0xC0, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0x78, 0xF0,
  0xF1, 0xE1, 0xE1, 0xC3, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78,
  0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x0F, 0x78, 0x1C, 0xF0, 0x38, 0xE0,
  0xF1, 0xC1, 0xE3, 0xC3, 0xC7, 0x87, 0x0F, 0x1E, 0x1E, 0x3C, 0x1E, 0x78,
  0x3C, 0x00, 0x38, 0x01, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0x86, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x40, 0xF0, 0x71, 0xF0, 0x7F, 0xE0, 0xFF,
  0xE0, 0x7F, 0x80, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x07, 0x87, 0x03, 0xC7, 0x81,
  0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x70, 0x3C, 0x78, 0x1C, 0x3C,
  0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xC3, 0xC1, 0xE1,
  0xE0, 0xF0, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1F,
  0x0F, 0x9F, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x00, 0xF0, 0x1F, 0xE0,
  0x7B, 0xC0, 0xF7, 0x83, 0xCF, 0x07, 0x9E, 0x0E, 0x3C, 0x3C, 0x78, 0x78,
  0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x9E, 0x0F, 0x38, 0x1E, 0xF0, 0x3D,
  0xE0, 0x7B, 0x80, 0xFF, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x1C, 0x0F, 0x78, 0x3C, 0x0E,
  0x78, 0x3C, 0x1E, 0x70, 0x7C, 0x1E, 0x70, 0x7C, 0x3C, 0x70, 0x7C, 0x3C,
  0x70, 0xFC, 0x38, 0x70, 0xFC, 0x78, 0x71, 0xDC, 0x78, 0x71, 0xDC, 0x70,
  0x71, 0xDC, 0xF0, 0x73, 0x9C, 0xE0, 0x73, 0x9D, 0xE0, 0x77, 0x9D, 0xE0,
  0x77, 0x1D, 0xC0, 0x77, 0x1F, 0xC0, 0x7E, 0x1B, 0x80, 0x7E, 0x3B, 0x80,
  0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC3, 0xC0, 0xF0, 0xE0, 0x3C,
  0x78, 0x0F, 0x1C, 0x03, 0xCF, 0x00, 0x73, 0x80, 0x1D, 0xE0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0x70, 0x03, 0xDE, 0x01, 0xE7,
  0x80, 0x71, 0xE0, 0x3C, 0x78, 0x1E, 0x1E, 0x07, 0x83, 0x83, 0xC0, 0xF0,
  0xF0, 0x7F, 0xC1, 0xEF, 0x0F, 0x3C, 0x3C, 0x71, 0xE1, 0xC7, 0x07, 0x3C,
  0x1C, 0xE0, 0x77, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1E,
  0x3C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0x1E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x8F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x81, 0xFC,
  0x0F, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0xF0,
  0x1D, 0xC0, 0xF7, 0x03, 0x9E, 0x1E, 0x38, 0x70, 0xE3, 0x83, 0x9E, 0x0F,
  0x70, 0x1F, 0xC0, 0x70, 0xFF, 0xFF, 0xFC, 0xF1, 0xE7, 0x8E, 0x3C, 0x03,
  0x00, 0x3F, 0x71, 0xFF, 0xCF, 0xFF, 0x3C, 0x7D, 0xE1, 0xE7, 0x87, 0x9E,
  0x1E, 0xF0, 0x7B, 0xC1, 0xCF, 0x07, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF,
  0x1E, 0x3C, 0xF8, 0xFF, 0xE3, 0xFF, 0x87, 0xDE, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x9C, 0x0E,
  0xF8, 0x7F, 0xF1, 0xFB, 0xC7, 0x87, 0x1E, 0x1C, 0xF0, 0x73, 0xC1, 0xCF,
  0x0F, 0x38, 0x3C, 0xE0, 0xF7, 0x83, 0xDE, 0x1E, 0x78, 0x79, 0xE1, 0xE7,
  0x8F, 0x3F, 0xF8, 0xEF, 0xE3, 0x9E, 0x00, 0x03, 0xC0, 0xFF, 0x1F, 0xE3,
  0xF6, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x08, 0xFF, 0x87, 0xF8, 0x3F, 0x00,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x07, 0x1C, 0x0F, 0xFC, 0x1F, 0xFC, 0x3E, 0xFC, 0x3C, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x70, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0xF0, 0x70,
  0xF0, 0xF0, 0xE0, 0xF0, 0xE0, 0xF0, 0xE1, 0xE0, 0xF1, 0xE0, 0xFF, 0xE0,
  0xFE, 0xE0, 0x7C, 0xC0, 0x03, 0xC0, 0xFE, 0x1F, 0xF3, 0xE7, 0x3C, 0x77,
  0x87, 0x78, 0x77, 0x0F, 0xFF, 0xEF, 0xFC, 0xFE, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0x04, 0xFF, 0xC7, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0x20, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0,
  0x03, 0xF7, 0x07, 0xF7, 0x0F, 0xFF, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x3C, 0x1E, 0x3C, 0x1C, 0x3C, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x78, 0x3C, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0xC1, 0xE0, 0xFF, 0xC0,
  0xFF, 0xC0, 0x7F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x9C, 0x0E, 0xF8, 0x7F, 0xF1, 0xFF, 0xC7,
  0x8F, 0x1E, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0E, 0x3C, 0x38, 0xE1, 0xE7,
  0x87, 0x9E, 0x1E, 0x78, 0x71, 0xC1, 0xC7, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3,
  0xC3, 0x80, 0x03, 0x03, 0xC1, 0xE0, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F,
  0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x00, 0x00, 0x30, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0x80, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x1E, 0x3C, 0x78, 0x79,
  0xE0, 0xE7, 0x81, 0xCF, 0x03, 0xBC, 0x0F, 0xF0, 0x1D, 0xE0, 0x3F, 0xC0,
  0x7F, 0x81, 0xFF, 0x03, 0xCE, 0x07, 0x1E, 0x0E, 0x3C, 0x1C, 0x78, 0x78,
  0xF0, 0xF0, 0xE1, 0xC1, 0xE0, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78,
  0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x00, 0x00,
  0x70, 0x60, 0x77, 0xCF, 0xC7, 0x7F, 0xFE, 0x3F, 0xFF, 0xF1, 0xE3, 0xE3,
  0x8F, 0x1E, 0x1C, 0xF0, 0xF1, 0xE7, 0x87, 0x0F, 0x3C, 0x38, 0x79, 0xC3,
  0xC3, 0x8E, 0x1E, 0x1C, 0xF0, 0xF1, 0xE7, 0x87, 0x0F, 0x3C, 0x38, 0x71,
  0xC3, 0xC3, 0x8E, 0x1E, 0x1C, 0xF0, 0xE1, 0xE7, 0x87, 0x0F, 0x3C, 0x78,
  0x70, 0x02, 0x70, 0x33, 0xE1, 0xDF, 0xC7, 0xFF, 0x1E, 0x3C, 0x78, 0xF1,
  0xC3, 0xCF, 0x0F, 0x3C, 0x38, 0xF0, 0xE3, 0x87, 0x9E, 0x1E, 0x78, 0x79,
  0xE1, 0xC7, 0x07, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0E, 0x00, 0x03,
  0xC0, 0x7F, 0x07, 0xFC, 0x7D, 0xF3, 0xC7, 0xBC, 0x3D, 0xE1, 0xEE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1D, 0xE0, 0xEE, 0x0F, 0x70, 0x7B, 0x87, 0x9E,
  0x7C, 0xFF, 0xC3, 0xFC, 0x0F, 0xC0, 0x00, 0x0C, 0x03, 0xBE, 0x07, 0x7F,
  0x07, 0xCF, 0x07, 0x87, 0x07, 0x87, 0x07, 0x07, 0x0F, 0x07, 0x0F, 0x07,
  0x0E, 0x0F, 0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x3C, 0x3F, 0xF8, 0x3F, 0xF8, 0x3D, 0xF0, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x3F, 0x71, 0xFD, 0xCF, 0xBF, 0x3C, 0x79, 0xE1, 0xE7, 0x87,
  0x9C, 0x1E, 0xF0, 0x7B, 0xC1, 0xCF, 0x07, 0x3C, 0x3C, 0xE0, 0xF3, 0x83,
  0xCE, 0x1E, 0x3C, 0x78, 0xFF, 0xE3, 0xFF, 0x87, 0xDC, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0x00, 0x70, 0xEF, 0x1D, 0xE1, 0xFE, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0x80, 0xFF, 0x1F, 0xF3, 0xE6, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x3C, 0x03, 0xC8, 0x7C, 0xFF, 0x8F, 0xF0, 0xFE, 0x00, 0x0E, 0x07,
  0x03, 0x83, 0xC7, 0xFB, 0xFD, 0xFE, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07,
  0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x8F, 0xC3, 0xE0, 0x1C,
  0x3C, 0xF0, 0xF3, 0xC3, 0x8E, 0x0E, 0x38, 0x79, 0xE1, 0xE7, 0x87, 0x1E,
  0x1C, 0x70, 0xF1, 0xC3, 0xCF, 0x0F, 0x3C, 0x38, 0xF1, 0xE3, 0x87, 0x8F,
  0x3E, 0x3F, 0xF8, 0xFF, 0xC1, 0xF7, 0x00, 0xF0, 0xFF, 0x87, 0xBC, 0x39,
  0xE3, 0xCF, 0x1C, 0x79, 0xE3, 0xCE, 0x1E, 0x70, 0xE7, 0x87, 0x38, 0x3B,
  0xC1, 0xDC, 0x0E, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0xF1, 0xF0, 0xFF, 0x1F, 0x1E, 0xF1, 0xF1, 0xCE, 0x3F, 0x1C, 0xE3,
  0xF3, 0xCE, 0x37, 0x38, 0xE7, 0x77, 0x8E, 0x77, 0x70, 0xEE, 0x77, 0x0E,
  0xE6, 0xF0, 0xEE, 0xEE, 0x0F, 0xCE, 0xE0, 0xFC, 0xFC, 0x0F, 0x8F, 0xC0,
  0xF8, 0xFC, 0x0F, 0x8F, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x07, 0x9E, 0x07, 0x9E, 0x07, 0xBC, 0x03, 0xB8, 0x03, 0xF8, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0,
  0x1E, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x78, 0x70, 0xF8, 0x78, 0x07, 0x83,
  0xC1, 0xE1, 0xE0, 0x78, 0x70, 0x1E, 0x3C, 0x07, 0x8E, 0x01, 0xE7, 0x80,
  0x79, 0xE0, 0x1E, 0x70, 0x03, 0xBC, 0x00, 0xEE, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF8, 0x7F,
  0x87, 0xFC, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1F, 0xF8, 0xFF,
  0xC7, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0x80, 0x78, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xE0,
  0x7E, 0x03, 0x80, 0x1F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x80, 0x7C,
  0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x1F, 0x01,
  0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xFC, 0x01, 0xC0, 0x3E, 0x03, 0xC0,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x10, 0x05, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFA, 0x00, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 9, 24, 8, 0, -24 },
  { 28, 11, 9, 13, 3, -24 },
  { 41, 16, 24, 16, 0, -24 },
  { 89, 15, 28, 14, 0, -26 },
  { 142, 20, 25, 23, 2, -25 },
  { 205, 16, 25, 16, 0, -25 },
  { 255, 6, 9, 8, 3, -24 },
  { 262, 10, 29, 9, 1, -24 },
  { 299, 11, 30, 9, -3, -25 },
  { 341, 12, 13, 13, 3, -26 },
  { 361, 14, 16, 15, 1, -20 },
  { 389, 7, 9, 8, -2, -4 },
  { 397, 9, 4, 9, 0, -11 },
  { 402, 5, 5, 8, 0, -5 },
  { 406, 17, 24, 12, -2, -24 },
  { 457, 13, 25, 14, 1, -25 },
  { 498, 10, 24, 14, 3, -24 },
  { 528, 15, 25, 14, -1, -25 },
  { 575, 16, 25, 14, -1, -25 },
  { 625, 15, 24, 14, -1, -24 },
  { 670, 15, 24, 14, 0, -24 },
  { 715, 14, 25, 14, 1, -25 },
  { 759, 15, 24, 14, 1, -24 },
  { 804, 15, 25, 14, 0, -25 },
  { 851, 14, 25, 14, 0, -25 },
  { 895, 8, 19, 8, 0, -19 },
  { 914, 10, 24, 8, -2, -19 },
  { 944, 14, 16, 15, 1, -20 },
  { 972, 14, 10, 15, 1, -17 },
  { 990, 14, 16, 15, 1, -20 },
  { 1018, 11, 25, 11, 1, -25 },
  { 1053, 20, 28, 21, 1, -25 },
  { 1123, 15, 24, 15, -2, -24 },
  { 1168, 16, 24, 16, 0, -24 },
  { 1216, 16, 25, 14, 1, -25 },
  { 1266, 17, 24, 17, 0, -24 },
  { 1317, 15, 24, 13, 0, -24 },
  { 1362, 15, 24, 13, 0, -24 },
  { 1407, 17, 25, 17, 1, -25 },
  { 1461, 18, 24, 17, 0, -24 },
  { 1515, 15, 24, 10, -2, -24 },
  { 1560, 14, 31, 8, -5, -24 },
  { 1615, 18, 24, 15, 0, -24 },
  { 1669, 10, 24, 12, 0, -24 },
  { 1699, 24, 24, 23, 0, -24 },
  { 1771, 19, 24, 18, 0, -24 },
  { 1828, 17, 25, 18, 1, -25 },
  { 1882, 16, 24, 15, 0, -24 },
  { 1930, 17, 31, 18, 1, -25 },
  { 1996, 15, 24, 15, 0, -24 },
  { 2041, 16, 25, 14, -1, -25 },
  { 2091, 13, 24, 13, 2, -24 },
  { 2130, 17, 24, 17, 1, -24 },
  { 2181, 15, 24, 15, 3, -24 },
  { 2226, 24, 24, 23, 2, -24 },
  { 2298, 18, 24, 14, -2, -24 },
  { 2352, 14, 24, 14, 3, -24 },
  { 2394, 16, 24, 13, -1, -24 },
  { 2442, 13, 29, 10, -1, -24 },
  { 2490, 7, 24, 12, 3, -24 },
  { 2511, 13, 29, 10, -2, -24 },
  { 2559, 14, 14, 14, 0, -24 },
  { 2584, 11, 2, 11, -3, 3 },
  { 2587, 6, 5, 10, 5, -26 },
  { 2591, 14, 19, 15, 1, -19 },
  { 2625, 14, 26, 15, 0, -26 },
  { 2671, 12, 19, 12, 1, -19 },
  { 2700, 16, 26, 15, 1, -26 },
  { 2752, 12, 19, 14, 1, -19 },
  { 2781, 17, 34, 9, -4, -26 },
  { 2854, 16, 27, 15, -1, -19 },
  { 2908, 14, 26, 15, 0, -26 },
  { 2954, 9, 26, 7, 0, -26 },
  { 2984, 13, 34, 7, -4, -26 },
  { 3040, 15, 26, 14, 0, -26 },
  { 3089, 9, 26, 7, 0, -26 },
  { 3119, 21, 19, 22, 0, -19 },
  { 3169, 14, 19, 15, 0, -19 },
  { 3203, 13, 19, 15, 1, -19 },
  { 3234, 16, 27, 15, -2, -19 },
  { 3288, 14, 27, 15, 1, -19 },
  { 3336, 12, 19, 10, 0, -19 },
  { 3365, 12, 19, 12, 0, -19 },
  { 3394, 9, 22, 9, 1, -22 },
  { 3419, 14, 18, 15, 1, -18 },
  { 3451, 13, 18, 13, 2, -18 },
  { 3481, 20, 18, 20, 2, -18 },
  { 3526, 16, 18, 13, -2, -18 },
  { 3562, 18, 26, 13, -3, -18 },
  { 3621, 13, 18, 11, -1, -18 },
  { 3651, 13, 29, 11, 1, -24 },
  { 3699, 4, 34, 13, 4, -26 },
  { 3716, 13, 29, 11, -2, -24 },
  { 3764, 14, 6, 15, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC34PT7B_H_
