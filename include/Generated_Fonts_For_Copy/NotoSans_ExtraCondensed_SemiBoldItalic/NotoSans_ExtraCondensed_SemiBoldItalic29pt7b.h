#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC29PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x38,
  0x38, 0x38, 0x38, 0x30, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xE0, 0x73, 0xB9,
  0xDC, 0xFC, 0xEE, 0x77, 0x3B, 0x99, 0x8C, 0x01, 0x9C, 0x0E, 0x60, 0x31,
  0x80, 0xCE, 0x07, 0x30, 0x18, 0xC3, 0xFF, 0xCF, 0xFF, 0x0E, 0x60, 0x33,
  0x80, 0xCC, 0x07, 0x30, 0x18, 0xC3, 0xFF, 0xCF, 0xFF, 0x0C, 0x60, 0x33,
  0x81, 0xCC, 0x06, 0x30, 0x19, 0xC0, 0xE6, 0x00, 0x00, 0xC0, 0x04, 0x00,
  0xF8, 0x1F, 0xF1, 0xFF, 0x0E, 0x90, 0x74, 0x03, 0x20, 0x1D, 0x00, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x1F, 0x80, 0x9C, 0x85, 0xE7,
  0x2E, 0x3F, 0xF1, 0xFF, 0x03, 0xE0, 0x04, 0x00, 0x20, 0x03, 0x00, 0x0E,
  0x07, 0x07, 0xC1, 0x83, 0xB0, 0xE0, 0xCC, 0x30, 0x73, 0x18, 0x18, 0xCE,
  0x06, 0x33, 0x01, 0x9D, 0xC0, 0xE7, 0x63, 0x39, 0xBB, 0xE6, 0xEC, 0xD9,
  0xF7, 0x67, 0x39, 0x99, 0xC0, 0xEE, 0x60, 0x33, 0x18, 0x1C, 0xC6, 0x06,
  0x33, 0x83, 0x8C, 0xC0, 0xC3, 0x30, 0x60, 0xF8, 0x38, 0x3C, 0x00, 0x03,
  0xC0, 0x1F, 0x80, 0xFF, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0x80, 0xEE, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xCF, 0x7B, 0xB9, 0xCE, 0xEE,
  0x3F, 0x38, 0x7C, 0xE1, 0xE3, 0x87, 0x8F, 0x7E, 0x3F, 0xFC, 0x7E, 0xF0,
  0x77, 0x77, 0xEE, 0xEC, 0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x60, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0C,
  0x00, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x83, 0x81,
  0xC1, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x00, 0x07, 0x00, 0xC1, 0x18, 0x3B,
  0x2F, 0xFC, 0x3F, 0xC7, 0x81, 0xF8, 0x73, 0x86, 0x70, 0x08, 0x00, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x39, 0xCE, 0xE7, 0x73,
  0x98, 0x7F, 0x7E, 0xFE, 0x7F, 0xFE, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x07, 0x81,
  0xF8, 0x7F, 0x8E, 0x73, 0x8E, 0x71, 0xDC, 0x3B, 0x87, 0x70, 0xFE, 0x1F,
  0x87, 0xF0, 0xEE, 0x1D, 0xC3, 0xB8, 0xF7, 0x1C, 0xE3, 0x9C, 0xE3, 0xFC,
  0x7F, 0x07, 0xC0, 0x07, 0x0F, 0x1F, 0x3F, 0x7F, 0xFE, 0x4E, 0x0E, 0x0E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70,
  0x01, 0xE0, 0x3F, 0x83, 0xFE, 0x1C, 0x70, 0x83, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1F, 0xF1, 0xFF, 0x8F, 0xFC, 0x00, 0x07,
  0xC1, 0xFF, 0x1F, 0xF0, 0x87, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x01,
  0xE0, 0xF8, 0x0F, 0x01, 0xFC, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC8, 0x3C, 0xFF, 0x8F, 0xF0, 0xFE, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x1F, 0x03, 0x60, 0x3E, 0x06, 0xE0, 0xEE, 0x0C, 0xE1, 0x9C, 0x39, 0xC3,
  0x1C, 0x71, 0xC6, 0x3C, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x3F, 0x83, 0xFC, 0x3F, 0xC0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x01, 0xC8, 0x3C, 0xFF, 0x8F, 0xF0, 0xFE, 0x00, 0x01,
  0xF0, 0x7F, 0x0F, 0xE0, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x77,
  0x87, 0xFC, 0xFF, 0xCF, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE3,
  0x8E, 0x38, 0xFF, 0x8F, 0xF0, 0x7E, 0x00, 0x3F, 0xF9, 0xFF, 0x8F, 0xFC,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0xFC, 0x38,
  0xE1, 0xC7, 0x8E, 0x38, 0x71, 0xC3, 0x9C, 0x1F, 0xE0, 0x7C, 0x03, 0xE0,
  0x7F, 0x07, 0x9C, 0x38, 0xE3, 0x83, 0x9C, 0x1C, 0xE1, 0xE7, 0x0E, 0x3D,
  0xF0, 0xFF, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0xFE, 0x1F, 0xF1, 0xC7, 0x3C,
  0x73, 0x87, 0x38, 0x73, 0x87, 0x38, 0xF3, 0x8F, 0x39, 0xE3, 0xFE, 0x3E,
  0xE0, 0x8E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x78, 0xFF, 0x0F, 0xE0, 0xFC,
  0x00, 0x0C, 0x3C, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x1E, 0x3C, 0x70, 0x03, 0x03, 0xC1, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x38, 0x1C,
  0x1C, 0x00, 0x00, 0x30, 0x0F, 0x03, 0xF0, 0xFC, 0x1F, 0x07, 0xC0, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF0, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x0F, 0x00, 0xC0, 0x00, 0x1F, 0x3F, 0xCF, 0xE4, 0x70, 0x38,
  0x1C, 0x0E, 0x0E, 0x0E, 0x0F, 0x07, 0x07, 0x03, 0x03, 0x81, 0xC0, 0x00,
  0x00, 0x30, 0x38, 0x1C, 0x0E, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xC1,
  0xC1, 0xC0, 0x61, 0xC0, 0x38, 0xC0, 0x0C, 0xC7, 0xE6, 0x67, 0xF3, 0x63,
  0x31, 0xB3, 0x18, 0xF9, 0x8C, 0xF9, 0xCE, 0x6C, 0xE7, 0x36, 0x63, 0x1B,
  0x33, 0x99, 0x9D, 0xDC, 0xCF, 0xFC, 0x63, 0x18, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x02, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x0E, 0xE0, 0x77, 0x07, 0x38, 0x39, 0xC1,
  0xCE, 0x1C, 0x70, 0xFF, 0x8F, 0xFC, 0x7F, 0xE7, 0x87, 0x38, 0x39, 0xC1,
  0xDE, 0x0E, 0xE0, 0x7F, 0x03, 0x80, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0x83,
  0x8E, 0x1E, 0x3C, 0x70, 0xE1, 0xC3, 0x87, 0x1E, 0x1C, 0xF0, 0xFF, 0x83,
  0xFC, 0x0F, 0xF8, 0x38, 0xF0, 0xE1, 0xC7, 0x07, 0x1C, 0x3C, 0x70, 0xF1,
  0xC7, 0x8F, 0xFC, 0x3F, 0xF0, 0xFF, 0x00, 0x01, 0xF0, 0x3F, 0xC3, 0xFC,
  0x3C, 0x21, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0xC0, 0xFF, 0x83,
  0x9F, 0x1E, 0x3C, 0x78, 0xF1, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0xF0, 0xF3,
  0x83, 0xCE, 0x0F, 0x38, 0x38, 0xE1, 0xE7, 0x87, 0x9C, 0x3C, 0x70, 0xF1,
  0xC7, 0x8F, 0xFC, 0x3F, 0xE0, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x83, 0xFC,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0xF0,
  0x7F, 0x83, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0xF8,
  0x41, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC7, 0xE7, 0x8F, 0xCF, 0x07, 0x9C, 0x0E, 0x38, 0x1C, 0x78, 0x38, 0xF0,
  0xF1, 0xE1, 0xC1, 0xFF, 0x83, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0x0F, 0x0E,
  0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x38, 0x38, 0x38,
  0x38, 0x78, 0x78, 0x70, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0x70, 0xF0,
  0xF0, 0xE0, 0xE0, 0x0F, 0xF0, 0xFE, 0x07, 0xC0, 0x38, 0x07, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x0F, 0xF0, 0xFE, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0xFC,
  0x0F, 0x80, 0xF0, 0x00, 0x0E, 0x0E, 0x1C, 0x3C, 0x38, 0xF0, 0x71, 0xC1,
  0xE7, 0x03, 0x9E, 0x07, 0x38, 0x0E, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0x78, 0x1C, 0xF0, 0x38, 0xE0, 0x71, 0xC0,
  0xE3, 0x83, 0xC7, 0x87, 0x0F, 0x0E, 0x0E, 0x00, 0x0F, 0x07, 0x03, 0x81,
  0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC1,
  0xE0, 0xE0, 0x70, 0x38, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0xF0, 0xF8,
  0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x1F, 0x83, 0xF1, 0xF8, 0x3E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8E, 0xE3, 0xB8, 0xFE, 0x3B, 0x9D, 0xC3,
  0xB9, 0xDC, 0x3B, 0x99, 0xC3, 0xBB, 0x9C, 0x73, 0xB3, 0x87, 0x3F, 0x38,
  0x73, 0xE3, 0x87, 0x3E, 0x38, 0xE3, 0xE3, 0x8E, 0x3C, 0x70, 0xE1, 0xC7,
  0x00, 0x0F, 0x03, 0x87, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE1, 0xF8, 0x70,
  0xFC, 0x70, 0x7E, 0x38, 0x3F, 0x1C, 0x1D, 0x8E, 0x1C, 0xC7, 0x0E, 0x77,
  0x07, 0x3B, 0x83, 0x9D, 0xC1, 0xCE, 0xE1, 0xC3, 0x70, 0xE1, 0xF0, 0x70,
  0xF8, 0x38, 0x7C, 0x38, 0x3E, 0x1C, 0x1F, 0x0E, 0x07, 0x00, 0x01, 0xE0,
  0x1F, 0xE0, 0xFF, 0x87, 0x8F, 0x1C, 0x3C, 0xF0, 0x73, 0x81, 0xDE, 0x0F,
  0x70, 0x3D, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x3B, 0xC1, 0xEE, 0x07,
  0x38, 0x1C, 0xF0, 0xF3, 0xC7, 0x87, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x0F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x83, 0x9E, 0x1E, 0x3C, 0x70, 0xF1, 0xC3, 0xC7,
  0x0E, 0x1C, 0x38, 0xF1, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0x8F, 0x1C, 0x3C, 0xF0, 0x73, 0x81,
  0xDE, 0x0F, 0x70, 0x3D, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x3B, 0xC1,
  0xEE, 0x07, 0xB8, 0x1C, 0xF0, 0xF3, 0xC7, 0x87, 0xFC, 0x1F, 0xE0, 0x3F,
  0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x0F, 0xC0,
  0x7F, 0x83, 0xFE, 0x1C, 0xF1, 0xE3, 0x8E, 0x1C, 0x70, 0xE3, 0x87, 0x1C,
  0x79, 0xE7, 0x8F, 0xF8, 0x7F, 0x83, 0xF8, 0x1D, 0xC1, 0xCF, 0x0E, 0x38,
  0x71, 0xC3, 0x8E, 0x3C, 0x71, 0xC3, 0xCE, 0x1E, 0x00, 0x01, 0xF0, 0x1F,
  0xF0, 0xFF, 0x83, 0xC6, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE1, 0x07, 0x87, 0xFC, 0x3F, 0xE0, 0x7F, 0x00, 0x7F, 0xEF,
  0xFF, 0xFF, 0x87, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80,
  0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x78, 0x0E, 0x00, 0x1E, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x0F, 0x3C, 0x3C,
  0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x78, 0x79, 0xE1, 0xC7, 0x07, 0x1C, 0x1C,
  0x70, 0x73, 0xC3, 0xCF, 0x0E, 0x38, 0x38, 0xE1, 0xE3, 0xC7, 0x0F, 0xFC,
  0x1F, 0xE0, 0x3F, 0x00, 0xE0, 0x7E, 0x0F, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE,
  0x1C, 0xE3, 0xCE, 0x38, 0xE3, 0x8E, 0x70, 0xE7, 0x0E, 0xE0, 0xEE, 0x0E,
  0xE0, 0xFC, 0x0F, 0xC0, 0xD8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x00,
  0x70, 0x70, 0x77, 0x07, 0x07, 0x70, 0xF0, 0xEF, 0x0F, 0x0E, 0xF1, 0xF1,
  0xEE, 0x1F, 0x1C, 0xE1, 0xF1, 0xCE, 0x3F, 0x38, 0xE3, 0x63, 0x8E, 0x76,
  0x78, 0xE7, 0x67, 0x0E, 0x66, 0x70, 0xEE, 0x6E, 0x0E, 0xE6, 0xE0, 0xFC,
  0x6E, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0x80, 0xF8, 0x78, 0x0F,
  0x07, 0x80, 0xF0, 0xF0, 0x00, 0x07, 0x07, 0x07, 0x0E, 0x07, 0x8E, 0x03,
  0x9C, 0x03, 0xBC, 0x03, 0xB8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xF0, 0x78, 0xF0, 0xF0, 0x70, 0x70,
  0x77, 0x0E, 0x70, 0xE7, 0x1C, 0x71, 0xC7, 0x38, 0x73, 0x87, 0x70, 0x37,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF,
  0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x80, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0xE7, 0x39, 0xCE, 0x31,
  0xCE, 0x73, 0x9C, 0xE7, 0x18, 0xE7, 0x39, 0xCE, 0x73, 0x80, 0x07, 0xE0,
  0xFC, 0x1F, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x87, 0xE0, 0xFC, 0x1F, 0x80, 0x01, 0x80,
  0x18, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xEC, 0x0C, 0xE1, 0xCE, 0x38, 0xE3,
  0x87, 0x70, 0x7E, 0x07, 0x7F, 0xFF, 0xF0, 0xF3, 0x8E, 0x70, 0x0F, 0x71,
  0xF7, 0x3F, 0xF7, 0x8E, 0x70, 0xE7, 0x0E, 0xF0, 0xEE, 0x1E, 0xE1, 0xCE,
  0x1C, 0xE1, 0xCE, 0x3C, 0xE3, 0xCF, 0xF8, 0xFF, 0x87, 0xB8, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1D, 0xE1, 0xFF, 0x1F, 0xF3,
  0xC7, 0x3C, 0x73, 0x87, 0x38, 0x73, 0x87, 0x70, 0x77, 0x0F, 0x70, 0xE7,
  0x0E, 0x71, 0xEF, 0xBC, 0xFF, 0x8E, 0xF0, 0x0F, 0x87, 0xF3, 0xF9, 0xE0,
  0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3D,
  0x8F, 0xE1, 0xF8, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x3D, 0xC3, 0xEE, 0x3F, 0xF1, 0xC7, 0x1C, 0x38, 0xE1, 0xCF, 0x0E,
  0x70, 0xF3, 0x87, 0x1C, 0x38, 0xE1, 0xC7, 0x1E, 0x38, 0xE1, 0xEF, 0x0F,
  0xF8, 0x3D, 0xC0, 0x07, 0x87, 0xF3, 0xDC, 0xE3, 0x70, 0xDC, 0x7E, 0x3F,
  0xFE, 0xFE, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x4F, 0xF1, 0xFC, 0x00,
  0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3F, 0x01,
  0xFC, 0x0F, 0xE0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xE0, 0x00, 0x03, 0xDC, 0x1F, 0x70, 0xFF, 0xC3, 0x8E, 0x1C, 0x38, 0x70,
  0xE3, 0xC3, 0x8E, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x3C, 0x38,
  0xF0, 0xFF, 0x83, 0xFE, 0x07, 0xB8, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x20,
  0xF0, 0xFF, 0x83, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x1D, 0xE1, 0xFF, 0x1F, 0xF1, 0xC7, 0x3C, 0x73,
  0x87, 0x38, 0xF3, 0x8E, 0x78, 0xE7, 0x0E, 0x70, 0xE7, 0x1E, 0x71, 0xCF,
  0x1C, 0xE1, 0xCE, 0x3C, 0x06, 0x1C, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x1C,
  0x78, 0xE1, 0xC3, 0x87, 0x1E, 0x38, 0x70, 0xE1, 0xC7, 0x8E, 0x1C, 0x00,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x83,
  0xF0, 0x7C, 0x0F, 0x00, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0xE3, 0x8E, 0x1C, 0xE0, 0xEF, 0x0E, 0x70, 0x77, 0x03,
  0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE1, 0xC7,
  0x0E, 0x3C, 0x70, 0xE0, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0,
  0xE0, 0xE0, 0x1D, 0xE7, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x71, 0xE7, 0x3C,
  0x71, 0xCE, 0x3C, 0x73, 0x8E, 0x1C, 0xE3, 0x8E, 0x78, 0xE3, 0x9C, 0x38,
  0xE7, 0x1C, 0x39, 0xC7, 0x0E, 0x71, 0xC7, 0x38, 0x71, 0xCE, 0x1C, 0x73,
  0x8E, 0x1C, 0x1D, 0xE1, 0xBF, 0x1F, 0xF1, 0xC7, 0x3C, 0x73, 0x87, 0x38,
  0xF3, 0x8E, 0x78, 0xE7, 0x0E, 0x70, 0xE7, 0x1E, 0x71, 0xCF, 0x1C, 0xE1,
  0xCE, 0x1C, 0x0F, 0x83, 0xF8, 0xFF, 0x3C, 0xF7, 0x0E, 0xE1, 0xF8, 0x3F,
  0x07, 0xE1, 0xFC, 0x3B, 0x87, 0x71, 0xEE, 0x39, 0xFF, 0x3F, 0xC3, 0xF0,
  0x07, 0x78, 0x1F, 0xF0, 0x6F, 0xC1, 0xC7, 0x0F, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x1C, 0x1C, 0x70, 0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x78, 0xFB,
  0xC3, 0xFE, 0x0E, 0xF0, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x00, 0x0F, 0x71, 0xFF, 0x3F, 0xF3, 0x8E, 0x70,
  0xE7, 0x0E, 0xF0, 0xEE, 0x1E, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0xE3,
  0x8F, 0xF8, 0xFF, 0x87, 0xB8, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x0E, 0x00, 0x1D, 0xC7, 0xF1, 0xBC, 0xFD, 0x3C, 0x0F, 0x03,
  0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80,
  0x0F, 0x87, 0xF3, 0xFC, 0xE1, 0x38, 0x0E, 0x03, 0xC0, 0xF8, 0x1F, 0x03,
  0xC0, 0x70, 0x1C, 0x87, 0x3F, 0xCF, 0xE3, 0xF0, 0x0C, 0x1C, 0x1C, 0x3F,
  0x7F, 0xFE, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE8, 0xF8, 0xF8, 0x38, 0x73, 0x8E, 0x38, 0xE7, 0x8E, 0x70, 0xE7, 0x0E,
  0x71, 0xC7, 0x1C, 0xE1, 0xCE, 0x1C, 0xE3, 0xCE, 0x38, 0xE3, 0x8F, 0xF8,
  0xFF, 0x8F, 0xB8, 0xE1, 0xF8, 0x7E, 0x3B, 0x8E, 0xE7, 0xB9, 0xCE, 0x73,
  0xB8, 0xEE, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xE3,
  0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE7, 0xCE, 0xE7, 0xCE, 0xEF, 0xDC, 0xEF,
  0xDC, 0xED, 0xDC, 0xDD, 0xB8, 0xD9, 0xB8, 0xD9, 0xB0, 0xF9, 0xF0, 0xF1,
  0xF0, 0xF1, 0xE0, 0xE1, 0xE0, 0xE1, 0xC0, 0x1C, 0x38, 0xF3, 0xC3, 0x9C,
  0x1D, 0xC0, 0xEE, 0x07, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0x7C, 0x07,
  0xE0, 0x7F, 0x03, 0xB8, 0x39, 0xE1, 0xC7, 0x1C, 0x38, 0x0E, 0x1E, 0x1C,
  0x38, 0x38, 0xF0, 0x71, 0xC0, 0xE3, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x70,
  0x0E, 0xE0, 0x1D, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x80, 0xE0, 0x38,
  0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xFF,
  0x3F, 0xC7, 0xF8, 0x00, 0x30, 0x1E, 0x03, 0xE0, 0x38, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0xBC, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0xE0, 0x1E, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x06, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1C,
  0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1E, 0x07,
  0xC1, 0xE0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x0F,
  0x07, 0xE0, 0xF8, 0x10, 0x00, 0x7C, 0x1F, 0xFF, 0xCF, 0xF8, 0x3C,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 21, 7, 0, -21 },
  { 22, 9, 8, 11, 3, -21 },
  { 31, 14, 21, 13, 0, -21 },
  { 68, 13, 24, 12, 0, -22 },
  { 107, 18, 21, 19, 1, -21 },
  { 155, 14, 21, 14, 0, -21 },
  { 192, 4, 8, 6, 3, -21 },
  { 196, 10, 26, 8, 0, -21 },
  { 229, 9, 26, 8, -2, -21 },
  { 259, 11, 11, 11, 2, -22 },
  { 275, 12, 14, 13, 1, -17 },
  { 296, 5, 8, 7, -1, -4 },
  { 301, 8, 3, 8, 0, -9 },
  { 304, 4, 4, 7, 0, -4 },
  { 306, 15, 21, 10, -2, -21 },
  { 346, 11, 21, 12, 1, -21 },
  { 375, 8, 21, 12, 3, -21 },
  { 396, 13, 21, 12, -1, -21 },
  { 431, 12, 21, 12, 0, -21 },
  { 463, 12, 21, 12, 0, -21 },
  { 495, 12, 21, 12, 0, -21 },
  { 527, 12, 21, 12, 1, -21 },
  { 559, 13, 21, 12, 1, -21 },
  { 594, 13, 21, 12, 0, -21 },
  { 629, 12, 21, 12, 0, -21 },
  { 661, 7, 16, 7, 0, -16 },
  { 675, 9, 20, 7, -2, -16 },
  { 698, 12, 13, 13, 1, -17 },
  { 718, 12, 8, 13, 1, -14 },
  { 730, 12, 13, 13, 1, -17 },
  { 750, 9, 21, 9, 1, -21 },
  { 774, 17, 23, 18, 1, -21 },
  { 823, 13, 21, 13, -2, -21 },
  { 858, 14, 21, 13, 0, -21 },
  { 895, 13, 21, 12, 1, -21 },
  { 930, 14, 21, 14, 0, -21 },
  { 967, 13, 21, 11, 0, -21 },
  { 1002, 13, 21, 11, 0, -21 },
  { 1037, 15, 21, 15, 1, -21 },
  { 1077, 16, 21, 15, 0, -21 },
  { 1119, 12, 21, 9, -1, -21 },
  { 1151, 12, 27, 7, -4, -21 },
  { 1192, 15, 21, 13, 0, -21 },
  { 1232, 9, 21, 11, 0, -21 },
  { 1256, 20, 21, 20, 0, -21 },
  { 1309, 17, 21, 16, 0, -21 },
  { 1354, 14, 21, 15, 1, -21 },
  { 1391, 14, 21, 13, 0, -21 },
  { 1428, 14, 26, 15, 1, -21 },
  { 1474, 13, 21, 13, 0, -21 },
  { 1509, 14, 21, 12, -1, -21 },
  { 1546, 11, 21, 11, 2, -21 },
  { 1575, 14, 21, 14, 1, -21 },
  { 1612, 12, 21, 13, 3, -21 },
  { 1644, 20, 21, 20, 2, -21 },
  { 1697, 16, 21, 12, -2, -21 },
  { 1739, 12, 21, 12, 2, -21 },
  { 1771, 14, 21, 11, -1, -21 },
  { 1808, 11, 26, 8, -1, -21 },
  { 1844, 5, 21, 11, 3, -21 },
  { 1858, 11, 26, 8, -2, -21 },
  { 1894, 12, 12, 12, 0, -21 },
  { 1912, 10, 2, 9, -3, 2 },
  { 1915, 5, 4, 8, 4, -22 },
  { 1918, 12, 16, 13, 1, -16 },
  { 1942, 12, 22, 13, 0, -22 },
  { 1975, 10, 16, 10, 1, -16 },
  { 1995, 13, 22, 13, 1, -22 },
  { 2031, 10, 16, 12, 1, -16 },
  { 2051, 14, 29, 8, -3, -22 },
  { 2102, 14, 23, 13, -1, -16 },
  { 2143, 12, 22, 13, 0, -22 },
  { 2176, 7, 22, 6, 0, -22 },
  { 2196, 11, 29, 6, -4, -22 },
  { 2236, 13, 22, 12, 0, -22 },
  { 2272, 8, 22, 6, 0, -22 },
  { 2294, 18, 16, 19, 0, -16 },
  { 2330, 12, 16, 13, 0, -16 },
  { 2354, 11, 16, 13, 1, -16 },
  { 2376, 14, 23, 13, -2, -16 },
  { 2417, 12, 23, 13, 1, -16 },
  { 2452, 10, 16, 9, 0, -16 },
  { 2472, 10, 16, 10, 0, -16 },
  { 2492, 8, 19, 8, 1, -19 },
  { 2511, 12, 16, 13, 1, -16 },
  { 2535, 10, 16, 11, 2, -16 },
  { 2555, 16, 16, 17, 2, -16 },
  { 2587, 13, 16, 11, -1, -16 },
  { 2613, 15, 23, 11, -2, -16 },
  { 2657, 11, 16, 9, -1, -16 },
  { 2679, 12, 26, 10, 0, -21 },
  { 2718, 3, 29, 11, 4, -22 },
  { 2729, 11, 26, 10, -2, -21 },
  { 2765, 12, 4, 13, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC29PT7B_H_
