#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC54PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0x00, 0x08, 0x00, 0x3F, 0x0F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3E, 0x1F, 0x8F, 0x87, 0xC7, 0xE1, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x3C, 0x3E, 0x1F, 0x00,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xF0, 0x00,
  0xF8, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC3, 0xC0,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x87, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x3C, 0x3E, 0x01, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x0F, 0x0F, 0x80, 0x07, 0xC3,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x87, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x3C, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFB,
  0xFC, 0x07, 0xE7, 0x18, 0x07, 0xE6, 0x08, 0x07, 0xC6, 0x00, 0x07, 0xC6,
  0x00, 0x07, 0xC6, 0x00, 0x07, 0xEE, 0x00, 0x07, 0xEC, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x37,
  0xF0, 0x00, 0x33, 0xF0, 0x00, 0x33, 0xF0, 0x00, 0x33, 0xF0, 0x00, 0x73,
  0xF0, 0x40, 0x63, 0xF0, 0x60, 0x63, 0xE0, 0x70, 0x67, 0xE0, 0x7F, 0x7F,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x07,
  0xF8, 0x01, 0xE0, 0x0F, 0xFC, 0x03, 0xE0, 0x0F, 0xFC, 0x03, 0xC0, 0x1F,
  0x3C, 0x07, 0xC0, 0x3E, 0x3C, 0x07, 0x80, 0x3C, 0x3C, 0x0F, 0x80, 0x3C,
  0x3C, 0x0F, 0x00, 0x7C, 0x3C, 0x1F, 0x00, 0x78, 0x3C, 0x1E, 0x00, 0x78,
  0x3C, 0x3E, 0x00, 0xF8, 0x7C, 0x3C, 0x00, 0xF8, 0x7C, 0x7C, 0x00, 0xF0,
  0x78, 0x78, 0x00, 0xF0, 0x78, 0xF8, 0x00, 0xF0, 0xF8, 0xF0, 0x60, 0xF0,
  0xF9, 0xE1, 0xFC, 0xF0, 0xF3, 0xE3, 0xFC, 0xF1, 0xF3, 0xC7, 0xFE, 0xF3,
  0xE7, 0xCF, 0xBE, 0xFF, 0xE7, 0x8F, 0x1E, 0xFF, 0xCF, 0x9F, 0x1E, 0x7F,
  0x8F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1E, 0x00, 0x1E, 0x3C, 0x1E, 0x00,
  0x3E, 0x3C, 0x1E, 0x00, 0x3C, 0x3C, 0x1E, 0x00, 0x7C, 0x7C, 0x3E, 0x00,
  0x78, 0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x3C, 0x01,
  0xE0, 0x78, 0x7C, 0x03, 0xE0, 0x78, 0x78, 0x03, 0xC0, 0x78, 0x78, 0x07,
  0xC0, 0x78, 0xF0, 0x07, 0x80, 0x7F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x0F,
  0x00, 0x3F, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xFC,
  0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xE0, 0x01, 0xF1,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x01,
  0x07, 0xFE, 0x0F, 0x83, 0xFF, 0xC7, 0xE1, 0xFB, 0xF1, 0xF8, 0xFC, 0xFC,
  0x7C, 0x3F, 0x1F, 0xBF, 0x1F, 0x87, 0xEF, 0x87, 0xC1, 0xFF, 0xE3, 0xF0,
  0x3F, 0xF0, 0xFC, 0x0F, 0xFC, 0x3F, 0x03, 0xFE, 0x0F, 0xC0, 0x7F, 0x83,
  0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xF0, 0x3F, 0x07, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFD, 0xFC, 0x0F, 0xFE, 0x3F, 0x01, 0xFF,
  0x0F, 0xE0, 0x04, 0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0,
  0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xC0, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x61, 0xF0, 0x1E, 0x7C, 0x0F, 0xDF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xC0,
  0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xF7, 0xC1, 0xF9, 0xF0, 0x7E, 0x3E, 0x0F,
  0x0F, 0xC1, 0x83, 0xC0, 0x20, 0x60, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x07,
  0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x00, 0x3E, 0x7F, 0x7F, 0xFF,
  0xFE, 0xFE, 0x7C, 0x30, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFC, 0xFC, 0x0F, 0xC3, 0xE0, 0xFC,
  0x1F, 0x07, 0xE0, 0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x3E, 0x3F, 0x01, 0xF1,
  0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01,
  0xF9, 0xF8, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0x3F,
  0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xFC, 0x07, 0xE7, 0xE0, 0x3F,
  0x3F, 0x01, 0xF9, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0,
  0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0xE3, 0xF8, 0x1F, 0xFF, 0x80,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x20,
  0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x07,
  0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0x7C, 0xFE, 0xFC, 0x7C,
  0xFC, 0x30, 0xFC, 0x10, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07,
  0xE3, 0xF8, 0x03, 0xC0, 0xFE, 0x01, 0xC0, 0x7F, 0x00, 0x40, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x08, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0xF8, 0xFF, 0x00, 0xC0, 0x7F, 0x00, 0x80, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x80, 0x0F, 0xE0,
  0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x05, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xFC, 0x00, 0x1E, 0xFC, 0x00, 0x3C, 0xF8,
  0x00, 0x3C, 0xF8, 0x00, 0x79, 0xF8, 0x00, 0xF1, 0xF8, 0x00, 0xF1, 0xF8,
  0x01, 0xE1, 0xF0, 0x03, 0xE3, 0xF0, 0x03, 0xC3, 0xF0, 0x07, 0x83, 0xF0,
  0x0F, 0x83, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x07, 0xE0, 0x3E, 0x07, 0xE0,
  0x3C, 0x07, 0xE0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0x60, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x80, 0x1F, 0xC1, 0xC0, 0x7F, 0x83, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xE0, 0x80, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE1, 0xC0, 0x0F, 0x9F, 0xE0, 0x3F,
  0x7F, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0x7F, 0x87, 0xF8,
  0x7F, 0x0F, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03,
  0xF1, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xE0, 0x7E, 0x1F, 0xC0,
  0xFC, 0x7F, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7E, 0x1F, 0xC0, 0xF8,
  0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x80, 0xFC, 0xFE,
  0x01, 0xFB, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xF3, 0xF0, 0x1F,
  0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xE0,
  0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01,
  0xF0, 0xFC, 0x07, 0xE1, 0xFC, 0x1F, 0xC3, 0xFE, 0xFF, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC0,
  0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC,
  0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x81, 0xFC, 0x7E,
  0x07, 0xF1, 0xF8, 0x3F, 0xC7, 0xF1, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xDF, 0x81, 0xFE, 0x7C, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x40, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0x10,
  0x00, 0x00, 0x08, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1E, 0x1F, 0x83, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0x80,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x07, 0xC0, 0x38,
  0x0F, 0x07, 0x81, 0xFF, 0x8F, 0x0F, 0x83, 0xFF, 0x8F, 0x0F, 0x07, 0xFF,
  0x8F, 0x1F, 0x0F, 0x8F, 0x0F, 0x1E, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x0F,
  0x0F, 0x3C, 0x1E, 0x1F, 0x0F, 0x3C, 0x3C, 0x1E, 0x0F, 0x3C, 0x3C, 0x1E,
  0x0F, 0x78, 0x7C, 0x1E, 0x1E, 0x78, 0x78, 0x3E, 0x1E, 0x78, 0x78, 0x3C,
  0x1E, 0x78, 0x78, 0x3C, 0x1E, 0x78, 0x78, 0x7C, 0x3C, 0x78, 0xF8, 0x7C,
  0x3C, 0xF0, 0xF8, 0x7C, 0x38, 0xF0, 0xF8, 0xF8, 0x78, 0xF0, 0x78, 0xFC,
  0xF0, 0xF0, 0x7F, 0xFF, 0xF0, 0xF0, 0x7F, 0xBF, 0xE0, 0xF0, 0x3F, 0x1F,
  0xC0, 0xF0, 0x1E, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x18, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x3E,
  0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x3E, 0x01, 0xF8, 0x3E,
  0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x3F,
  0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xC7,
  0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3F,
  0x01, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC1, 0xFC, 0x07, 0xE7, 0xFC, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x7C, 0x3F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC,
  0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x03,
  0xF8, 0x3F, 0x07, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0x3C, 0x03, 0xF8, 0x04, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x03, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0x87, 0xF8, 0x07, 0xE0, 0xFF, 0x03, 0xF0,
  0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x07,
  0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x07, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00,
  0x7F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7E,
  0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0,
  0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0x1F, 0x00, 0xFF, 0x00,
  0x60, 0x3F, 0xC0, 0x04, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0x03, 0xFF, 0x8F, 0xE0, 0x7F, 0xF1,
  0xFC, 0x0F, 0xFE, 0x3F, 0x81, 0xFF, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x0F,
  0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07,
  0xF0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0,
  0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x67, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F,
  0x81, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x0F,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x7F, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x1F,
  0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x01,
  0xF7, 0xC0, 0x7D, 0xF8, 0x07, 0xDF, 0x01, 0xF7, 0xE0, 0x3F, 0x7E, 0x0F,
  0x9F, 0x80, 0xFC, 0xF8, 0x3E, 0x7C, 0x03, 0xF3, 0xE1, 0xF3, 0xF0, 0x0F,
  0x8F, 0x87, 0xCF, 0xC0, 0x3E, 0x3E, 0x3E, 0x3F, 0x01, 0xF8, 0xF8, 0xF8,
  0xF8, 0x07, 0xE3, 0xE7, 0xE7, 0xE0, 0x1F, 0x8F, 0x9F, 0x1F, 0x80, 0x7C,
  0x3E, 0x7C, 0x7E, 0x01, 0xF0, 0xFB, 0xE1, 0xF8, 0x0F, 0xC3, 0xEF, 0x87,
  0xC0, 0x3F, 0x0F, 0xFC, 0x3F, 0x00, 0xF8, 0x3F, 0xF0, 0xFC, 0x03, 0xE0,
  0xFF, 0x83, 0xF0, 0x0F, 0x83, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xF0, 0x3E,
  0x01, 0xF8, 0x3F, 0xC1, 0xF8, 0x07, 0xC0, 0xFF, 0x07, 0xE0, 0x1F, 0x03,
  0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7C, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF0, 0x0F, 0xF0, 0x03, 0xE0, 0x1F, 0xE0,
  0x0F, 0xC0, 0x3F, 0xE0, 0x1F, 0x80, 0x7F, 0xC0, 0x3F, 0x00, 0xFF, 0x80,
  0x7C, 0x03, 0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x03, 0xF0, 0x0F, 0xFC, 0x07,
  0xE0, 0x1F, 0x7C, 0x0F, 0xC0, 0x3E, 0xF8, 0x1F, 0x00, 0xFD, 0xF0, 0x7E,
  0x01, 0xFB, 0xE0, 0xFC, 0x03, 0xE7, 0xC1, 0xF8, 0x07, 0xCF, 0x83, 0xE0,
  0x1F, 0x8F, 0x87, 0xC0, 0x3F, 0x1F, 0x1F, 0x80, 0x7E, 0x3E, 0x3F, 0x00,
  0xF8, 0x7C, 0x7E, 0x01, 0xF0, 0xF8, 0xF8, 0x07, 0xE1, 0xF9, 0xF0, 0x0F,
  0xC1, 0xF7, 0xE0, 0x1F, 0x83, 0xEF, 0xC0, 0x3E, 0x07, 0xDF, 0x80, 0x7C,
  0x0F, 0xBE, 0x01, 0xF8, 0x1F, 0x7C, 0x03, 0xF0, 0x3F, 0xF8, 0x07, 0xC0,
  0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x00, 0xFF, 0x80, 0x7E, 0x01,
  0xFF, 0x00, 0xFC, 0x03, 0xFE, 0x01, 0xF0, 0x07, 0xFC, 0x03, 0xE0, 0x07,
  0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x9F, 0xE0, 0x3F, 0x83,
  0xF8, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xF1, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3,
  0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07,
  0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xEF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x3F,
  0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E,
  0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x7F, 0x81,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x9F, 0xE0, 0x3F, 0x83,
  0xF8, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xF1, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3,
  0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07,
  0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xEF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x3F,
  0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFE,
  0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x07,
  0xF8, 0x1F, 0xC3, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xDF, 0xF8, 0x07, 0xE1, 0xFC,
  0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x81,
  0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x03, 0xF1,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xC7, 0xE0, 0x07,
  0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0,
  0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F,
  0x83, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xF0, 0x38, 0x07, 0xF0, 0x08, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x80, 0x0F, 0xC0, 0x60, 0x0F, 0xE0, 0x3E,
  0x1F, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x1F,
  0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F,
  0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x3F, 0x80,
  0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03,
  0xF0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07,
  0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x3F,
  0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE3,
  0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xF0,
  0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0x80, 0x3E, 0x3F,
  0x00, 0x7C, 0x7E, 0x00, 0xF9, 0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xE7, 0xC0,
  0x07, 0xDF, 0x80, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0xFC, 0x01, 0xFB, 0xE0, 0x07, 0xE0, 0x0F, 0xDF, 0x00, 0x3F,
  0x00, 0x7E, 0xF8, 0x03, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0x80, 0x3F, 0x3E,
  0x00, 0xFC, 0x03, 0xF1, 0xF0, 0x0F, 0xE0, 0x1F, 0x8F, 0x80, 0x7F, 0x00,
  0xFC, 0x7C, 0x07, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0xC0, 0x7E, 0x1F, 0x01,
  0xFE, 0x03, 0xE1, 0xF8, 0x1F, 0xF0, 0x3F, 0x0F, 0xC0, 0xFF, 0x81, 0xF8,
  0x7E, 0x0F, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0xE0, 0xFC, 0x1F, 0x83, 0xDF,
  0x07, 0xC0, 0xFC, 0x3E, 0xF8, 0x7E, 0x07, 0xE1, 0xF7, 0xC3, 0xF0, 0x3F,
  0x1F, 0x3E, 0x3F, 0x01, 0xF8, 0xF9, 0xF1, 0xF8, 0x0F, 0xC7, 0xCF, 0x8F,
  0xC0, 0x7E, 0x7C, 0x7C, 0xFC, 0x03, 0xF3, 0xE3, 0xE7, 0xE0, 0x1F, 0xBE,
  0x1F, 0x3E, 0x00, 0xFD, 0xF0, 0xFB, 0xF0, 0x07, 0xEF, 0x87, 0xDF, 0x80,
  0x3E, 0xF8, 0x3F, 0xF8, 0x01, 0xF7, 0xC1, 0xFF, 0xC0, 0x0F, 0xBC, 0x0F,
  0x7C, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0xFC,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0xF8, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF9,
  0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x07,
  0xF0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x03,
  0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC0,
  0xF8, 0x3E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F, 0x3F, 0x00, 0xFC,
  0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFC, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0xC0,
  0x07, 0xEF, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x01,
  0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7C,
  0x03, 0xF1, 0xF0, 0x03, 0xE7, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0xBF, 0x00,
  0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0xFE, 0x7F, 0x1F,
  0x87, 0xC3, 0xF0, 0xF8, 0x7C, 0x1F, 0x00, 0x38, 0x00, 0x01, 0xFC, 0x7C,
  0x07, 0xFC, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFE, 0x7F, 0x83,
  0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFC,
  0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80,
  0x7C, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF0, 0x0F,
  0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF8,
  0x7E, 0x0F, 0xF0, 0xFE, 0x1F, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0x7E, 0x03, 0xFC, 0xF8, 0x03, 0xF1, 0xF0, 0x00, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x8F, 0x00, 0x3E,
  0x7F, 0x80, 0x7D, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xF8,
  0xFE, 0x0F, 0xE0, 0xFC, 0x3F, 0x81, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07,
  0xE1, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E,
  0x3F, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF0, 0xFE,
  0x07, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xFD, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3E, 0xFF, 0xE0, 0x7C, 0xFF, 0x80, 0xF8, 0xFE, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F,
  0xFC, 0x1F, 0xF3, 0x83, 0xF8, 0x10, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x04,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0xE0, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0xDF,
  0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xF0,
  0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8,
  0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x7F, 0x00,
  0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0x7C, 0x00, 0xFF, 0x9E,
  0x00, 0x1F, 0xC7, 0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07,
  0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFE, 0x1F, 0x0F,
  0xC1, 0xF1, 0xF8, 0x1F, 0x1F, 0x81, 0xF3, 0xF0, 0x1F, 0x3F, 0x03, 0xF3,
  0xE0, 0x7E, 0x7E, 0x1F, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xE0,
  0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0x07, 0xF0,
  0x70, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x9F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0xE7, 0xC0, 0x1F, 0xF3, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xE7, 0xF8, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07,
  0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x0F,
  0xF0, 0x3F, 0x8F, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0x7E, 0x00, 0xFF, 0xBE, 0x00, 0x3F, 0x3F, 0x00, 0x04, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x08, 0x01, 0xF8, 0x07, 0x83, 0xFC, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x78, 0x03, 0xE7,
  0xF8, 0x0F, 0xBF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F,
  0x03, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xF8, 0x7E, 0x07,
  0xE1, 0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xC3,
  0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3E, 0x03, 0xF1, 0xF8, 0x0F, 0x87, 0xE0,
  0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7C,
  0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC0, 0x00, 0x30, 0x03, 0xF0, 0x0F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x8F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xE0,
  0xFC, 0x07, 0xE1, 0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xC3, 0xF0, 0x07, 0xC7,
  0xE0, 0x0F, 0xCF, 0xC0, 0x0F, 0xCF, 0xC0, 0x0F, 0x9F, 0x80, 0x0F, 0xBF,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x1F,
  0x00, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x21, 0xE0, 0x1E, 0x00,
  0xF1, 0xFE, 0x3F, 0xC0, 0x3C, 0xFF, 0x9F, 0xF8, 0x1F, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFE, 0x7F, 0xE7, 0xF0, 0x7F, 0x0F, 0xF0,
  0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x03, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x3E, 0x03, 0xE0, 0x7E, 0x1F, 0x81,
  0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x81, 0xF0, 0x7C,
  0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC0, 0xF8, 0x3E, 0x03, 0xE0, 0x7E,
  0x0F, 0x80, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x81,
  0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC0, 0xF8, 0x3F, 0x03,
  0xE0, 0x7E, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x1F, 0xE0, 0x3C, 0xFF, 0x81,
  0xF7, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xF7, 0xF0, 0x7F, 0x0F, 0xC1, 0xF8,
  0x3F, 0x0F, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x01, 0xF8, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF0, 0xF8, 0x0F, 0xC7, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7E, 0x07, 0xE1,
  0xF0, 0x1F, 0x87, 0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x07, 0xF9, 0xF8, 0x3F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x81, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF7, 0xE0, 0x1F,
  0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7C, 0x01, 0xF7, 0xE0,
  0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3,
  0xF0, 0x3F, 0x9F, 0x81, 0xF8, 0x7E, 0x1F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x04, 0x3C, 0x00, 0x1E, 0x3F, 0xC0, 0x07, 0x9F, 0xF8, 0x03, 0xEF,
  0xFE, 0x00, 0xFB, 0xFF, 0x80, 0x3F, 0xC7, 0xF0, 0x0F, 0xE0, 0xFC, 0x03,
  0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E,
  0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80,
  0xFE, 0x07, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7E, 0xFF, 0xC0, 0x1F, 0xBF, 0xE0, 0x07, 0xE7,
  0xF0, 0x01, 0xF0, 0x20, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xFE, 0x7C, 0x07, 0xFC, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFE,
  0x7F, 0x83, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0x81, 0xFC, 0x3E, 0x03,
  0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F,
  0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x03, 0xF1, 0xF8, 0x07, 0xE3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F,
  0x03, 0xF8, 0x7E, 0x07, 0xE0, 0xFE, 0x1F, 0xC1, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFE, 0xF8, 0x03, 0xF3, 0xF0, 0x01, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x21, 0xE0, 0x78, 0xFC, 0x0F, 0x3F, 0x83, 0xEF, 0xE0, 0x7D, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xA0, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC,
  0x1F, 0x83, 0x87, 0xE0, 0x20, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC4, 0x03, 0xF0, 0xC0, 0xFE, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x02,
  0xC0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x07, 0xFF, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC7, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x18, 0x00, 0x07, 0xE0, 0x7E, 0x0F, 0x80,
  0xF8, 0x3F, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF0, 0x1F,
  0x87, 0xE0, 0x3E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3E, 0x03, 0xF0,
  0x7C, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F,
  0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x1F, 0x83, 0xE0, 0x3F, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07,
  0xF0, 0x7E, 0x1F, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xBE,
  0x03, 0xFE, 0x7C, 0x03, 0xF8, 0xF8, 0x00, 0x80, 0x00, 0x00, 0xFC, 0x03,
  0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7C, 0xFC, 0x0F, 0xCF, 0xC0,
  0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3E, 0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xCF, 0xC0, 0x7C, 0xF8, 0x07,
  0xCF, 0x80, 0x7D, 0xF8, 0x07, 0xDF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x7B, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x0F, 0xE0, 0x7F, 0xF8, 0x1F, 0xC0, 0xFF, 0xF0, 0x3F, 0x81, 0xF7, 0xE0,
  0xFF, 0x07, 0xEF, 0xC1, 0xFE, 0x0F, 0x9F, 0x87, 0xFC, 0x1F, 0x3F, 0x0F,
  0xF8, 0x7E, 0x7E, 0x1F, 0xF0, 0xF8, 0xFC, 0x7F, 0xE3, 0xF1, 0xF8, 0xF7,
  0xC7, 0xC3, 0xF1, 0xEF, 0x8F, 0x87, 0xE7, 0xDF, 0x3F, 0x0F, 0x8F, 0x3E,
  0x7C, 0x1F, 0x3E, 0x78, 0xF8, 0x3E, 0x7C, 0xF3, 0xE0, 0x7C, 0xF1, 0xE7,
  0xC0, 0xFB, 0xE3, 0xDF, 0x81, 0xF7, 0x87, 0xBE, 0x03, 0xEF, 0x0F, 0x7C,
  0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0,
  0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01,
  0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x0F,
  0xC0, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xE0, 0x0F,
  0x83, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x00,
  0x0F, 0xCF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xE7, 0xC0,
  0x01, 0xF9, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x87,
  0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0xFE,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x3F, 0x00,
  0x3E, 0x07, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F,
  0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x01,
  0xF1, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xF0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x08, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x02, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x60,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0x80,
  0x05, 0xFF, 0x80, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xEC, 0x03, 0xFF, 0x20, 0x01, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 15, 40, 13, 0, -39 },
  { 76, 18, 14, 20, 5, -39 },
  { 108, 26, 39, 25, 0, -39 },
  { 235, 24, 44, 22, 0, -41 },
  { 367, 32, 39, 36, 3, -39 },
  { 523, 26, 40, 26, 0, -39 },
  { 653, 9, 14, 12, 5, -39 },
  { 669, 17, 48, 14, 1, -39 },
  { 771, 17, 48, 14, -4, -39 },
  { 873, 18, 20, 21, 5, -41 },
  { 918, 21, 26, 24, 2, -32 },
  { 987, 11, 14, 12, -3, -7 },
  { 1007, 13, 5, 15, 1, -17 },
  { 1016, 8, 8, 12, 0, -7 },
  { 1024, 27, 39, 19, -3, -39 },
  { 1156, 21, 40, 22, 1, -39 },
  { 1261, 16, 39, 23, 5, -39 },
  { 1339, 25, 39, 22, -2, -39 },
  { 1461, 24, 40, 22, -1, -39 },
  { 1581, 24, 39, 23, -1, -39 },
  { 1698, 23, 40, 22, 0, -39 },
  { 1813, 23, 40, 22, 1, -39 },
  { 1928, 24, 39, 22, 1, -39 },
  { 2045, 23, 40, 22, 0, -39 },
  { 2160, 22, 40, 22, 0, -39 },
  { 2270, 12, 31, 12, 0, -30 },
  { 2317, 15, 37, 12, -3, -30 },
  { 2387, 21, 25, 24, 2, -32 },
  { 2453, 21, 16, 24, 2, -27 },
  { 2495, 22, 25, 24, 2, -32 },
  { 2564, 19, 39, 17, 1, -39 },
  { 2657, 32, 43, 34, 1, -39 },
  { 2829, 24, 39, 24, -3, -39 },
  { 2946, 25, 39, 25, 0, -39 },
  { 3068, 24, 40, 23, 2, -39 },
  { 3188, 26, 39, 27, 0, -39 },
  { 3315, 23, 39, 21, 0, -39 },
  { 3428, 23, 39, 20, 0, -39 },
  { 3541, 27, 40, 28, 2, -39 },
  { 3676, 29, 39, 28, 0, -39 },
  { 3818, 22, 39, 16, -2, -39 },
  { 3926, 22, 50, 12, -8, -39 },
  { 4064, 29, 39, 24, 0, -39 },
  { 4206, 16, 39, 20, 0, -39 },
  { 4284, 38, 39, 37, 0, -39 },
  { 4470, 31, 39, 29, 0, -39 },
  { 4622, 26, 40, 28, 2, -39 },
  { 4752, 25, 39, 24, 0, -39 },
  { 4874, 26, 48, 28, 2, -39 },
  { 5030, 25, 39, 24, 0, -39 },
  { 5152, 25, 40, 21, -1, -39 },
  { 5277, 21, 39, 20, 4, -39 },
  { 5380, 27, 40, 27, 2, -39 },
  { 5515, 23, 39, 24, 5, -39 },
  { 5628, 37, 39, 37, 4, -39 },
  { 5809, 29, 39, 22, -3, -39 },
  { 5951, 22, 39, 22, 4, -39 },
  { 6059, 25, 39, 20, -2, -39 },
  { 6181, 21, 48, 15, -2, -39 },
  { 6307, 11, 39, 20, 5, -39 },
  { 6361, 21, 48, 15, -4, -39 },
  { 6487, 23, 23, 23, 0, -39 },
  { 6554, 18, 3, 17, -5, 5 },
  { 6561, 9, 8, 15, 8, -41 },
  { 6570, 23, 31, 24, 1, -30 },
  { 6660, 23, 42, 24, 0, -41 },
  { 6781, 19, 31, 19, 1, -30 },
  { 6855, 26, 42, 24, 1, -41 },
  { 6992, 20, 31, 22, 1, -30 },
  { 7070, 26, 54, 14, -6, -41 },
  { 7246, 25, 43, 24, -1, -30 },
  { 7381, 22, 41, 24, 0, -41 },
  { 7494, 14, 41, 12, 0, -41 },
  { 7566, 21, 54, 12, -7, -41 },
  { 7708, 24, 41, 22, 0, -41 },
  { 7831, 14, 41, 12, 0, -41 },
  { 7903, 34, 30, 35, 0, -30 },
  { 8031, 22, 30, 24, 0, -30 },
  { 8114, 21, 31, 23, 1, -30 },
  { 8196, 26, 43, 24, -3, -30 },
  { 8336, 23, 43, 24, 1, -30 },
  { 8460, 19, 30, 16, 0, -30 },
  { 8532, 19, 31, 19, 0, -30 },
  { 8606, 14, 37, 15, 2, -36 },
  { 8671, 23, 30, 24, 1, -29 },
  { 8758, 20, 29, 20, 3, -29 },
  { 8831, 31, 29, 32, 3, -29 },
  { 8944, 26, 29, 21, -3, -29 },
  { 9039, 27, 42, 20, -4, -29 },
  { 9181, 21, 29, 17, -2, -29 },
  { 9258, 21, 48, 18, 1, -39 },
  { 9384, 5, 53, 20, 7, -41 },
  { 9418, 20, 48, 18, -3, -39 },
  { 9538, 22, 8, 24, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC54PT7B_H_
