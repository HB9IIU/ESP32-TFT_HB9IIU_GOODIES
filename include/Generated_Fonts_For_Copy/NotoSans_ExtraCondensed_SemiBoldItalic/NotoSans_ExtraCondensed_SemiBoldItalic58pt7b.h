#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC58PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x30,
  0x00, 0x3F, 0x0F, 0xCF, 0xC7, 0xF7, 0xF1, 0xFD, 0xF8, 0x7E, 0x7E, 0x1F,
  0x9F, 0x87, 0xE7, 0xE1, 0xF1, 0xF0, 0xFC, 0x7C, 0x3F, 0x3F, 0x0F, 0xCF,
  0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x07, 0xC0, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF8,
  0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x3E,
  0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x7C, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x7C, 0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFE, 0x67, 0x80, 0x7E, 0x70,
  0xC0, 0x7E, 0x30, 0x00, 0x3F, 0x18, 0x00, 0x1F, 0x8C, 0x00, 0x0F, 0xC6,
  0x00, 0x07, 0xE7, 0x00, 0x03, 0xFB, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0x7F, 0x00, 0x01, 0x9F, 0x80, 0x00, 0xCF, 0xC0, 0x00, 0xE7, 0xE0,
  0x00, 0x63, 0xF0, 0x00, 0x31, 0xF8, 0x20, 0x18, 0xFC, 0x1C, 0x0C, 0xFE,
  0x0F, 0x8E, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x7F,
  0xE0, 0x0F, 0x80, 0x3F, 0xF8, 0x03, 0xE0, 0x0F, 0xBE, 0x01, 0xF0, 0x07,
  0xC7, 0xC0, 0x7C, 0x01, 0xE1, 0xF0, 0x3E, 0x00, 0xF8, 0x7C, 0x0F, 0x80,
  0x3C, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xE0, 0xF8,
  0x01, 0xF0, 0x78, 0x3E, 0x00, 0x78, 0x3E, 0x1F, 0x00, 0x3E, 0x0F, 0x87,
  0x80, 0x0F, 0x83, 0xE3, 0xE0, 0x03, 0xE0, 0xF0, 0xF0, 0x00, 0xF8, 0x7C,
  0x7C, 0x00, 0x3E, 0x1F, 0x3E, 0x1F, 0xCF, 0x87, 0x8F, 0x8F, 0xFB, 0xE3,
  0xE7, 0xC7, 0xFE, 0xF8, 0xF9, 0xF3, 0xFF, 0xFE, 0xFC, 0xF8, 0xF9, 0xFF,
  0xFE, 0x3E, 0x7C, 0x7D, 0xFF, 0x9F, 0x1E, 0x1F, 0x3F, 0x87, 0xCF, 0x87,
  0xC7, 0xC3, 0xE3, 0xE1, 0xF0, 0x00, 0xF8, 0xF0, 0x7C, 0x00, 0x7C, 0x7C,
  0x1F, 0x00, 0x1E, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xC1, 0xE0, 0x03, 0xC1,
  0xE0, 0xF8, 0x01, 0xF0, 0x78, 0x3E, 0x00, 0xF8, 0x3E, 0x0F, 0x80, 0x3E,
  0x0F, 0x83, 0xC0, 0x1F, 0x03, 0xE1, 0xF0, 0x07, 0xC0, 0xF8, 0x7C, 0x03,
  0xE0, 0x3E, 0x3E, 0x00, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x01, 0xFF, 0xC0,
  0x1F, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x0F, 0xF0, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xF8, 0x3F,
  0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01,
  0xF8, 0x7C, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0x07, 0xFF,
  0x87, 0xE0, 0xFF, 0xF8, 0x7E, 0x1F, 0xDF, 0x8F, 0xC3, 0xF9, 0xFC, 0xFC,
  0x3F, 0x0F, 0xCF, 0xC7, 0xE0, 0xFD, 0xF8, 0x7E, 0x0F, 0xFF, 0x8F, 0xE0,
  0x7F, 0xF0, 0xFC, 0x07, 0xFF, 0x0F, 0xC0, 0x7F, 0xE0, 0xFC, 0x03, 0xFC,
  0x0F, 0xC0, 0x3F, 0xC0, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0xC0, 0xFE,
  0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xE7,
  0xF0, 0x3F, 0xFC, 0x7F, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0x00, 0x00, 0x00,
  0x3F, 0x9F, 0x8F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x3F,
  0x1F, 0x8F, 0x87, 0xC3, 0xE0, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x20, 0xF8, 0x07, 0x8F, 0x80, 0x7E, 0xF8, 0x37, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xF8, 0x00, 0x7F,
  0xC0, 0x1F, 0xFE, 0x03, 0xFB, 0xE0, 0x7F, 0x3F, 0x03, 0xF1, 0xF0, 0x1E,
  0x1F, 0x80, 0xC1, 0xF0, 0x04, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC,
  0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x07, 0xC0,
  0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF,
  0xE0, 0x1E, 0x3F, 0x7F, 0x7F, 0xFF, 0xFF, 0xFE, 0x7C, 0x10, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x7E, 0x3F, 0x81, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC,
  0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC7,
  0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFC,
  0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F, 0x9F, 0x80,
  0x7F, 0x3F, 0x00, 0xFE, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF8, 0x0F,
  0xE7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x1F, 0x80, 0xFE, 0x3F, 0x01, 0xFC,
  0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0x7F, 0x07,
  0xF0, 0xFC, 0x07, 0xE7, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8,
  0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x7F, 0xBF, 0x3F, 0x3F, 0x8F, 0x1F,
  0x83, 0x0F, 0xC1, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xC1, 0xFC, 0x01, 0xC0, 0x7F, 0x00, 0x60, 0x0F, 0xC0, 0x10, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0x03, 0xFC, 0x01, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x04,
  0x7F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x83, 0x00, 0x3F, 0xC0, 0xF0, 0x3F, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7B, 0xF0, 0x00, 0x3D, 0xF8, 0x00, 0x0F, 0x7E, 0x00, 0x07,
  0x9F, 0x80, 0x03, 0xE7, 0xE0, 0x00, 0xF3, 0xF8, 0x00, 0x78, 0xFC, 0x00,
  0x3E, 0x3F, 0x00, 0x0F, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF8,
  0x00, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x01,
  0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x7F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x20, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x40, 0x07, 0xF8, 0x30, 0x07, 0xF8, 0x1E, 0x0F,
  0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x87, 0x00, 0x1F,
  0x9F, 0xE0, 0x0F, 0xDF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x81, 0xFE, 0x1F, 0xC1, 0xFE, 0x07, 0xE0, 0xFF, 0x03, 0xF0,
  0x7F, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F,
  0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07,
  0xE0, 0xFE, 0x03, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC1,
  0xFC, 0x07, 0xF1, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xE3, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0,
  0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7E,
  0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xF1, 0xFC, 0x03,
  0xFB, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x1F, 0xE7, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F,
  0x07, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0xC0,
  0x7E, 0x0F, 0xF0, 0x7F, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x1F, 0x80, 0x7F, 0x1F, 0x80, 0xFF, 0x1F, 0x80, 0xFE, 0x1F, 0xC1, 0xFE,
  0x1F, 0xC1, 0xFE, 0x1F, 0xF7, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFE, 0xFC, 0x07, 0xFC, 0xFC, 0x03, 0xF1, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x80, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x16, 0x00, 0x00, 0x00, 0xE0, 0x0F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7C, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x0F,
  0x80, 0x10, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x06, 0x07, 0xF0, 0x40, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0xFE, 0x3E, 0x0F, 0x03, 0xFF,
  0xC3, 0xC3, 0xE0, 0xFF, 0xF8, 0x78, 0x78, 0x3F, 0x1E, 0x1F, 0x1F, 0x07,
  0xC3, 0xC3, 0xE3, 0xC1, 0xF0, 0xF8, 0x7C, 0x78, 0x3C, 0x1F, 0x0F, 0x9F,
  0x0F, 0x83, 0xC1, 0xE3, 0xC1, 0xE0, 0xF8, 0x3C, 0x78, 0x7C, 0x1F, 0x07,
  0x8F, 0x0F, 0x83, 0xE0, 0xF3, 0xE1, 0xE0, 0x78, 0x3C, 0x78, 0x3C, 0x1F,
  0x07, 0x8F, 0x0F, 0x83, 0xE0, 0xF1, 0xE1, 0xF0, 0x7C, 0x3C, 0x3C, 0x3E,
  0x1F, 0x07, 0x87, 0x87, 0xC3, 0xE0, 0xF1, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E,
  0x1F, 0x1F, 0x8F, 0x87, 0xC3, 0xFF, 0x7F, 0xE0, 0xF8, 0x3F, 0xEF, 0xF8,
  0x1F, 0x07, 0xF9, 0xFE, 0x03, 0xE0, 0x7E, 0x1F, 0x80, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x01, 0x80, 0x00, 0x7F, 0x81, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0x7C, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF3, 0xF0,
  0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3,
  0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xE0,
  0x0F, 0xC3, 0xF8, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x3F,
  0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x03, 0xF8, 0x3F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x07, 0xF0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x81,
  0xFC, 0x07, 0xE0, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xF0, 0x7F,
  0x80, 0x7E, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xE0, 0x7E,
  0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE,
  0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xE0,
  0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xF0,
  0x70, 0x0F, 0xF0, 0x04, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x01, 0x00, 0x7F,
  0xE7, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xCF, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x1F,
  0xC0, 0xFF, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x03, 0xF8, 0x07,
  0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x00,
  0x7F, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x1F, 0xC0,
  0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x03, 0xF8,
  0x1F, 0x80, 0x3F, 0x83, 0xF8, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xF0,
  0x0F, 0xE0, 0x3F, 0x01, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x0F, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x07, 0xFC, 0x07, 0x80, 0x7F, 0xC0, 0x0C, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x03, 0xFF, 0x87, 0xF0, 0x1F, 0xFC, 0x3F, 0x80, 0xFF, 0xE1,
  0xF8, 0x0F, 0xFF, 0x1F, 0xC0, 0x7F, 0xF0, 0xFE, 0x03, 0xFF, 0x87, 0xF0,
  0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03,
  0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0,
  0xFE, 0x00, 0x7E, 0x07, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF,
  0x01, 0xFC, 0x07, 0xFE, 0x1F, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF8,
  0x07, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x43, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC,
  0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xC0,
  0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x1F,
  0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x7E, 0x7F, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x1F,
  0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x01, 0xF7, 0xE0, 0x0F, 0xBF, 0x01, 0xFB, 0xF0, 0x0F,
  0xDF, 0x80, 0xFB, 0xF8, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x03, 0xF7, 0xE0,
  0x7C, 0xFC, 0x01, 0xFB, 0xF0, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x3F, 0x3F,
  0x00, 0xFC, 0xFC, 0x1F, 0x3F, 0x80, 0x7E, 0x7E, 0x1F, 0x9F, 0x80, 0x3F,
  0x1F, 0x0F, 0x8F, 0xC0, 0x1F, 0x8F, 0x8F, 0xC7, 0xE0, 0x1F, 0x87, 0xC7,
  0xC7, 0xF0, 0x0F, 0xC3, 0xE7, 0xE3, 0xF0, 0x07, 0xE1, 0xF3, 0xE1, 0xF8,
  0x03, 0xF0, 0xFB, 0xF0, 0xFC, 0x01, 0xF8, 0x7D, 0xF0, 0x7E, 0x01, 0xF8,
  0x3E, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xFC,
  0x1F, 0x80, 0x3F, 0x07, 0xFE, 0x0F, 0xC0, 0x1F, 0x03, 0xFE, 0x07, 0xE0,
  0x1F, 0x81, 0xFF, 0x07, 0xF0, 0x0F, 0xC0, 0xFF, 0x03, 0xF0, 0x07, 0xE0,
  0x7F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0xC0,
  0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x7F, 0x80, 0x0F, 0xC0, 0x3F, 0xC0,
  0x07, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x0F, 0xF8, 0x03, 0xF0, 0x0F, 0xFC,
  0x01, 0xF8, 0x07, 0xFE, 0x00, 0xFC, 0x03, 0xFF, 0x00, 0xFE, 0x01, 0xFF,
  0x80, 0x7E, 0x00, 0xFF, 0xE0, 0x3F, 0x00, 0xFF, 0xF0, 0x1F, 0x80, 0x7F,
  0xF8, 0x0F, 0xC0, 0x3F, 0x7C, 0x0F, 0xC0, 0x1F, 0xBE, 0x07, 0xE0, 0x0F,
  0x9F, 0x03, 0xF0, 0x0F, 0xCF, 0xC1, 0xF8, 0x07, 0xE7, 0xE0, 0xFC, 0x03,
  0xF3, 0xF0, 0xFC, 0x01, 0xF8, 0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x3F, 0x00,
  0xFC, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x8F, 0xC0, 0x3F, 0x0F, 0xCF, 0xC0,
  0x1F, 0x87, 0xE7, 0xE0, 0x1F, 0x81, 0xF3, 0xF0, 0x0F, 0xC0, 0xF9, 0xF8,
  0x07, 0xE0, 0x7C, 0xF8, 0x03, 0xF0, 0x3F, 0xFC, 0x01, 0xF8, 0x1F, 0xFE,
  0x01, 0xF8, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x7E, 0x01, 0xFF,
  0x80, 0x3F, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x3F,
  0xF0, 0x0F, 0xC0, 0x1F, 0xF8, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xF0, 0x03,
  0xFC, 0x03, 0xF0, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07,
  0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F,
  0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x7E, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00,
  0x1F, 0xCF, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0xCF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x03, 0xF8, 0xFF, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0,
  0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC1, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x1F,
  0x81, 0xFE, 0x07, 0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x1F,
  0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF3, 0xF8, 0x00,
  0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC,
  0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xE0,
  0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x7F,
  0xCF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0x0F, 0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x07,
  0xE0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0x7E, 0x1F, 0xF0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E,
  0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x7F, 0x00,
  0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x3F,
  0x81, 0xF8, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xE0,
  0x1F, 0x83, 0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xC3, 0xE0, 0x1F, 0xE0, 0x18,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x01, 0x00, 0x1F, 0xC0, 0x38, 0x07, 0xF8, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F,
  0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80,
  0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xFE, 0x01, 0xFF,
  0x3F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xF3, 0xF8,
  0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE3,
  0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F,
  0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F,
  0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3F,
  0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F,
  0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x00,
  0x7F, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x7E,
  0x00, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x7E, 0x01, 0xFE,
  0x01, 0xFC, 0x7E, 0x01, 0xFE, 0x01, 0xF8, 0x7E, 0x01, 0xFE, 0x01, 0xF8,
  0x7E, 0x03, 0xFE, 0x03, 0xF8, 0x7E, 0x03, 0xFE, 0x03, 0xF0, 0x7E, 0x07,
  0xFE, 0x07, 0xF0, 0x7E, 0x07, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xFE, 0x07,
  0xE0, 0x7E, 0x0F, 0xBE, 0x0F, 0xE0, 0x7E, 0x0F, 0xBE, 0x0F, 0xC0, 0x7E,
  0x1F, 0xBE, 0x0F, 0xC0, 0x7E, 0x1F, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x3E,
  0x1F, 0x80, 0x7E, 0x3F, 0x3E, 0x3F, 0x80, 0x7E, 0x3E, 0x3E, 0x3F, 0x00,
  0x7C, 0x7E, 0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x3E, 0x7E, 0x00, 0xFC, 0x7C,
  0x3E, 0x7E, 0x00, 0xFC, 0xFC, 0x7E, 0xFE, 0x00, 0xFC, 0xF8, 0x7E, 0xFC,
  0x00, 0xFD, 0xF8, 0x7C, 0xFC, 0x00, 0xFD, 0xF0, 0x7D, 0xF8, 0x00, 0xFD,
  0xF0, 0x7D, 0xF8, 0x00, 0xFF, 0xF0, 0x7D, 0xF8, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x03,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x3F,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFB, 0xF8, 0x07, 0xF3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7E,
  0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x7E, 0x03, 0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F,
  0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7D, 0xF8, 0x00, 0xFC,
  0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xE0,
  0x7C, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x7E, 0x1F, 0x80,
  0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xFF,
  0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0xCF, 0xC0, 0x7F, 0xE7, 0xE0, 0x7F, 0xFB, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xC1, 0xFE,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F,
  0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFE, 0x01,
  0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7E, 0x1F, 0xC0,
  0x3F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0xC7, 0xFC, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xBF, 0x00, 0xFF, 0x9F, 0x80,
  0x3F, 0x8F, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x8F, 0x80,
  0x1F, 0x9F, 0xE0, 0x0F, 0xDF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0x7F, 0x81, 0xFE, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x7E, 0x03,
  0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x7F, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8,
  0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F,
  0x00, 0xFE, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x87,
  0xF0, 0x1F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x7E, 0xFF, 0xE0, 0x3E, 0x7F, 0xE0, 0x1F, 0x1F, 0xE0,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFE, 0xF0, 0x3F, 0xC0, 0x81, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x10,
  0x1F, 0xC1, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xF9, 0xF8, 0x01, 0xFF, 0xDF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0xF0, 0x0F, 0xE0,
  0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x0F, 0xE0,
  0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC,
  0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0xFE,
  0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x3F,
  0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x1F, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFB, 0xE0, 0x07, 0xFF, 0xBE, 0x00, 0x3F, 0xF3,
  0xE0, 0x01, 0xFC, 0x3C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F,
  0xC3, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03,
  0xF3, 0xF8, 0x0F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF9, 0xFC, 0x7F, 0xC7,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x18, 0x1F,
  0xF7, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0x10, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xFC, 0xFC, 0x01, 0xFF, 0xDF, 0x80, 0x7F, 0xFB,
  0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x1F,
  0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFE,
  0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xF0,
  0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x0F, 0xE0,
  0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07,
  0xF0, 0x7F, 0x80, 0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFB, 0xF0, 0x03, 0xFE, 0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x83, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x20, 0x03, 0xF8, 0x06, 0x00,
  0xFE, 0x00, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0xF8, 0x03, 0xF3, 0xFC, 0x03, 0xF7, 0xFE, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0x07,
  0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0xFE, 0x1F,
  0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F,
  0x01, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x7F,
  0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFE,
  0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0x00,
  0x18, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x40, 0xFC, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F,
  0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF9,
  0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xDF, 0x80, 0x03,
  0xEF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x7E, 0x00, 0x3F, 0x9F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0x3E, 0x3F, 0xC3, 0xFE, 0x03, 0xE7, 0xFE,
  0x7F, 0xE0, 0x3E, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xF0, 0x7F, 0x07, 0xF8, 0x3F,
  0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E,
  0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0xFC,
  0x07, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0xFC, 0x0F, 0xE1, 0xF8, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8,
  0x0F, 0xC3, 0xF0, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x0F, 0xC3, 0xF0,
  0x1F, 0x81, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0,
  0x3F, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0xFE, 0x07, 0xE0, 0x3F, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x03, 0xE3, 0xFC, 0x03, 0xE7, 0xFE, 0x03, 0xEF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x3F,
  0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0xFE,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0xFC,
  0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8,
  0x7F, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0xFE, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x1F,
  0xC0, 0xFE, 0x3F, 0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xF8, 0x07, 0xF3, 0xF0,
  0x0F, 0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00,
  0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F,
  0x9F, 0xC0, 0x7F, 0x3F, 0x00, 0xFE, 0x7F, 0x01, 0xF8, 0xFE, 0x07, 0xF0,
  0xFC, 0x1F, 0xC1, 0xFC, 0x7F, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x07, 0xC7, 0xF8, 0x00, 0x7C, 0xFF, 0xC0, 0x07, 0xDF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF8, 0xFE, 0x00, 0xFF, 0x07, 0xE0,
  0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xE0, 0x3F,
  0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xBF, 0xFC, 0x01, 0xFB, 0xFF, 0x80, 0x1F, 0x9F, 0xF0, 0x01,
  0xF8, 0xFE, 0x00, 0x1F, 0x83, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC7, 0xC0, 0x7F,
  0xF7, 0xE0, 0x7F, 0xFB, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xDF, 0xF8, 0x3F,
  0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x7F, 0x07,
  0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xE1,
  0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x1F,
  0xC3, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x07,
  0xF8, 0x3F, 0xC7, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xBF, 0x00, 0xFF, 0x9F, 0x80, 0x3F, 0x9F, 0xC0, 0x02, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x3E, 0x3F, 0x03, 0xE7, 0xF0,
  0x3E, 0xFF, 0x03, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xF0, 0xF0, 0x3F, 0x01, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x84, 0x03, 0xF8, 0x38, 0x3F, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE1, 0x0F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x0C, 0x00, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC,
  0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8,
  0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xF7, 0xC0,
  0x3F, 0xE7, 0xC0, 0x1F, 0xC7, 0xC0, 0x02, 0x00, 0x00, 0xFC, 0x01, 0xFD,
  0xF0, 0x07, 0xE7, 0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0x7C, 0x07, 0xF1, 0xF0,
  0x1F, 0x87, 0xC0, 0x7E, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x7E,
  0x07, 0xC1, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x07,
  0xC7, 0xE0, 0x1F, 0x1F, 0x80, 0x7C, 0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xCF,
  0x80, 0x1F, 0x7E, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x07, 0xF8, 0x0F, 0xDF, 0x81, 0xFE, 0x07, 0xE7, 0xC0, 0x7F, 0x81, 0xF9,
  0xF0, 0x3F, 0xE0, 0xFC, 0x7C, 0x0F, 0xF0, 0x3F, 0x1F, 0x03, 0xFC, 0x0F,
  0xC7, 0xC1, 0xFF, 0x07, 0xE1, 0xF0, 0x7F, 0xC1, 0xF8, 0x7C, 0x3F, 0xF0,
  0x7C, 0x3F, 0x0F, 0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0x0F, 0xC3, 0xF1, 0xF7,
  0xC7, 0xE0, 0xFC, 0x7D, 0xF1, 0xF8, 0x3F, 0x3E, 0x7C, 0x7C, 0x0F, 0xCF,
  0x9F, 0x3F, 0x03, 0xF3, 0xE7, 0xCF, 0xC0, 0xFD, 0xF1, 0xF3, 0xE0, 0x3F,
  0x7C, 0x7D, 0xF8, 0x0F, 0xDF, 0x1F, 0x7C, 0x03, 0xFF, 0x87, 0xFF, 0x00,
  0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x03, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F,
  0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC1,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x03, 0xF8, 0x3F,
  0x00, 0x3F, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x80,
  0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x07,
  0xE0, 0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x3F,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x7E, 0x7C, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x1F, 0xBE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x02,
  0x7F, 0xE0, 0x05, 0xFF, 0xF0, 0x1F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFE, 0x80, 0x03, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 16, 42, 14, 0, -41 },
  { 85, 18, 15, 22, 6, -41 },
  { 119, 28, 41, 27, 0, -41 },
  { 263, 25, 47, 24, 0, -44 },
  { 410, 34, 43, 39, 3, -42 },
  { 593, 28, 43, 28, 0, -42 },
  { 744, 9, 15, 13, 6, -41 },
  { 761, 19, 51, 15, 1, -42 },
  { 883, 18, 51, 15, -4, -42 },
  { 998, 20, 22, 23, 5, -44 },
  { 1053, 23, 27, 26, 2, -34 },
  { 1131, 12, 15, 13, -3, -7 },
  { 1154, 14, 6, 16, 1, -19 },
  { 1165, 8, 9, 13, 0, -8 },
  { 1174, 29, 42, 21, -3, -42 },
  { 1327, 23, 43, 24, 1, -42 },
  { 1451, 17, 41, 24, 6, -41 },
  { 1539, 26, 42, 24, -2, -42 },
  { 1676, 26, 43, 24, -1, -42 },
  { 1816, 26, 42, 24, -1, -42 },
  { 1953, 25, 42, 24, 0, -41 },
  { 2085, 25, 43, 24, 1, -42 },
  { 2220, 25, 41, 24, 2, -41 },
  { 2349, 25, 43, 24, 0, -42 },
  { 2484, 24, 43, 24, 0, -42 },
  { 2613, 13, 33, 13, 0, -32 },
  { 2667, 16, 40, 13, -3, -32 },
  { 2747, 23, 27, 26, 2, -34 },
  { 2825, 23, 17, 26, 2, -29 },
  { 2874, 23, 27, 26, 2, -34 },
  { 2952, 20, 43, 18, 1, -42 },
  { 3060, 35, 47, 36, 1, -42 },
  { 3266, 26, 42, 26, -4, -42 },
  { 3403, 27, 41, 27, 0, -41 },
  { 3542, 26, 43, 24, 2, -42 },
  { 3682, 28, 41, 29, 0, -41 },
  { 3826, 25, 41, 22, 0, -41 },
  { 3955, 25, 41, 21, 0, -41 },
  { 4084, 29, 43, 30, 2, -42 },
  { 4240, 32, 41, 30, 0, -41 },
  { 4404, 24, 41, 17, -3, -41 },
  { 4527, 24, 53, 13, -9, -41 },
  { 4686, 31, 41, 26, 0, -41 },
  { 4845, 18, 41, 21, 0, -41 },
  { 4938, 41, 41, 39, 0, -41 },
  { 5149, 33, 41, 32, 0, -41 },
  { 5319, 28, 43, 31, 2, -42 },
  { 5470, 27, 41, 25, 0, -41 },
  { 5609, 28, 52, 31, 2, -42 },
  { 5791, 26, 41, 26, 0, -41 },
  { 5925, 27, 43, 23, -1, -42 },
  { 6071, 22, 41, 22, 4, -41 },
  { 6184, 29, 42, 29, 2, -41 },
  { 6337, 26, 41, 26, 5, -41 },
  { 6471, 40, 41, 40, 4, -41 },
  { 6676, 31, 41, 24, -3, -41 },
  { 6835, 23, 41, 23, 5, -41 },
  { 6953, 27, 41, 21, -2, -41 },
  { 7092, 23, 51, 16, -2, -42 },
  { 7239, 11, 42, 21, 6, -42 },
  { 7297, 23, 51, 16, -4, -42 },
  { 7444, 24, 23, 24, 0, -41 },
  { 7513, 19, 4, 18, -5, 5 },
  { 7523, 10, 9, 16, 8, -44 },
  { 7535, 25, 33, 26, 1, -32 },
  { 7639, 25, 45, 26, 0, -44 },
  { 7780, 21, 33, 20, 1, -32 },
  { 7867, 28, 45, 26, 1, -44 },
  { 8025, 22, 33, 24, 1, -32 },
  { 8116, 29, 58, 15, -7, -44 },
  { 8327, 27, 46, 26, -1, -32 },
  { 8483, 24, 44, 26, 0, -44 },
  { 8615, 15, 44, 12, 0, -44 },
  { 8698, 22, 58, 12, -7, -44 },
  { 8858, 26, 44, 23, 0, -44 },
  { 9001, 15, 44, 12, 0, -44 },
  { 9084, 36, 32, 38, 0, -32 },
  { 9228, 24, 32, 26, 0, -32 },
  { 9324, 23, 33, 25, 1, -32 },
  { 9419, 28, 46, 26, -3, -32 },
  { 9580, 25, 46, 26, 1, -32 },
  { 9724, 20, 32, 18, 0, -32 },
  { 9804, 21, 33, 20, 0, -32 },
  { 9891, 16, 39, 16, 2, -38 },
  { 9969, 24, 32, 25, 1, -31 },
  { 10065, 22, 31, 22, 3, -31 },
  { 10151, 34, 31, 34, 3, -31 },
  { 10283, 28, 31, 22, -3, -31 },
  { 10392, 30, 45, 22, -5, -31 },
  { 10561, 22, 31, 18, -2, -31 },
  { 10647, 22, 50, 19, 1, -41 },
  { 10785, 5, 57, 21, 8, -44 },
  { 10821, 21, 50, 19, -3, -41 },
  { 10953, 23, 9, 26, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC58PT7B_H_
