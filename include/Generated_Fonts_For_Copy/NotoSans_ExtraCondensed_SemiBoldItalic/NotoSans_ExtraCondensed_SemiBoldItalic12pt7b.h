#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC12PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0xB4, 0x84, 0xC0, 0x5D, 0xAA, 0x14, 0xA2, 0x9F, 0x51, 0x4F,
  0x98, 0xA0, 0x11, 0xD4, 0xC3, 0x18, 0xDE, 0x42, 0x00, 0x45, 0x52, 0xA5,
  0x8D, 0xF5, 0x4C, 0xAA, 0xCC, 0x10, 0xA2, 0x8C, 0x21, 0xF9, 0xA4, 0xF8,
  0x5E, 0x12, 0x24, 0x4C, 0xC8, 0x88, 0x40, 0x31, 0x11, 0x11, 0x22, 0x24,
  0xC0, 0x2F, 0x6F, 0x21, 0x3E, 0x42, 0x10, 0x69, 0x60, 0xE0, 0x70, 0x04,
  0x30, 0x86, 0x10, 0xC2, 0x10, 0xC0, 0x11, 0xD2, 0x95, 0xEF, 0x5E, 0x60,
  0x36, 0xE2, 0x26, 0x44, 0x40, 0x33, 0xC2, 0x31, 0x11, 0x18, 0xF0, 0x33,
  0xC2, 0x36, 0x08, 0x52, 0xE0, 0x08, 0xCE, 0x65, 0x4B, 0xE6, 0x20, 0x39,
  0xD8, 0x87, 0x08, 0x56, 0xE0, 0x19, 0xD8, 0xA7, 0xEF, 0x7A, 0x70, 0x7D,
  0xE0, 0x84, 0x10, 0x82, 0x10, 0xC0, 0x33, 0x52, 0xF3, 0x2A, 0x52, 0xF0,
  0x33, 0xD2, 0x95, 0xBC, 0x46, 0xE0, 0x2C, 0x01, 0x30, 0x13, 0x00, 0x06,
  0x44, 0x80, 0x09, 0xB0, 0xE1, 0x84, 0xF8, 0x3F, 0xF0, 0xC3, 0x86, 0x6C,
  0x40, 0x35, 0x13, 0x24, 0x04, 0xC0, 0x0C, 0x64, 0x8A, 0xF6, 0xB5, 0x6A,
  0xCA, 0x40, 0xF0, 0x0C, 0x71, 0xC7, 0x2C, 0xF7, 0xD3, 0xCC, 0x30, 0xF6,
  0xD2, 0x71, 0x6C, 0xB6, 0xF0, 0x1C, 0xE6, 0x10, 0x43, 0x0C, 0x10, 0x70,
  0x30, 0xE6, 0xD3, 0x4D, 0x2C, 0xB6, 0xF0, 0x39, 0xD8, 0xC7, 0x23, 0x18,
  0xF0, 0x39, 0xD8, 0xC7, 0x23, 0x18, 0x80, 0x1C, 0xF6, 0x10, 0x5F, 0x3C,
  0x92, 0x78, 0x26, 0x49, 0x92, 0x67, 0xC9, 0x32, 0x64, 0x98, 0x38, 0x84,
  0x23, 0x10, 0x84, 0xF0, 0x08, 0x46, 0x31, 0x08, 0x46, 0x21, 0x38, 0x24,
  0xB6, 0x94, 0x71, 0x45, 0x34, 0x98, 0x22, 0x64, 0x44, 0xCC, 0xF0, 0x31,
  0x33, 0x73, 0x55, 0x57, 0x5A, 0x5A, 0xDA, 0x96, 0x22, 0x4D, 0xD2, 0xA5,
  0x4A, 0x97, 0x6C, 0x98, 0x18, 0xF6, 0x51, 0x47, 0x3C, 0xD6, 0x70, 0x30,
  0xE6, 0xD2, 0x59, 0xCC, 0x30, 0x80, 0x18, 0xF6, 0x51, 0x47, 0x3C, 0xD6,
  0x70, 0xC1, 0x00, 0x31, 0xDA, 0x97, 0xB9, 0x5A, 0x98, 0x3B, 0xD0, 0xC7,
  0x18, 0x56, 0xE0, 0xFF, 0x64, 0x44, 0xCC, 0x80, 0x24, 0x96, 0x53, 0x4D,
  0x2C, 0xB6, 0x70, 0x8C, 0x65, 0x2B, 0x53, 0x98, 0xC0, 0x89, 0x9B, 0x9A,
  0xAA, 0xBE, 0xBC, 0xD4, 0xD8, 0xD8, 0x36, 0x68, 0x70, 0xC1, 0x07, 0x0E,
  0x34, 0xC8, 0x9C, 0xBD, 0xC6, 0x21, 0x18, 0x80, 0x7B, 0xC4, 0x62, 0x31,
  0x10, 0xF0, 0x32, 0x64, 0x44, 0x48, 0x88, 0xC0, 0xBD, 0x55, 0x40, 0x38,
  0xC4, 0x21, 0x08, 0xC4, 0x21, 0x38, 0x11, 0x8C, 0xBC, 0x80, 0xF0, 0x90,
  0x2B, 0xD3, 0xBD, 0xE9, 0xC0, 0x21, 0x1C, 0xF4, 0xA7, 0x7A, 0xF0, 0x3B,
  0x91, 0x8C, 0x61, 0x80, 0x04, 0x32, 0x9E, 0x4B, 0x2D, 0xB4, 0x70, 0x13,
  0xD7, 0xEC, 0x61, 0xC0, 0x1C, 0x43, 0x8C, 0x20, 0x82, 0x18, 0x41, 0x04,
  0x20, 0x2B, 0xD3, 0xBD, 0xEB, 0xC2, 0xB7, 0x00, 0x21, 0x1C, 0xF4, 0xAF,
  0x5A, 0x90, 0x25, 0xA4, 0xB6, 0x80, 0x08, 0x46, 0x21, 0x08, 0xC6, 0x21,
  0x09, 0x80, 0x21, 0x1A, 0xB5, 0x33, 0xD2, 0x90, 0x25, 0xA4, 0xB6, 0x80,
  0x52, 0x7F, 0x4A, 0x5A, 0xD2, 0xD2, 0x96, 0x53, 0xD2, 0xBD, 0x6A, 0x40,
  0x33, 0xD3, 0x9D, 0xE9, 0xC0, 0x28, 0xF2, 0x49, 0x6D, 0xA7, 0x90, 0x43,
  0x00, 0x2B, 0xD3, 0x9D, 0xEB, 0xC2, 0x31, 0x00, 0x57, 0x44, 0xCC, 0x80,
  0x35, 0x46, 0x22, 0xE0, 0x23, 0x64, 0x44, 0xCE, 0x6A, 0x52, 0xBD, 0x6B,
  0xC0, 0x9B, 0xAA, 0xCC, 0x80, 0xB7, 0x6A, 0xD6, 0xCD, 0x9B, 0x24, 0x00,
  0x24, 0xA3, 0x84, 0x31, 0xCD, 0x80, 0x24, 0xB2, 0x8A, 0x30, 0xC2, 0x08,
  0x63, 0x00, 0x77, 0x26, 0x48, 0xE0, 0x09, 0xC8, 0x42, 0x61, 0x08, 0x42,
  0x18, 0xFF, 0xF0, 0x21, 0x84, 0x21, 0x0C, 0xC4, 0x23, 0x30, 0xFC, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 4, 4, 4, 1, -9 },
  { 7, 6, 9, 5, 0, -9 },
  { 14, 5, 10, 5, 0, -9 },
  { 21, 7, 9, 8, 1, -9 },
  { 29, 6, 9, 6, 0, -9 },
  { 36, 2, 4, 3, 1, -9 },
  { 37, 4, 11, 3, 0, -9 },
  { 43, 4, 11, 3, -1, -9 },
  { 49, 4, 4, 5, 1, -9 },
  { 51, 5, 6, 5, 0, -7 },
  { 55, 3, 4, 3, -1, -2 },
  { 57, 3, 1, 3, 0, -4 },
  { 58, 2, 2, 3, 0, -2 },
  { 59, 6, 9, 4, -1, -9 },
  { 66, 5, 9, 5, 0, -9 },
  { 72, 4, 9, 5, 1, -9 },
  { 77, 5, 9, 5, 0, -9 },
  { 83, 5, 9, 5, 0, -9 },
  { 89, 5, 9, 5, 0, -9 },
  { 95, 5, 9, 5, 0, -9 },
  { 101, 5, 9, 5, 0, -9 },
  { 107, 6, 9, 5, 0, -9 },
  { 114, 5, 9, 5, 0, -9 },
  { 120, 5, 9, 5, 0, -9 },
  { 126, 3, 7, 3, 0, -7 },
  { 129, 4, 9, 3, -1, -7 },
  { 134, 5, 6, 5, 0, -7 },
  { 138, 5, 4, 5, 0, -6 },
  { 141, 5, 6, 5, 0, -7 },
  { 145, 4, 9, 4, 0, -9 },
  { 150, 7, 10, 8, 0, -9 },
  { 159, 6, 9, 5, -1, -9 },
  { 166, 6, 9, 6, 0, -9 },
  { 173, 6, 9, 5, 0, -9 },
  { 180, 6, 9, 6, 0, -9 },
  { 187, 5, 9, 5, 0, -9 },
  { 193, 5, 9, 4, 0, -9 },
  { 199, 6, 9, 6, 0, -9 },
  { 206, 7, 9, 6, 0, -9 },
  { 214, 5, 9, 4, -1, -9 },
  { 220, 5, 11, 3, -2, -9 },
  { 227, 6, 9, 5, 0, -9 },
  { 234, 4, 9, 4, 0, -9 },
  { 239, 8, 9, 8, 0, -9 },
  { 248, 7, 9, 7, 0, -9 },
  { 256, 6, 9, 6, 0, -9 },
  { 263, 6, 9, 5, 0, -9 },
  { 270, 6, 11, 6, 0, -9 },
  { 279, 5, 9, 5, 0, -9 },
  { 285, 5, 9, 5, 0, -9 },
  { 291, 4, 9, 5, 1, -9 },
  { 296, 6, 9, 6, 0, -9 },
  { 303, 5, 9, 5, 1, -9 },
  { 309, 8, 9, 8, 1, -9 },
  { 318, 7, 9, 5, -1, -9 },
  { 326, 5, 9, 5, 1, -9 },
  { 332, 5, 9, 4, 0, -9 },
  { 338, 4, 11, 3, 0, -9 },
  { 344, 2, 9, 4, 1, -9 },
  { 347, 5, 11, 3, -1, -9 },
  { 354, 5, 5, 5, 0, -9 },
  { 358, 4, 1, 4, -1, 1 },
  { 359, 2, 2, 3, 2, -9 },
  { 360, 5, 7, 5, 0, -7 },
  { 365, 5, 9, 5, 0, -9 },
  { 371, 5, 7, 4, 0, -7 },
  { 376, 6, 9, 5, 0, -9 },
  { 383, 5, 7, 5, 0, -7 },
  { 388, 6, 12, 3, -1, -9 },
  { 397, 5, 10, 5, 0, -7 },
  { 404, 5, 9, 5, 0, -9 },
  { 410, 3, 9, 3, 0, -9 },
  { 414, 5, 12, 3, -2, -9 },
  { 422, 5, 9, 5, 0, -9 },
  { 428, 3, 9, 3, 0, -9 },
  { 432, 8, 7, 8, 0, -7 },
  { 439, 5, 7, 5, 0, -7 },
  { 444, 5, 7, 5, 0, -7 },
  { 449, 6, 10, 5, -1, -7 },
  { 457, 5, 10, 5, 0, -7 },
  { 464, 4, 7, 4, 0, -7 },
  { 468, 4, 7, 4, 0, -7 },
  { 472, 4, 8, 3, 0, -8 },
  { 476, 5, 7, 5, 0, -7 },
  { 481, 4, 7, 5, 1, -7 },
  { 485, 7, 7, 7, 1, -7 },
  { 492, 6, 7, 5, -1, -7 },
  { 498, 6, 10, 5, -1, -7 },
  { 506, 4, 7, 4, 0, -7 },
  { 510, 5, 11, 4, 0, -9 },
  { 517, 1, 12, 4, 2, -9 },
  { 519, 5, 11, 4, -1, -9 },
  { 526, 5, 2, 5, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC12PT7B_H_
