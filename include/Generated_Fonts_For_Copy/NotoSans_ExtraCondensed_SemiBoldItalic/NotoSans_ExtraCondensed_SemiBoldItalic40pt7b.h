#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC40PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x78, 0x1F,
  0x83, 0xF0, 0x7C, 0x0F, 0x00, 0x7C, 0xFB, 0xE7, 0xDE, 0x3C, 0xF1, 0xE7,
  0x8F, 0x3C, 0xF1, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8E, 0x38, 0x70, 0x00,
  0x70, 0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x3C, 0x01,
  0xC7, 0x00, 0x78, 0xE0, 0x0E, 0x3C, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x8F, 0xFF, 0xF0, 0x38, 0xE0, 0x0E, 0x1C, 0x01, 0xC7, 0x00, 0x38,
  0xE0, 0x0E, 0x1C, 0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF0, 0x38, 0xE0, 0x0F, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0xE0, 0x0F, 0x1C,
  0x01, 0xC3, 0x80, 0x38, 0xE0, 0x0F, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x1F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x1E,
  0x66, 0x0F, 0x20, 0x07, 0xB0, 0x03, 0xD8, 0x01, 0xEC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x37, 0xC0, 0x1B, 0xE0, 0x0D, 0xF1, 0x04, 0xF8, 0xC2, 0x78, 0xFF,
  0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x08, 0x00, 0x07, 0x80, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0xE0,
  0x70, 0x3D, 0xE0, 0xE0, 0x38, 0xE0, 0xE0, 0x78, 0xE1, 0xC0, 0x70, 0xE3,
  0xC0, 0x71, 0xE3, 0x80, 0x71, 0xE7, 0x80, 0xF1, 0xC7, 0x00, 0xE1, 0xCF,
  0x00, 0xE1, 0xCE, 0x18, 0xE3, 0x9E, 0x7C, 0xE3, 0x9C, 0xFE, 0xE7, 0xBD,
  0xFE, 0xFF, 0x39, 0xCE, 0x7E, 0x73, 0x8F, 0x3C, 0x73, 0x8F, 0x00, 0xE3,
  0x8E, 0x01, 0xE7, 0x8E, 0x01, 0xC7, 0x0E, 0x03, 0xC7, 0x0E, 0x03, 0x87,
  0x1E, 0x07, 0x87, 0x1C, 0x07, 0x07, 0x1C, 0x0F, 0x07, 0x38, 0x0E, 0x07,
  0xF8, 0x1E, 0x07, 0xF0, 0x3C, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xC0,
  0x07, 0xFC, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0,
  0x3C, 0x78, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x8F, 0x3F, 0xF3, 0xC7,
  0x9E, 0x79, 0xE3, 0xFF, 0x3C, 0x7F, 0xCF, 0x87, 0xF9, 0xE0, 0xFE, 0x3C,
  0x1F, 0x87, 0x81, 0xF0, 0xF0, 0x7E, 0x1F, 0xBF, 0xE3, 0xFF, 0xFC, 0x3F,
  0xEF, 0x83, 0xF8, 0xF8, 0x3D, 0xF7, 0xDE, 0x79, 0xE7, 0xBC, 0xF3, 0xCF,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3C,
  0x10, 0xF0, 0x73, 0xC1, 0xFE, 0x37, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x3F,
  0x01, 0xFC, 0x0F, 0xF8, 0x7C, 0xF0, 0xE3, 0xC1, 0x0E, 0x00, 0x10, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F,
  0x1F, 0x1E, 0x1E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x11, 0xE7, 0xFF, 0xFB, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFC,
  0x03, 0xFE, 0x07, 0xFE, 0x0F, 0x9E, 0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1F,
  0x3E, 0x1F, 0x3C, 0x1F, 0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C,
  0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0xFE,
  0x1F, 0xE3, 0xFE, 0x7F, 0xCF, 0xBC, 0x73, 0xC6, 0x3C, 0x07, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07,
  0x8F, 0xC0, 0xC1, 0xF0, 0x20, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0x87, 0xC0, 0x81, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x04, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x80, 0x7C, 0x3E, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0x78, 0x01, 0xFE, 0x00, 0xEF, 0x00, 0x3B,
  0xC0, 0x1C, 0xF0, 0x0F, 0x7C, 0x03, 0x9E, 0x01, 0xC7, 0x80, 0xF1, 0xE0,
  0x38, 0x78, 0x1C, 0x3E, 0x0F, 0x0F, 0x03, 0x83, 0xC1, 0xFF, 0xFE, 0x7F,
  0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0xFF, 0xE0, 0x7F, 0xF0, 0x20, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x80,
  0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0xBF, 0x07,
  0xFF, 0xC3, 0xFF, 0xE1, 0xFD, 0xF0, 0xF8, 0x78, 0xF8, 0x3C, 0x7C, 0x1E,
  0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE3, 0xC1, 0xF1, 0xE0,
  0xF0, 0xF8, 0xF8, 0x7F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x00,
  0x0F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xF0, 0xF8, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F,
  0x0F, 0x87, 0x87, 0x83, 0xE7, 0xC1, 0xF7, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0x3E, 0x1F, 0x0F, 0x1F, 0x07,
  0xCF, 0x83, 0xE7, 0x81, 0xF3, 0xC0, 0xF9, 0xE0, 0x78, 0xF8, 0x7C, 0x7E,
  0x7C, 0x1F, 0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xF8, 0xF0, 0x78, 0x7C, 0x7C, 0x3E, 0x3C,
  0x1F, 0x1E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xC7, 0xC1, 0xE3, 0xE1, 0xF1,
  0xF0, 0xF8, 0xF8, 0xFC, 0x7F, 0xFE, 0x1F, 0xFE, 0x0F, 0xEF, 0x01, 0xCF,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x77, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0x07,
  0xC3, 0xE1, 0xF0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0x80, 0x01,
  0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0,
  0x00, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x1C, 0x00,
  0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0xF8, 0x01, 0xC0, 0x02, 0x00, 0x00,
  0x03, 0xE0, 0xFF, 0x8F, 0xFE, 0x3F, 0xF1, 0x87, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xF0, 0x3C,
  0x03, 0xC0, 0x1E, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x07,
  0x1E, 0x1F, 0xC7, 0x1C, 0x3F, 0xC7, 0x3C, 0x7B, 0xC7, 0x38, 0xF1, 0xC7,
  0x38, 0xE3, 0x87, 0x71, 0xE3, 0x8E, 0x71, 0xC3, 0x8E, 0x71, 0xC7, 0x8E,
  0x73, 0xC7, 0x0E, 0xE3, 0x87, 0x0C, 0xE3, 0x87, 0x1C, 0xE3, 0x8F, 0x1C,
  0xE3, 0x8F, 0x38, 0xE3, 0xDF, 0x70, 0xE3, 0xF7, 0xF0, 0xE1, 0xF3, 0xE0,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x02, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F,
  0x3C, 0x03, 0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x0F,
  0x03, 0xC3, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3,
  0xC0, 0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x80, 0xF3, 0xC0,
  0x3D, 0xF0, 0x0F, 0xF8, 0x03, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x03, 0xFF, 0xE0, 0x78, 0x7C, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x7C,
  0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x1F, 0x07, 0x87, 0xC1, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1E, 0x1F, 0x07, 0xC1,
  0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0xF8, 0x1E, 0x1F, 0x07,
  0xC3, 0xC0, 0xF8, 0x78, 0x3E, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7E, 0x18, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x08, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x7D, 0xFE,
  0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x81, 0xE1, 0xF0, 0x3C,
  0x3C, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8,
  0xF0, 0x1F, 0x1E, 0x03, 0xE7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1E, 0x03, 0xE3,
  0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x78, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0,
  0x7F, 0x0E, 0x03, 0xE0, 0x10, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x0F, 0xE1, 0xF0, 0xFF, 0x0F, 0x87, 0xF8, 0x78, 0x3F, 0xC3, 0xC0, 0x3E,
  0x3E, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC1, 0xE0,
  0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xF0,
  0x3C, 0x07, 0x81, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xE0, 0x78,
  0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1F,
  0x03, 0xC0, 0x78, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01,
  0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x78, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x1F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xC0, 0x00, 0x03,
  0xC0, 0xF8, 0x1E, 0x07, 0x80, 0xF0, 0x7C, 0x0F, 0x87, 0xC0, 0x78, 0x3C,
  0x03, 0xC3, 0xE0, 0x1E, 0x3E, 0x01, 0xF1, 0xE0, 0x0F, 0x9F, 0x00, 0x79,
  0xF0, 0x03, 0xDF, 0x00, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0x9E,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0xC0, 0x1E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F,
  0x07, 0x80, 0x78, 0x3C, 0x03, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C,
  0x0F, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x1F,
  0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3B, 0xC0, 0xFF, 0x07, 0xBC, 0x1F, 0xF0, 0x77, 0xC1, 0xE7, 0x0F,
  0x78, 0x1E, 0x70, 0xF7, 0x81, 0xE7, 0x1E, 0x78, 0x1E, 0x71, 0xE7, 0x83,
  0xC7, 0x3C, 0xF8, 0x3C, 0x73, 0xCF, 0x03, 0xC7, 0x38, 0xF0, 0x3C, 0x77,
  0x8F, 0x03, 0xC7, 0xF0, 0xF0, 0x78, 0x7F, 0x1F, 0x07, 0x87, 0xE1, 0xE0,
  0x78, 0x7E, 0x1E, 0x07, 0x87, 0xE1, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x07,
  0xC3, 0xC0, 0xF0, 0x78, 0x3C, 0x00, 0x03, 0xE0, 0x1E, 0x07, 0xC0, 0x3C,
  0x0F, 0x80, 0xF0, 0x3F, 0x01, 0xE0, 0x7F, 0x03, 0xC0, 0xFE, 0x07, 0x81,
  0xFC, 0x1F, 0x07, 0xF8, 0x3C, 0x0F, 0x70, 0x78, 0x1E, 0xE0, 0xF0, 0x3D,
  0xE1, 0xE0, 0x7B, 0xC7, 0xC1, 0xE7, 0x8F, 0x03, 0xCF, 0x1E, 0x07, 0x8E,
  0x3C, 0x0F, 0x1C, 0x78, 0x1E, 0x3D, 0xE0, 0x78, 0x7B, 0xC0, 0xF0, 0xF7,
  0x81, 0xE1, 0xEF, 0x03, 0xC1, 0xDE, 0x07, 0x83, 0xF8, 0x1E, 0x07, 0xF0,
  0x3C, 0x0F, 0xE0, 0x78, 0x1F, 0xC0, 0xF0, 0x3F, 0x83, 0xE0, 0x3E, 0x07,
  0x80, 0x7C, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xE3, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF1,
  0xF0, 0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1E,
  0x7C, 0x01, 0xE7, 0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x03,
  0xE7, 0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x80,
  0xF8, 0xF8, 0x0F, 0x87, 0x81, 0xF0, 0x7C, 0x3E, 0x07, 0xFF, 0xE0, 0x3F,
  0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x7C, 0xFC, 0x0F, 0x07, 0xC1, 0xE0, 0xF8,
  0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x07, 0x83, 0xE1,
  0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x07,
  0xFF, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0xFE, 0x07, 0xE3, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF1, 0xF0, 0x1F,
  0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1E, 0x7C, 0x01,
  0xE7, 0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x03, 0xE7, 0x80,
  0x3C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0xF8,
  0x0F, 0x87, 0x81, 0xF0, 0x7C, 0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0x8F, 0xC1, 0xE1, 0xF0,
  0x78, 0x3C, 0x3E, 0x0F, 0x0F, 0x83, 0xC3, 0xC1, 0xF0, 0xF0, 0x7C, 0x3C,
  0x1E, 0x1F, 0x0F, 0x87, 0xC7, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xBE, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1F, 0x07,
  0xC7, 0xC1, 0xE1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x83, 0xE3, 0xE0,
  0xF8, 0xF0, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x7E, 0x38, 0x0F, 0x81, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x82, 0x01,
  0xF0, 0x60, 0x7C, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFC,
  0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x78,
  0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0xF0, 0x1E, 0x0F,
  0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xE0, 0x3C, 0x1E, 0x03, 0xC3,
  0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3C, 0x07, 0x83, 0xC0, 0x78,
  0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x83, 0xE0, 0xFC, 0x7E, 0x07, 0xFF,
  0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xDE, 0x03, 0xEF, 0x01, 0xE7, 0x81, 0xF3, 0xC0, 0xF1,
  0xE0, 0x78, 0xF0, 0x7C, 0x78, 0x3C, 0x3C, 0x3E, 0x1E, 0x1E, 0x0F, 0x1F,
  0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE7, 0xC0, 0xF3, 0xC0, 0x7B, 0xE0, 0x3D,
  0xE0, 0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x0F, 0x01, 0xF7, 0x80, 0xF0, 0x1E, 0xF8, 0x1F, 0x03, 0xEF, 0x81, 0xF0,
  0x3C, 0xF8, 0x1F, 0x03, 0xCF, 0x83, 0xF0, 0x7C, 0xF8, 0x3F, 0x07, 0x8F,
  0x87, 0xF0, 0x78, 0xF0, 0x7F, 0x0F, 0x0F, 0x07, 0xF0, 0xF0, 0xF0, 0xFF,
  0x1F, 0x0F, 0x0E, 0xF1, 0xE0, 0xF1, 0xEF, 0x1E, 0x0F, 0x1E, 0xF3, 0xE0,
  0xF1, 0xCE, 0x3C, 0x0F, 0x3C, 0xE7, 0xC0, 0xF3, 0xCE, 0x78, 0x0F, 0x78,
  0xE7, 0x80, 0xF7, 0x8E, 0xF8, 0x0F, 0x70, 0xEF, 0x00, 0xFF, 0x0E, 0xF0,
  0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC,
  0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x81, 0xF8,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0x78,
  0x3C, 0x03, 0xC3, 0xE0, 0x1E, 0x1E, 0x00, 0xF1, 0xF0, 0x07, 0x8F, 0x00,
  0x3E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7B, 0xC0,
  0x07, 0xDF, 0x00, 0x3C, 0xF8, 0x03, 0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xE0,
  0xF0, 0x1F, 0x07, 0x80, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x0F,
  0x78, 0x1F, 0x78, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x7C, 0x78, 0x78,
  0x7C, 0xF8, 0x7C, 0xF0, 0x3D, 0xF0, 0x3D, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0xF0, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xF0,
  0xF0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x38,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x0F, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xB8, 0x07, 0x9E, 0x03, 0x8F, 0x03,
  0xC7, 0x83, 0xC1, 0xC1, 0xE0, 0xF1, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x0E,
  0xF0, 0x07, 0x80, 0x7F, 0xFB, 0xFF, 0xFF, 0xFE, 0xFB, 0xE7, 0x9F, 0x3C,
  0x71, 0xC0, 0x03, 0xE7, 0x83, 0xFB, 0xC3, 0xFD, 0xE3, 0xFF, 0xE1, 0xF1,
  0xF1, 0xF0, 0xF8, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1E, 0x3C, 0x0F, 0x3E,
  0x07, 0x9F, 0x07, 0xCF, 0x83, 0xC7, 0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xF8,
  0xF0, 0x7C, 0x7C, 0x7C, 0x3E, 0x7E, 0x1F, 0xFF, 0x07, 0xF7, 0x81, 0xF3,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xBE, 0x07, 0xBF, 0x83, 0xFF,
  0xC1, 0xFF, 0xF1, 0xF8, 0xF8, 0xF8, 0x3C, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E,
  0x0F, 0x9F, 0x07, 0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF9,
  0xF0, 0x7C, 0xF8, 0x3C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1F, 0x9F, 0x1F, 0xFF,
  0x0F, 0x7F, 0x07, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0x87, 0xFE,
  0x1F, 0x08, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0,
  0x8F, 0xDC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x03, 0xE7, 0x80, 0xFE, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF,
  0x81, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0xC3, 0xE0, 0xF0, 0x78, 0x1E,
  0x0F, 0x03, 0xC3, 0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0x83, 0xC1, 0xE0, 0x78,
  0x3C, 0x0F, 0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x1F, 0x03, 0xE7, 0xE0,
  0x7F, 0xFC, 0x07, 0xF7, 0x80, 0x7C, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0xF8,
  0x3F, 0xF0, 0xF9, 0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0xBC, 0x1E, 0x78,
  0x7C, 0xFF, 0xF3, 0xFF, 0xC7, 0xFE, 0x0F, 0xC0, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0xC3, 0xFF, 0x87, 0xFF, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0x20, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x9F, 0x00, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00, 0xF9, 0xE0,
  0x3F, 0xBC, 0x0F, 0xF7, 0x83, 0xFF, 0xE0, 0x7C, 0x7C, 0x1F, 0x0F, 0x83,
  0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0x83, 0xC0, 0xF0, 0xF8, 0x1E, 0x1F,
  0x07, 0xC3, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x3C,
  0x1F, 0x07, 0xC7, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x82, 0x03,
  0xE0, 0x70, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x20,
  0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xBE, 0x07, 0xBF, 0x83, 0xFF,
  0xC1, 0xFF, 0xF0, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x3C, 0x3C, 0x1E, 0x1E,
  0x0F, 0x1F, 0x07, 0x8F, 0x87, 0xC7, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF1,
  0xF0, 0x78, 0xF8, 0x7C, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x1F, 0x0F,
  0x8F, 0x07, 0xC7, 0x83, 0xC0, 0x01, 0xC0, 0xF0, 0x7C, 0x1F, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0,
  0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x78,
  0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C,
  0x05, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x3C,
  0x7C, 0x0F, 0x3E, 0x07, 0x8F, 0x01, 0xE7, 0x80, 0x7B, 0xE0, 0x1F, 0xF0,
  0x0F, 0x78, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xBC, 0x07,
  0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF8, 0x1E, 0x3E, 0x07, 0x87, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x00, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0,
  0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x00,
  0x0F, 0x3E, 0x1E, 0x07, 0xBF, 0xBF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0xF8, 0xFC, 0xF8, 0xF8, 0x7C, 0x3C, 0x7C, 0x3C, 0x1E, 0x3C, 0x1E,
  0x1F, 0x1E, 0x0F, 0x0F, 0x1F, 0x0F, 0x07, 0x8F, 0x07, 0x83, 0xC7, 0x83,
  0xC1, 0xE3, 0xC1, 0xE1, 0xF1, 0xE1, 0xF0, 0xF1, 0xF0, 0xF0, 0x78, 0xF0,
  0x78, 0x3C, 0x78, 0x3C, 0x1E, 0x3C, 0x1E, 0x1E, 0x1E, 0x1F, 0x0F, 0x1F,
  0x0F, 0x07, 0x8F, 0x07, 0x83, 0xC7, 0x83, 0xC3, 0xE0, 0x0F, 0x3E, 0x07,
  0xBF, 0x83, 0xBF, 0xC1, 0xFF, 0xF0, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x3C,
  0x3C, 0x1E, 0x1E, 0x0F, 0x1F, 0x07, 0x8F, 0x87, 0xC7, 0x83, 0xC3, 0xC1,
  0xE1, 0xE0, 0xF1, 0xF0, 0x78, 0xF0, 0x7C, 0x78, 0x3C, 0x3C, 0x1E, 0x1E,
  0x0F, 0x1F, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xC0, 0x01, 0xF0, 0x0F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xF1, 0xE1, 0xE7, 0xC3, 0xCF, 0x07, 0xBE, 0x0F, 0x78,
  0x1E, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0x78, 0x3E, 0xF0, 0x79, 0xF1, 0xF3, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x03,
  0xF0, 0x00, 0x03, 0xCF, 0x80, 0x7B, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x3E, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE1,
  0xF0, 0x7C, 0x3C, 0x0F, 0x87, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x87,
  0xC1, 0xF0, 0xF8, 0x3C, 0x1F, 0x0F, 0x83, 0xE1, 0xE0, 0x7E, 0xFC, 0x1E,
  0xFF, 0x03, 0xDF, 0xC0, 0x79, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE7, 0x83, 0xFB, 0xC3, 0xFD, 0xE3, 0xFF,
  0xE1, 0xE1, 0xF1, 0xF0, 0xF8, 0xF0, 0x7C, 0xF8, 0x3C, 0x78, 0x1E, 0x3C,
  0x0F, 0x3E, 0x07, 0x9F, 0x03, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1,
  0xE0, 0xF8, 0xF0, 0x7C, 0x78, 0x7C, 0x3E, 0x7E, 0x1F, 0xFF, 0x07, 0xF7,
  0x81, 0xF7, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x0F, 0x3C, 0x3D, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0xC7, 0xFE, 0x3E, 0x08,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF2, 0x07, 0x8F, 0xFE,
  0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x80,
  0xFE, 0x7F, 0xDF, 0xFB, 0xFE, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0,
  0x3E, 0x47, 0xF0, 0x7E, 0x0F, 0xC0, 0x1F, 0x0F, 0x8F, 0x07, 0x87, 0x83,
  0xC3, 0xC1, 0xE3, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C,
  0x1E, 0x3E, 0x1F, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE3,
  0xE1, 0xF1, 0xE0, 0xF0, 0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0xFE, 0x1F, 0xFF,
  0x0F, 0xF7, 0x03, 0xF3, 0x80, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xF7, 0xC3,
  0xE7, 0x87, 0x8E, 0x0F, 0x1C, 0x3C, 0x38, 0x78, 0x71, 0xE0, 0xE3, 0xC1,
  0xC7, 0x83, 0x9E, 0x07, 0x3C, 0x0E, 0xF0, 0x1D, 0xE0, 0x3B, 0x80, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x78,
  0x3C, 0x1E, 0xF0, 0xF8, 0x3D, 0xE1, 0xF0, 0xFF, 0xC7, 0xE1, 0xEF, 0x0F,
  0xC3, 0xDE, 0x1F, 0x8F, 0x3C, 0x7F, 0x1E, 0x78, 0xEE, 0x3C, 0xF3, 0xDC,
  0xF1, 0xE7, 0xB9, 0xE3, 0xCE, 0xF7, 0x87, 0xBD, 0xEF, 0x0F, 0x73, 0xDE,
  0x1E, 0xE7, 0xF8, 0x3F, 0xCF, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81,
  0xF8, 0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F,
  0x07, 0xC0, 0x00, 0x07, 0x83, 0xE0, 0xF8, 0x78, 0x1F, 0x1F, 0x01, 0xE7,
  0xC0, 0x3C, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0x80, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xCF, 0x80, 0xF8, 0xF0,
  0x1E, 0x1E, 0x07, 0x83, 0xC1, 0xF0, 0x7C, 0x00, 0x03, 0xC0, 0xF0, 0x3C,
  0x1F, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03,
  0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xCF, 0x80, 0x3C, 0xF0, 0x03, 0xCF, 0x00,
  0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0,
  0x00, 0x06, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0xFE, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x0F, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 11, 29, 10, 0, -29 },
  { 41, 13, 11, 15, 4, -29 },
  { 59, 19, 29, 18, 0, -29 },
  { 128, 17, 32, 16, 0, -30 },
  { 196, 24, 29, 27, 2, -29 },
  { 283, 19, 29, 19, 0, -29 },
  { 352, 6, 11, 9, 4, -29 },
  { 361, 13, 35, 11, 1, -29 },
  { 418, 13, 35, 11, -3, -29 },
  { 475, 14, 16, 16, 3, -31 },
  { 503, 15, 19, 18, 2, -24 },
  { 539, 8, 10, 9, -2, -5 },
  { 549, 9, 4, 11, 1, -13 },
  { 554, 6, 6, 9, 0, -6 },
  { 559, 20, 29, 14, -2, -29 },
  { 632, 16, 29, 16, 1, -29 },
  { 690, 12, 29, 17, 4, -29 },
  { 734, 18, 29, 16, -1, -29 },
  { 800, 18, 29, 16, -1, -29 },
  { 866, 18, 29, 17, -1, -29 },
  { 932, 17, 29, 16, 0, -29 },
  { 994, 17, 29, 16, 1, -29 },
  { 1056, 18, 29, 16, 1, -29 },
  { 1122, 17, 29, 16, 0, -29 },
  { 1184, 17, 29, 16, 0, -29 },
  { 1246, 9, 22, 9, 0, -22 },
  { 1271, 11, 27, 9, -2, -22 },
  { 1309, 15, 19, 18, 2, -24 },
  { 1345, 15, 12, 18, 2, -20 },
  { 1368, 15, 19, 18, 2, -24 },
  { 1404, 13, 29, 13, 1, -29 },
  { 1452, 24, 32, 25, 1, -29 },
  { 1548, 18, 29, 18, -3, -29 },
  { 1614, 19, 29, 18, 0, -29 },
  { 1683, 19, 29, 17, 1, -29 },
  { 1752, 19, 29, 20, 0, -29 },
  { 1821, 17, 29, 15, 0, -29 },
  { 1883, 17, 29, 15, 0, -29 },
  { 1945, 21, 29, 21, 1, -29 },
  { 2022, 22, 29, 21, 0, -29 },
  { 2102, 17, 29, 12, -2, -29 },
  { 2164, 17, 37, 9, -6, -29 },
  { 2243, 21, 29, 18, 0, -29 },
  { 2320, 12, 29, 15, 0, -29 },
  { 2364, 28, 29, 27, 0, -29 },
  { 2466, 23, 29, 22, 0, -29 },
  { 2550, 20, 29, 21, 1, -29 },
  { 2623, 19, 29, 18, 0, -29 },
  { 2692, 20, 36, 21, 1, -29 },
  { 2782, 18, 29, 18, 0, -29 },
  { 2848, 19, 29, 16, -1, -29 },
  { 2917, 15, 29, 15, 3, -29 },
  { 2972, 20, 29, 20, 1, -29 },
  { 3045, 17, 29, 18, 4, -29 },
  { 3107, 28, 29, 27, 3, -29 },
  { 3209, 21, 29, 17, -2, -29 },
  { 3286, 16, 29, 16, 3, -29 },
  { 3344, 19, 29, 15, -2, -29 },
  { 3413, 15, 35, 11, -1, -29 },
  { 3479, 8, 29, 14, 4, -29 },
  { 3508, 16, 35, 11, -3, -29 },
  { 3578, 17, 17, 17, 0, -29 },
  { 3615, 13, 3, 13, -4, 3 },
  { 3620, 6, 7, 11, 6, -31 },
  { 3626, 17, 22, 18, 1, -22 },
  { 3673, 17, 30, 18, 0, -30 },
  { 3737, 14, 22, 14, 1, -22 },
  { 3776, 19, 30, 18, 1, -30 },
  { 3848, 15, 22, 16, 1, -22 },
  { 3890, 20, 41, 10, -5, -31 },
  { 3993, 19, 32, 18, -1, -22 },
  { 4069, 17, 30, 18, 0, -30 },
  { 4133, 10, 30, 9, 0, -30 },
  { 4171, 15, 40, 9, -5, -30 },
  { 4246, 18, 30, 16, 0, -30 },
  { 4314, 11, 30, 9, 0, -30 },
  { 4356, 25, 22, 26, 0, -22 },
  { 4425, 17, 22, 18, 0, -22 },
  { 4472, 15, 22, 17, 1, -22 },
  { 4514, 19, 31, 18, -2, -22 },
  { 4588, 17, 32, 18, 1, -22 },
  { 4656, 14, 22, 12, 0, -22 },
  { 4695, 14, 22, 14, 0, -22 },
  { 4734, 11, 26, 11, 1, -26 },
  { 4770, 17, 22, 17, 1, -22 },
  { 4817, 15, 22, 15, 2, -22 },
  { 4859, 23, 22, 23, 2, -22 },
  { 4923, 19, 22, 15, -2, -22 },
  { 4976, 20, 32, 15, -3, -22 },
  { 5056, 16, 22, 13, -2, -22 },
  { 5100, 15, 35, 13, 1, -29 },
  { 5166, 4, 40, 15, 5, -31 },
  { 5186, 15, 35, 13, -2, -29 },
  { 5252, 15, 6, 18, 2, -17 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC40PT7B_H_
