#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC62PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0x00,
  0x00, 0x3F, 0x87, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xE3, 0xF0, 0xFE, 0x3F,
  0x0F, 0xE3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF0,
  0xFC, 0x1F, 0x0F, 0x83, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07,
  0xC1, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01,
  0xF0, 0x78, 0x00, 0x0F, 0x83, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x7C, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E,
  0x0F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFE, 0xE3, 0xC0, 0x3F, 0x9C, 0x10, 0x07, 0xE3,
  0x80, 0x00, 0xFC, 0x60, 0x00, 0x3F, 0x8C, 0x00, 0x07, 0xF3, 0x80, 0x00,
  0xFE, 0x70, 0x00, 0x0F, 0xEE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1B, 0xFC, 0x00, 0x07, 0x3F, 0x80, 0x00,
  0xE7, 0xF0, 0x00, 0x1C, 0xFE, 0x00, 0x03, 0x1F, 0xC0, 0x00, 0x63, 0xF8,
  0x20, 0x1C, 0x7E, 0x07, 0x03, 0x9F, 0xC0, 0xF0, 0x77, 0xF8, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x80,
  0x0F, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x0F, 0xFE, 0x00,
  0x7C, 0x00, 0xFF, 0xF8, 0x07, 0xE0, 0x07, 0xC7, 0xC0, 0x3E, 0x00, 0x7C,
  0x3E, 0x03, 0xF0, 0x03, 0xE1, 0xF0, 0x1F, 0x00, 0x3E, 0x0F, 0x81, 0xF8,
  0x01, 0xF0, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0xF8, 0x1F,
  0x07, 0xC0, 0x07, 0xC1, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x83, 0xE0, 0x01,
  0xF0, 0x7C, 0x3E, 0x00, 0x0F, 0x83, 0xE1, 0xF0, 0x00, 0xF8, 0x1F, 0x1F,
  0x00, 0x07, 0xC1, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x8F, 0x83, 0xF1, 0xF0,
  0x7C, 0xFC, 0x7F, 0xCF, 0x87, 0xC7, 0xC7, 0xFF, 0x7C, 0x3E, 0x7E, 0x3F,
  0xFB, 0xE3, 0xE3, 0xE3, 0xFF, 0xDF, 0xFF, 0x3F, 0x3E, 0x3E, 0x7F, 0xF1,
  0xF1, 0xF0, 0xFB, 0xFF, 0x1F, 0x1F, 0x07, 0xCF, 0xF0, 0xF8, 0xF8, 0x3E,
  0x1E, 0x0F, 0x87, 0x83, 0xF0, 0x00, 0x7C, 0x7C, 0x1F, 0x00, 0x07, 0xC3,
  0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x3E, 0x00,
  0x1F, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x7C, 0x1F, 0x80, 0x1F, 0x83, 0xE0,
  0xF8, 0x00, 0xF8, 0x1F, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x3E, 0x00, 0x7C,
  0x07, 0xC3, 0xE0, 0x07, 0xE0, 0x3E, 0x1F, 0x00, 0x3E, 0x01, 0xF1, 0xF0,
  0x03, 0xE0, 0x0F, 0x9F, 0x80, 0x1F, 0x00, 0x7F, 0xF8, 0x01, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0x9F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x1F,
  0x9F, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x3F, 0x07, 0xFF, 0xC3, 0xF8, 0x7F,
  0xFE, 0x1F, 0xC7, 0xF3, 0xF8, 0xFC, 0x7F, 0x1F, 0xCF, 0xE3, 0xF8, 0xFE,
  0x7E, 0x3F, 0x83, 0xFF, 0xF1, 0xFC, 0x1F, 0xFF, 0x0F, 0xC0, 0xFF, 0xF8,
  0xFE, 0x03, 0xFF, 0x87, 0xF0, 0x1F, 0xFC, 0x3F, 0x80, 0xFF, 0xC1, 0xFC,
  0x03, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x01, 0xFF, 0x03, 0xF8, 0x1F,
  0xFC, 0x1F, 0xF3, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xCF, 0xE0, 0x7F, 0xFC, 0x7F, 0x80, 0xFF, 0x83, 0xFC, 0x00,
  0xC0, 0x00, 0x00, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF1,
  0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x20, 0x7E, 0x00, 0xE1, 0xF8,
  0x03, 0xE7, 0xC0, 0x1F, 0xDF, 0x0E, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xDF, 0x80, 0xFE, 0x7E, 0x07, 0xF8, 0xFC,
  0x07, 0xC3, 0xF0, 0x0E, 0x0F, 0xE0, 0x10, 0x1E, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F,
  0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80,
  0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF,
  0xFF, 0x00, 0x04, 0x1F, 0x9F, 0xEF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFE, 0x7E,
  0x08, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFD,
  0xFC, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F,
  0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x8F,
  0xE0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8,
  0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F,
  0x1F, 0xC0, 0x3F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F,
  0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0,
  0x7F, 0x01, 0xF8, 0x7F, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F,
  0xEF, 0xCF, 0xF3, 0xF1, 0xF9, 0xFC, 0x7C, 0x7F, 0x0E, 0x1F, 0x81, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x07, 0xC0, 0xFF, 0x00, 0x78,
  0x07, 0xF0, 0x02, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0x0F, 0xF8, 0x03, 0x80, 0xFF, 0x00,
  0x40, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC1, 0x00, 0x07, 0xF8, 0x38, 0x03, 0xFE, 0x07, 0xF3, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xEF,
  0xC0, 0x00, 0x79, 0xF8, 0x00, 0x1F, 0x7F, 0x00, 0x03, 0xCF, 0xC0, 0x00,
  0xF9, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0x8F, 0xE0, 0x01, 0xF1, 0xFC,
  0x00, 0x7C, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xFC, 0x00, 0xF8,
  0x3F, 0x80, 0x1F, 0x07, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x1F, 0x80,
  0x3E, 0x07, 0xF0, 0x0F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7C, 0x03,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE7,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xE3, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x08, 0x00, 0x7F, 0x81, 0xC0, 0x3F, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xF0, 0x20,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x7F, 0x7F, 0xE0, 0x0F, 0xDF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFE, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x7F, 0xC0, 0xFE,
  0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0,
  0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xE0,
  0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x3F, 0x01,
  0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0,
  0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0xC1, 0xFC, 0x03,
  0xF8, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0x8F, 0xE0,
  0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x1F, 0xC1, 0xFC,
  0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x3F,
  0xC7, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xC0,
  0x7F, 0x87, 0xF8, 0x3F, 0xE1, 0xFE, 0x1F, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xF7, 0xF0, 0x0F, 0xF9, 0xF8,
  0x01, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03,
  0xC7, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0xFC, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x03, 0xF0, 0x1F, 0xC0,
  0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x01, 0xF8, 0x01, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x1E, 0x0F,
  0xE0, 0xC0, 0x7F, 0x04, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xF7, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x07, 0x81, 0xF0, 0x1F, 0xFC, 0x3C,
  0x1F, 0x03, 0xFF, 0xE1, 0xE0, 0xF0, 0x3F, 0xFE, 0x0F, 0x0F, 0x81, 0xF1,
  0xF0, 0x78, 0x7C, 0x1F, 0x0F, 0x83, 0xC7, 0xC1, 0xF0, 0x7C, 0x1E, 0x3E,
  0x0F, 0x83, 0xE1, 0xF1, 0xE0, 0xF8, 0x3E, 0x0F, 0x9F, 0x07, 0xC1, 0xF0,
  0x7C, 0xF8, 0x7C, 0x0F, 0x83, 0xE7, 0xC3, 0xE0, 0x7C, 0x1E, 0x3C, 0x1F,
  0x07, 0xC0, 0xF3, 0xE0, 0xF0, 0x3E, 0x0F, 0x9F, 0x0F, 0x81, 0xF0, 0x78,
  0xF8, 0x7C, 0x0F, 0x83, 0xC7, 0xC3, 0xE0, 0xF8, 0x3E, 0x3C, 0x1F, 0x07,
  0xC1, 0xE1, 0xE0, 0xF8, 0x7E, 0x0F, 0x0F, 0x07, 0xC3, 0xF0, 0xF0, 0xF8,
  0x3E, 0x3F, 0x8F, 0x87, 0xC1, 0xFB, 0xFC, 0xF8, 0x3E, 0x0F, 0xFD, 0xFF,
  0x81, 0xF0, 0x3F, 0xEF, 0xFC, 0x0F, 0x81, 0xFE, 0x3F, 0xC0, 0x3C, 0x03,
  0xC0, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x30, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x1F, 0xBE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x01,
  0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x87,
  0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F,
  0x3F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF7, 0xF0,
  0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0x1F, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x1F,
  0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0xE0, 0x3F,
  0x81, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x00,
  0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC,
  0x0F, 0xE0, 0x1F, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x3F,
  0x81, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xE7, 0xC0, 0x1F, 0xF0, 0x08, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x60, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xE1, 0xFF, 0x80, 0x3F, 0x81, 0xFE,
  0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03,
  0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x07,
  0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xFC,
  0x01, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x01,
  0xFE, 0x03, 0xF8, 0x0F, 0xF8, 0x0F, 0xE0, 0x7F, 0xC0, 0x7F, 0x03, 0xFE,
  0x01, 0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xF8, 0x7E, 0x00, 0xFF, 0xC0, 0x1C, 0x01, 0xFE, 0x00, 0x08,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x1F, 0xFE, 0x1F, 0xC0, 0x3F, 0xFC, 0x3F, 0x80, 0x7F, 0xF8, 0x7F, 0x01,
  0xFF, 0xE0, 0xFE, 0x03, 0xFF, 0xC3, 0xFC, 0x07, 0xFF, 0x87, 0xF8, 0x00,
  0x7F, 0x0F, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x07,
  0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x3F,
  0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8,
  0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0,
  0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x7F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0,
  0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xF8,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x01, 0xFB, 0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC1, 0xFE,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x1F,
  0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xE0,
  0x0F, 0xBF, 0x80, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x1F,
  0xBF, 0x00, 0x3F, 0x7E, 0x03, 0xF7, 0xF0, 0x07, 0xF7, 0xE0, 0x3F, 0x7F,
  0x00, 0x7E, 0x7E, 0x07, 0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x0F, 0xC7, 0xE0, 0x0F, 0xE7, 0xE0, 0xFC, 0xFE, 0x00, 0xFE,
  0x7E, 0x0F, 0x8F, 0xE0, 0x0F, 0xC7, 0xE1, 0xF8, 0xFE, 0x00, 0xFC, 0x7E,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE3, 0xF1, 0xFC, 0x01, 0xFC, 0x7E, 0x3F,
  0x1F, 0xC0, 0x1F, 0xC3, 0xE7, 0xE1, 0xFC, 0x01, 0xF8, 0x3E, 0x7E, 0x1F,
  0x80, 0x1F, 0x83, 0xEF, 0xC1, 0xF8, 0x01, 0xF8, 0x3E, 0xFC, 0x3F, 0x80,
  0x3F, 0x83, 0xEF, 0x83, 0xF8, 0x03, 0xF0, 0x3F, 0xF8, 0x3F, 0x80, 0x3F,
  0x03, 0xFF, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0xF0, 0x3F, 0x00, 0x3F, 0x03,
  0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0x00, 0x7E, 0x03, 0xFE,
  0x07, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xFC, 0x07,
  0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x0F,
  0xF0, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0xE0, 0x07, 0xF0,
  0x0F, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xF0, 0x03,
  0xF0, 0x07, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xC0, 0x3F, 0xFC,
  0x03, 0xF0, 0x07, 0xFF, 0x80, 0x7E, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x1F,
  0xFE, 0x03, 0xF8, 0x07, 0xEF, 0xC0, 0x7F, 0x00, 0xFC, 0xF8, 0x0F, 0xC0,
  0x1F, 0x9F, 0x81, 0xF8, 0x03, 0xF3, 0xF0, 0x7F, 0x00, 0x7E, 0x7E, 0x0F,
  0xE0, 0x1F, 0xCF, 0xC1, 0xF8, 0x03, 0xF1, 0xF8, 0x3F, 0x00, 0x7E, 0x1F,
  0x07, 0xE0, 0x0F, 0xC3, 0xF1, 0xFC, 0x03, 0xF8, 0x7E, 0x3F, 0x80, 0x7F,
  0x0F, 0xC7, 0xE0, 0x0F, 0xC1, 0xF8, 0xFC, 0x01, 0xF8, 0x3F, 0x1F, 0x80,
  0x3F, 0x03, 0xE7, 0xF0, 0x0F, 0xE0, 0x7E, 0xFE, 0x01, 0xFC, 0x0F, 0xDF,
  0x80, 0x3F, 0x01, 0xFB, 0xF0, 0x07, 0xE0, 0x3F, 0x7E, 0x00, 0xFC, 0x07,
  0xEF, 0xC0, 0x3F, 0x80, 0x7F, 0xF8, 0x07, 0xE0, 0x0F, 0xFE, 0x00, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0x00,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0xF8, 0x03, 0xF0, 0x01, 0xFF,
  0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x07, 0xFC, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0x81,
  0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F,
  0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF1,
  0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0xFF,
  0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFF, 0x3F, 0x80,
  0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0xFE, 0x7F, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F,
  0x3F, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0x8F,
  0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00,
  0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xF8,
  0x3F, 0xE0, 0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x81,
  0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0x81, 0xFE, 0x03, 0xFC,
  0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xC1, 0xFC, 0x00,
  0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x03, 0xF9, 0xFE,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00,
  0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x01,
  0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFE,
  0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F,
  0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x01, 0xFC,
  0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x0F,
  0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03,
  0xF8, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x01,
  0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x07, 0xFC, 0x07, 0xF3, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00,
  0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x83, 0xF8, 0x01, 0xF8,
  0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8,
  0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x1C,
  0x01, 0xFE, 0x00, 0x80, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x40, 0x03, 0xFC, 0x06, 0x00, 0x7F, 0xC0, 0xFC, 0x0F, 0xF8,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8,
  0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80,
  0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07,
  0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80,
  0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01,
  0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFE,
  0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0,
  0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0x7E, 0x00,
  0x1F, 0xC7, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x07, 0xF0,
  0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0,
  0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8,
  0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E,
  0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07,
  0xE3, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7E,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xEF,
  0xE0, 0x03, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0x01,
  0xF8, 0x7F, 0x00, 0xFF, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xF0, 0x0F, 0xE1,
  0xFC, 0x07, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0xFF, 0xC0, 0x7F, 0x07, 0xF0,
  0x1F, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFF,
  0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xFF, 0x83,
  0xF8, 0x0F, 0xC0, 0xFB, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x7E, 0x1F, 0xC0,
  0x3F, 0x07, 0xCF, 0xC3, 0xF8, 0x07, 0xE1, 0xF9, 0xF8, 0x7E, 0x00, 0xFC,
  0x3F, 0x3F, 0x1F, 0xC0, 0x1F, 0x87, 0xC7, 0xE3, 0xF8, 0x03, 0xF1, 0xF8,
  0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x1F, 0x1F, 0xC0, 0x0F, 0xCF, 0xC3, 0xE3,
  0xF0, 0x01, 0xF9, 0xF8, 0x7C, 0xFE, 0x00, 0x3F, 0x3E, 0x0F, 0x9F, 0xC0,
  0x07, 0xEF, 0xC1, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x3E, 0xFE, 0x00, 0x1F,
  0xBE, 0x07, 0xDF, 0x80, 0x03, 0xFF, 0xC0, 0xFB, 0xF0, 0x00, 0x7F, 0xF0,
  0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00,
  0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xC7, 0xF0,
  0x0F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x7F,
  0x03, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xFC, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x7F, 0x00,
  0x3F, 0xBF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x04, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF9,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F,
  0xC0, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01,
  0xF9, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0xFF, 0x1F, 0xC7, 0xF0, 0xFE,
  0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x87, 0xE0, 0x0F,
  0xF8, 0xFC, 0x03, 0xFF, 0xBF, 0x80, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x81, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0,
  0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3,
  0xF8, 0x03, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03,
  0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F,
  0x80, 0x7F, 0x07, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8,
  0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x07, 0xF9, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xDF, 0x80, 0x3F, 0xF3, 0xF0, 0x03, 0xFC,
  0x7E, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x9F, 0xF0, 0x0F, 0xEF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0x07,
  0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F,
  0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00,
  0x7F, 0x0F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x7E,
  0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F,
  0xE1, 0xFE, 0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x1F, 0xF1, 0xFE, 0x07, 0xFF,
  0xFF, 0x83, 0xF7, 0xFF, 0xC0, 0xFD, 0xFF, 0xE0, 0x3F, 0x3F, 0xF0, 0x0F,
  0x87, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F,
  0x81, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x40, 0x7F,
  0xCF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xFC, 0xFE, 0x00, 0x3F, 0xFB, 0xF0, 0x01, 0xFF, 0xEF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xF8, 0x07,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8,
  0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0xFE,
  0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFC, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0x7C, 0x00, 0x3F, 0xF9, 0xF0, 0x00, 0xFF, 0xC7, 0xC0, 0x01,
  0xFE, 0x1F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0x1F,
  0xC1, 0xFC, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC,
  0x7E, 0x01, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x8F,
  0xCF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF,
  0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x01, 0x07, 0xF8, 0x0C, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFE, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x23, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0xFF, 0x8F,
  0xC0, 0x0F, 0xFE, 0xFE, 0x00, 0xFF, 0xF7, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0x83, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x03,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F,
  0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x01,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x87, 0xFC, 0x03, 0xFE,
  0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xDF,
  0x80, 0x0F, 0xFD, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x30, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x04, 0x00, 0x7F,
  0x80, 0x3C, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x3F,
  0x80, 0x1F, 0x9F, 0xF0, 0x0F, 0xEF, 0xFE, 0x03, 0xF7, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0xC1,
  0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x1F,
  0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xC0,
  0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F,
  0x80, 0x7F, 0x07, 0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF8,
  0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xC1, 0xFC, 0x07,
  0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0x83, 0xF8,
  0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x0C, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x87, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFC,
  0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x3F,
  0x0F, 0xE0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE3, 0xF8,
  0x00, 0x7E, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFE, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x0F,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00,
  0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01,
  0xF0, 0xFE, 0x07, 0xF0, 0x03, 0xE7, 0xFE, 0x1F, 0xF0, 0x0F, 0xDF, 0xFE,
  0x7F, 0xF0, 0x1F, 0xFF, 0xFD, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x0F, 0xFC, 0x3F, 0x83, 0xFC, 0x1F,
  0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x81, 0xFC,
  0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0xFE, 0x03,
  0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0x7F,
  0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x3F, 0x80,
  0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0,
  0x3F, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x07,
  0xE0, 0xFE, 0x03, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xF0, 0x1F, 0x83, 0xF8,
  0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x7F, 0x01,
  0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0xFE,
  0x03, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0xFE,
  0x00, 0x7C, 0x7F, 0xC0, 0x3F, 0x3F, 0xF8, 0x0F, 0xDF, 0xFE, 0x03, 0xEF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0x7F, 0x07,
  0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x1F, 0x80, 0x7E,
  0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x00,
  0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7E,
  0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x0F, 0xE0,
  0xFE, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F,
  0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xE0,
  0x1F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x3F, 0x80, 0x3F,
  0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC,
  0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x07, 0xF0,
  0x7F, 0x9F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3E, 0x0F,
  0xC0, 0x01, 0xF1, 0xFF, 0x00, 0x1F, 0x9F, 0xFC, 0x00, 0xFD, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xF7, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x1F,
  0xE0, 0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC,
  0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F,
  0xC0, 0x1F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00,
  0x7F, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F,
  0xF0, 0xFF, 0x00, 0xFF, 0xCF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x03, 0xFB, 0xFF, 0x80, 0x1F, 0xDF, 0xF8, 0x00, 0xFC, 0x7F, 0x80,
  0x07, 0xE0, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x0F,
  0xF8, 0xFC, 0x03, 0xFF, 0x9F, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x81, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0,
  0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x03, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03,
  0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F,
  0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x3F,
  0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8,
  0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF9, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xDF, 0x80, 0x3F, 0xF3, 0xF0, 0x03, 0xFC,
  0xFE, 0x00, 0x1C, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0xFC, 0x07, 0xC7, 0xF0, 0x3F,
  0x3F, 0x80, 0xFD, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0x9F, 0x01, 0xFC, 0x06, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC2, 0x00, 0x7F, 0x87, 0x00, 0xFF, 0x0F,
  0xCF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xFF, 0x0F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC4,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x03,
  0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xFC,
  0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0xFE, 0x01,
  0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC,
  0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0x81,
  0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F,
  0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0,
  0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x1F,
  0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x3F, 0xE0, 0xFF, 0x1F, 0xF0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xEF, 0xC0, 0x3F, 0xF3,
  0xE0, 0x07, 0xF8, 0xF8, 0x00, 0x30, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFE, 0xFC, 0x03, 0xFB, 0xF0, 0x0F,
  0xCF, 0xC0, 0x7F, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F,
  0xC0, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x0F, 0xC3,
  0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0,
  0x3F, 0x3F, 0x00, 0xFD, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xFB, 0xF0,
  0x0F, 0xE0, 0x1F, 0x9F, 0x80, 0xFF, 0x01, 0xFC, 0xFC, 0x07, 0xF8, 0x0F,
  0xC7, 0xE0, 0x7F, 0xC0, 0xFE, 0x3F, 0x03, 0xFE, 0x07, 0xE1, 0xF8, 0x1F,
  0xF0, 0x3F, 0x0F, 0xC1, 0xFF, 0x83, 0xF8, 0x7E, 0x0F, 0xFC, 0x1F, 0x83,
  0xF0, 0xFF, 0xE0, 0xFC, 0x1F, 0x87, 0xDF, 0x0F, 0xC0, 0xFC, 0x3E, 0xF8,
  0x7E, 0x07, 0xE3, 0xF7, 0xC7, 0xF0, 0x3F, 0x1F, 0x3E, 0x3F, 0x01, 0xF8,
  0xFB, 0xF1, 0xF8, 0x0F, 0xCF, 0xDF, 0x9F, 0x80, 0x7E, 0x7C, 0xFC, 0xFC,
  0x03, 0xF7, 0xE7, 0xE7, 0xE0, 0x1F, 0xBE, 0x3F, 0x7E, 0x00, 0xF9, 0xF1,
  0xF3, 0xF0, 0x07, 0xDF, 0x8F, 0xBF, 0x00, 0x7E, 0xF8, 0x7D, 0xF8, 0x03,
  0xF7, 0xC3, 0xEF, 0xC0, 0x1F, 0xFC, 0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x0F,
  0xE0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xC3,
  0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0,
  0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x3F, 0x80, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0x3E, 0x7F, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x8F,
  0xF8, 0x00, 0x4F, 0xFF, 0x00, 0x6F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0xC0, 0x07, 0xFE,
  0x40, 0x00, 0x3C, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 17, 45, 15, 0, -44 },
  { 97, 20, 16, 23, 6, -44 },
  { 137, 30, 44, 28, 0, -44 },
  { 302, 27, 51, 26, 0, -47 },
  { 475, 37, 46, 41, 3, -45 },
  { 688, 29, 46, 30, 0, -45 },
  { 855, 10, 16, 14, 6, -44 },
  { 875, 20, 54, 16, 1, -44 },
  { 1010, 20, 55, 17, -5, -45 },
  { 1148, 22, 23, 24, 5, -47 },
  { 1212, 25, 30, 28, 2, -37 },
  { 1306, 13, 16, 14, -3, -8 },
  { 1332, 15, 7, 17, 1, -20 },
  { 1346, 9, 10, 14, 0, -9 },
  { 1358, 30, 45, 22, -3, -45 },
  { 1527, 25, 46, 26, 1, -45 },
  { 1671, 18, 44, 26, 6, -44 },
  { 1770, 28, 45, 26, -2, -45 },
  { 1928, 27, 46, 26, -1, -45 },
  { 2084, 27, 45, 26, -1, -45 },
  { 2236, 27, 45, 26, 0, -44 },
  { 2388, 27, 46, 26, 1, -45 },
  { 2544, 27, 44, 26, 2, -44 },
  { 2693, 27, 46, 26, 0, -45 },
  { 2849, 26, 46, 26, 0, -45 },
  { 2999, 14, 35, 14, 0, -34 },
  { 3061, 17, 42, 14, -3, -34 },
  { 3151, 25, 29, 28, 2, -37 },
  { 3242, 25, 18, 28, 2, -31 },
  { 3299, 25, 29, 28, 2, -37 },
  { 3390, 21, 46, 20, 1, -45 },
  { 3511, 37, 50, 39, 1, -45 },
  { 3743, 28, 44, 28, -4, -44 },
  { 3897, 29, 44, 28, 0, -44 },
  { 4057, 28, 46, 26, 2, -45 },
  { 4218, 30, 44, 31, 0, -44 },
  { 4383, 27, 44, 24, 0, -44 },
  { 4532, 27, 44, 23, 0, -44 },
  { 4681, 31, 46, 32, 2, -45 },
  { 4860, 34, 44, 32, 0, -44 },
  { 5047, 26, 44, 18, -3, -44 },
  { 5190, 25, 57, 14, -9, -44 },
  { 5369, 33, 44, 27, 0, -44 },
  { 5551, 19, 44, 23, 0, -44 },
  { 5656, 44, 44, 42, 0, -44 },
  { 5898, 35, 44, 34, 0, -44 },
  { 6091, 30, 46, 33, 2, -45 },
  { 6264, 29, 44, 27, 0, -44 },
  { 6424, 30, 56, 33, 2, -45 },
  { 6634, 28, 44, 28, 0, -44 },
  { 6788, 28, 46, 25, -1, -45 },
  { 6949, 24, 44, 23, 4, -44 },
  { 7081, 31, 45, 31, 2, -44 },
  { 7256, 28, 44, 27, 5, -44 },
  { 7410, 43, 44, 42, 4, -44 },
  { 7647, 34, 44, 26, -4, -44 },
  { 7834, 25, 44, 25, 5, -44 },
  { 7972, 29, 44, 23, -2, -44 },
  { 8132, 24, 55, 18, -2, -45 },
  { 8297, 12, 45, 22, 6, -45 },
  { 8365, 24, 55, 18, -4, -45 },
  { 8530, 26, 25, 26, 0, -44 },
  { 8612, 21, 4, 20, -6, 5 },
  { 8623, 10, 9, 17, 9, -47 },
  { 8635, 27, 35, 28, 1, -34 },
  { 8754, 26, 48, 27, 0, -47 },
  { 8910, 22, 35, 22, 1, -34 },
  { 9007, 30, 48, 28, 1, -47 },
  { 9187, 23, 35, 25, 1, -34 },
  { 9288, 30, 62, 16, -7, -47 },
  { 9521, 29, 49, 28, -1, -34 },
  { 9699, 26, 47, 27, 0, -47 },
  { 9852, 16, 47, 13, 0, -47 },
  { 9946, 24, 62, 13, -8, -47 },
  { 10132, 28, 47, 25, 0, -47 },
  { 10297, 16, 47, 13, 0, -47 },
  { 10391, 39, 34, 40, 0, -34 },
  { 10557, 26, 34, 27, 0, -34 },
  { 10668, 24, 35, 27, 1, -34 },
  { 10773, 29, 49, 27, -3, -34 },
  { 10951, 27, 49, 28, 1, -34 },
  { 11117, 22, 34, 19, 0, -34 },
  { 11211, 23, 35, 21, -1, -34 },
  { 11312, 17, 42, 17, 2, -41 },
  { 11402, 26, 35, 27, 1, -34 },
  { 11516, 22, 34, 23, 4, -34 },
  { 11610, 37, 34, 36, 3, -34 },
  { 11768, 29, 34, 24, -3, -34 },
  { 11892, 32, 49, 24, -5, -34 },
  { 12088, 24, 34, 20, -2, -34 },
  { 12190, 24, 54, 21, 1, -44 },
  { 12352, 6, 61, 23, 8, -47 },
  { 12398, 24, 54, 21, -4, -44 },
  { 12560, 25, 10, 28, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC62PT7B_H_
