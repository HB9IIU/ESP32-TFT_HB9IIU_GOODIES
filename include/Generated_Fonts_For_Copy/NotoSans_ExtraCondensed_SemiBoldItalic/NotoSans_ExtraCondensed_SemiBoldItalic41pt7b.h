#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC41PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x7C, 0x1F,
  0x83, 0xF0, 0x7C, 0x0F, 0x80, 0x7C, 0xFB, 0xE7, 0xDE, 0x3C, 0xF1, 0xE7,
  0x8F, 0x3C, 0x79, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x00, 0x00, 0x78,
  0xE0, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x0F, 0x1C, 0x00, 0xE1, 0xC0, 0x0E,
  0x3C, 0x01, 0xE3, 0x80, 0x1C, 0x38, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F,
  0xFF, 0xE0, 0x38, 0xF0, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0x1E, 0x00,
  0x71, 0xC0, 0x0F, 0x1C, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0x1C, 0x38, 0x01, 0xC7, 0x80, 0x3C, 0x70, 0x03, 0x87, 0x00, 0x38, 0xF0,
  0x07, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x1E, 0x00, 0xF1, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF8, 0x3E, 0xCC, 0x0F, 0x31, 0x03, 0xC8, 0x00, 0xF2, 0x00,
  0x3D, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x02, 0xF8, 0x00, 0x9E, 0x00, 0x67,
  0x80, 0x19, 0xE1, 0x06, 0xF8, 0x61, 0x3E, 0x3F, 0xFF, 0x0F, 0xFF, 0x83,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x04, 0x0F, 0xC0, 0x38, 0x1F, 0xE0, 0x78, 0x1F,
  0xE0, 0x70, 0x3C, 0xE0, 0xF0, 0x38, 0xE0, 0xE0, 0x78, 0xE1, 0xE0, 0x70,
  0xE1, 0xC0, 0x70, 0xE3, 0x80, 0x71, 0xE7, 0x80, 0xF1, 0xE7, 0x00, 0xE1,
  0xCF, 0x00, 0xE1, 0xCE, 0x3C, 0xE3, 0xDE, 0x7E, 0xE3, 0x9C, 0xFF, 0xF7,
  0xBC, 0xEF, 0x7F, 0x39, 0xC7, 0x7E, 0x79, 0xC7, 0x18, 0x73, 0x87, 0x00,
  0xF3, 0x87, 0x00, 0xE3, 0x8F, 0x01, 0xC7, 0x8F, 0x01, 0xC7, 0x8E, 0x03,
  0x87, 0x0E, 0x07, 0x87, 0x1E, 0x07, 0x07, 0x1C, 0x0F, 0x07, 0x3C, 0x0E,
  0x07, 0xF8, 0x1E, 0x03, 0xF8, 0x1C, 0x03, 0xF0, 0x00, 0x18, 0x00, 0x1F,
  0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xE1,
  0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x1F, 0x78, 0x03, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0x8F, 0x1F, 0xF1,
  0xE7, 0xDE, 0x7C, 0xF3, 0xEF, 0x3C, 0x7D, 0xE7, 0x87, 0xF9, 0xF0, 0xFF,
  0x3C, 0x1F, 0xC7, 0x81, 0xF8, 0xF0, 0x3E, 0x1F, 0x0F, 0xE3, 0xF7, 0xFC,
  0x7F, 0xFF, 0x87, 0xFC, 0xF8, 0x7F, 0x1F, 0x00, 0x3D, 0xF7, 0xDE, 0x79,
  0xE7, 0x9C, 0xF3, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x7C,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x11, 0xE0, 0xF7, 0x8B, 0xFF, 0xEF, 0xFF,
  0xC7, 0xFF, 0x0F, 0x80, 0x7E, 0x03, 0xFC, 0x3E, 0x78, 0x79, 0xE0, 0xC7,
  0xC1, 0x0C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x7C,
  0x78, 0x78, 0xF0, 0xF0, 0xFF, 0xFF, 0xEF, 0xFB, 0xFE, 0x19, 0xF7, 0xFF,
  0xF9, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x01, 0xFC, 0x03, 0xFE, 0x07,
  0xFF, 0x07, 0xDF, 0x0F, 0x8F, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1E, 0x78,
  0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0,
  0x7C, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xF1, 0xF0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xC0, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFE, 0x1F,
  0xE3, 0xFE, 0x7F, 0xEF, 0xBC, 0x73, 0xC2, 0x3C, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F,
  0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x07, 0xEF,
  0xC0, 0xC1, 0xF0, 0x20, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x00, 0x3C, 0x00,
  0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3C, 0xFC, 0x06, 0x0F, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x18, 0x0F, 0xC3, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07,
  0x78, 0x01, 0xDE, 0x00, 0xEF, 0x80, 0x3B, 0xC0, 0x1C, 0xF0, 0x0E, 0x3C,
  0x03, 0x9F, 0x01, 0xC7, 0xC0, 0xF1, 0xE0, 0x38, 0x78, 0x1C, 0x1E, 0x0F,
  0x0F, 0x83, 0x83, 0xC1, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF,
  0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x80, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0x10, 0x3E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x8E, 0x03, 0xDF,
  0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0xFC, 0x7C, 0x7C, 0x3E, 0x7C, 0x1F, 0x3E,
  0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF8,
  0xF8, 0x78, 0x7C, 0x7C, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xC0,
  0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0x8F, 0xC3, 0xE1, 0xF0, 0xF0, 0x7C, 0x3C,
  0x1F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x3E, 0x7C, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xDF, 0x07,
  0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x1E, 0x3E, 0x07, 0x8F, 0x01, 0xE3, 0xC0,
  0x78, 0xF0, 0x3E, 0x3E, 0x0F, 0x0F, 0xCF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0,
  0x07, 0xF8, 0x00, 0x00, 0x38, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFD, 0xF8, 0x7C, 0x7C, 0x7C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x07,
  0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0xFC, 0xF8, 0x7C, 0x7E,
  0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xF7, 0x80, 0x43, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0x87, 0xC3, 0xE1, 0xF0,
  0xF0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x3C, 0x3F, 0x1F, 0x8F, 0x87, 0x80, 0x01, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x03,
  0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x70, 0x00, 0x00,
  0x03, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x01, 0xC0, 0x3F, 0xC3, 0xFF, 0x87, 0xFF, 0x1C, 0x7C,
  0x41, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x0F, 0x07, 0x80, 0x07, 0x0F, 0x00, 0x07, 0x0E, 0x07, 0x87, 0x1C,
  0x1F, 0xE7, 0x1C, 0x3F, 0xC7, 0x38, 0x79, 0xC7, 0x38, 0xF1, 0xC7, 0x38,
  0xE1, 0xC7, 0x71, 0xE3, 0xC7, 0x71, 0xC3, 0x87, 0x71, 0xC3, 0x86, 0xF1,
  0xC7, 0x8E, 0xE3, 0xC7, 0x8E, 0xE3, 0x87, 0x0C, 0xE3, 0x8F, 0x1C, 0xE3,
  0x8F, 0x18, 0xE3, 0xDB, 0xF8, 0xE1, 0xFB, 0xF0, 0xE1, 0xF3, 0xE0, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x02, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xDC, 0x00,
  0x7B, 0x80, 0x0F, 0x70, 0x03, 0xEE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03,
  0xCF, 0x80, 0x79, 0xF0, 0x1F, 0x3E, 0x03, 0xC7, 0xC0, 0x78, 0xF8, 0x1F,
  0x1F, 0x03, 0xC3, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF,
  0xFE, 0x1E, 0x07, 0xC7, 0xC0, 0xF8, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0,
  0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x3E, 0x03, 0xFF, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0xC1, 0xE0,
  0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x78, 0x3C, 0x1F, 0x07, 0x87,
  0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1E, 0x1F,
  0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x1E, 0x07, 0xC3, 0xC0, 0xF8, 0xF8, 0x1F,
  0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x78, 0x3E, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xE0, 0x3F, 0xB8, 0x0F, 0xC1, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC1, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xC7, 0xE0, 0x7C, 0x3F, 0x07, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x1F,
  0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x03, 0xE1, 0xE0, 0x3E, 0x1E, 0x03, 0xE3,
  0xE0, 0x3E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3C, 0x0F, 0x87, 0xC0, 0xF8,
  0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0x78, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF8, 0x1F, 0xFE, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x80,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xDF, 0x03, 0xF0, 0x10, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x7F, 0x8F, 0x83, 0xFC,
  0x7C, 0x3F, 0xC3, 0xE1, 0xFE, 0x1E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80,
  0x7C, 0x7C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83,
  0xF0, 0x7C, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xF0, 0x3C, 0x07, 0xC1, 0xF0, 0x1E,
  0x07, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x83, 0xE0, 0x3E, 0x0F,
  0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1F, 0x03, 0xC0, 0x7C, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1E, 0x03, 0xE0,
  0xF8, 0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0xC1, 0xF0,
  0x1F, 0x07, 0xC0, 0x78, 0x1F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3E,
  0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xC0, 0xF8, 0x1F, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0xFC, 0x0F, 0x03, 0xC0,
  0x3C, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1E, 0x1F, 0x00, 0x78,
  0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x00, 0xF7, 0xC0,
  0x03, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFD, 0xE0, 0x03, 0xE7, 0x80, 0x0F, 0x1F,
  0x00, 0x3C, 0x7C, 0x00, 0xF1, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x80,
  0x78, 0x3E, 0x01, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x07, 0x80, 0xF8,
  0x1F, 0x00, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0,
  0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC1,
  0xFE, 0x03, 0xFC, 0x0F, 0x70, 0x1F, 0xE0, 0x7B, 0x81, 0xEF, 0x03, 0xDC,
  0x0F, 0xF8, 0x1E, 0xE0, 0xF7, 0x81, 0xF7, 0x87, 0xBC, 0x0F, 0x3C, 0x79,
  0xE0, 0x79, 0xE3, 0xDF, 0x03, 0xCF, 0x1C, 0xF8, 0x1E, 0x79, 0xE7, 0x81,
  0xF3, 0xCF, 0x3C, 0x0F, 0x1E, 0xF1, 0xE0, 0x78, 0xF7, 0x9F, 0x03, 0xC7,
  0xF8, 0xF8, 0x1E, 0x3F, 0xC7, 0x81, 0xF1, 0xFC, 0x3C, 0x0F, 0x0F, 0xE1,
  0xE0, 0x78, 0x7E, 0x1F, 0x03, 0xC3, 0xF0, 0xF0, 0x3E, 0x1F, 0x07, 0x81,
  0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE0, 0x1E, 0x07,
  0xC0, 0x3C, 0x0F, 0xC0, 0x78, 0x3F, 0x81, 0xF0, 0x7F, 0x03, 0xC0, 0xFE,
  0x07, 0x81, 0xFC, 0x0F, 0x07, 0xBC, 0x1E, 0x0F, 0x78, 0x7C, 0x1E, 0xF0,
  0xF0, 0x3D, 0xE1, 0xE0, 0x7B, 0xC3, 0xC1, 0xF7, 0x8F, 0x83, 0xC7, 0x9F,
  0x07, 0x8F, 0x3C, 0x0F, 0x1E, 0x78, 0x1E, 0x3C, 0xF0, 0x7C, 0x7B, 0xE0,
  0xF0, 0xF7, 0x81, 0xE0, 0xFF, 0x03, 0xC1, 0xFE, 0x07, 0x83, 0xFC, 0x1F,
  0x07, 0xF8, 0x3C, 0x0F, 0xE0, 0x78, 0x1F, 0xC0, 0xF0, 0x1F, 0x83, 0xE0,
  0x3F, 0x07, 0x80, 0x7E, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x07,
  0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xF7, 0xE0, 0x7C, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3,
  0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F,
  0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07,
  0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x07, 0xC3,
  0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7C, 0x3E, 0x0F,
  0x07, 0xC1, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3C,
  0x0F, 0x87, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0xFF, 0xE0, 0xFF,
  0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x07,
  0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xF7, 0xE0, 0x7C, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3,
  0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F,
  0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07,
  0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x07, 0xC3,
  0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x7C, 0x7C, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xCF, 0x00,
  0xF9, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0xC0, 0x78, 0xF8, 0x1F, 0x0F, 0x03,
  0xE1, 0xE0, 0x78, 0x3E, 0x0F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F,
  0x81, 0xF0, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xC1, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x40,
  0x3E, 0x0E, 0x0F, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0xF8, 0x3C, 0x07, 0x83, 0xE0, 0x3C, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0x83, 0xE0, 0x3C, 0x1F, 0x03, 0xE0,
  0xF8, 0x1F, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0x83, 0xE0, 0x7C, 0x1F, 0x03,
  0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF0, 0x7C, 0x07, 0x83, 0xE0, 0x7C, 0x1F,
  0x03, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C,
  0x1F, 0x03, 0xC0, 0x7C, 0x3E, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F,
  0xF0, 0x01, 0xFE, 0x00, 0x00, 0xF0, 0x07, 0xFC, 0x03, 0xEF, 0x00, 0xF3,
  0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x0F, 0x8F, 0x03, 0xE3, 0xC0, 0xF0, 0xF0,
  0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x83, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x7C,
  0x0F, 0x1E, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x7C, 0x03,
  0xDE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0xF7, 0x80, 0xF0, 0x1F, 0x78, 0x1F, 0x01, 0xE7, 0x81, 0xF0,
  0x3E, 0x78, 0x1F, 0x03, 0xEF, 0x83, 0xF0, 0x3C, 0xF8, 0x3F, 0x07, 0xCF,
  0x83, 0xF0, 0x78, 0xF8, 0x7F, 0x0F, 0x8F, 0x87, 0x70, 0xF8, 0xF8, 0xFF,
  0x0F, 0x0F, 0x8F, 0xF1, 0xF0, 0xF8, 0xEF, 0x1E, 0x0F, 0x1E, 0xF1, 0xE0,
  0xF1, 0xEF, 0x3E, 0x0F, 0x3C, 0xF3, 0xC0, 0xF3, 0xCF, 0x7C, 0x0F, 0x38,
  0xF7, 0x80, 0xF7, 0x8F, 0x78, 0x0F, 0x78, 0xFF, 0x80, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x7C, 0x07, 0x83, 0xE0, 0x1E,
  0x0F, 0x00, 0x78, 0x7C, 0x01, 0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3C,
  0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0xBE, 0x00, 0x3E, 0x78, 0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x3E,
  0x1E, 0x00, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x00, 0x78, 0x0F, 0xBC, 0x0F, 0x9E, 0x07, 0x8F, 0x07, 0xC7, 0xC3, 0xC3,
  0xE3, 0xE1, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x1E, 0xF8, 0x0F, 0x78,
  0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x00, 0xFF,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0x78, 0x07, 0xBC, 0x07, 0x9E, 0x07, 0x87, 0x03, 0xC3, 0xC3, 0xC1, 0xE1,
  0xE0, 0xF1, 0xE0, 0x39, 0xE0, 0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0xF8, 0xF1, 0xF1, 0xE3, 0xC3, 0xC0, 0x00, 0x80, 0x03,
  0xF3, 0xC3, 0xFD, 0xE1, 0xFF, 0xF1, 0xFB, 0xF9, 0xF0, 0xF8, 0xF8, 0x7C,
  0x78, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9E, 0x07, 0x9F, 0x03, 0xCF, 0x81,
  0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xE0, 0x78, 0xF0, 0x7C, 0x78, 0x3E, 0x3E,
  0x3F, 0x1F, 0xFF, 0x8F, 0xFF, 0x83, 0xFB, 0xC0, 0xF9, 0xE0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x8C, 0x07, 0xDF, 0x83, 0xDF, 0xE1, 0xFF, 0xF0,
  0xFC, 0xF8, 0xFC, 0x3C, 0x7C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x03,
  0xCF, 0x81, 0xE7, 0x81, 0xF3, 0xC0, 0xF9, 0xE0, 0x7C, 0xF0, 0x3C, 0xF8,
  0x3E, 0x7C, 0x1F, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0xCF, 0x8F, 0xFF, 0x87,
  0xBF, 0x83, 0xCF, 0x80, 0x00, 0x60, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE1,
  0xF9, 0x87, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x87, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x87, 0xC0, 0xFE, 0xF0,
  0x3F, 0xDE, 0x07, 0xFF, 0xC1, 0xF3, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC1,
  0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x03, 0xE1, 0xE0, 0x78, 0x7C, 0x0F, 0x0F,
  0x81, 0xE1, 0xF0, 0x3C, 0x3C, 0x0F, 0x87, 0x81, 0xE0, 0xF0, 0x3C, 0x1E,
  0x0F, 0x83, 0xE3, 0xF0, 0x7E, 0xFC, 0x0F, 0xFF, 0x80, 0xFE, 0xF0, 0x0F,
  0x9E, 0x00, 0x00, 0x60, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xF1, 0xF1, 0xE7,
  0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x78, 0x3E, 0xF0, 0xF9, 0xFF, 0xE7, 0xFF,
  0x8F, 0xFC, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x47, 0xE1, 0x87, 0xFF, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x40, 0x07, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xBC, 0x0F, 0xF7,
  0x81, 0xFF, 0xF0, 0x7E, 0xFE, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x78, 0x3E,
  0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x78, 0x1E, 0x1F, 0x03, 0xC3, 0xE0, 0x78,
  0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xE0, 0x78, 0x3C, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xBC, 0x03, 0xEF, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x40, 0x3E, 0x0C,
  0x0F, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x8C, 0x07, 0xDF, 0x83, 0xDF, 0xE1,
  0xFF, 0xF0, 0xFD, 0xF8, 0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1E, 0x0F,
  0x8F, 0x07, 0x8F, 0x83, 0xC7, 0xC1, 0xE3, 0xC1, 0xF1, 0xE0, 0xF8, 0xF0,
  0x78, 0xF8, 0x3C, 0x7C, 0x1E, 0x3C, 0x1F, 0x1E, 0x0F, 0x8F, 0x07, 0x8F,
  0x83, 0xC7, 0xC3, 0xE3, 0xC1, 0xF0, 0x01, 0xC0, 0x7C, 0x0F, 0x83, 0xE0,
  0x3C, 0x02, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE1, 0xF0, 0xF0, 0xF8,
  0x3C, 0x3C, 0x0F, 0x1F, 0x03, 0xCF, 0x81, 0xF7, 0xC0, 0x79, 0xE0, 0x1E,
  0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xEF, 0x01, 0xF3, 0xE0, 0x78, 0xF8, 0x1E, 0x3E, 0x07, 0x87, 0x81,
  0xE1, 0xE0, 0xF8, 0x7C, 0x3C, 0x1F, 0x0F, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F,
  0x81, 0xF0, 0x3C, 0x00, 0x00, 0x0C, 0x04, 0x03, 0xCF, 0xCF, 0xE0, 0xF7,
  0xF7, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xDF, 0xEF, 0xC3, 0xE3, 0xF1, 0xF1,
  0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x1E, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1,
  0xE3, 0xE0, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x3C, 0x1E, 0x0F, 0x0F, 0x07,
  0x83, 0xC3, 0xC1, 0xE0, 0xF1, 0xF0, 0xF8, 0x7C, 0x78, 0x3E, 0x1E, 0x1E,
  0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0xF8, 0x7C, 0x3E,
  0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC0, 0x00, 0x08, 0x07, 0x9F, 0x83,
  0xDF, 0xE1, 0xFF, 0xF0, 0xFC, 0xF8, 0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F,
  0x1E, 0x0F, 0x8F, 0x07, 0x8F, 0x83, 0xC7, 0xC1, 0xE3, 0xC1, 0xF1, 0xE0,
  0xF8, 0xF0, 0x78, 0xF8, 0x3C, 0x7C, 0x1E, 0x3C, 0x1F, 0x1E, 0x0F, 0x8F,
  0x07, 0x8F, 0x83, 0xC7, 0xC1, 0xE3, 0xC1, 0xF0, 0x00, 0xE0, 0x03, 0xF8,
  0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x3E, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E,
  0xF0, 0x3E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF8, 0xF8, 0xFF, 0xF8,
  0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0x03, 0x00, 0x79, 0xF8, 0x0F,
  0x7F, 0x81, 0xFF, 0xF0, 0x3F, 0x3E, 0x07, 0xC3, 0xC1, 0xF0, 0x78, 0x3E,
  0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0xC1, 0xF0, 0xF0,
  0x3E, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE1,
  0xF0, 0x7C, 0x3E, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7B, 0xFC, 0x0F, 0x3E,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0xFB, 0xC1, 0xFD, 0xE1, 0xFF, 0xF1, 0xF3, 0xF8,
  0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x3E, 0x7C, 0x1F, 0x3C, 0x0F, 0x9E, 0x07,
  0x9F, 0x03, 0xCF, 0x81, 0xE7, 0xC0, 0xF3, 0xC0, 0xF9, 0xE0, 0x78, 0xF0,
  0x3C, 0x78, 0x3E, 0x3E, 0x3F, 0x1F, 0xBF, 0x0F, 0xFF, 0x83, 0xFB, 0xC0,
  0xFB, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x00,
  0x00, 0x0C, 0x3C, 0xF0, 0xF7, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0xF8, 0x3F, 0xF8, 0xFF,
  0xE1, 0xF1, 0x87, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE2, 0x07, 0xC7, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0,
  0x00, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x3F, 0xDF, 0xFB, 0xFF,
  0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0xC8, 0xFF, 0x0F,
  0xE1, 0xFC, 0x00, 0x1F, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xC3, 0xC1, 0xE3,
  0xE0, 0xF1, 0xF0, 0x78, 0xF0, 0x7C, 0x78, 0x3C, 0x3C, 0x1E, 0x3E, 0x0F,
  0x1E, 0x0F, 0x8F, 0x07, 0xC7, 0x83, 0xC3, 0xC1, 0xE3, 0xE1, 0xF1, 0xE0,
  0xF8, 0xF0, 0x78, 0x78, 0x7C, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xF7, 0x83,
  0xF3, 0x80, 0xF8, 0x1F, 0xF8, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x78,
  0x78, 0x78, 0x78, 0xF8, 0x78, 0xF0, 0x79, 0xF0, 0x79, 0xE0, 0x79, 0xE0,
  0x7B, 0xC0, 0x7B, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x77, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x3E,
  0x0F, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0xFE, 0x3E, 0x78, 0xFE,
  0x3C, 0xF8, 0xFE, 0x3C, 0xF9, 0xFC, 0x78, 0xF9, 0xDC, 0x78, 0xF1, 0xDC,
  0x78, 0xF3, 0xDC, 0xF0, 0xF3, 0x9C, 0xF0, 0xF7, 0x9D, 0xE0, 0xF7, 0x9D,
  0xE0, 0xF7, 0x1D, 0xE0, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xF8, 0x3F,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0xF8, 0x78, 0x0F, 0x1F, 0x01,
  0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0xBE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x1F, 0x7C, 0x03, 0xC7, 0x80, 0xF8,
  0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0x00, 0x03, 0xC0, 0xF8,
  0x1E, 0x07, 0x80, 0xF0, 0x7C, 0x07, 0x83, 0xC0, 0x3C, 0x3E, 0x01, 0xE1,
  0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x00,
  0xF3, 0xC0, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0x07,
  0xFF, 0x07, 0xFF, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7F, 0xF8, 0x7F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0x00, 0x3E, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x3F, 0x80, 0xFE,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFE, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xE0, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x10, 0x01, 0x7F, 0x01, 0xFF, 0xC7, 0xFF, 0xFF, 0xC7, 0xFF, 0x81,
  0xFE, 0x80, 0x18,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 11, 29, 10, 0, -29 },
  { 41, 13, 10, 15, 4, -29 },
  { 58, 20, 29, 19, 0, -29 },
  { 131, 18, 33, 17, 0, -31 },
  { 206, 24, 30, 27, 2, -30 },
  { 296, 19, 30, 20, 0, -30 },
  { 368, 6, 10, 9, 4, -29 },
  { 376, 13, 35, 11, 1, -29 },
  { 433, 13, 36, 11, -3, -30 },
  { 492, 14, 15, 16, 4, -31 },
  { 519, 16, 19, 18, 2, -24 },
  { 557, 8, 11, 9, -2, -5 },
  { 568, 10, 4, 11, 1, -13 },
  { 573, 6, 6, 9, 0, -6 },
  { 578, 20, 30, 15, -2, -30 },
  { 653, 16, 30, 17, 1, -30 },
  { 713, 12, 29, 17, 4, -29 },
  { 757, 18, 30, 17, -1, -30 },
  { 825, 19, 30, 17, -1, -30 },
  { 897, 18, 29, 17, -1, -29 },
  { 963, 18, 29, 17, 0, -29 },
  { 1029, 17, 30, 17, 1, -30 },
  { 1093, 18, 29, 17, 1, -29 },
  { 1159, 18, 30, 17, 0, -30 },
  { 1227, 17, 30, 17, 0, -30 },
  { 1291, 9, 22, 9, 0, -22 },
  { 1316, 11, 28, 9, -2, -22 },
  { 1355, 16, 19, 18, 2, -24 },
  { 1393, 16, 12, 18, 2, -20 },
  { 1417, 16, 19, 18, 2, -24 },
  { 1455, 14, 30, 13, 1, -30 },
  { 1508, 24, 33, 26, 1, -30 },
  { 1607, 19, 29, 18, -3, -29 },
  { 1676, 19, 29, 19, 0, -29 },
  { 1745, 19, 30, 17, 1, -30 },
  { 1817, 20, 29, 20, 0, -29 },
  { 1890, 18, 29, 16, 0, -29 },
  { 1956, 18, 29, 15, 0, -29 },
  { 2022, 21, 30, 21, 1, -30 },
  { 2101, 22, 29, 21, 0, -29 },
  { 2181, 17, 29, 12, -2, -29 },
  { 2243, 17, 37, 9, -6, -29 },
  { 2322, 22, 29, 18, 0, -29 },
  { 2402, 12, 29, 15, 0, -29 },
  { 2446, 29, 29, 28, 0, -29 },
  { 2552, 23, 29, 22, 0, -29 },
  { 2636, 20, 30, 22, 1, -30 },
  { 2711, 19, 29, 18, 0, -29 },
  { 2780, 20, 37, 22, 1, -30 },
  { 2873, 19, 29, 18, 0, -29 },
  { 2942, 19, 30, 16, -1, -30 },
  { 3014, 16, 29, 15, 3, -29 },
  { 3072, 21, 29, 20, 1, -29 },
  { 3149, 18, 29, 18, 4, -29 },
  { 3215, 28, 29, 28, 3, -29 },
  { 3317, 22, 29, 17, -2, -29 },
  { 3397, 17, 29, 16, 3, -29 },
  { 3459, 20, 29, 15, -2, -29 },
  { 3532, 16, 36, 12, -1, -29 },
  { 3604, 8, 30, 15, 4, -30 },
  { 3634, 16, 36, 12, -3, -29 },
  { 3706, 17, 17, 17, 0, -29 },
  { 3743, 14, 2, 13, -4, 4 },
  { 3747, 7, 6, 11, 6, -31 },
  { 3753, 17, 23, 18, 1, -23 },
  { 3802, 17, 31, 18, 0, -31 },
  { 3868, 15, 23, 14, 1, -23 },
  { 3912, 19, 31, 18, 1, -31 },
  { 3986, 15, 23, 17, 1, -23 },
  { 4030, 20, 41, 11, -5, -31 },
  { 4133, 19, 33, 18, -1, -23 },
  { 4212, 17, 31, 18, 0, -31 },
  { 4278, 11, 31, 9, 0, -31 },
  { 4321, 16, 41, 9, -5, -31 },
  { 4403, 18, 31, 16, 0, -31 },
  { 4473, 11, 31, 9, 0, -31 },
  { 4516, 26, 23, 27, 0, -23 },
  { 4591, 17, 23, 18, 0, -23 },
  { 4640, 16, 23, 18, 1, -23 },
  { 4686, 19, 33, 18, -2, -23 },
  { 4765, 17, 33, 18, 1, -23 },
  { 4836, 14, 23, 13, 0, -23 },
  { 4877, 15, 23, 14, 0, -23 },
  { 4921, 11, 27, 11, 1, -27 },
  { 4959, 17, 22, 18, 1, -22 },
  { 5006, 16, 22, 15, 2, -22 },
  { 5050, 24, 22, 24, 2, -22 },
  { 5116, 19, 22, 16, -2, -22 },
  { 5169, 21, 32, 16, -3, -22 },
  { 5253, 16, 22, 13, -2, -22 },
  { 5297, 15, 35, 14, 1, -29 },
  { 5363, 4, 40, 15, 5, -31 },
  { 5383, 15, 35, 14, -2, -29 },
  { 5449, 16, 7, 18, 2, -18 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC41PT7B_H_
