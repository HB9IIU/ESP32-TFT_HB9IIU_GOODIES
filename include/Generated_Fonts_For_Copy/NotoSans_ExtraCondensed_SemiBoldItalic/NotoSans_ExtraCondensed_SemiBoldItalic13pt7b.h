#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC13PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x66, 0x44, 0x0C, 0xC0, 0x55, 0xB0, 0x14, 0x97, 0xCA, 0x2B,
  0xE5, 0x14, 0xA0, 0x10, 0xF7, 0x94, 0x60, 0xC3, 0xAE, 0xF0, 0x84, 0x00,
  0x65, 0x5A, 0xA5, 0xBD, 0x65, 0x4A, 0xA5, 0xCC, 0x38, 0xA2, 0x8C, 0x77,
  0x79, 0xA6, 0xEC, 0x5C, 0x12, 0x64, 0x4C, 0xCC, 0xCC, 0x40, 0x31, 0x11,
  0x11, 0x32, 0x24, 0xC0, 0x25, 0x1F, 0xC5, 0x00, 0x63, 0x19, 0xF6, 0x30,
  0x2D, 0x60, 0xE0, 0xF0, 0x06, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x20, 0xC0,
  0x3B, 0x52, 0x9C, 0xEF, 0x7A, 0x60, 0x37, 0xF2, 0x26, 0x64, 0x40, 0x7A,
  0x42, 0x31, 0x11, 0x18, 0xF0, 0x78, 0x30, 0x86, 0x70, 0x61, 0xA4, 0xF0,
  0x0C, 0x62, 0x8E, 0x5A, 0x4F, 0x84, 0x30, 0x3C, 0x86, 0x1C, 0x58, 0x61,
  0xA4, 0xF0, 0x1C, 0x86, 0x1E, 0x5B, 0x2D, 0xB4, 0x70, 0x7C, 0x20, 0x86,
  0x10, 0xC2, 0x18, 0xC0, 0x39, 0xB6, 0x8E, 0x73, 0x69, 0xA6, 0xF0, 0x3B,
  0x52, 0x97, 0xBC, 0x46, 0xE0, 0x6C, 0x01, 0xB0, 0x33, 0x00, 0x06, 0x64,
  0xC0, 0x04, 0x77, 0x30, 0x38, 0x30, 0xFC, 0x0F, 0xC0, 0x86, 0x1C, 0x36,
  0x40, 0x78, 0xC4, 0x66, 0x20, 0x08, 0xC0, 0x1E, 0x21, 0x4D, 0x55, 0x55,
  0xAD, 0xAA, 0x94, 0x40, 0x78, 0x0C, 0x71, 0x4D, 0x24, 0xF6, 0x51, 0xCC,
  0x3C, 0x96, 0xDA, 0x79, 0x2C, 0xB6, 0xF0, 0x3C, 0x86, 0x10, 0x43, 0x0C,
  0x12, 0x70, 0x3C, 0x96, 0x59, 0x45, 0x3C, 0xB6, 0xF0, 0x3C, 0x86, 0x1A,
  0x71, 0x0C, 0x30, 0xF0, 0x3C, 0x86, 0x18, 0x79, 0x0C, 0x30, 0xC0, 0x1E,
  0x61, 0x82, 0x04, 0xD8, 0xB3, 0x26, 0x78, 0x26, 0x4D, 0x93, 0xE7, 0xC9,
  0xB3, 0x64, 0xC8, 0x3C, 0x41, 0x04, 0x30, 0xC2, 0x08, 0xF0, 0x08, 0x46,
  0x31, 0x08, 0x46, 0x31, 0x39, 0x80, 0x26, 0x59, 0xE3, 0x87, 0x0A, 0x14,
  0x6C, 0x98, 0x22, 0x66, 0x44, 0xCC, 0xF0, 0x31, 0x99, 0xDC, 0xEA, 0xE5,
  0x52, 0xA9, 0x6D, 0xB6, 0x92, 0x00, 0x32, 0x65, 0xDA, 0xB5, 0x4B, 0x97,
  0x66, 0x8C, 0x3C, 0x4D, 0x9A, 0x34, 0x58, 0xB3, 0x24, 0x70, 0x3C, 0x96,
  0x5B, 0x79, 0xCC, 0x30, 0xC0, 0x3C, 0x4D, 0x9A, 0x34, 0x58, 0xB3, 0x24,
  0x78, 0x20, 0x60, 0x3C, 0xB6, 0xDB, 0x79, 0x45, 0x36, 0x98, 0x3D, 0x86,
  0x18, 0x30, 0x41, 0xA4, 0xF0, 0xFB, 0x18, 0xC4, 0x23, 0x18, 0x80, 0x26,
  0x4D, 0x93, 0x24, 0xC9, 0xB2, 0x6C, 0x70, 0xCF, 0x2D, 0xB4, 0xF3, 0x8A,
  0x38, 0xC0, 0xC9, 0xCC, 0xA6, 0xD7, 0x4A, 0xA5, 0x73, 0x31, 0x98, 0xCC,
  0x00, 0x36, 0x28, 0x70, 0xC1, 0x87, 0x0A, 0x34, 0xC8, 0xDE, 0xBC, 0xC6,
  0x21, 0x18, 0xC0, 0x3E, 0x18, 0x20, 0xC1, 0x06, 0x08, 0x20, 0xF8, 0x39,
  0x18, 0x84, 0x21, 0x18, 0x84, 0x30, 0xC9, 0x24, 0x93, 0x60, 0x38, 0xC6,
  0x21, 0x08, 0xC4, 0x21, 0x38, 0x11, 0xCA, 0x9C, 0x80, 0xF0, 0xD0, 0x3D,
  0xB4, 0xB2, 0xDB, 0x67, 0x00, 0x20, 0x82, 0x1E, 0x6D, 0x24, 0xB2, 0xDA,
  0xC0, 0x3B, 0x11, 0x8C, 0x69, 0xC0, 0x04, 0x10, 0x4F, 0x6D, 0x2C, 0xB2,
  0xD9, 0xC0, 0x3A, 0x57, 0xEC, 0x61, 0xC0, 0x0E, 0x10, 0x20, 0xE1, 0x82,
  0x04, 0x08, 0x30, 0x60, 0x81, 0x0E, 0x00, 0x3D, 0xB4, 0xB2, 0xDB, 0x67,
  0x04, 0xB3, 0x80, 0x21, 0x08, 0xF6, 0xA5, 0x3B, 0xDC, 0x80, 0x24, 0x36,
  0x96, 0xD0, 0x08, 0x40, 0x31, 0x88, 0x46, 0x31, 0x08, 0x4E, 0x00, 0x20,
  0x82, 0x1B, 0x59, 0xC7, 0x34, 0xD2, 0x40, 0x24, 0xB6, 0x96, 0xD0, 0x7F,
  0x6D, 0x49, 0x4B, 0xDB, 0xD2, 0x92, 0x7B, 0x52, 0x9D, 0xEE, 0x40, 0x3B,
  0x53, 0x9C, 0xED, 0xC0, 0x3C, 0x6C, 0x99, 0x26, 0x4D, 0x96, 0x20, 0x41,
  0x80, 0x3D, 0xB4, 0xB2, 0xCB, 0x67, 0x04, 0x10, 0xC0, 0x7B, 0x10, 0x8C,
  0x62, 0x00, 0x7A, 0x10, 0xC3, 0x5B, 0x80, 0x22, 0x76, 0x44, 0x4C, 0xE0,
  0x6D, 0x24, 0x92, 0xDB, 0x6F, 0x00, 0x9D, 0xA9, 0x4E, 0x63, 0x00, 0x93,
  0x6E, 0xD7, 0xAD, 0x9B, 0x26, 0x00, 0x26, 0x78, 0xE0, 0x83, 0x8F, 0x32,
  0x00, 0x26, 0x48, 0xA1, 0x43, 0x86, 0x0C, 0x10, 0x61, 0x80, 0x3C, 0x21,
  0x0C, 0x21, 0x8F, 0x00, 0x19, 0x8C, 0x46, 0x61, 0x8C, 0x42, 0x18, 0xFF,
  0xF8, 0x30, 0xC4, 0x21, 0x0C, 0xC4, 0x23, 0x30, 0x47, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 4, 9, 3, 0, -9 },
  { 6, 4, 3, 5, 1, -9 },
  { 8, 6, 9, 6, 0, -9 },
  { 15, 6, 11, 5, 0, -10 },
  { 24, 7, 9, 9, 1, -9 },
  { 32, 6, 9, 6, 0, -9 },
  { 39, 2, 3, 3, 1, -9 },
  { 40, 4, 11, 3, 0, -9 },
  { 46, 4, 11, 3, -1, -9 },
  { 52, 5, 5, 5, 1, -10 },
  { 56, 5, 6, 6, 1, -8 },
  { 60, 3, 4, 3, -1, -2 },
  { 62, 3, 1, 4, 0, -4 },
  { 63, 2, 2, 3, 0, -2 },
  { 64, 7, 9, 5, -1, -9 },
  { 72, 5, 9, 5, 0, -9 },
  { 78, 4, 9, 5, 1, -9 },
  { 83, 5, 9, 5, 0, -9 },
  { 89, 6, 9, 5, 0, -9 },
  { 96, 6, 9, 5, 0, -9 },
  { 103, 6, 9, 5, 0, -9 },
  { 110, 6, 9, 5, 0, -9 },
  { 117, 6, 9, 5, 0, -9 },
  { 124, 6, 9, 5, 0, -9 },
  { 131, 5, 9, 5, 0, -9 },
  { 137, 3, 7, 3, 0, -7 },
  { 140, 4, 9, 3, -1, -7 },
  { 145, 6, 6, 6, 0, -8 },
  { 150, 6, 3, 6, 0, -6 },
  { 153, 5, 6, 6, 1, -8 },
  { 157, 5, 9, 4, 0, -9 },
  { 163, 8, 10, 8, 0, -9 },
  { 173, 6, 9, 6, -1, -9 },
  { 180, 6, 9, 6, 0, -9 },
  { 187, 6, 9, 5, 0, -9 },
  { 194, 6, 9, 6, 0, -9 },
  { 201, 6, 9, 5, 0, -9 },
  { 208, 6, 9, 5, 0, -9 },
  { 215, 7, 9, 7, 0, -9 },
  { 223, 7, 9, 7, 0, -9 },
  { 231, 6, 9, 4, -1, -9 },
  { 238, 5, 12, 3, -2, -9 },
  { 246, 7, 9, 6, 0, -9 },
  { 254, 4, 9, 5, 0, -9 },
  { 259, 9, 9, 9, 0, -9 },
  { 270, 7, 9, 7, 0, -9 },
  { 278, 7, 9, 7, 0, -9 },
  { 286, 6, 9, 6, 0, -9 },
  { 293, 7, 11, 7, 0, -9 },
  { 303, 6, 9, 6, 0, -9 },
  { 310, 6, 9, 5, 0, -9 },
  { 317, 5, 9, 5, 1, -9 },
  { 323, 7, 9, 6, 0, -9 },
  { 331, 6, 9, 6, 1, -9 },
  { 338, 9, 9, 9, 1, -9 },
  { 349, 7, 9, 5, -1, -9 },
  { 357, 5, 9, 5, 1, -9 },
  { 363, 7, 9, 5, -1, -9 },
  { 371, 5, 11, 4, 0, -9 },
  { 378, 3, 9, 5, 1, -9 },
  { 382, 5, 11, 4, -1, -9 },
  { 389, 5, 5, 5, 0, -9 },
  { 393, 4, 1, 4, -1, 1 },
  { 394, 2, 2, 4, 2, -10 },
  { 395, 6, 7, 6, 0, -7 },
  { 401, 6, 10, 6, 0, -10 },
  { 409, 5, 7, 5, 0, -7 },
  { 414, 6, 10, 6, 0, -10 },
  { 422, 5, 7, 5, 0, -7 },
  { 427, 7, 13, 3, -2, -10 },
  { 439, 6, 10, 6, 0, -7 },
  { 447, 5, 10, 6, 0, -10 },
  { 454, 3, 10, 3, 0, -10 },
  { 458, 5, 13, 3, -2, -10 },
  { 467, 6, 10, 5, 0, -10 },
  { 475, 3, 10, 3, 0, -10 },
  { 479, 8, 7, 8, 0, -7 },
  { 486, 5, 7, 6, 0, -7 },
  { 491, 5, 7, 6, 0, -7 },
  { 496, 7, 10, 6, -1, -7 },
  { 505, 6, 10, 6, 0, -7 },
  { 513, 5, 7, 4, 0, -7 },
  { 518, 5, 7, 4, 0, -7 },
  { 523, 4, 9, 4, 0, -9 },
  { 528, 6, 7, 6, 0, -7 },
  { 534, 5, 7, 5, 1, -7 },
  { 539, 7, 7, 8, 1, -7 },
  { 546, 7, 7, 5, -1, -7 },
  { 553, 7, 10, 5, -1, -7 },
  { 562, 6, 7, 4, -1, -7 },
  { 568, 5, 11, 4, 0, -9 },
  { 575, 1, 13, 5, 2, -10 },
  { 577, 5, 11, 4, -1, -9 },
  { 584, 6, 2, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC13PT7B_H_
