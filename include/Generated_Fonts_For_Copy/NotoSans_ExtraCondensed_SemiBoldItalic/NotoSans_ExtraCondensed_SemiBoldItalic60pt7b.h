#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC60PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x7C, 0x00, 0x38, 0x00, 0x3F, 0x8F, 0xE7, 0xF1, 0xFC, 0xFC, 0x3F,
  0x9F, 0x87, 0xE7, 0xF0, 0xFC, 0xFE, 0x1F, 0x9F, 0x87, 0xE3, 0xF0, 0xFC,
  0x7E, 0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0xC3, 0xF1,
  0xF0, 0x7E, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x1E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x78,
  0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x7C, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xC1, 0xF0,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x1F, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x80, 0x3E, 0x0F, 0x80, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0xF8, 0x3C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xF6, 0x3C, 0x03, 0xF1,
  0x82, 0x00, 0xFC, 0x60, 0x00, 0x7E, 0x38, 0x00, 0x1F, 0x8E, 0x00, 0x07,
  0xE3, 0x00, 0x01, 0xFC, 0xC0, 0x00, 0x7F, 0x30, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0x7F, 0x00, 0x01, 0x9F, 0xC0,
  0x00, 0x63, 0xF0, 0x00, 0x18, 0xFC, 0x00, 0x0E, 0x3F, 0x04, 0x03, 0x9F,
  0xC1, 0x80, 0xC7, 0xF0, 0x78, 0x33, 0xF8, 0x1F, 0xCF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x07, 0xC0, 0x1F, 0xF8, 0x01, 0xF0,
  0x07, 0xFF, 0x80, 0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0x80, 0x3E, 0x3E, 0x01,
  0xF0, 0x07, 0xC7, 0xC0, 0x7C, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0x3E, 0x1F,
  0x03, 0xE0, 0x07, 0x83, 0xE0, 0x7C, 0x01, 0xF0, 0x7C, 0x1F, 0x00, 0x3E,
  0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xF0, 0xF8, 0x00, 0xF0, 0x3E, 0x3E, 0x00,
  0x3E, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xF1, 0xF0, 0x00, 0xF8, 0x3E, 0x3E,
  0x00, 0x1F, 0x07, 0x8F, 0x83, 0xF3, 0xE1, 0xF1, 0xF1, 0xFF, 0x7C, 0x3E,
  0x7C, 0x7F, 0xEF, 0x8F, 0x8F, 0x9F, 0xFF, 0xF3, 0xF3, 0xE3, 0xE7, 0xFF,
  0xFC, 0x7C, 0xF8, 0xFB, 0xFF, 0x1F, 0x1F, 0x1F, 0x7F, 0xC3, 0xE7, 0xC3,
  0xE7, 0xF0, 0xF8, 0xF8, 0x7C, 0x00, 0x3E, 0x1E, 0x0F, 0x80, 0x07, 0xC7,
  0xC1, 0xF0, 0x01, 0xF0, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x07, 0xC0, 0x0F,
  0x83, 0xC0, 0xF8, 0x01, 0xF0, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x07, 0xC0,
  0x0F, 0x83, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0x87,
  0xC0, 0x1F, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0x3E, 0x3E, 0x00, 0xF8, 0x07,
  0xCF, 0xC0, 0x1F, 0x00, 0xFF, 0xF0, 0x07, 0xC0, 0x0F, 0xFC, 0x01, 0xF0,
  0x01, 0xFF, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x7E, 0x3E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC1, 0xFC, 0x1F, 0xFE, 0x0F, 0xC1,
  0xFF, 0xF8, 0x7E, 0x0F, 0xDF, 0xC7, 0xF0, 0xFC, 0xFE, 0x3F, 0x0F, 0xE3,
  0xFB, 0xF8, 0x7E, 0x1F, 0xDF, 0x87, 0xE0, 0x7E, 0xFC, 0x3F, 0x03, 0xFF,
  0xC3, 0xF8, 0x1F, 0xFE, 0x1F, 0x80, 0x7F, 0xE0, 0xFC, 0x03, 0xFF, 0x07,
  0xE0, 0x1F, 0xF0, 0x3F, 0x00, 0x7F, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xE0,
  0x7F, 0xE0, 0x7F, 0x8F, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0x7F, 0x01, 0xFF, 0xE3, 0xFC, 0x07, 0xFE, 0x0F, 0xE0,
  0x03, 0x80, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF9, 0xFC,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF0, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x18, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0xCF, 0x86,
  0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xBF, 0x03,
  0xFC, 0xF8, 0x0F, 0xC7, 0xE0, 0x3C, 0x1F, 0x80, 0xE0, 0xF8, 0x02, 0x07,
  0x80, 0x00, 0x10, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07,
  0xE0, 0x7C, 0x0F, 0xC0, 0x7F, 0xFE, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF,
  0xFF, 0xDF, 0xFF, 0x00, 0x1F, 0x3F, 0x7F, 0x7F, 0xFF, 0xFF, 0xFE, 0x7E,
  0x10, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x7F, 0x03, 0xF8,
  0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80,
  0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00,
  0x7E, 0x3F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0xFE, 0x01,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0xFE, 0x07,
  0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x7F, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0xCF,
  0xF7, 0xE3, 0xF9, 0xF8, 0x7C, 0x7E, 0x0E, 0x3F, 0x82, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFE, 0xFF, 0xC0, 0x1F,
  0x07, 0xF8, 0x03, 0x80, 0x7F, 0x00, 0x60, 0x0F, 0xE0, 0x04, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFD, 0xFF,
  0x80, 0x1C, 0x07, 0xF8, 0x02, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF0, 0x40, 0x01, 0xFC, 0x0C, 0x00, 0xFF, 0x81, 0xF0, 0x7F, 0xE0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xDF, 0x80, 0x00, 0xF3, 0xF0, 0x00, 0x3E, 0xFE, 0x00, 0x07, 0x9F, 0x80,
  0x01, 0xF3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x0F, 0xC0, 0x03, 0xE3,
  0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x1E, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x01,
  0xF0, 0x3F, 0x00, 0x3E, 0x0F, 0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0x3F,
  0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x01, 0xFC, 0x07, 0xC0, 0x3F, 0x80, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x60,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x82, 0x00, 0x3F, 0xC0, 0xC0, 0x1F, 0xF0, 0x3E,
  0x1F, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFE, 0x30, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC1, 0x00, 0x07, 0xF3, 0xF8, 0x01, 0xF9, 0xFF, 0x00,
  0x7E, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0x3F,
  0xC1, 0xFF, 0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x1F, 0xE0, 0x3F, 0x07, 0xF0,
  0x0F, 0xC1, 0xFC, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x0F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0xFE,
  0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0xC3,
  0xFC, 0x07, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7F, 0x03,
  0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7E,
  0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xE3,
  0xF8, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xF7, 0xF0, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x3F,
  0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xE0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F,
  0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0xC1, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F,
  0x83, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03,
  0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x1F, 0xC0,
  0x3F, 0x8F, 0xE0, 0x3F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC,
  0x0F, 0xF0, 0xFE, 0x0F, 0xF8, 0x7F, 0x8F, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xBF, 0x01, 0xFF, 0xBF, 0x80, 0x7F, 0x9F, 0x80,
  0x06, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x03, 0x03, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7C, 0x00, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x03, 0xC3, 0xFC, 0x18, 0x0F, 0xE0, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x01, 0xF8,
  0x1F, 0x07, 0xC0, 0x7F, 0xF0, 0xF0, 0x7C, 0x0F, 0xFF, 0x0F, 0x0F, 0x81,
  0xFF, 0xF0, 0xF0, 0xF8, 0x3E, 0x1E, 0x0F, 0x0F, 0x07, 0xC3, 0xE0, 0xF1,
  0xF0, 0x78, 0x3E, 0x1F, 0x1E, 0x0F, 0x83, 0xE1, 0xF1, 0xE0, 0xF0, 0x3C,
  0x1F, 0x3E, 0x1F, 0x07, 0xC1, 0xE3, 0xC1, 0xF0, 0x7C, 0x1E, 0x3C, 0x1E,
  0x07, 0xC1, 0xE7, 0xC3, 0xE0, 0x78, 0x3E, 0x7C, 0x3E, 0x0F, 0x83, 0xC7,
  0xC3, 0xE0, 0xF8, 0x3C, 0x78, 0x3C, 0x0F, 0x83, 0xC7, 0x83, 0xC1, 0xF0,
  0x78, 0x78, 0x3C, 0x1F, 0x07, 0x87, 0x87, 0xC1, 0xF0, 0xF0, 0xF8, 0x3C,
  0x3F, 0x0F, 0x0F, 0x83, 0xE7, 0xF1, 0xE0, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F,
  0x83, 0xFE, 0x7F, 0xC0, 0xF8, 0x1F, 0xC7, 0xF8, 0x0F, 0x80, 0xF8, 0x3E,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x06, 0x00, 0x01, 0xFE, 0x07, 0xE0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF3, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x81,
  0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE1, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE,
  0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x7F, 0x00,
  0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x07, 0xF0,
  0x1F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x07, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x3F, 0xE0, 0x0F, 0xC0, 0x7F,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x03, 0xF8, 0x1F,
  0x80, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x07,
  0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xF8, 0x0C, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x80,
  0x1F, 0xFD, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xF0,
  0xFF, 0xC0, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81,
  0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x7F, 0x07, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xF0, 0x7E, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1,
  0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7E, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x81,
  0xFC, 0x07, 0xF8, 0x0F, 0xC0, 0x7F, 0x80, 0xFE, 0x07, 0xFC, 0x07, 0xF0,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x1C, 0x01, 0xFE,
  0x00, 0x30, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xE1, 0xFC,
  0x07, 0xFF, 0x87, 0xF0, 0x1F, 0xFE, 0x1F, 0xC0, 0x7F, 0xF8, 0x7F, 0x01,
  0xFF, 0xC3, 0xFC, 0x07, 0xFF, 0x0F, 0xE0, 0x21, 0xFC, 0x3F, 0x80, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFC, 0x0F,
  0xF0, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x01, 0xFE,
  0x01, 0xFC, 0x03, 0xFF, 0xBF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFC,
  0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x03, 0xF7, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x0F, 0xFF, 0x00,
  0xFD, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0x7C, 0x01, 0xF7, 0xE0, 0x0F, 0xDF,
  0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xC0, 0x3E, 0xFE, 0x01, 0xF9, 0xF0, 0x1F,
  0xBF, 0x80, 0x7E, 0x7C, 0x07, 0xEF, 0xC0, 0x1F, 0x9F, 0x03, 0xF3, 0xF0,
  0x07, 0xE7, 0xC0, 0xFC, 0xFC, 0x03, 0xF9, 0xF0, 0x3E, 0x7F, 0x00, 0xFC,
  0x7C, 0x1F, 0x9F, 0xC0, 0x3F, 0x1F, 0x07, 0xC7, 0xE0, 0x0F, 0xC7, 0xE3,
  0xF1, 0xF8, 0x03, 0xF1, 0xF8, 0xF8, 0x7E, 0x01, 0xFC, 0x7E, 0x7E, 0x3F,
  0x80, 0x7E, 0x1F, 0x9F, 0x8F, 0xE0, 0x1F, 0x87, 0xEF, 0xC3, 0xF0, 0x07,
  0xE1, 0xFB, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0xF8, 0x3F, 0x00, 0xFE, 0x1F,
  0xFE, 0x1F, 0xC0, 0x3F, 0x07, 0xFF, 0x07, 0xE0, 0x0F, 0xC1, 0xFF, 0xC1,
  0xF8, 0x03, 0xF0, 0x7F, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xF8, 0x3F, 0x80,
  0x7E, 0x07, 0xFC, 0x0F, 0xE0, 0x1F, 0x81, 0xFF, 0x03, 0xF0, 0x07, 0xE0,
  0x7F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0xFE, 0x07, 0xF8,
  0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x0F, 0xF8,
  0x00, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x3F,
  0xE0, 0x07, 0xE0, 0x0F, 0xF8, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0x7E, 0x01,
  0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xF0, 0x0F, 0xC0, 0x1F, 0xFC, 0x03, 0xF0,
  0x07, 0xDF, 0x00, 0xFC, 0x03, 0xF7, 0xC0, 0x7F, 0x00, 0xFD, 0xF8, 0x1F,
  0x80, 0x3F, 0x7E, 0x07, 0xE0, 0x0F, 0xDF, 0x81, 0xF8, 0x03, 0xF7, 0xE0,
  0x7E, 0x01, 0xF8, 0xF8, 0x3F, 0x80, 0x7E, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F,
  0xC3, 0xF0, 0x07, 0xE3, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x1F, 0xC0, 0x3F, 0x07, 0xC7, 0xE0, 0x0F, 0xC1, 0xF9, 0xF8, 0x03,
  0xF0, 0x7E, 0x7E, 0x01, 0xFC, 0x1F, 0x9F, 0x80, 0x7E, 0x07, 0xEF, 0xE0,
  0x1F, 0x81, 0xFB, 0xF0, 0x07, 0xE0, 0x3E, 0xFC, 0x01, 0xF8, 0x0F, 0xFF,
  0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F,
  0xF8, 0x03, 0xF0, 0x0F, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x7E, 0x00,
  0x7F, 0xE0, 0x1F, 0x80, 0x1F, 0xF0, 0x07, 0xE0, 0x07, 0xFC, 0x01, 0xF8,
  0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x0F, 0xF0, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x07,
  0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0,
  0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE7, 0xF8,
  0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x01,
  0xFE, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9,
  0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xE7, 0xF8,
  0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x01,
  0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0xFF,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x1F,
  0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07,
  0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x07, 0xE0, 0x7F, 0x80, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xF8,
  0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFE,
  0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x7F, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFC,
  0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x87, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F,
  0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE,
  0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x7F, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F,
  0xE3, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xFC,
  0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xFC,
  0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x83, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xC1, 0xE0, 0x0F, 0xF0, 0x0C, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x81, 0x00, 0x0F, 0xE0, 0x30, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xC0,
  0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x07,
  0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x07,
  0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC,
  0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00,
  0x7E, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x3F,
  0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x14, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00,
  0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7,
  0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07,
  0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xF0, 0x3F,
  0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xCF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0x7F, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x7D, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xC0, 0x07,
  0xE7, 0xF0, 0x03, 0xF0, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F,
  0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xFF, 0x00,
  0xFE, 0x1F, 0x80, 0x7F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0xF0, 0x1F, 0xC1,
  0xF8, 0x0F, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xFF, 0x01, 0xF8, 0x1F, 0x80,
  0xFF, 0xC0, 0xFE, 0x07, 0xE0, 0x7D, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x7C,
  0x1F, 0xC0, 0x7E, 0x0F, 0xDF, 0x07, 0xF0, 0x1F, 0x83, 0xE7, 0xC1, 0xF8,
  0x07, 0xE0, 0xFB, 0xF0, 0xFE, 0x01, 0xF8, 0x7E, 0xFC, 0x3F, 0x00, 0x7E,
  0x1F, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xCF, 0xC7, 0xF0, 0x07, 0xE3, 0xF3,
  0xF1, 0xF8, 0x01, 0xF8, 0xF8, 0xFC, 0xFE, 0x00, 0x7E, 0x7E, 0x3F, 0x3F,
  0x00, 0x1F, 0x9F, 0x0F, 0xCF, 0xC0, 0x07, 0xEF, 0xC3, 0xE7, 0xF0, 0x01,
  0xFB, 0xF0, 0xF9, 0xF8, 0x00, 0x7E, 0xF8, 0x3E, 0xFE, 0x00, 0x1F, 0x7E,
  0x0F, 0xBF, 0x00, 0x0F, 0xDF, 0x03, 0xEF, 0xC0, 0x03, 0xF7, 0xC0, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x03,
  0xF8, 0x7F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBF,
  0x00, 0x1F, 0x9F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC3, 0xE0, 0x0F, 0xC1,
  0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x03, 0xF0,
  0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF1, 0xF8, 0x00, 0xF9, 0xF8,
  0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x87, 0xF1, 0xFC,
  0x3F, 0x0F, 0xE1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x0F, 0xC0,
  0x3F, 0xE3, 0xF0, 0x1F, 0xFC, 0xFC, 0x0F, 0xFF, 0x7E, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F, 0xF8, 0x3F, 0x81, 0xFE, 0x1F, 0xE0,
  0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xFC, 0x03, 0xF8,
  0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x07,
  0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0x83, 0xF8,
  0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0xFF, 0x81,
  0xFC, 0x7F, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFE, 0xFC, 0x03, 0xFF, 0x3F,
  0x00, 0xFF, 0xCF, 0x80, 0x1F, 0xC3, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x9F, 0xE0,
  0x0F, 0xDF, 0xFC, 0x03, 0xF7, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xF0, 0xFE, 0x07, 0xF8, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x7E,
  0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xE0,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F,
  0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xE0,
  0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x1F,
  0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0xC7, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0xDF, 0xFE, 0x03, 0xF7, 0xFF, 0x80, 0xF8, 0xFF,
  0xC0, 0x3E, 0x1F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0x02, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x10, 0x1F, 0xE1,
  0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xFE, 0x7F,
  0x00, 0x3F, 0xFB, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xE1, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x07,
  0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7F,
  0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03,
  0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xF7, 0xE0, 0x03, 0xFF, 0x3E,
  0x00, 0x0F, 0xF1, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFF, 0x1F, 0x81, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F,
  0x00, 0xF8, 0x7E, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xE0,
  0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x01, 0x03, 0xF8, 0x06, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x09, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC3, 0xF0,
  0x01, 0xFF, 0x3F, 0x00, 0x7F, 0xF3, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFC, 0x3F, 0xE0, 0x3F, 0x81, 0xFE,
  0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE,
  0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x1F,
  0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0x3F, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07,
  0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x03,
  0xF8, 0x1F, 0xE0, 0x3F, 0x83, 0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xEF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xDF, 0x80,
  0x07, 0xF9, 0xF8, 0x00, 0x08, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x08, 0x00, 0xFE, 0x00, 0xC0, 0x1F, 0xE0, 0x0F, 0x83, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC7,
  0xE0, 0x0F, 0xEF, 0xF8, 0x07, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xF0, 0x7F, 0x83, 0xF8, 0x3F,
  0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x07,
  0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0,
  0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x80, 0xFE,
  0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F,
  0xC1, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x3F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0,
  0x3F, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x19, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8,
  0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0x01, 0xF9,
  0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xFB, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xF9, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFE,
  0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E,
  0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF8,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x07, 0xE0, 0x0F, 0xCF, 0xF8,
  0x7F, 0xC0, 0x3E, 0x7F, 0xF3, 0xFF, 0x80, 0xFB, 0xFF, 0xDF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x87, 0xFC,
  0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F,
  0x80, 0xFE, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x03,
  0xF0, 0x7E, 0x03, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x1F,
  0x83, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x81, 0xFC,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x83, 0xF8, 0x0F,
  0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x0F, 0xE0,
  0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x01, 0xF1, 0xFF, 0x00,
  0xF9, 0xFF, 0xC0, 0x7D, 0xFF, 0xE0, 0x3E, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x1F, 0xF0, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F,
  0xC1, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x3F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC1, 0xFC,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x3F,
  0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x87,
  0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0,
  0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x80,
  0x7F, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7F, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7E, 0x00,
  0xFC, 0xFE, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x1F,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x03,
  0xF1, 0xFE, 0x00, 0x1F, 0xBF, 0xF8, 0x00, 0xF9, 0xFF, 0xE0, 0x07, 0xDF,
  0xFF, 0x00, 0x3F, 0xE7, 0xF8, 0x03, 0xFE, 0x1F, 0xC0, 0x1F, 0xE0, 0x7E,
  0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x3F,
  0x80, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xF1, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xF3, 0xFF, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0x18, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x07, 0xC0, 0x1F, 0xF3, 0xF0, 0x0F, 0xFC, 0xFC, 0x07, 0xFF, 0xBE, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0x0F, 0xF8, 0x3F, 0x81, 0xFE,
  0x0F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE1, 0xFC,
  0x01, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1,
  0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xE0,
  0x7F, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFE, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xDF, 0x80, 0x1F, 0xC7, 0xE0, 0x00, 0x81, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0xF8, 0x1F, 0x9F,
  0xC0, 0xFD, 0xFE, 0x07, 0xCF, 0xE0, 0x3E, 0xFF, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xF8, 0xF8, 0x3F, 0x80, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x20, 0x0F, 0xE1, 0xE1, 0xFF, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0x18, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x0F, 0xFF, 0x3F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x20, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0,
  0x04, 0x00, 0x03, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x80, 0xFC,
  0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x1F,
  0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x03,
  0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0,
  0x7F, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0xC1, 0xF8,
  0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F,
  0x83, 0xFC, 0x1F, 0xE3, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xDF, 0x01,
  0xFF, 0xEF, 0x80, 0x7F, 0xE7, 0xC0, 0x1F, 0xC3, 0xE0, 0x01, 0x80, 0x00,
  0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF, 0x00, 0xFC,
  0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC,
  0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F,
  0x03, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0xFC, 0x03,
  0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xFF,
  0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x07,
  0xEF, 0xC0, 0x7F, 0x00, 0xFD, 0xF8, 0x0F, 0xE0, 0x3F, 0x3F, 0x03, 0xFC,
  0x07, 0xE7, 0xE0, 0x7F, 0x81, 0xFC, 0xFC, 0x1F, 0xF0, 0x3F, 0x1F, 0x83,
  0xFE, 0x07, 0xE3, 0xF0, 0x7F, 0xC1, 0xF8, 0x7E, 0x1F, 0xF8, 0x3F, 0x0F,
  0xC3, 0xFF, 0x07, 0xE1, 0xF8, 0x7F, 0xE1, 0xF8, 0x3F, 0x1F, 0x7C, 0x3F,
  0x07, 0xE3, 0xEF, 0x8F, 0xC0, 0xF8, 0xFD, 0xF1, 0xF8, 0x1F, 0x1F, 0x3E,
  0x3F, 0x03, 0xE3, 0xE7, 0xCF, 0xC0, 0xFC, 0xF8, 0xF9, 0xF8, 0x1F, 0x9F,
  0x1F, 0x3E, 0x03, 0xF7, 0xE3, 0xEF, 0xC0, 0x7E, 0xF8, 0x7D, 0xF8, 0x0F,
  0xDF, 0x1F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xF8, 0x7D, 0xF0,
  0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8,
  0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE7,
  0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x1F,
  0xC3, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x07, 0xF0, 0x1F,
  0xC0, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x1F,
  0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x8F, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x02, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x01, 0x3F, 0xF0, 0x01, 0x7F, 0xFC,
  0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x80, 0x03, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 16, 44, 15, 0, -43 },
  { 89, 19, 16, 22, 6, -43 },
  { 127, 29, 43, 27, 0, -43 },
  { 283, 26, 49, 25, 0, -46 },
  { 443, 35, 44, 40, 3, -43 },
  { 636, 29, 44, 29, 0, -43 },
  { 796, 9, 16, 13, 6, -43 },
  { 814, 19, 52, 16, 1, -43 },
  { 938, 20, 53, 16, -5, -44 },
  { 1071, 21, 23, 24, 5, -46 },
  { 1132, 24, 28, 27, 2, -35 },
  { 1216, 12, 16, 13, -3, -8 },
  { 1240, 15, 6, 17, 1, -19 },
  { 1252, 8, 9, 13, 0, -8 },
  { 1261, 29, 43, 21, -3, -43 },
  { 1417, 24, 44, 25, 1, -43 },
  { 1549, 18, 43, 25, 6, -43 },
  { 1646, 27, 43, 25, -2, -43 },
  { 1792, 27, 44, 25, -1, -43 },
  { 1941, 27, 43, 25, -1, -43 },
  { 2087, 26, 44, 25, 0, -43 },
  { 2230, 26, 45, 25, 1, -44 },
  { 2377, 26, 43, 25, 2, -43 },
  { 2517, 26, 44, 25, 0, -43 },
  { 2660, 25, 45, 25, 0, -44 },
  { 2801, 13, 34, 14, 0, -33 },
  { 2857, 17, 41, 14, -3, -33 },
  { 2945, 24, 28, 27, 2, -35 },
  { 3029, 24, 18, 27, 2, -30 },
  { 3083, 24, 28, 27, 2, -35 },
  { 3167, 21, 44, 19, 1, -43 },
  { 3283, 36, 48, 38, 1, -43 },
  { 3499, 27, 43, 27, -4, -43 },
  { 3645, 28, 43, 27, 0, -43 },
  { 3796, 27, 45, 25, 2, -44 },
  { 3948, 29, 43, 30, 0, -43 },
  { 4104, 26, 43, 23, 0, -43 },
  { 4244, 26, 43, 22, 0, -43 },
  { 4384, 30, 45, 31, 2, -44 },
  { 4553, 33, 43, 31, 0, -43 },
  { 4731, 25, 43, 18, -3, -43 },
  { 4866, 25, 55, 14, -9, -43 },
  { 5038, 32, 43, 26, 0, -43 },
  { 5210, 18, 43, 22, 0, -43 },
  { 5307, 42, 43, 41, 0, -43 },
  { 5533, 34, 43, 33, 0, -43 },
  { 5716, 29, 44, 32, 2, -43 },
  { 5876, 28, 43, 26, 0, -43 },
  { 6027, 29, 53, 32, 2, -43 },
  { 6220, 27, 43, 27, 0, -43 },
  { 6366, 27, 44, 24, -1, -43 },
  { 6515, 23, 43, 23, 4, -43 },
  { 6639, 30, 44, 30, 2, -43 },
  { 6804, 27, 43, 26, 5, -43 },
  { 6950, 42, 43, 41, 4, -43 },
  { 7176, 32, 43, 25, -3, -43 },
  { 7348, 24, 43, 24, 5, -43 },
  { 7477, 28, 43, 22, -2, -43 },
  { 7628, 23, 53, 17, -2, -43 },
  { 7781, 11, 43, 22, 6, -43 },
  { 7841, 23, 53, 17, -4, -43 },
  { 7994, 25, 25, 25, 0, -43 },
  { 8073, 20, 4, 19, -6, 5 },
  { 8083, 10, 10, 17, 9, -46 },
  { 8096, 26, 34, 27, 1, -33 },
  { 8207, 26, 47, 27, 0, -46 },
  { 8360, 22, 34, 21, 1, -33 },
  { 8454, 29, 47, 27, 1, -46 },
  { 8625, 23, 34, 24, 1, -33 },
  { 8723, 30, 60, 16, -7, -46 },
  { 8948, 28, 47, 27, -1, -33 },
  { 9113, 25, 46, 26, 0, -46 },
  { 9257, 15, 45, 13, 0, -45 },
  { 9342, 23, 59, 13, -8, -45 },
  { 9512, 27, 46, 24, 0, -46 },
  { 9668, 16, 46, 13, 0, -46 },
  { 9760, 38, 33, 39, 0, -33 },
  { 9917, 25, 33, 26, 0, -33 },
  { 10021, 24, 34, 26, 1, -33 },
  { 10123, 29, 47, 27, -3, -33 },
  { 10294, 26, 47, 27, 1, -33 },
  { 10447, 21, 33, 18, 0, -33 },
  { 10534, 21, 34, 21, 0, -33 },
  { 10624, 16, 41, 16, 2, -40 },
  { 10706, 25, 34, 26, 1, -33 },
  { 10813, 22, 33, 23, 4, -33 },
  { 10904, 35, 33, 35, 3, -33 },
  { 11049, 28, 33, 23, -3, -33 },
  { 11165, 31, 47, 23, -5, -33 },
  { 11348, 23, 33, 19, -2, -33 },
  { 11443, 23, 52, 20, 1, -43 },
  { 11593, 6, 60, 22, 8, -46 },
  { 11638, 23, 52, 20, -4, -43 },
  { 11788, 24, 9, 27, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC60PT7B_H_
