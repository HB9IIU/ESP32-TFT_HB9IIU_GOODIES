#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_ExtraCondensed_SemiBoldItalic
// Headers: 67

#include "NotoSans_ExtraCondensed_SemiBoldItalic6pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic7pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic8pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic9pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic10pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic11pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic12pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic13pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic14pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic15pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic16pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic17pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic18pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic19pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic20pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic21pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic22pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic23pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic24pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic25pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic26pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic27pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic28pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic29pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic30pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic31pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic32pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic33pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic34pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic35pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic36pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic37pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic38pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic39pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic40pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic41pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic42pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic43pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic44pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic45pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic46pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic47pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic48pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic49pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic50pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic51pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic52pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic53pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic54pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic55pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic56pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic57pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic58pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic59pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic60pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic61pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic62pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic63pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic64pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic65pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic66pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic67pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic68pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic69pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic70pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic71pt7b.h"
#include "NotoSans_ExtraCondensed_SemiBoldItalic72pt7b.h"
