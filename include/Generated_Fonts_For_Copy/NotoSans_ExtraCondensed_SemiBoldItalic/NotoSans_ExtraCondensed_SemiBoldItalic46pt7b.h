#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC46PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x78, 0x00, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8,
  0xF9, 0xF1, 0xE3, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3C, 0x78, 0x78,
  0xF0, 0xF1, 0xE3, 0xC7, 0x87, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xE0,
  0x03, 0xC7, 0x80, 0x0E, 0x1E, 0x00, 0x78, 0x70, 0x01, 0xE3, 0xC0, 0x07,
  0x0F, 0x00, 0x3C, 0x38, 0x00, 0xF1, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x07, 0x0F, 0x00, 0x3C, 0x38, 0x00,
  0xF1, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1C, 0x00, 0x78, 0xF0, 0x01, 0xC3,
  0xC0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x07, 0x87, 0x00,
  0x1E, 0x3C, 0x00, 0x70, 0xF0, 0x03, 0xC3, 0x80, 0x0F, 0x1E, 0x00, 0x38,
  0x78, 0x00, 0xE1, 0xE0, 0x07, 0x87, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00,
  0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xE9, 0xC0,
  0xF9, 0x84, 0x0F, 0x98, 0x00, 0xF9, 0x80, 0x0F, 0x98, 0x00, 0xFB, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x5F, 0x80, 0x0C,
  0xF8, 0x00, 0xCF, 0x80, 0x0C, 0xF8, 0x40, 0xCF, 0x86, 0x09, 0xF0, 0x7D,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x03, 0xE0, 0x0F, 0x00, 0xFE, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0x3C,
  0x0F, 0x01, 0xC7, 0x83, 0xC0, 0x78, 0xF0, 0x78, 0x0E, 0x1E, 0x1E, 0x03,
  0xC3, 0xC3, 0xC0, 0x78, 0x78, 0xF0, 0x0F, 0x0E, 0x1C, 0x01, 0xC3, 0xC7,
  0x80, 0x38, 0x78, 0xE0, 0x0F, 0x0F, 0x3C, 0x01, 0xE1, 0xCF, 0x0F, 0x3C,
  0x79, 0xE7, 0xF7, 0x8F, 0x79, 0xFF, 0xF3, 0xCF, 0x3D, 0xEF, 0xF3, 0xCF,
  0x1D, 0xFE, 0x79, 0xC3, 0x9F, 0x1E, 0x78, 0x70, 0x03, 0xCF, 0x0E, 0x00,
  0xF1, 0xC3, 0xC0, 0x1E, 0x78, 0x78, 0x07, 0x8F, 0x0F, 0x00, 0xE1, 0xE1,
  0xE0, 0x3C, 0x3C, 0x38, 0x07, 0x07, 0x8F, 0x01, 0xE0, 0xF1, 0xE0, 0x78,
  0x1E, 0x78, 0x0F, 0x03, 0xCF, 0x03, 0xC0, 0x7F, 0xC0, 0x78, 0x07, 0xF0,
  0x1E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7D, 0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00,
  0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x1F, 0x00, 0x3E, 0x78, 0x00, 0xFB,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x7C, 0x3F, 0xE1, 0xF1, 0xFF, 0xCF, 0x8F, 0x9F, 0x3E, 0x3E,
  0x7C, 0xF1, 0xF1, 0xFF, 0xC7, 0x83, 0xFE, 0x3E, 0x0F, 0xF8, 0xF8, 0x3F,
  0xC3, 0xE0, 0x7F, 0x0F, 0x81, 0xF8, 0x3E, 0x0F, 0xE0, 0xFC, 0x7F, 0xC3,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xF9, 0xF8, 0x3F, 0xC3, 0xF0, 0x7E,
  0xF9, 0xF3, 0xE7, 0xCF, 0x3E, 0x7C, 0xF9, 0xE3, 0xC7, 0x80, 0x00, 0x3E,
  0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x41, 0xE0,
  0x71, 0xC0, 0x7D, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x07, 0xFF,
  0x0F, 0xE0, 0x1F, 0xE0, 0x3E, 0xF0, 0x7C, 0xF8, 0x3C, 0x78, 0x18, 0x7C,
  0x08, 0x60, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8,
  0xF8, 0x7C, 0x3C, 0x3E, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFC, 0x3D, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0x07, 0xEF,
  0xC1, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF3,
  0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF7, 0xC0, 0x7D, 0xF0,
  0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xEF, 0xC0, 0xFB, 0xE0, 0x7E, 0xF8, 0x1F,
  0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F,
  0x87, 0xC3, 0xE3, 0xF0, 0xF9, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFF,
  0x0F, 0xF8, 0xFF, 0xCF, 0xBE, 0xFB, 0xE7, 0x9F, 0x18, 0xF8, 0x87, 0xC0,
  0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0x1F, 0x80,
  0xE0, 0x7C, 0x02, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x1E, 0x3F, 0x80, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE1,
  0x00, 0x7E, 0x0E, 0x07, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x3B, 0xE0, 0x03, 0xDF, 0x00, 0x1C, 0xF0, 0x01, 0xEF, 0x80,
  0x1E, 0x7C, 0x00, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0xF0, 0xF0, 0x07, 0x8F,
  0x80, 0x78, 0x7C, 0x03, 0x83, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xF0, 0x1C,
  0x0F, 0x81, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x30, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x83, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x08, 0x07, 0xE0, 0xE0, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0x82, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE7,
  0xC0, 0x7D, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0x9F, 0x8F, 0xC3,
  0xF1, 0xF8, 0x3E, 0x7E, 0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x3F, 0x3E, 0x07,
  0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0xF8, 0x7C, 0x3F,
  0x07, 0xCF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F,
  0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xC3,
  0xF0, 0x7C, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x7C, 0x07, 0xCF, 0xC0, 0x7F, 0xF8, 0x03,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xBE, 0x03,
  0xF3, 0xF0, 0x7E, 0x1F, 0x07, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0x80, 0xF8,
  0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xFC, 0x3F,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7E, 0x7E, 0x1F,
  0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C,
  0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8,
  0x7E, 0x1F, 0x9F, 0xC3, 0xFF, 0xF8, 0x7F, 0xDF, 0x07, 0xFF, 0xC0, 0x7C,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x08, 0x1F, 0x81, 0xFF, 0xF0, 0x3F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0,
  0xF8, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1E, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x81, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x38,
  0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x3F,
  0x80, 0x0F, 0x80, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x0F,
  0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1C, 0x3F, 0x10, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0x80,
  0xF0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE1, 0xE0, 0xFF,
  0x1C, 0x38, 0x3F, 0xE3, 0x8F, 0x0F, 0xFC, 0x71, 0xC3, 0xC7, 0x8E, 0x78,
  0xF0, 0xE1, 0xCE, 0x1E, 0x3C, 0x39, 0xC3, 0x87, 0x87, 0x78, 0xF0, 0xF1,
  0xEE, 0x1C, 0x1C, 0x3D, 0xC3, 0x87, 0x87, 0x38, 0xF0, 0xF0, 0xEF, 0x1E,
  0x1E, 0x3D, 0xE3, 0xC7, 0x87, 0x3C, 0x78, 0xF0, 0xE7, 0x8F, 0x3E, 0x38,
  0xF1, 0xEF, 0xEF, 0x1E, 0x3F, 0xDF, 0xC3, 0xC3, 0xF3, 0xF0, 0x78, 0x18,
  0x38, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x80, 0x07, 0xF1, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x0F,
  0x3C, 0x00, 0xF9, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0x78, 0x03, 0xE3, 0xC0,
  0x3E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x87, 0x80, 0xF8, 0x3C, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xE0, 0x1F,
  0x9F, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x01,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3E, 0x3F,
  0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E,
  0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xC3, 0xF0,
  0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xC3,
  0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87,
  0xC0, 0x7C, 0x3E, 0x07, 0xE3, 0xF0, 0x3E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F,
  0x87, 0xC3, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xF9, 0xE0, 0x7E, 0x04, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x40,
  0xFE, 0x1C, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0x87, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0x80,
  0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x1F, 0x80, 0xFC,
  0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x01, 0xF8, 0xFC,
  0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E, 0x07, 0xE1, 0xF8, 0x1F,
  0x87, 0xC0, 0xFC, 0x1F, 0x0F, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x08, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xCF, 0x80, 0xFE, 0x03, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x0F, 0xF8, 0xFC, 0x1F, 0xF1, 0xF8, 0x3F, 0xE3, 0xE0, 0x7F,
  0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8,
  0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x07,
  0xE0, 0x3E, 0x07, 0xF0, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0,
  0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x81, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x1F, 0x03, 0xF0, 0x1F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x80,
  0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x8F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x00,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x7C,
  0x03, 0xE0, 0xF8, 0x03, 0xE1, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0,
  0x07, 0xC7, 0xE0, 0x07, 0xCF, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x80,
  0x0F, 0xBF, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xBE, 0x00,
  0x1F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x01,
  0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03,
  0xFE, 0x07, 0xBC, 0x07, 0xFC, 0x07, 0xBC, 0x07, 0xFC, 0x0F, 0xBC, 0x0F,
  0xFC, 0x0F, 0xBC, 0x0F, 0x7C, 0x0F, 0xBC, 0x1F, 0x7C, 0x0F, 0xBC, 0x1E,
  0x78, 0x0F, 0x3C, 0x3E, 0xF8, 0x1F, 0x3C, 0x3C, 0xF8, 0x1F, 0x3C, 0x3C,
  0xF8, 0x1F, 0x3C, 0x7C, 0xF8, 0x1F, 0x3C, 0x79, 0xF0, 0x1E, 0x3C, 0xF9,
  0xF0, 0x3E, 0x3C, 0xF1, 0xF0, 0x3E, 0x3D, 0xF1, 0xF0, 0x3E, 0x3D, 0xE1,
  0xF0, 0x3C, 0x3F, 0xE3, 0xE0, 0x3C, 0x3F, 0xC3, 0xE0, 0x7C, 0x3F, 0xC3,
  0xE0, 0x7C, 0x3F, 0x83, 0xE0, 0x7C, 0x3F, 0x83, 0xC0, 0x78, 0x3F, 0x87,
  0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3E, 0x07,
  0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x3F, 0x80, 0x7C, 0x0F,
  0xE0, 0x1F, 0x03, 0xF8, 0x07, 0x80, 0xFE, 0x03, 0xE0, 0x3F, 0xC0, 0xF8,
  0x1F, 0xF0, 0x3E, 0x07, 0xFC, 0x0F, 0x81, 0xEF, 0x03, 0xC0, 0x7B, 0xC1,
  0xF0, 0x3E, 0xF0, 0x7C, 0x0F, 0xBE, 0x1F, 0x03, 0xEF, 0x87, 0x80, 0xF9,
  0xE3, 0xE0, 0x3C, 0x78, 0xF8, 0x1F, 0x1E, 0x3E, 0x07, 0xC7, 0xCF, 0x81,
  0xF1, 0xF3, 0xC0, 0x78, 0x7D, 0xF0, 0x1E, 0x0F, 0x7C, 0x0F, 0x83, 0xDF,
  0x03, 0xE0, 0xF7, 0xC0, 0xF8, 0x3F, 0xE0, 0x3C, 0x0F, 0xF8, 0x0F, 0x03,
  0xFE, 0x07, 0xC0, 0x7F, 0x81, 0xF0, 0x1F, 0xC0, 0x7C, 0x07, 0xF0, 0x1E,
  0x01, 0xFC, 0x0F, 0x80, 0x7F, 0x03, 0xE0, 0x1F, 0xC0, 0xF8, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE,
  0x07, 0xF3, 0xF8, 0x3F, 0x83, 0xE0, 0xFC, 0x0F, 0x87, 0xE0, 0x3F, 0x1F,
  0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x7E, 0x00,
  0xFD, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFB,
  0xF0, 0x07, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0,
  0x0F, 0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x3F,
  0x0F, 0x80, 0xFC, 0x3F, 0x07, 0xE0, 0xFE, 0x7F, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0x87,
  0xE0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x07, 0xE0, 0xF8,
  0x3F, 0x03, 0xE1, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0xFF, 0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0x83, 0xE0, 0xFC, 0x0F, 0x87, 0xE0,
  0x3F, 0x1F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3F,
  0x7E, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC,
  0x00, 0xFB, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x01,
  0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE3,
  0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3F, 0x07, 0xE0, 0xFE, 0x7F, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3E, 0xFF, 0x01, 0xF0, 0xFC,
  0x0F, 0x87, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0,
  0x7E, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x1F, 0x81,
  0xF3, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xF3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E,
  0x3F, 0x01, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0,
  0x3E, 0x0F, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0x00,
  0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x03, 0xF8, 0x10, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x10, 0x07, 0xE0, 0xC0, 0x7E,
  0x07, 0xDF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F,
  0xFF, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE1, 0xF8, 0x0F,
  0x87, 0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x0F,
  0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x1F, 0x80,
  0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x01, 0xF0,
  0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE0, 0xF8,
  0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x81, 0xF8, 0x3E, 0x0F, 0xC0, 0xFC, 0x7F,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07,
  0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0x81,
  0xF0, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0xF8,
  0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x0F,
  0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x1F, 0x7C, 0x03, 0xE0, 0x1F, 0x7C, 0x03, 0xE0, 0x3E, 0x7C,
  0x07, 0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0x7E, 0x7C, 0x0F, 0xE0, 0x7C, 0x7C,
  0x0F, 0xE0, 0x7C, 0x7C, 0x0F, 0xE0, 0xF8, 0x7C, 0x1F, 0xE0, 0xF8, 0x7C,
  0x1F, 0xC0, 0xF8, 0x7C, 0x3F, 0xC1, 0xF0, 0x7C, 0x3F, 0xC1, 0xF0, 0x7C,
  0x3F, 0xC3, 0xE0, 0x78, 0x7B, 0xC3, 0xE0, 0x78, 0x7B, 0xC3, 0xE0, 0x78,
  0xFB, 0xC7, 0xC0, 0x78, 0xF3, 0xC7, 0xC0, 0x78, 0xF3, 0xCF, 0x80, 0x79,
  0xF3, 0xCF, 0x80, 0x79, 0xE3, 0xCF, 0x80, 0x7B, 0xE3, 0xDF, 0x00, 0xFB,
  0xC3, 0xDF, 0x00, 0xFB, 0xC3, 0xDE, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xF9, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xCF, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x00, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x80, 0xFB, 0xE0, 0x7E, 0x7C, 0x1F, 0x1F, 0x0F, 0xC7, 0xC3, 0xE1, 0xF1,
  0xF0, 0x7C, 0x7C, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF7, 0xC0, 0x7D, 0xF0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xF0,
  0xF0, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C,
  0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x1F, 0x0F, 0x0F, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xEF, 0x80,
  0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xC0, 0xF8, 0x7C, 0x3E, 0x07, 0x87,
  0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xEF, 0x80, 0x3F, 0xE0, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFD, 0xF9, 0xF3, 0xE3, 0xE3, 0xC7,
  0x80, 0x01, 0xF9, 0xF0, 0x3F, 0x9E, 0x07, 0xFD, 0xE0, 0xFF, 0xFE, 0x1F,
  0x8F, 0xE1, 0xF0, 0x7E, 0x3F, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC7,
  0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8,
  0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3F,
  0x0F, 0x83, 0xF0, 0xFC, 0x7E, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFB,
  0xE0, 0x3F, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x7F, 0xFC, 0x07, 0xBF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xE3, 0xE0, 0xFC, 0x3E, 0x0F, 0x83, 0xF1, 0xF8,
  0x3F, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xE0, 0x3E, 0x3E,
  0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC7,
  0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0x3F, 0xC0, 0xF3, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xFF,
  0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xC6, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x10,
  0xFC, 0x30, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x1F, 0x9F, 0x00, 0xFF, 0x78, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x81, 0xF8, 0xFE, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F,
  0xFF, 0x80, 0x7F, 0xDE, 0x01, 0xFE, 0x78, 0x03, 0xF1, 0xC0, 0x00, 0x00,
  0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF1, 0xF8, 0xF8, 0xF8, 0x3C,
  0xF8, 0x1E, 0x7C, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F, 0x9F, 0x7F, 0x8F, 0xFF,
  0x8F, 0xFF, 0x87, 0xFF, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0x7F, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0x88, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x02, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x7C, 0x03, 0xFD, 0xE0, 0x1F, 0xF7, 0x80, 0xFF, 0xFE, 0x07,
  0xE3, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0xFC, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0xFC, 0x0F, 0x87, 0xF0, 0x3F, 0x1F, 0x80, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFB, 0xE0, 0x0F, 0xCF, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x08, 0x07,
  0xE0, 0x3C, 0x3F, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x7E, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF,
  0xC3, 0xF9, 0xF8, 0x7E, 0x1F, 0x0F, 0x83, 0xE3, 0xF0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E,
  0x3E, 0x07, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8,
  0xF8, 0x3E, 0x1F, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3,
  0xE0, 0xF8, 0x00, 0x00, 0x40, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x01, 0x00, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x2F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x7E, 0x0F, 0x87, 0xE0,
  0x78, 0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x3E, 0x01, 0xF3, 0xF0, 0x0F, 0x1F,
  0x00, 0x79, 0xF0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xEF, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0x7C, 0x01, 0xFB, 0xE0,
  0x0F, 0x9F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xE0, 0x3E, 0x1F, 0x01, 0xE0,
  0xF8, 0x0F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC0,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0x9F, 0x87, 0xE0, 0x3D, 0xFE, 0x7F,
  0x81, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFE, 0x7F, 0x9F, 0x87,
  0xE1, 0xF8, 0x7C, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1E, 0x1F, 0x07,
  0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x3C, 0x0F, 0x83,
  0xE3, 0xE0, 0x78, 0x1E, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x87,
  0xC1, 0xF0, 0x7C, 0x3C, 0x0F, 0x83, 0xE3, 0xE0, 0x78, 0x1E, 0x1F, 0x07,
  0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x3C, 0x0F, 0x83,
  0xE3, 0xE0, 0x78, 0x1E, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x80,
  0x07, 0x8F, 0x80, 0xF7, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFE, 0x7E,
  0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x78,
  0x7C, 0x1F, 0x0F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xE1,
  0xF0, 0x7C, 0x3E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0x87,
  0xC1, 0xF0, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x3E, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x8F, 0x87,
  0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x7E, 0x07, 0xDF, 0x01, 0xF7, 0xC0,
  0x7D, 0xF0, 0x1F, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E,
  0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xF3, 0xE0, 0xF8, 0xFC, 0x7E, 0x1F,
  0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xE3, 0xE0,
  0x07, 0xBF, 0xC0, 0x1E, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xF8, 0xF8, 0x0F,
  0xC3, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3E, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8,
  0x0F, 0xBF, 0xC0, 0x3E, 0x7E, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF9, 0xF0, 0x3F, 0xDE, 0x07, 0xFD, 0xE0, 0xFF, 0xFE, 0x1F, 0x8F,
  0xE1, 0xF0, 0x7E, 0x3F, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xC0,
  0x7C, 0x7C, 0x07, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x8F, 0x80, 0xF8, 0xF8,
  0x0F, 0x8F, 0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F,
  0x83, 0xF0, 0xFC, 0x7E, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFB, 0xE0,
  0x3F, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0x9F, 0x07, 0xBF, 0x07, 0xBF,
  0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFF,
  0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0x06, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x80, 0xF8,
  0xC1, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xFC, 0xFF, 0xE7, 0xFE, 0x7F,
  0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x0F,
  0x83, 0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x8F, 0x81, 0xE1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0x87, 0xC1, 0xF0, 0xF8,
  0x3E, 0x1E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1E, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0x78, 0x1F, 0x1F, 0x07, 0xE3, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F, 0x8F,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFD, 0xE0, 0x3F, 0x3C, 0x00, 0xF8,
  0x1F, 0xFC, 0x0F, 0xBE, 0x07, 0xDE, 0x07, 0xCF, 0x03, 0xE7, 0x83, 0xE3,
  0xC1, 0xF1, 0xE0, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x7C, 0x1E, 0x3E,
  0x0F, 0x3E, 0x07, 0x9F, 0x03, 0xCF, 0x01, 0xEF, 0x80, 0xF7, 0x80, 0x7B,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x83, 0xEF, 0x83, 0xF0, 0x7D,
  0xF0, 0xFE, 0x0F, 0x3C, 0x1F, 0xC3, 0xE7, 0x83, 0xF8, 0x7C, 0xF0, 0xFF,
  0x1F, 0x1E, 0x1F, 0xE3, 0xE3, 0xC7, 0xB8, 0x78, 0x78, 0xF7, 0x1F, 0x0F,
  0x1F, 0xE3, 0xE1, 0xE7, 0xBC, 0x78, 0x3C, 0xF7, 0x9F, 0x07, 0x9E, 0xF3,
  0xC0, 0xF7, 0x9E, 0xF8, 0x1E, 0xF3, 0xDF, 0x03, 0xFC, 0x7B, 0xC0, 0x7F,
  0x8F, 0xF8, 0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xF8,
  0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x0F, 0x87, 0xE0,
  0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x07, 0x9F, 0x00, 0x1E,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xCF,
  0x80, 0x1F, 0x1E, 0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0,
  0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x3E,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0xF8,
  0x01, 0xF0, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF3, 0xE0,
  0x01, 0xF3, 0xE0, 0x01, 0xF3, 0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xF7, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x4F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x0F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x18, 0x00, 0x5F, 0xE0, 0x1F, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 13, 33, 11, 0, -33 },
  { 55, 15, 12, 17, 4, -33 },
  { 78, 22, 33, 21, 0, -33 },
  { 169, 20, 38, 19, 0, -35 },
  { 264, 27, 33, 31, 2, -33 },
  { 376, 22, 33, 22, 0, -33 },
  { 467, 7, 12, 10, 5, -33 },
  { 478, 15, 40, 12, 1, -33 },
  { 553, 15, 40, 12, -4, -33 },
  { 628, 16, 17, 18, 4, -35 },
  { 662, 18, 22, 21, 2, -27 },
  { 712, 9, 12, 10, -2, -6 },
  { 726, 11, 5, 13, 1, -15 },
  { 733, 6, 6, 10, 0, -6 },
  { 738, 22, 33, 16, -2, -33 },
  { 829, 18, 33, 19, 1, -33 },
  { 904, 13, 33, 19, 5, -33 },
  { 958, 21, 33, 19, -2, -33 },
  { 1045, 21, 33, 19, -1, -33 },
  { 1132, 21, 33, 19, -1, -33 },
  { 1219, 20, 33, 19, 0, -33 },
  { 1302, 19, 33, 19, 1, -33 },
  { 1381, 20, 33, 19, 1, -33 },
  { 1464, 20, 33, 19, 0, -33 },
  { 1547, 19, 33, 19, 0, -33 },
  { 1626, 10, 25, 10, 0, -25 },
  { 1658, 12, 31, 10, -2, -25 },
  { 1705, 18, 21, 21, 2, -27 },
  { 1753, 18, 14, 21, 2, -23 },
  { 1785, 18, 21, 21, 2, -27 },
  { 1833, 16, 33, 15, 1, -33 },
  { 1899, 27, 37, 29, 1, -33 },
  { 2024, 21, 33, 20, -3, -33 },
  { 2111, 21, 33, 21, 0, -33 },
  { 2198, 20, 33, 19, 2, -33 },
  { 2281, 22, 33, 23, 0, -33 },
  { 2372, 20, 33, 18, 0, -33 },
  { 2455, 20, 33, 17, 0, -33 },
  { 2538, 23, 33, 24, 2, -33 },
  { 2633, 25, 33, 24, 0, -33 },
  { 2737, 19, 33, 14, -2, -33 },
  { 2816, 19, 42, 11, -7, -33 },
  { 2916, 24, 33, 20, 0, -33 },
  { 3015, 14, 33, 17, 0, -33 },
  { 3073, 32, 33, 31, 0, -33 },
  { 3205, 26, 33, 25, 0, -33 },
  { 3313, 22, 33, 24, 2, -33 },
  { 3404, 22, 33, 20, 0, -33 },
  { 3495, 22, 41, 24, 2, -33 },
  { 3608, 21, 33, 21, 0, -33 },
  { 3695, 21, 33, 18, -1, -33 },
  { 3782, 18, 33, 17, 3, -33 },
  { 3857, 22, 33, 23, 2, -33 },
  { 3948, 20, 33, 20, 4, -33 },
  { 4031, 32, 33, 31, 3, -33 },
  { 4163, 25, 33, 19, -3, -33 },
  { 4267, 18, 33, 18, 4, -33 },
  { 4342, 22, 33, 17, -2, -33 },
  { 4433, 18, 40, 13, -2, -33 },
  { 4523, 8, 33, 17, 5, -33 },
  { 4556, 18, 40, 13, -3, -33 },
  { 4646, 19, 19, 19, 0, -33 },
  { 4692, 15, 3, 15, -4, 4 },
  { 4698, 7, 7, 13, 7, -35 },
  { 4705, 20, 25, 21, 1, -25 },
  { 4768, 20, 35, 20, 0, -35 },
  { 4856, 16, 25, 16, 1, -25 },
  { 4906, 22, 35, 21, 1, -35 },
  { 5003, 17, 25, 19, 1, -25 },
  { 5057, 22, 46, 12, -5, -35 },
  { 5184, 22, 36, 21, -1, -25 },
  { 5283, 19, 35, 20, 0, -35 },
  { 5367, 12, 35, 10, 0, -35 },
  { 5420, 18, 46, 10, -6, -35 },
  { 5524, 21, 35, 18, 0, -35 },
  { 5616, 12, 35, 10, 0, -35 },
  { 5669, 29, 25, 30, 0, -25 },
  { 5760, 19, 25, 20, 0, -25 },
  { 5820, 18, 25, 20, 1, -25 },
  { 5877, 22, 36, 20, -2, -25 },
  { 5976, 20, 36, 20, 1, -25 },
  { 6066, 16, 25, 14, 0, -25 },
  { 6116, 16, 25, 16, 0, -25 },
  { 6166, 13, 30, 13, 1, -30 },
  { 6215, 19, 25, 20, 1, -25 },
  { 6275, 17, 25, 17, 3, -25 },
  { 6329, 27, 25, 27, 2, -25 },
  { 6414, 22, 25, 18, -2, -25 },
  { 6483, 24, 36, 17, -4, -25 },
  { 6591, 18, 25, 15, -2, -25 },
  { 6648, 17, 40, 15, 1, -33 },
  { 6733, 4, 46, 17, 6, -35 },
  { 6756, 18, 40, 15, -3, -33 },
  { 6846, 18, 7, 21, 2, -20 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC46PT7B_H_
