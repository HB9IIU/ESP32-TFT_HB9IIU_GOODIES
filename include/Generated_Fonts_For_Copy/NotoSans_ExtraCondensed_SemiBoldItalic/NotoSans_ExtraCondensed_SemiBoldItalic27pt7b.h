#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC27PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xE1, 0x83,
  0x00, 0x00, 0x30, 0xF1, 0xE3, 0x80, 0x77, 0xE7, 0xE7, 0xE6, 0xC6, 0xCE,
  0xCC, 0x03, 0x38, 0x19, 0x81, 0xCC, 0x0C, 0xE0, 0x66, 0x1F, 0xFC, 0xFF,
  0xE1, 0x98, 0x0C, 0xC0, 0xC6, 0x06, 0x61, 0xFF, 0xCF, 0xFE, 0x19, 0x80,
  0xCC, 0x0C, 0x60, 0x67, 0x03, 0x30, 0x39, 0x80, 0x00, 0x80, 0x08, 0x01,
  0x80, 0x7F, 0x1F, 0xE1, 0xD6, 0x39, 0x03, 0xA0, 0x3E, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x5C, 0x05, 0xC0, 0x5C, 0xCD, 0xCF, 0xF8, 0xFF,
  0x03, 0xE0, 0x08, 0x01, 0x00, 0x10, 0x00, 0x04, 0x02, 0x1E, 0x0C, 0x3F,
  0x1C, 0x33, 0x18, 0x67, 0x38, 0x67, 0x30, 0x66, 0x60, 0xE6, 0x60, 0xE6,
  0xCE, 0xEC, 0xDF, 0xFD, 0x9B, 0x79, 0xB3, 0x23, 0x33, 0x07, 0x73, 0x06,
  0x63, 0x0E, 0x67, 0x0C, 0x66, 0x1C, 0x66, 0x18, 0x7C, 0x38, 0x38, 0x01,
  0x00, 0x3E, 0x03, 0xF8, 0x19, 0xC0, 0xCE, 0x0E, 0x70, 0x73, 0x01, 0xB8,
  0x0F, 0x80, 0x78, 0x07, 0xCE, 0x7E, 0x67, 0x77, 0x71, 0xFB, 0x8F, 0x9C,
  0x7C, 0xE3, 0xC7, 0x3E, 0x3F, 0xF8, 0xF9, 0xC0, 0x7E, 0xEE, 0xEC, 0xC0,
  0x03, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x06, 0x03,
  0x81, 0xC0, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x07, 0x03,
  0x83, 0x81, 0xC1, 0xC1, 0xC0, 0x0C, 0x03, 0x84, 0xE1, 0xB1, 0xFF, 0xCF,
  0xF1, 0xE0, 0xF8, 0x77, 0x08, 0xC0, 0x20, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x39, 0xDC, 0xEE, 0x73, 0x00, 0x7E, 0xFF, 0xF8, 0x6F, 0xFE, 0x00,
  0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x00, 0x02, 0x03, 0xE1, 0xFC, 0x77, 0x39,
  0xCC, 0x77, 0x1D, 0xC7, 0x61, 0xF8, 0x7E, 0x1F, 0x8E, 0xE3, 0xB8, 0xEC,
  0x3B, 0x1C, 0xC7, 0x3B, 0x8F, 0xC1, 0xE0, 0x0F, 0x1E, 0x3E, 0x7E, 0xEE,
  0xCC, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70,
  0x70, 0x70, 0x00, 0x80, 0x7E, 0x0F, 0xF0, 0xC7, 0x08, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0xC0, 0x38, 0x07, 0xFC, 0xFF, 0xCF, 0xF8, 0x01, 0x00, 0xFE, 0x1F,
  0xE1, 0x8E, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x03, 0xC1, 0xF0, 0x1F,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x8C, 0xF8, 0xFF,
  0x0F, 0xE0, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x06, 0xC0, 0x7C, 0x0D,
  0xC1, 0xDC, 0x19, 0xC3, 0x18, 0x73, 0x86, 0x38, 0xFF, 0xEF, 0xFC, 0xFF,
  0xC0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x0F, 0xF0, 0xFE, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0xF0, 0x3F, 0x83, 0xFC, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC8, 0x38, 0xEF, 0x8F, 0xF0, 0xFC, 0x00,
  0x00, 0xC0, 0xFC, 0x3F, 0x8F, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0x7F,
  0x9F, 0xF3, 0xCE, 0x71, 0xCE, 0x39, 0xC7, 0x38, 0xE7, 0x1C, 0xE7, 0x1D,
  0xE3, 0xF8, 0x3E, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x00, 0x01, 0x00, 0xFE,
  0x1F, 0xE1, 0xCF, 0x18, 0x73, 0x87, 0x38, 0xE1, 0xDE, 0x1F, 0xC0, 0xF8,
  0x1F, 0x03, 0xB8, 0x73, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCF, 0x38,
  0x7F, 0x07, 0xE0, 0x01, 0x01, 0xF8, 0x7F, 0x8E, 0x73, 0x8E, 0x71, 0xCE,
  0x39, 0x87, 0x70, 0xEF, 0x3C, 0xFF, 0x9F, 0xE1, 0xDC, 0x03, 0x80, 0xE0,
  0x1C, 0x07, 0x13, 0xE3, 0xF8, 0x7E, 0x00, 0x08, 0x73, 0xC6, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0xF3, 0xCE, 0x00, 0x06, 0x1C, 0x78, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x1C, 0x38, 0xE1, 0xC3, 0x00,
  0x00, 0x20, 0x1C, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x3C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0x70, 0x02, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x80, 0x1C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x07,
  0xC0, 0x78, 0x3E, 0x1F, 0x0F, 0x83, 0xC0, 0x60, 0x08, 0x00, 0x04, 0x1F,
  0x9F, 0xE4, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x0E, 0x06, 0x07,
  0x03, 0x00, 0x00, 0x00, 0x40, 0x70, 0x38, 0x1C, 0x00, 0x03, 0xF8, 0x07,
  0x9C, 0x0E, 0x06, 0x18, 0x06, 0x38, 0x03, 0x31, 0xF3, 0x63, 0xF3, 0x66,
  0x73, 0x66, 0x66, 0xCC, 0x66, 0xCC, 0x66, 0xCC, 0xE6, 0xCC, 0xCC, 0xCD,
  0xCC, 0xCF, 0x78, 0xC6, 0x70, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x40, 0x7F,
  0xC0, 0x3F, 0x80, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1B, 0x03, 0xB0, 0x3B,
  0x03, 0x30, 0x73, 0x07, 0x70, 0xE7, 0x0E, 0x71, 0xFF, 0x1F, 0xF1, 0xFF,
  0x38, 0x73, 0x87, 0x78, 0x77, 0x07, 0xF0, 0x70, 0x0F, 0xE0, 0x7F, 0x87,
  0x1C, 0x38, 0xF1, 0xC7, 0x8E, 0x38, 0x71, 0xC7, 0x1C, 0x3F, 0xC1, 0xFE,
  0x0E, 0x78, 0x61, 0xC7, 0x0E, 0x38, 0x71, 0xC3, 0x8E, 0x38, 0xFF, 0xC7,
  0xFC, 0x3F, 0xC0, 0x00, 0xC0, 0x7F, 0x0F, 0xF1, 0xE2, 0x3C, 0x03, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0xB0, 0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x7F,
  0x87, 0x3E, 0x38, 0xF1, 0xC3, 0x8E, 0x1C, 0x70, 0xE7, 0x07, 0x38, 0x39,
  0xC3, 0xCE, 0x1E, 0x70, 0xE7, 0x07, 0x38, 0x71, 0xC7, 0x8E, 0x78, 0xFF,
  0xC7, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x3F, 0xC3, 0xF8, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFE,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x3F, 0xC3, 0xF8,
  0x3F, 0x83, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x00, 0x00, 0x40, 0x1F, 0xF0, 0xFF, 0x87, 0xC6, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC7, 0xCE, 0x1F, 0x38, 0xFC, 0xE0,
  0xF3, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xF0, 0xE1, 0xF7, 0x07, 0xFC, 0x0F,
  0xE0, 0x0E, 0x1E, 0x1C, 0x38, 0x78, 0x70, 0xE0, 0xE1, 0xC1, 0xC3, 0x87,
  0x07, 0x0E, 0x1C, 0x1C, 0x3F, 0xF8, 0x7F, 0xF0, 0xE1, 0xC1, 0xC3, 0x87,
  0x07, 0x0E, 0x0E, 0x1C, 0x3C, 0x38, 0x70, 0xF0, 0xE1, 0xC1, 0xC3, 0x87,
  0x80, 0x0F, 0xE1, 0xF8, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38,
  0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE1, 0x38, 0x3F, 0x07,
  0xC0, 0x40, 0x00, 0x0E, 0x1C, 0x38, 0xE1, 0xC7, 0x07, 0x3C, 0x1C, 0xE0,
  0x77, 0x01, 0xFC, 0x0E, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0E, 0xE0,
  0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x00, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x70, 0x70, 0x70, 0x70, 0xFF, 0xFF, 0xFF, 0x0F, 0x03, 0xE1, 0xE0,
  0x7C, 0x7C, 0x0F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x86, 0xC3,
  0x71, 0xD8, 0xEC, 0x3B, 0x1F, 0x87, 0x67, 0x70, 0xEC, 0xEE, 0x19, 0x99,
  0xC7, 0x37, 0x70, 0xE6, 0xCE, 0x1C, 0xF9, 0xC3, 0x1E, 0x38, 0xE3, 0xC6,
  0x1C, 0x71, 0xC3, 0x8E, 0x38, 0x00, 0x0F, 0x0E, 0x1E, 0x1C, 0x7C, 0x38,
  0xF8, 0x71, 0xF0, 0xC3, 0x63, 0x86, 0xE7, 0x1D, 0xCE, 0x3B, 0x9C, 0x77,
  0x30, 0xE6, 0xE1, 0x8D, 0xC7, 0x1F, 0x8E, 0x3F, 0x1C, 0x7C, 0x30, 0xF8,
  0xE0, 0xF1, 0xC1, 0xE3, 0x83, 0x80, 0x00, 0x80, 0x3F, 0x03, 0xFC, 0x3C,
  0xF3, 0xC3, 0x9C, 0x1D, 0xE0, 0xEE, 0x07, 0x70, 0x3F, 0x83, 0xFC, 0x1F,
  0xC0, 0xEE, 0x07, 0x70, 0x7B, 0x83, 0x9C, 0x1C, 0xE1, 0xC7, 0xFE, 0x1F,
  0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x87, 0x3C, 0x38, 0xF1, 0xC3, 0x8E,
  0x3C, 0x71, 0xC7, 0x0E, 0x38, 0xF1, 0xFF, 0x0F, 0xF0, 0x7E, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x00, 0x00, 0x80,
  0x3F, 0x03, 0xFC, 0x3C, 0xF3, 0xC3, 0x9C, 0x1D, 0xE0, 0xEE, 0x07, 0x70,
  0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xEE, 0x07, 0x70, 0x7B, 0x83, 0x9C, 0x1C,
  0xE1, 0xC7, 0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0xF0, 0x07, 0x80, 0x0F, 0xE0, 0xFF, 0x1C, 0xF1, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x73, 0x8F, 0x39, 0xE3, 0xFC, 0x3F, 0x83, 0x38, 0x73, 0x87, 0x38,
  0x73, 0x87, 0x38, 0xE1, 0xCE, 0x1C, 0xE1, 0xC0, 0x00, 0x40, 0x3F, 0xC3,
  0xFC, 0x1E, 0x61, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x41, 0xC3,
  0xFE, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0xFF, 0xF1, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x0E, 0x00, 0x1C, 0x38, 0xE1, 0xCE, 0x0E, 0x70, 0xF3,
  0x87, 0x1C, 0x39, 0xE1, 0xCE, 0x0E, 0x70, 0xE3, 0x87, 0x1C, 0x39, 0xE1,
  0xCE, 0x0E, 0x70, 0xE3, 0x87, 0x1C, 0x78, 0xFF, 0x83, 0xFC, 0x1F, 0x80,
  0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xCE, 0x1C, 0xE3, 0x8E, 0x38,
  0xE3, 0x0E, 0x70, 0x67, 0x06, 0xE0, 0x6E, 0x06, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x70, 0x00, 0xE0, 0xE1, 0xFC, 0x1C, 0x3B, 0x87, 0x87,
  0x70, 0xF1, 0xCE, 0x3E, 0x39, 0xC7, 0xCE, 0x38, 0xF9, 0xC7, 0x3F, 0x38,
  0xE6, 0xCE, 0x1D, 0xD9, 0xC3, 0xBB, 0x30, 0x76, 0x6E, 0x0F, 0xCD, 0xC1,
  0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x03,
  0x83, 0x80, 0x00, 0x07, 0x0E, 0x0E, 0x38, 0x1C, 0x70, 0x39, 0xC0, 0x37,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x01, 0xD8, 0x07, 0x38, 0x1E, 0x70, 0x38, 0xE0, 0xE1,
  0xC3, 0xC3, 0x80, 0xE0, 0xEE, 0x39, 0xC7, 0x39, 0xC7, 0x38, 0xEE, 0x1D,
  0xC3, 0xF0, 0x7C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0C, 0x03, 0x80, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x7F, 0x87, 0xFC, 0x3F,
  0xE0, 0x07, 0xE0, 0xF8, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xF8, 0x3F, 0x00, 0xC7, 0x39, 0xCE,
  0x71, 0x8C, 0x63, 0x9C, 0xE7, 0x38, 0xC6, 0x31, 0xCE, 0x07, 0xE0, 0xF8,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06,
  0x01, 0xC1, 0xF8, 0x3F, 0x00, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xE0, 0xFC,
  0x3B, 0x86, 0x31, 0xC7, 0x70, 0xEE, 0x1F, 0x81, 0x80, 0xFF, 0xFF, 0xEF,
  0x73, 0x30, 0x0E, 0x63, 0xFC, 0xFF, 0xBC, 0xF7, 0x1D, 0xE3, 0xB8, 0x77,
  0x0E, 0xE1, 0x9C, 0x73, 0x8E, 0x73, 0xCE, 0x79, 0xF6, 0x1C, 0xC0, 0x0E,
  0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x70, 0xFF, 0x1F, 0xE7,
  0x9C, 0xE3, 0x9C, 0x73, 0x0E, 0xE1, 0xDC, 0x3B, 0x87, 0x71, 0xCE, 0x3B,
  0xEE, 0x7F, 0xCC, 0xF0, 0x0F, 0x0F, 0xCF, 0xCF, 0x07, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x67, 0xF1, 0xF0, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x0E, 0xE1, 0xFE, 0x3F, 0xE7, 0x1C,
  0x71, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xEF, 0x8F, 0xF0, 0x7B, 0x00, 0x0F, 0x07, 0xE3, 0xBD, 0xC7, 0x71, 0xF8,
  0xEF, 0xFB, 0xF8, 0xF0, 0x30, 0x0C, 0x03, 0x00, 0xE1, 0x3F, 0x87, 0xE0,
  0x00, 0x30, 0x07, 0xC0, 0x7C, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0F, 0x81,
  0xFC, 0x0F, 0xE0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0x98, 0x3F, 0xC3,
  0xFE, 0x3C, 0xF1, 0xC7, 0x1E, 0x38, 0xE1, 0xC7, 0x0E, 0x38, 0xE1, 0xC7,
  0x0E, 0x38, 0x73, 0xC3, 0xBE, 0x1F, 0x60, 0x7F, 0x00, 0x38, 0x01, 0xC0,
  0x1C, 0x30, 0xE1, 0xFE, 0x0F, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x38, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0x70, 0xFF, 0x1F, 0xE7, 0x9C, 0xE3, 0x9C, 0x73,
  0x8E, 0xE1, 0xDC, 0x73, 0x8E, 0x71, 0xCE, 0x3B, 0x86, 0x71, 0xCE, 0x38,
  0x0E, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x0C, 0x38, 0x70, 0xE1, 0xC7, 0x0E,
  0x1C, 0x38, 0x71, 0xC3, 0x87, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0,
  0xF0, 0x3C, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x71, 0xCE, 0x19, 0xE3, 0x9C, 0x3B, 0x83, 0xF0, 0x37, 0x07, 0xF0,
  0x7F, 0x07, 0x70, 0x77, 0x06, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x80, 0x0E,
  0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x8E, 0x1C,
  0x38, 0x70, 0xE3, 0x87, 0x0E, 0x00, 0x19, 0xC7, 0x0D, 0xFF, 0xC7, 0xFF,
  0xE7, 0x9E, 0x73, 0x8E, 0x39, 0xC7, 0x1C, 0xE3, 0x0C, 0xE3, 0x8E, 0x71,
  0xC7, 0x38, 0xE3, 0x9C, 0x71, 0x8C, 0x31, 0xCE, 0x38, 0xE7, 0x1C, 0x73,
  0x8E, 0x38, 0x19, 0xC3, 0x7C, 0x7F, 0x9E, 0x73, 0x8E, 0x71, 0xCE, 0x3B,
  0x87, 0x71, 0xCE, 0x39, 0xC7, 0x38, 0xEE, 0x19, 0xC7, 0x38, 0xE0, 0x0F,
  0x07, 0xE3, 0xFD, 0xC7, 0x71, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xEC,
  0x3B, 0x8E, 0xE7, 0x3F, 0x87, 0xC0, 0x0C, 0xE0, 0xDF, 0x0F, 0xF1, 0xE7,
  0x1C, 0x31, 0xC7, 0x18, 0x73, 0x87, 0x38, 0x73, 0x87, 0x38, 0xE3, 0x8E,
  0x7D, 0xC7, 0xFC, 0x77, 0x87, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x00, 0x0E, 0x63, 0xFC, 0xFF, 0xB8, 0xF7, 0x1D, 0xC3, 0xB8, 0x77,
  0x0E, 0xE1, 0x9C, 0x73, 0x8E, 0x71, 0xCE, 0xF9, 0xF6, 0x1F, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x19, 0xC6, 0xE1, 0xF8, 0xF8,
  0x3C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x0E, 0x00, 0x0F, 0x07, 0xF3, 0xF8, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xC0, 0x70, 0x1C, 0xCF, 0x3F, 0x8F, 0xC0, 0x0C, 0x30, 0x61,
  0xF7, 0xFF, 0xDC, 0x38, 0x70, 0xE1, 0x87, 0x0E, 0x1C, 0x38, 0x74, 0xF9,
  0xF0, 0x38, 0xE7, 0x1D, 0xC3, 0x38, 0xE7, 0x1C, 0xE3, 0x98, 0x77, 0x0C,
  0xE3, 0x9C, 0x73, 0x8E, 0x73, 0xCE, 0xF1, 0xF6, 0x3C, 0xC0, 0xC1, 0xF0,
  0xEC, 0x3B, 0x1C, 0xC7, 0x33, 0x8C, 0xE3, 0x30, 0xDC, 0x36, 0x0F, 0x83,
  0xE0, 0xF0, 0x3C, 0x0E, 0x00, 0x61, 0xC7, 0x63, 0xC7, 0x63, 0xC6, 0x63,
  0xCE, 0x66, 0xCE, 0x66, 0xDC, 0x6F, 0xDC, 0x6D, 0xD8, 0x6D, 0xF8, 0x7D,
  0xF8, 0xF9, 0xF0, 0xF9, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF1, 0xE0, 0x1C,
  0x71, 0xC7, 0x1C, 0xE0, 0xCC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x0F,
  0x01, 0xF0, 0x1B, 0x83, 0xB8, 0x73, 0x87, 0x38, 0xE3, 0x80, 0x0E, 0x1C,
  0x38, 0xE0, 0xE3, 0x83, 0x9C, 0x0E, 0x70, 0x39, 0x80, 0xEE, 0x03, 0xB0,
  0x0F, 0xC0, 0x3F, 0x00, 0xD8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0x1F,
  0xC7, 0xF1, 0xFC, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03,
  0x81, 0xC0, 0x70, 0x3F, 0xCF, 0xF0, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x81, 0xF0, 0x30, 0x0F, 0x80,
  0x70, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x70, 0x0F,
  0x80, 0x60, 0x7C, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC1, 0xF0, 0x3C, 0x00, 0x20, 0x3F, 0x87, 0xFF, 0xC3, 0xE8, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 19, 7, 0, -19 },
  { 18, 8, 7, 10, 3, -19 },
  { 25, 13, 19, 12, 0, -19 },
  { 56, 12, 23, 11, 0, -21 },
  { 91, 16, 20, 18, 1, -20 },
  { 131, 13, 20, 13, 0, -20 },
  { 164, 4, 7, 6, 3, -19 },
  { 168, 9, 23, 7, 0, -19 },
  { 194, 9, 24, 7, -2, -20 },
  { 221, 10, 11, 11, 2, -21 },
  { 235, 11, 13, 12, 1, -16 },
  { 253, 5, 7, 6, -1, -3 },
  { 258, 7, 3, 7, 0, -9 },
  { 261, 4, 4, 6, 0, -4 },
  { 263, 13, 19, 10, -1, -19 },
  { 294, 10, 20, 11, 1, -20 },
  { 319, 8, 19, 11, 3, -19 },
  { 338, 12, 20, 11, -1, -20 },
  { 368, 12, 20, 11, 0, -20 },
  { 398, 12, 19, 11, 0, -19 },
  { 427, 12, 19, 11, 0, -19 },
  { 456, 11, 20, 11, 1, -20 },
  { 484, 12, 19, 11, 1, -19 },
  { 513, 12, 20, 11, 0, -20 },
  { 543, 11, 20, 11, 0, -20 },
  { 571, 6, 15, 6, 0, -15 },
  { 583, 7, 19, 6, -1, -15 },
  { 600, 11, 13, 12, 1, -16 },
  { 618, 11, 7, 12, 1, -13 },
  { 628, 11, 13, 12, 1, -16 },
  { 646, 9, 20, 9, 1, -20 },
  { 669, 16, 21, 17, 1, -19 },
  { 711, 12, 19, 12, -2, -19 },
  { 740, 13, 19, 12, 0, -19 },
  { 771, 12, 20, 11, 1, -20 },
  { 801, 13, 19, 13, 0, -19 },
  { 832, 12, 19, 10, 0, -19 },
  { 861, 12, 19, 10, 0, -19 },
  { 890, 14, 20, 14, 1, -20 },
  { 925, 15, 19, 14, 0, -19 },
  { 961, 11, 19, 8, -1, -19 },
  { 988, 11, 25, 6, -4, -19 },
  { 1023, 14, 19, 12, 0, -19 },
  { 1057, 8, 19, 10, 0, -19 },
  { 1076, 19, 19, 18, 0, -19 },
  { 1122, 15, 19, 15, 0, -19 },
  { 1158, 13, 20, 14, 1, -20 },
  { 1191, 13, 19, 12, 0, -19 },
  { 1222, 13, 25, 14, 1, -20 },
  { 1263, 12, 19, 12, 0, -19 },
  { 1292, 13, 20, 11, -1, -20 },
  { 1325, 10, 19, 10, 2, -19 },
  { 1349, 13, 19, 13, 1, -19 },
  { 1380, 12, 19, 12, 2, -19 },
  { 1409, 19, 19, 18, 2, -19 },
  { 1455, 15, 19, 11, -2, -19 },
  { 1491, 11, 19, 11, 2, -19 },
  { 1518, 13, 19, 10, -1, -19 },
  { 1549, 11, 23, 8, -1, -19 },
  { 1581, 5, 19, 10, 3, -19 },
  { 1593, 11, 23, 8, -2, -19 },
  { 1625, 11, 11, 11, 0, -19 },
  { 1641, 8, 2, 9, -2, 2 },
  { 1643, 4, 5, 8, 4, -21 },
  { 1646, 11, 15, 12, 1, -15 },
  { 1667, 11, 21, 12, 0, -21 },
  { 1696, 9, 15, 9, 1, -15 },
  { 1713, 12, 21, 12, 1, -21 },
  { 1745, 10, 15, 11, 1, -15 },
  { 1764, 13, 27, 7, -3, -21 },
  { 1808, 13, 21, 12, -1, -15 },
  { 1843, 11, 21, 12, 0, -21 },
  { 1872, 7, 20, 6, 0, -20 },
  { 1890, 10, 26, 6, -3, -20 },
  { 1923, 12, 21, 11, 0, -21 },
  { 1955, 7, 21, 6, 0, -21 },
  { 1974, 17, 15, 18, 0, -15 },
  { 2006, 11, 15, 12, 0, -15 },
  { 2027, 10, 15, 12, 1, -15 },
  { 2046, 12, 21, 12, -1, -15 },
  { 2078, 11, 21, 12, 1, -15 },
  { 2107, 10, 15, 8, 0, -15 },
  { 2126, 10, 15, 9, 0, -15 },
  { 2145, 7, 18, 7, 1, -18 },
  { 2161, 11, 15, 12, 1, -15 },
  { 2182, 10, 15, 10, 2, -15 },
  { 2201, 16, 15, 16, 1, -15 },
  { 2231, 12, 15, 10, -1, -15 },
  { 2254, 14, 21, 10, -2, -15 },
  { 2291, 10, 15, 9, -1, -15 },
  { 2310, 11, 23, 9, 0, -19 },
  { 2342, 2, 27, 10, 4, -21 },
  { 2349, 11, 23, 9, -2, -19 },
  { 2381, 11, 5, 12, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic27pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC27PT7B_H_
