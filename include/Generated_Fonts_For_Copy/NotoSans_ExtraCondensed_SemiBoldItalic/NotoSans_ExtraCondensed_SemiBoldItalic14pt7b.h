#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC14PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x26, 0x64, 0x40, 0xCC, 0x5A, 0x95, 0xA0, 0x16, 0x28, 0xD3,
  0xF2, 0x85, 0x3F, 0x28, 0x51, 0x60, 0x08, 0x63, 0xDC, 0x70, 0xC1, 0x8A,
  0xAB, 0xE2, 0x10, 0x62, 0xB4, 0xA4, 0xA8, 0xBF, 0xD5, 0x3D, 0x29, 0x6A,
  0x4E, 0x18, 0x58, 0xB1, 0x43, 0x0E, 0xF5, 0x4E, 0xD9, 0xF8, 0x69, 0x60,
  0x19, 0x88, 0xC4, 0x23, 0x18, 0xC6, 0x30, 0x80, 0x11, 0x11, 0x11, 0x13,
  0x22, 0x4C, 0x35, 0x3E, 0xCD, 0x08, 0x21, 0x3F, 0xF2, 0x10, 0x2D, 0x60,
  0xFE, 0xF0, 0x06, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10, 0x61, 0x80, 0x18,
  0xB6, 0xD3, 0x4F, 0x2C, 0xB6, 0xD1, 0xC0, 0x19, 0xB4, 0x63, 0x10, 0x8C,
  0x62, 0x00, 0x1C, 0x6C, 0x18, 0x30, 0xC1, 0x04, 0x18, 0x65, 0xF0, 0x3C,
  0xB0, 0xC2, 0x30, 0xE1, 0x86, 0x9B, 0xC0, 0x0C, 0x71, 0x8A, 0x69, 0x69,
  0xBE, 0x10, 0xC0, 0x3C, 0x82, 0x18, 0x78, 0x60, 0x86, 0x9B, 0xC0, 0x1C,
  0xC2, 0x18, 0x79, 0x2C, 0xB2, 0xD9, 0xC0, 0x3E, 0x88, 0x30, 0x41, 0x82,
  0x0C, 0x10, 0x61, 0x80, 0x3D, 0xB6, 0xDB, 0x31, 0xEC, 0xA2, 0xDB, 0xC0,
  0x39, 0xB6, 0xD3, 0x4D, 0xE0, 0x86, 0x33, 0x80, 0x2C, 0x00, 0x36, 0x13,
  0x00, 0x00, 0x66, 0x4C, 0x09, 0xB1, 0x83, 0x04, 0xF8, 0x01, 0xF0, 0x87,
  0x0E, 0x7E, 0x40, 0x7A, 0xC2, 0x23, 0x31, 0x00, 0x46, 0x00, 0x0F, 0x18,
  0x88, 0x29, 0xD5, 0x4A, 0xAA, 0xD5, 0x3C, 0x80, 0x20, 0x1F, 0x00, 0x0C,
  0x31, 0xC5, 0x34, 0xD3, 0xD9, 0x47, 0x10, 0x3C, 0x48, 0x9B, 0x27, 0x89,
  0x13, 0x66, 0xD9, 0xE0, 0x1E, 0x69, 0x83, 0x04, 0x08, 0x30, 0x20, 0x68,
  0xF0, 0x3C, 0x5C, 0x9B, 0x36, 0x6C, 0xD1, 0x66, 0xD9, 0xE0, 0x3C, 0x82,
  0x18, 0x79, 0x04, 0x30, 0xC3, 0xC0, 0x3C, 0x82, 0x18, 0x79, 0xE4, 0x30,
  0xC3, 0x00, 0x1F, 0x32, 0x20, 0x60, 0x4E, 0x4E, 0xC4, 0x44, 0x6C, 0x7C,
  0x33, 0x22, 0x26, 0x66, 0x7E, 0x44, 0x44, 0xCC, 0xCC, 0xCC, 0x3C, 0x61,
  0x84, 0x10, 0xC3, 0x08, 0x23, 0xC0, 0x0C, 0x20, 0x86, 0x18, 0x61, 0x04,
  0x30, 0xC2, 0x38, 0xC0, 0x36, 0x48, 0xB3, 0xC7, 0x0E, 0x16, 0x2C, 0xD9,
  0x90, 0x32, 0x26, 0x64, 0x4C, 0xCF, 0x31, 0xCC, 0x73, 0x19, 0xCA, 0x73,
  0x95, 0xE5, 0x51, 0x74, 0xD9, 0x36, 0xC0, 0x33, 0x33, 0x32, 0x72, 0x7A,
  0x5E, 0x4E, 0x4C, 0xCC, 0xCC, 0x1E, 0x6D, 0x8B, 0x14, 0x68, 0xF1, 0xE2,
  0x6C, 0xF0, 0x3C, 0x58, 0x9B, 0x26, 0xCF, 0x10, 0x60, 0xC1, 0x80, 0x1E,
  0x6D, 0x8B, 0x14, 0x68, 0xF1, 0xE2, 0x6C, 0xF0, 0x60, 0xC0, 0x3C, 0xB2,
  0x59, 0x6D, 0xE5, 0x96, 0xDB, 0x20, 0x3D, 0x96, 0x18, 0x30, 0xE1, 0x86,
  0x9B, 0xC0, 0xF9, 0x08, 0xC6, 0x31, 0x18, 0xC6, 0x00, 0x32, 0x44, 0x9B,
  0x36, 0x48, 0x93, 0x66, 0x48, 0xF0, 0xC7, 0x3C, 0xB6, 0xD3, 0x4F, 0x38,
  0xE3, 0x00, 0xCC, 0xF3, 0x2D, 0xDB, 0x74, 0xDB, 0x3A, 0xCA, 0xA3, 0xB8,
  0xCC, 0x33, 0x00, 0x33, 0x16, 0x14, 0x1C, 0x18, 0x18, 0x38, 0x28, 0x6C,
  0xCC, 0xCF, 0x65, 0x1C, 0x61, 0x84, 0x10, 0xC3, 0x00, 0x3E, 0x0C, 0x30,
  0x41, 0x82, 0x0C, 0x30, 0x41, 0xF0, 0x39, 0x08, 0xC6, 0x21, 0x08, 0xC4,
  0x21, 0xC0, 0xC9, 0x24, 0x9B, 0x64, 0x38, 0x42, 0x31, 0x08, 0x46, 0x31,
  0x09, 0xC0, 0x18, 0x62, 0x9A, 0x4F, 0x30, 0xF0, 0xD4, 0x35, 0xF6, 0xD3,
  0xCB, 0x2D, 0x9E, 0x30, 0x82, 0x0A, 0x7D, 0xB4, 0xD3, 0xCB, 0x6B, 0x00,
  0x19, 0xD8, 0x8C, 0x63, 0x4E, 0x06, 0x0C, 0x11, 0xA7, 0xCD, 0x93, 0x64,
  0xC9, 0xB1, 0xA0, 0x18, 0xB4, 0x96, 0xE3, 0x0C, 0x9C, 0x06, 0x1C, 0x20,
  0x61, 0xC3, 0x06, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x1C, 0x00, 0x35, 0xF6,
  0xD3, 0xCB, 0x2D, 0x9E, 0x18, 0x4F, 0x00, 0x30, 0x82, 0x0A, 0x7D, 0xB4,
  0xD2, 0xCB, 0x6D, 0x80, 0x23, 0x02, 0x66, 0x44, 0xCC, 0xC0, 0x08, 0x30,
  0x02, 0x18, 0x61, 0x04, 0x30, 0xC3, 0x08, 0x23, 0x80, 0x30, 0x82, 0x09,
  0x69, 0xE7, 0x1C, 0xD3, 0x69, 0x80, 0x32, 0x22, 0x66, 0x44, 0xCC, 0xC0,
  0x39, 0x3F, 0xDB, 0x69, 0x24, 0x96, 0x4B, 0x6D, 0xB6, 0x29, 0xF6, 0xD3,
  0x4B, 0x2D, 0xB6, 0x19, 0xF4, 0xD3, 0xCF, 0x2D, 0x9C, 0x14, 0x7C, 0xD9,
  0x32, 0x6C, 0x9B, 0x3C, 0x40, 0x83, 0x00, 0x34, 0xF6, 0xD3, 0xCB, 0x2D,
  0x9E, 0x18, 0x43, 0x00, 0x2B, 0xD8, 0x84, 0x63, 0x18, 0x33, 0xD0, 0xC3,
  0x1A, 0xDC, 0x23, 0x76, 0x44, 0x4C, 0x60, 0x25, 0xB6, 0xD2, 0x4B, 0x2D,
  0x9E, 0x9C, 0xA5, 0x6A, 0x73, 0x18, 0x9B, 0x9A, 0xBA, 0xBE, 0xFC, 0xD4,
  0xD8, 0xD8, 0x36, 0x68, 0xF0, 0xC1, 0x87, 0x1A, 0x64, 0x26, 0x4C, 0x91,
  0x62, 0x87, 0x0C, 0x18, 0x20, 0xC3, 0x00, 0x3C, 0xF1, 0x84, 0x30, 0x86,
  0x3E, 0x1C, 0x43, 0x0C, 0x33, 0x8C, 0x18, 0x61, 0x04, 0x18, 0xFF, 0xFC,
  0x30, 0xC6, 0x31, 0x0C, 0x66, 0x21, 0x19, 0xC0, 0xED, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 4, 10, 3, 0, -10 },
  { 6, 5, 4, 5, 1, -10 },
  { 9, 7, 10, 6, 0, -10 },
  { 18, 6, 12, 6, 0, -11 },
  { 27, 8, 10, 9, 1, -10 },
  { 37, 7, 10, 7, 0, -10 },
  { 46, 3, 4, 3, 1, -10 },
  { 48, 5, 12, 4, 0, -10 },
  { 56, 4, 12, 4, -1, -10 },
  { 62, 5, 6, 5, 1, -11 },
  { 66, 5, 6, 6, 1, -8 },
  { 70, 3, 4, 3, -1, -2 },
  { 72, 4, 2, 4, 0, -5 },
  { 73, 2, 2, 3, 0, -2 },
  { 74, 7, 10, 5, -1, -10 },
  { 83, 6, 10, 6, 0, -10 },
  { 91, 5, 10, 6, 1, -10 },
  { 98, 7, 10, 6, -1, -10 },
  { 107, 6, 10, 6, 0, -10 },
  { 115, 6, 10, 6, 0, -10 },
  { 123, 6, 10, 6, 0, -10 },
  { 131, 6, 10, 6, 0, -10 },
  { 139, 7, 10, 6, 0, -10 },
  { 148, 6, 10, 6, 0, -10 },
  { 156, 6, 10, 6, 0, -10 },
  { 164, 3, 8, 3, 0, -8 },
  { 167, 4, 10, 3, -1, -8 },
  { 172, 5, 6, 6, 1, -8 },
  { 176, 5, 4, 6, 1, -7 },
  { 179, 5, 6, 6, 1, -8 },
  { 183, 5, 10, 4, 0, -10 },
  { 190, 9, 11, 9, 0, -10 },
  { 203, 6, 10, 6, -1, -10 },
  { 211, 7, 10, 6, 0, -10 },
  { 220, 7, 10, 6, 0, -10 },
  { 229, 7, 10, 7, 0, -10 },
  { 238, 6, 10, 5, 0, -10 },
  { 246, 6, 10, 5, 0, -10 },
  { 254, 8, 10, 7, 0, -10 },
  { 264, 8, 10, 7, 0, -10 },
  { 274, 6, 10, 4, -1, -10 },
  { 282, 6, 13, 3, -2, -10 },
  { 292, 7, 10, 6, 0, -10 },
  { 301, 4, 10, 5, 0, -10 },
  { 306, 10, 10, 9, 0, -10 },
  { 319, 8, 10, 8, 0, -10 },
  { 329, 7, 10, 7, 0, -10 },
  { 338, 7, 10, 6, 0, -10 },
  { 347, 7, 12, 7, 0, -10 },
  { 358, 6, 10, 6, 0, -10 },
  { 366, 6, 10, 6, 0, -10 },
  { 374, 5, 10, 5, 1, -10 },
  { 381, 7, 10, 7, 0, -10 },
  { 390, 6, 10, 6, 1, -10 },
  { 398, 10, 10, 10, 1, -10 },
  { 411, 8, 10, 6, -1, -10 },
  { 421, 6, 10, 6, 1, -10 },
  { 429, 7, 10, 5, -1, -10 },
  { 438, 5, 12, 4, 0, -10 },
  { 446, 3, 10, 5, 1, -10 },
  { 450, 5, 12, 4, -1, -10 },
  { 458, 6, 6, 6, 0, -10 },
  { 463, 4, 1, 4, -1, 1 },
  { 464, 2, 3, 4, 2, -11 },
  { 465, 6, 8, 6, 0, -8 },
  { 471, 6, 11, 6, 0, -11 },
  { 480, 5, 8, 5, 0, -8 },
  { 485, 7, 11, 6, 0, -11 },
  { 495, 6, 8, 6, 0, -8 },
  { 501, 7, 14, 4, -2, -11 },
  { 514, 6, 11, 6, 0, -8 },
  { 523, 6, 11, 6, 0, -11 },
  { 532, 4, 11, 3, 0, -11 },
  { 538, 6, 14, 3, -2, -11 },
  { 549, 6, 11, 6, 0, -11 },
  { 558, 4, 11, 3, 0, -11 },
  { 564, 9, 8, 9, 0, -8 },
  { 573, 6, 8, 6, 0, -8 },
  { 579, 6, 8, 6, 0, -8 },
  { 585, 7, 11, 6, -1, -8 },
  { 595, 6, 11, 6, 0, -8 },
  { 604, 5, 8, 4, 0, -8 },
  { 609, 5, 8, 5, 0, -8 },
  { 614, 4, 9, 4, 0, -9 },
  { 619, 6, 8, 6, 0, -8 },
  { 625, 5, 8, 5, 1, -8 },
  { 630, 8, 8, 8, 1, -8 },
  { 638, 7, 8, 5, -1, -8 },
  { 645, 7, 11, 5, -1, -8 },
  { 655, 6, 8, 4, -1, -8 },
  { 661, 6, 12, 5, 0, -10 },
  { 670, 1, 14, 5, 2, -11 },
  { 672, 5, 12, 5, -1, -10 },
  { 680, 5, 2, 6, 1, -6 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC14PT7B_H_
