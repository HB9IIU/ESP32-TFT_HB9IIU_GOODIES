#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC61PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0x00,
  0x00, 0x3F, 0x87, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFE, 0x3F,
  0x0F, 0xE3, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF8, 0xFC, 0x1F, 0x0F, 0xC1, 0xF0,
  0xF8, 0x3F, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07,
  0xC3, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x78,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x78, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x01, 0xFC, 0xE3, 0x80, 0x3F, 0x18, 0x10, 0x07, 0xE3,
  0x00, 0x01, 0xFC, 0x60, 0x00, 0x3F, 0x1C, 0x00, 0x07, 0xF3, 0x80, 0x00,
  0xFE, 0x60, 0x00, 0x0F, 0xEC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xDF, 0xC0, 0x00, 0x3B, 0xF8, 0x00, 0x07, 0x3F, 0x00, 0x00,
  0xC7, 0xF0, 0x00, 0x18, 0xFC, 0x00, 0x03, 0x1F, 0x81, 0x00, 0xE3, 0xF0,
  0x30, 0x1C, 0xFE, 0x07, 0x83, 0x3F, 0xC0, 0xFF, 0x7F, 0xF0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x03, 0xF0,
  0x07, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x07, 0xC0, 0x0F, 0xDF, 0x00,
  0x7C, 0x01, 0xF8, 0xF8, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0xF8, 0x03, 0xE0,
  0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x3E, 0x00,
  0x7C, 0x1F, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x07,
  0xC0, 0x07, 0xC1, 0xF0, 0xF8, 0x00, 0x78, 0x1F, 0x1F, 0x80, 0x0F, 0x83,
  0xF1, 0xF0, 0x00, 0xF8, 0x3E, 0x3F, 0x00, 0x0F, 0x83, 0xE3, 0xE0, 0xF0,
  0xF8, 0x3E, 0x7C, 0x3F, 0xCF, 0x87, 0xC7, 0xC7, 0xFE, 0xF8, 0x7C, 0xF8,
  0xFF, 0xEF, 0x8F, 0x8F, 0x8F, 0xFF, 0xFD, 0xF9, 0xF1, 0xF1, 0xF7, 0xFF,
  0x1F, 0x3E, 0x1F, 0x7F, 0xE3, 0xE3, 0xE1, 0xF3, 0xFC, 0x3E, 0x3C, 0x1F,
  0x1F, 0x87, 0xC7, 0xC1, 0xF0, 0x00, 0x7C, 0x7C, 0x1F, 0x00, 0x0F, 0x87,
  0x81, 0xF0, 0x01, 0xF8, 0xF8, 0x1F, 0x00, 0x1F, 0x0F, 0x83, 0xE0, 0x03,
  0xF0, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x3E,
  0x00, 0x7C, 0x1F, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x7C, 0x00, 0xF8, 0x1F,
  0x07, 0xC0, 0x1F, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0x3E,
  0x00, 0xF9, 0xF0, 0x03, 0xE0, 0x0F, 0xFF, 0x00, 0x7C, 0x00, 0xFF, 0xE0,
  0x07, 0xC0, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0x1F, 0xC0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07,
  0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x0F, 0xE0, 0xFF, 0xF8, 0x7F, 0x0F, 0xFF, 0xC3, 0xF0, 0xFE, 0xFE, 0x3F,
  0x87, 0xE3, 0xF9, 0xF8, 0x7F, 0x1F, 0xCF, 0xC7, 0xF0, 0xFE, 0xFE, 0x3F,
  0x03, 0xFF, 0xE1, 0xF8, 0x1F, 0xFF, 0x1F, 0xC0, 0x7F, 0xF0, 0xFE, 0x03,
  0xFF, 0x87, 0xE0, 0x1F, 0xF8, 0x3F, 0x00, 0x7F, 0x81, 0xF8, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0x03, 0xFF, 0x03, 0xFC, 0x7F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFB, 0xFC, 0x0F, 0xFF,
  0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0x80, 0x18, 0x00, 0x00, 0x00, 0x3F, 0xCF,
  0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x10, 0x3E, 0x00, 0xE1, 0xF0, 0x0F, 0xCF, 0x81, 0x7F, 0xFC, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xDF, 0x01, 0xFC, 0xFC, 0x1F,
  0xE7, 0xE0, 0x7E, 0x1F, 0x81, 0xE0, 0xFC, 0x07, 0x07, 0xC0, 0x10, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E,
  0x0F, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xF0,
  0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF7,
  0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x00, 0x3F, 0x1F, 0x9F, 0xEF,
  0xFF, 0xF7, 0xFB, 0xFC, 0xFC, 0x10, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFC,
  0x7F, 0x03, 0xF8, 0x3F, 0x03, 0xF8, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xF0,
  0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0,
  0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x80,
  0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x7E, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x7E, 0x01,
  0xFC, 0x7E, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFD, 0xFC, 0x7C, 0x7E,
  0x0E, 0x1F, 0x83, 0x0F, 0xE0, 0x43, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x07,
  0x80, 0xFF, 0x00, 0x70, 0x0F, 0xF0, 0x02, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1E, 0x07, 0xF8, 0x03, 0x00, 0xFF, 0x00,
  0x40, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x08, 0x00, 0x3F,
  0xC1, 0x80, 0x1F, 0xF0, 0x3F, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFB, 0xF0,
  0x00, 0x1E, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xF8, 0x00, 0x3E,
  0x7F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x3F, 0x00,
  0x1F, 0x0F, 0xE0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x07,
  0xE0, 0x07, 0xC1, 0xFC, 0x01, 0xF0, 0x3F, 0x80, 0x7C, 0x07, 0xE0, 0x0F,
  0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x10, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x80, 0x0F, 0xF0, 0x30, 0x07, 0xFC,
  0x0F, 0xCF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x07, 0xF7, 0xFC, 0x01, 0xFB,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFE, 0x1F, 0xC1, 0xFF, 0x07, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xE0, 0x3F,
  0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0x80,
  0x7F, 0x07, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0x7E, 0x07, 0xF0,
  0x1F, 0xC3, 0xFC, 0x07, 0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0x9F, 0xF0, 0x1F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F,
  0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x7F,
  0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07,
  0xF9, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0xFE, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE,
  0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x0F,
  0xC1, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0,
  0x1F, 0xC7, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFC, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF8, 0x3F, 0xDF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xBF, 0x01, 0xFF, 0xBF, 0x80, 0x7F, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x03, 0x87, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F,
  0xE0, 0x3F, 0x80, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7C, 0x00,
  0x60, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x1C, 0x0F, 0xE0, 0x80,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x3E,
  0x03, 0xFE, 0x0F, 0x83, 0xE0, 0x3F, 0xF8, 0x7C, 0x1F, 0x03, 0xFF, 0xC3,
  0xE1, 0xF0, 0x3F, 0xFE, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xF8, 0x78, 0x3E,
  0x0F, 0x07, 0xC7, 0xC1, 0xE0, 0xF8, 0x3C, 0x3C, 0x1F, 0x07, 0xC1, 0xE3,
  0xE0, 0xF0, 0x3E, 0x0F, 0x1F, 0x0F, 0x81, 0xE0, 0x78, 0xF0, 0x7C, 0x1F,
  0x07, 0xC7, 0x83, 0xC0, 0xF8, 0x3E, 0x7C, 0x3E, 0x07, 0xC1, 0xE3, 0xE1,
  0xF0, 0x3C, 0x0F, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0xF0, 0x7C, 0x1F, 0x07,
  0x87, 0x83, 0xE0, 0xF8, 0x3C, 0x3C, 0x1F, 0x0F, 0xC3, 0xC1, 0xE0, 0xF8,
  0x7C, 0x1E, 0x1F, 0x07, 0xC7, 0xE1, 0xE0, 0xF8, 0x3E, 0x7F, 0x9F, 0x07,
  0xC1, 0xFF, 0xBF, 0xF0, 0x3E, 0x0F, 0xF9, 0xFF, 0x01, 0xF0, 0x3F, 0x87,
  0xF0, 0x07, 0x80, 0xF8, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x0C, 0x00, 0x01, 0xFE, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3E, 0xFC,
  0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F,
  0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0,
  0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00,
  0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0x87, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xCF, 0xF0,
  0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFD,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFC, 0x1F, 0xF0, 0x0F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x07, 0xF0,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0xFC,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F,
  0x81, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x3F,
  0x80, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x0F,
  0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0x83, 0x80, 0x1F, 0xE0, 0x08, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x06, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0x83,
  0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFF, 0x01, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0,
  0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x1F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x01,
  0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0xFF,
  0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x81,
  0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFE,
  0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0xC0, 0x7F, 0x03,
  0xFE, 0x01, 0xFC, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xF0, 0x3E, 0x00, 0xFF, 0x80, 0x18, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x0F,
  0xE0, 0x1F, 0xFC, 0x1F, 0xC0, 0x7F, 0xF8, 0x3F, 0x80, 0xFF, 0xF0, 0x7F,
  0x01, 0xFF, 0xE1, 0xFE, 0x03, 0xFF, 0xC3, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x01, 0xFC,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0,
  0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x80,
  0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF9, 0xFE, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x03, 0xF7, 0xF8, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x1F, 0xE7, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xEF, 0x80,
  0x1F, 0xFE, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFF,
  0xF8, 0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x00, 0x7E, 0xFC, 0x07, 0xEF, 0xC0,
  0x1F, 0xDF, 0x80, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x00, 0x7E,
  0x7E, 0x07, 0xCF, 0xE0, 0x0F, 0xCF, 0xC1, 0xF9, 0xFC, 0x03, 0xF9, 0xF8,
  0x3F, 0x3F, 0x00, 0x7F, 0x3F, 0x0F, 0xC7, 0xE0, 0x0F, 0xC7, 0xE1, 0xF9,
  0xFC, 0x01, 0xF8, 0xFC, 0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0x8F, 0xC7, 0xF0,
  0x0F, 0xE3, 0xF1, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x7E, 0x1F, 0x80, 0x3F,
  0x0F, 0xCF, 0x87, 0xF0, 0x07, 0xE1, 0xFB, 0xF0, 0xFE, 0x00, 0xFC, 0x3F,
  0x7C, 0x1F, 0x80, 0x3F, 0x87, 0xFF, 0x83, 0xF0, 0x07, 0xE0, 0xFF, 0xF0,
  0x7E, 0x00, 0xFC, 0x1F, 0xFC, 0x1F, 0xC0, 0x1F, 0x81, 0xFF, 0x83, 0xF8,
  0x03, 0xF0, 0x3F, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xFC, 0x0F, 0xC0, 0x1F,
  0x80, 0xFF, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x00, 0x7E, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x07,
  0xE0, 0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0xC0,
  0x07, 0xE0, 0x0F, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x3F,
  0xF0, 0x07, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x80,
  0x3F, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x1F,
  0xC0, 0x1F, 0x7E, 0x03, 0xF0, 0x07, 0xEF, 0xC0, 0x7E, 0x00, 0xFD, 0xF8,
  0x0F, 0xC0, 0x1F, 0xBF, 0x03, 0xF8, 0x03, 0xF3, 0xE0, 0x7E, 0x00, 0x7E,
  0x7E, 0x0F, 0xC0, 0x1F, 0x8F, 0xC1, 0xF8, 0x03, 0xF1, 0xF8, 0x7F, 0x00,
  0x7E, 0x3F, 0x0F, 0xE0, 0x0F, 0xC7, 0xE1, 0xF8, 0x03, 0xF8, 0x7C, 0x3F,
  0x00, 0x7E, 0x0F, 0xC7, 0xE0, 0x0F, 0xC1, 0xF9, 0xFC, 0x01, 0xF8, 0x3F,
  0x3F, 0x80, 0x3F, 0x07, 0xE7, 0xE0, 0x0F, 0xE0, 0xFC, 0xFC, 0x01, 0xF8,
  0x0F, 0x9F, 0x80, 0x3F, 0x01, 0xFB, 0xF0, 0x07, 0xE0, 0x3F, 0xFE, 0x00,
  0xFC, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0xFF, 0xF0, 0x07, 0xE0, 0x1F, 0xFE,
  0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xF0, 0x03, 0xF0, 0x07,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x1F, 0xF8, 0x03, 0xF0,
  0x03, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0x03,
  0xF0, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC,
  0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF9, 0xFC,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x3F, 0xBF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE,
  0x7F, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC,
  0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xF9, 0xFF, 0xC0, 0x1F, 0x81, 0xFE, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x01, 0xFC,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x03, 0xFC, 0x03, 0xF0, 0x7F,
  0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC,
  0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF9, 0xFC,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x3F, 0xBF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFE,
  0x7F, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFC,
  0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xF0, 0x3F,
  0xC1, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFC,
  0x3F, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x3F,
  0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F,
  0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x07,
  0xF0, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xC7, 0xE0, 0x01,
  0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x87,
  0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x3F, 0x83, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x01, 0xFC,
  0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xCF, 0xC0,
  0x1F, 0xE0, 0x18, 0x03, 0xFC, 0x00, 0x80, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x04, 0x00, 0x3F, 0xC0, 0x60, 0x07, 0xF8, 0x07, 0x80, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F,
  0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0,
  0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x03,
  0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE,
  0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03,
  0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFC,
  0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F,
  0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80,
  0x0F, 0xE7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x03,
  0xF8, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F,
  0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFE,
  0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7E,
  0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x3F, 0x80,
  0x07, 0xE7, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0xEF, 0xE0, 0x03, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xFC,
  0x03, 0xF8, 0x7F, 0x00, 0xFF, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0xFF, 0xC0, 0x7E, 0x07,
  0xE0, 0x3F, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xFE, 0x03, 0xF8, 0x1F, 0x80,
  0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xDF,
  0x03, 0xF0, 0x0F, 0xC1, 0xFB, 0xE0, 0xFE, 0x01, 0xF8, 0x3F, 0x7C, 0x1F,
  0xC0, 0x3F, 0x07, 0xCF, 0x83, 0xF0, 0x07, 0xE1, 0xF9, 0xF0, 0xFE, 0x00,
  0xFC, 0x3F, 0x3E, 0x1F, 0x80, 0x1F, 0x87, 0xC7, 0xC3, 0xF0, 0x03, 0xF1,
  0xF8, 0xF8, 0xFE, 0x00, 0x7E, 0x3E, 0x1F, 0x1F, 0x80, 0x0F, 0xCF, 0xC3,
  0xE7, 0xF0, 0x01, 0xF9, 0xF8, 0x7C, 0xFE, 0x00, 0x3F, 0x3E, 0x0F, 0x9F,
  0x80, 0x07, 0xEF, 0xC1, 0xF7, 0xF0, 0x00, 0xFD, 0xF0, 0x7E, 0xFC, 0x00,
  0x1F, 0xFE, 0x0F, 0xDF, 0x80, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x7D,
  0xF0, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xE0, 0x0F,
  0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x01, 0xFC, 0x7E, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x1F, 0xC7,
  0xF0, 0x0F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xE0, 0xFE, 0x07, 0xF0,
  0x7F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xFC,
  0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7F,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x0F, 0xC0,
  0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x3E, 0x01, 0xF8,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x0F,
  0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F,
  0xBF, 0x00, 0x03, 0xF0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xC7, 0xF1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x3E,
  0x0F, 0xC1, 0xF0, 0x00, 0x0C, 0x00, 0x20, 0x0F, 0xF0, 0xF8, 0x03, 0xFF,
  0x3F, 0x00, 0xFF, 0xF7, 0xE0, 0x3F, 0xFE, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xFE, 0x3F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F,
  0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7E,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xE0,
  0x0F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0,
  0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x87,
  0xFC, 0x07, 0xF1, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0xFC, 0x01,
  0xFF, 0xDF, 0x80, 0x3F, 0xF3, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x38, 0x00, 0x7E, 0x7F, 0x80,
  0x3F, 0xBF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0xE3, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0xC1, 0xFC,
  0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3,
  0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0x80,
  0x3F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F,
  0x80, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0xC7, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xDF, 0xFF, 0x03, 0xF7, 0xFF,
  0x80, 0xFC, 0xFF, 0xC0, 0x3E, 0x1F, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x83, 0x03, 0xFC, 0x04, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x40, 0x7F, 0x8F, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0xFE, 0x00,
  0x3F, 0xC7, 0xE0, 0x03, 0xFF, 0x3F, 0x00, 0x3F, 0xFD, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFE, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xC0,
  0x1F, 0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x3F,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x07,
  0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF,
  0x00, 0x7F, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x7C, 0x00,
  0x7F, 0xF7, 0xE0, 0x03, 0xFF, 0x3F, 0x00, 0x0F, 0xF1, 0xF0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0x87,
  0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC,
  0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x8F, 0xC3, 0xFE, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x02, 0x07,
  0xF0, 0x0C, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF1, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x23, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x08, 0x00, 0xFF, 0x0F, 0x80, 0x0F, 0xFC, 0xFC,
  0x00, 0xFF, 0xF7, 0xE0, 0x0F, 0xFF, 0xBF, 0x00, 0x7F, 0xFF, 0xF8, 0x07,
  0xF8, 0xFF, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x03, 0xF0, 0x1F,
  0xC0, 0x1F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80,
  0x7F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x80, 0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x7F, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xDF, 0x80, 0x0F, 0xFD, 0xFC,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x20, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x04, 0x00, 0x7F, 0x00, 0x3C, 0x0F, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x83, 0x80, 0x0F, 0xCF, 0xF0, 0x0F, 0xEF, 0xFC, 0x07, 0xEF,
  0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0x9F, 0xE0, 0xFF,
  0x87, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xC1,
  0xF8, 0x07, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xF8,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F,
  0x87, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07,
  0xF0, 0xFE, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x80,
  0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0x80, 0x00,
  0x1C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x8F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x0F,
  0xC3, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0,
  0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFB,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xEF,
  0xC0, 0x07, 0xF9, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0x87, 0xF0, 0x03,
  0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F,
  0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x01, 0x80, 0x07,
  0xC7, 0xF8, 0x3F, 0xC0, 0x3F, 0x3F, 0xF1, 0xFF, 0x80, 0xFD, 0xFF, 0xCF,
  0xFF, 0x03, 0xEF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xE7, 0xFF, 0x1F, 0xC1, 0xFE, 0x0F, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0xC0,
  0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x1F, 0xC3, 0xF8,
  0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x07,
  0xE0, 0xFC, 0x07, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0x7E, 0x03, 0xF8, 0x7F, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0xFE, 0x03,
  0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7F, 0x01, 0xF8,
  0x3F, 0x01, 0xFC, 0x07, 0xE1, 0xFC, 0x07, 0xE0, 0x3F, 0x87, 0xF0, 0x1F,
  0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x0F, 0xC1,
  0xF8, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x3F, 0x80, 0xFC,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0xC0, 0x7E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0xF8, 0xFF, 0x00, 0xFC, 0xFF, 0xC0, 0x7C, 0xFF,
  0xF0, 0x3E, 0xFF, 0xF8, 0x1F, 0x7F, 0xFC, 0x0F, 0xF9, 0xFE, 0x0F, 0xF8,
  0x7F, 0x07, 0xF8, 0x1F, 0x83, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0xFC,
  0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F,
  0x80, 0x7E, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8,
  0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F,
  0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F,
  0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xF0, 0x7F, 0x0F,
  0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F,
  0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F,
  0x00, 0x7F, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E,
  0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE,
  0x01, 0xFC, 0xFE, 0x03, 0xF8, 0x7E, 0x07, 0xF8, 0x7F, 0x07, 0xF0, 0x7F,
  0x9F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x01, 0xF1, 0xFE, 0x00, 0x1F, 0x9F, 0xF8, 0x00, 0xFD, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0,
  0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE,
  0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07,
  0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x7E,
  0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0,
  0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x03, 0xFB, 0xFF, 0x80, 0x1F, 0xDF, 0xF8, 0x00, 0xFC, 0x7F, 0x80, 0x07,
  0xE0, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0xE1, 0xF0, 0x0F, 0xFC, 0xFC,
  0x07, 0xFF, 0xBF, 0x03, 0xFF, 0xEF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0x8F,
  0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF0, 0x1F, 0xE1, 0xFC,
  0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3,
  0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F,
  0x87, 0xF0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x80,
  0x3F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F,
  0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xE0, 0xFF, 0x1F, 0xF8,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xEF, 0xC0, 0x3F, 0xF7,
  0xF0, 0x07, 0xF9, 0xFC, 0x00, 0x60, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xC7, 0xE0,
  0x3F, 0x3F, 0x80, 0xFD, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xBF, 0xC0, 0x3F,
  0xFF, 0x01, 0xFF, 0xCC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFE, 0x07, 0x03,
  0xF8, 0x08, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x08, 0x03, 0xFC, 0x20, 0x0F, 0xE0, 0xF0, 0xFF, 0x83,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF,
  0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xFF, 0x1F, 0xFF, 0x3F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x20, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x04, 0x00, 0x03, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xE0, 0x7E, 0x01,
  0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE,
  0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0xC1,
  0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F,
  0x81, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x0F, 0xC0,
  0x3F, 0x03, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xF8, 0x1F,
  0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0x7E, 0x07, 0xF8,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFE, 0xFC, 0x07, 0xFF, 0xBE, 0x00, 0xFF, 0xCF, 0x80, 0x1F,
  0xC3, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xEF,
  0xC0, 0x3F, 0xBF, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0,
  0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F,
  0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E,
  0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x7E, 0x03, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0xC0, 0x7E, 0x7E, 0x03,
  0xFC, 0x07, 0xE7, 0xE0, 0x7F, 0xC0, 0xFC, 0x7E, 0x07, 0xFC, 0x0F, 0xC7,
  0xE0, 0x7F, 0xC1, 0xFC, 0x7E, 0x0F, 0xFC, 0x1F, 0x87, 0xE0, 0xFF, 0xC1,
  0xF8, 0x7E, 0x1F, 0xFC, 0x3F, 0x07, 0xE1, 0xFF, 0xC3, 0xF0, 0x7E, 0x1F,
  0xF8, 0x3F, 0x07, 0xE3, 0xEF, 0x87, 0xE0, 0x7E, 0x3E, 0xF8, 0x7E, 0x07,
  0xE7, 0xEF, 0x8F, 0xC0, 0x7E, 0x7C, 0xF8, 0xFC, 0x07, 0xE7, 0xCF, 0x8F,
  0xC0, 0x7C, 0xFC, 0xF9, 0xF8, 0x07, 0xCF, 0x8F, 0x9F, 0x80, 0xFC, 0xF8,
  0xFB, 0xF0, 0x0F, 0xDF, 0x0F, 0xBF, 0x00, 0xFD, 0xF0, 0xFB, 0xF0, 0x0F,
  0xDF, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x7F, 0x7E, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x01,
  0xFC, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x1F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x3F,
  0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x8F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x9F, 0xFC, 0x00, 0xDF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFD, 0x80, 0x1F, 0xFC, 0x80, 0x01, 0xF8, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 17, 45, 15, 0, -44 },
  { 97, 20, 16, 23, 6, -44 },
  { 137, 30, 44, 28, 0, -44 },
  { 302, 27, 50, 25, 0, -46 },
  { 471, 36, 45, 41, 3, -44 },
  { 674, 29, 45, 29, 0, -44 },
  { 838, 10, 16, 14, 6, -44 },
  { 858, 20, 54, 16, 1, -44 },
  { 993, 20, 54, 16, -5, -44 },
  { 1128, 21, 24, 24, 5, -47 },
  { 1191, 24, 29, 28, 2, -36 },
  { 1278, 12, 16, 14, -3, -8 },
  { 1302, 15, 7, 17, 1, -20 },
  { 1316, 9, 9, 14, 0, -8 },
  { 1327, 30, 44, 22, -3, -44 },
  { 1492, 24, 45, 25, 1, -44 },
  { 1627, 18, 44, 26, 6, -44 },
  { 1726, 28, 44, 25, -2, -44 },
  { 1880, 27, 45, 25, -1, -44 },
  { 2032, 27, 44, 26, -1, -44 },
  { 2181, 26, 45, 25, 0, -44 },
  { 2328, 26, 45, 25, 1, -44 },
  { 2475, 26, 44, 25, 2, -44 },
  { 2618, 26, 45, 25, 0, -44 },
  { 2765, 25, 45, 25, 0, -44 },
  { 2906, 14, 34, 14, 0, -33 },
  { 2966, 17, 41, 14, -3, -33 },
  { 3054, 24, 28, 28, 2, -36 },
  { 3138, 24, 18, 28, 2, -30 },
  { 3192, 25, 28, 28, 2, -36 },
  { 3280, 21, 45, 19, 1, -44 },
  { 3399, 37, 49, 38, 1, -44 },
  { 3626, 27, 44, 27, -4, -44 },
  { 3775, 28, 44, 28, 0, -44 },
  { 3929, 28, 45, 26, 2, -44 },
  { 4087, 30, 44, 30, 0, -44 },
  { 4252, 26, 44, 24, 0, -44 },
  { 4395, 26, 44, 23, 0, -44 },
  { 4538, 31, 45, 31, 2, -44 },
  { 4713, 33, 44, 31, 0, -44 },
  { 4895, 25, 44, 18, -3, -44 },
  { 5033, 25, 56, 14, -9, -44 },
  { 5208, 32, 44, 27, 0, -44 },
  { 5384, 18, 44, 22, 0, -44 },
  { 5483, 43, 44, 41, 0, -44 },
  { 5720, 35, 44, 33, 0, -44 },
  { 5913, 29, 45, 32, 2, -44 },
  { 6077, 29, 44, 27, 0, -44 },
  { 6237, 29, 54, 32, 2, -44 },
  { 6433, 28, 44, 27, 0, -44 },
  { 6587, 28, 45, 24, -1, -44 },
  { 6745, 24, 44, 23, 4, -44 },
  { 6877, 30, 45, 30, 2, -44 },
  { 7046, 27, 44, 27, 5, -44 },
  { 7195, 43, 44, 42, 4, -44 },
  { 7432, 34, 44, 25, -4, -44 },
  { 7619, 25, 44, 24, 5, -44 },
  { 7757, 28, 44, 23, -2, -44 },
  { 7911, 24, 54, 17, -2, -44 },
  { 8073, 12, 44, 22, 6, -44 },
  { 8139, 23, 54, 17, -4, -44 },
  { 8295, 26, 26, 26, 0, -44 },
  { 8380, 20, 4, 19, -6, 5 },
  { 8390, 10, 10, 17, 9, -47 },
  { 8403, 27, 35, 27, 1, -34 },
  { 8522, 26, 47, 27, 0, -46 },
  { 8675, 22, 35, 21, 1, -34 },
  { 8772, 29, 47, 27, 1, -46 },
  { 8943, 23, 35, 25, 1, -34 },
  { 9044, 30, 62, 16, -7, -47 },
  { 9277, 29, 49, 27, -1, -34 },
  { 9455, 25, 46, 27, 0, -46 },
  { 9599, 16, 46, 13, 0, -46 },
  { 9691, 24, 61, 13, -8, -46 },
  { 9874, 27, 46, 24, 0, -46 },
  { 10030, 16, 46, 13, 0, -46 },
  { 10122, 38, 34, 40, 0, -34 },
  { 10284, 25, 34, 27, 0, -34 },
  { 10391, 24, 35, 26, 1, -34 },
  { 10496, 29, 48, 27, -3, -34 },
  { 10670, 26, 49, 27, 1, -34 },
  { 10830, 22, 34, 19, 0, -34 },
  { 10924, 22, 35, 21, 0, -34 },
  { 11021, 16, 41, 17, 2, -40 },
  { 11103, 26, 34, 27, 1, -33 },
  { 11214, 22, 33, 23, 4, -33 },
  { 11305, 36, 33, 36, 3, -33 },
  { 11454, 29, 33, 23, -3, -33 },
  { 11574, 31, 48, 23, -5, -33 },
  { 11760, 23, 33, 19, -2, -33 },
  { 11855, 24, 54, 20, 1, -44 },
  { 12017, 6, 61, 23, 8, -47 },
  { 12063, 23, 54, 20, -4, -44 },
  { 12219, 25, 9, 28, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC61PT7B_H_
