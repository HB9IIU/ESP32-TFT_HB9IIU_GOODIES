#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC26PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xE1, 0x83,
  0x00, 0x00, 0x10, 0xF1, 0xE3, 0x80, 0x67, 0xE7, 0xE6, 0xEE, 0xCE, 0xCE,
  0xCC, 0x03, 0x30, 0x19, 0x81, 0x8C, 0x0C, 0xC0, 0x66, 0x07, 0x34, 0xFF,
  0xC7, 0xFE, 0x0C, 0xC0, 0xCC, 0x06, 0x60, 0x33, 0x0F, 0xFE, 0x7F, 0xF0,
  0xCC, 0x0C, 0xE0, 0x66, 0x03, 0x30, 0x33, 0x80, 0x01, 0x80, 0x20, 0x0E,
  0x07, 0xF1, 0xFE, 0x34, 0x8E, 0x81, 0xD0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x78, 0x0B, 0x81, 0x74, 0x5C, 0xFF, 0x9F, 0xE1, 0xF0, 0x08, 0x01,
  0x00, 0x20, 0x00, 0x0C, 0x0C, 0x3E, 0x18, 0x36, 0x18, 0x66, 0x30, 0x66,
  0x30, 0x66, 0x60, 0xE6, 0x60, 0xC6, 0xC0, 0xCD, 0xDE, 0xED, 0xBE, 0x7B,
  0xB7, 0x73, 0x67, 0x07, 0x66, 0x06, 0x66, 0x0C, 0x66, 0x0C, 0x66, 0x18,
  0x6C, 0x18, 0x7C, 0x30, 0x78, 0x03, 0x80, 0x7C, 0x0E, 0xE0, 0xCE, 0x1C,
  0xC1, 0xCC, 0x1D, 0xC1, 0xF8, 0x0F, 0x01, 0xE0, 0x3F, 0x77, 0x77, 0x67,
  0x6E, 0x3E, 0xE3, 0xCE, 0x3C, 0xE7, 0xCF, 0xFC, 0x7C, 0xE0, 0x7E, 0xEE,
  0xEC, 0xC0, 0x03, 0x83, 0x81, 0x81, 0xC1, 0xC0, 0xE0, 0x60, 0x70, 0x38,
  0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C,
  0x06, 0x03, 0x01, 0xC0, 0x06, 0x07, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x38,
  0x30, 0x70, 0xE0, 0x0E, 0x06, 0x13, 0x0F, 0xBF, 0xF8, 0xFC, 0xF8, 0xEC,
  0x67, 0x13, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x39, 0x9C, 0xEE, 0x73, 0x00, 0x7F,
  0xF8, 0x2F, 0xFE, 0x00, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x00, 0x07, 0x03, 0xE1, 0xFC,
  0xE7, 0x31, 0xDC, 0x77, 0x1D, 0x87, 0xE1, 0xF8, 0xEE, 0x3B, 0x8E, 0xC3,
  0xB1, 0xCC, 0x73, 0x18, 0xEE, 0x3F, 0x07, 0x80, 0x06, 0x1C, 0xFB, 0xFE,
  0xDB, 0xA7, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x70, 0xE1,
  0x80, 0x03, 0xC0, 0x7E, 0x1F, 0xF0, 0xC7, 0x08, 0x70, 0x07, 0x00, 0x60,
  0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x7F, 0x8F, 0xF8, 0xFF, 0x80, 0x07, 0x83, 0xF8, 0x7F, 0x88, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x1F, 0x83, 0xC0, 0x7E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x8F, 0x1F, 0xE3, 0xF0, 0x00, 0x00, 0xE0, 0x3C,
  0x07, 0x81, 0xE0, 0x2C, 0x0F, 0x83, 0x70, 0x6E, 0x19, 0x86, 0x70, 0xCE,
  0x31, 0xCE, 0x39, 0xFF, 0xBF, 0xF0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x00,
  0x0F, 0xE1, 0xFC, 0x7F, 0x8E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xF0, 0x3F,
  0x87, 0xF0, 0x0F, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0xCF, 0x1F,
  0xE3, 0xF0, 0x00, 0x01, 0xE0, 0xF8, 0x3F, 0x0E, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0xB8, 0xFF, 0x9F, 0xF3, 0x8E, 0x71, 0xCE, 0x39, 0x87, 0x30, 0xE7,
  0x38, 0xEF, 0x1F, 0xC1, 0xF0, 0x00, 0x3F, 0xE7, 0xFD, 0xFF, 0x80, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x00, 0x07, 0x81, 0xF8,
  0x7F, 0x8C, 0x73, 0x8E, 0x71, 0xCE, 0x38, 0xEE, 0x1F, 0x83, 0xE0, 0xFE,
  0x39, 0xCE, 0x19, 0xC3, 0xB8, 0x77, 0x1C, 0xE3, 0x9F, 0xE1, 0xF8, 0x00,
  0x07, 0x81, 0xF8, 0x7F, 0x1E, 0x73, 0x8E, 0x71, 0xCC, 0x3B, 0x87, 0x71,
  0xEF, 0x78, 0xFF, 0x1E, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x8F, 0x1F,
  0xC3, 0xE0, 0x00, 0x1C, 0xF3, 0x84, 0x00, 0x00, 0x00, 0x00, 0x02, 0x3C,
  0xE3, 0x80, 0x0E, 0x3C, 0x78, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC7, 0x0E, 0x18, 0x70, 0xC1, 0x80, 0x00, 0x40, 0x70, 0x7C, 0x7C, 0x7C,
  0x3C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0C, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x70, 0x7C, 0x7C, 0x7C, 0x3C, 0x0E, 0x02, 0x00, 0x1E, 0x7F,
  0x7F, 0x43, 0x03, 0x07, 0x07, 0x0E, 0x1C, 0x38, 0x30, 0x70, 0x60, 0x00,
  0x00, 0x00, 0xE0, 0xE0, 0xC0, 0x00, 0xE0, 0x07, 0xF0, 0x38, 0x70, 0xE0,
  0x71, 0x80, 0x66, 0x3E, 0xD8, 0xF9, 0xB3, 0x33, 0x66, 0x67, 0x98, 0xCF,
  0x33, 0x16, 0x66, 0x6C, 0xCC, 0xD9, 0xBB, 0x33, 0xFE, 0x67, 0x38, 0xC0,
  0x01, 0x80, 0x03, 0x81, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0x70, 0x77, 0x07, 0x70, 0xE7,
  0x0E, 0x71, 0xFF, 0x1F, 0xF1, 0xFF, 0x38, 0x73, 0x87, 0x70, 0x77, 0x07,
  0xF0, 0x70, 0x0F, 0x00, 0xFE, 0x1F, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x18,
  0x73, 0x8E, 0x3F, 0xC3, 0xF8, 0x3F, 0xC3, 0x0C, 0x70, 0xE7, 0x0E, 0x71,
  0xC7, 0x1C, 0xE7, 0xCF, 0xF8, 0xFE, 0x00, 0x03, 0xC0, 0xFF, 0x1F, 0xE1,
  0xC2, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF3, 0x07, 0xF0, 0x3F, 0x00,
  0x0F, 0x00, 0x7F, 0x07, 0xFC, 0x38, 0xE1, 0xC7, 0x0E, 0x3C, 0x71, 0xE7,
  0x0F, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x60, 0xE7, 0x0F, 0x38, 0x71, 0xC7,
  0x8E, 0x78, 0xFF, 0x87, 0xF8, 0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x7F, 0x8E,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x3F, 0x87, 0xF0, 0xFE, 0x18, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0xFF, 0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xE1,
  0xFC, 0x7F, 0x8E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0xF0,
  0xFE, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x3F, 0xC3, 0xFC, 0x3C, 0x23, 0xC0, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x1F, 0xB8, 0xF9, 0xC1, 0xCE, 0x0E, 0x70, 0x73,
  0x83, 0x1C, 0x38, 0xF9, 0xC3, 0xFE, 0x0F, 0xE0, 0x0E, 0x1C, 0x38, 0x71,
  0xC1, 0xC7, 0x06, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x0E, 0x3F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x0C, 0x1C, 0x70, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0xE0, 0xE3, 0x83, 0x8E, 0x1C, 0x00, 0x0F, 0xE3, 0xF8, 0x1C, 0x03, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x38, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xE0, 0x1C,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xE1, 0x78, 0x3F, 0x07, 0xC0, 0x0E, 0x1C, 0x30, 0xE1, 0xC7, 0x07,
  0x1C, 0x1C, 0xE0, 0x77, 0x01, 0x9C, 0x0E, 0xE0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0E, 0xC0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0xE3, 0x83,
  0x87, 0x0E, 0x1C, 0x00, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38,
  0x38, 0x38, 0x38, 0x30, 0x70, 0x70, 0x70, 0x70, 0xFF, 0xFF, 0xFE, 0x0F,
  0x03, 0xC3, 0xC0, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0xC7, 0xC3,
  0xE1, 0xF0, 0xF8, 0xFC, 0x7E, 0x3B, 0x1B, 0x8E, 0xCE, 0xC3, 0x33, 0x70,
  0xCD, 0xDC, 0x73, 0x67, 0x1C, 0xF9, 0xC7, 0x3C, 0x61, 0x8F, 0x38, 0xE3,
  0xCE, 0x38, 0xE3, 0x8E, 0x38, 0xE0, 0x0E, 0x0E, 0x1C, 0x1C, 0x78, 0x30,
  0xF8, 0x61, 0xF1, 0xC3, 0xE3, 0x86, 0xC7, 0x1D, 0x8C, 0x3B, 0x38, 0x77,
  0x70, 0xCE, 0xE1, 0x9D, 0xC7, 0x1B, 0x0E, 0x36, 0x1C, 0x7C, 0x30, 0xF8,
  0xE1, 0xE1, 0xC1, 0xC3, 0x83, 0x80, 0x03, 0xC0, 0xFE, 0x1F, 0xF1, 0xC7,
  0x38, 0x73, 0x87, 0x70, 0x77, 0x07, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xEE, 0x0E, 0xE1, 0xEE, 0x1C, 0xF7, 0x87, 0xF0, 0x3E, 0x00, 0x0F,
  0x00, 0xFE, 0x1F, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0x87, 0x38,
  0xE3, 0xBE, 0x3F, 0xC3, 0xF8, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0xFE, 0x1F, 0xF1, 0xC7, 0x38, 0x73,
  0x87, 0x70, 0x77, 0x07, 0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xEE,
  0x0E, 0xE1, 0xEE, 0x1C, 0xF7, 0x87, 0xF8, 0x3E, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x0F, 0x00, 0xFE, 0x1F, 0xE1, 0xCF, 0x1C, 0x71, 0xC7,
  0x18, 0x73, 0x8E, 0x38, 0xE3, 0xFC, 0x3F, 0x83, 0x70, 0x73, 0x07, 0x38,
  0x73, 0x87, 0x38, 0xE3, 0x8E, 0x3C, 0xE1, 0xC0, 0x01, 0xE0, 0x7F, 0x0F,
  0xF1, 0xE2, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC4, 0x1C, 0x7F, 0x87, 0xF8, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E,
  0x00, 0x1C, 0x38, 0xE1, 0xCE, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x39, 0xC1,
  0xCE, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x39, 0xC1, 0x8E, 0x1C, 0x70, 0xE3,
  0x87, 0x1C, 0x70, 0xF7, 0x87, 0xF8, 0x1F, 0x80, 0xE0, 0x7E, 0x0E, 0xE0,
  0xEE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE3, 0x8E, 0x38, 0xE7, 0x0E, 0x70, 0xE6,
  0x0E, 0xE0, 0xEE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x00, 0xE0, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x3B, 0x87, 0x0E, 0xE3, 0xC7,
  0x38, 0xF1, 0xCE, 0x7C, 0x73, 0x9B, 0x38, 0xE6, 0xCE, 0x3B, 0xB3, 0x0E,
  0xCD, 0xC3, 0xB3, 0x70, 0xFC, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x03, 0xC7,
  0xC0, 0xF1, 0xF0, 0x3C, 0x78, 0x0E, 0x1E, 0x00, 0x07, 0x0E, 0x0E, 0x38,
  0x1C, 0x60, 0x39, 0xC0, 0x77, 0x00, 0x6E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0x70,
  0x0C, 0x60, 0x38, 0xE0, 0xE1, 0xC3, 0xC3, 0x80, 0xE0, 0xFC, 0x39, 0x87,
  0x31, 0xC7, 0x30, 0xEE, 0x1D, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x1C,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x00, 0x0F,
  0xF0, 0xFF, 0x1F, 0xF0, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x7F,
  0x8F, 0xF8, 0xFF, 0x80, 0x07, 0xC1, 0xF0, 0xFC, 0x38, 0x0E, 0x03, 0x00,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x3F, 0x0F, 0xC0, 0xC6, 0x31, 0xCE,
  0x73, 0x8C, 0x63, 0x18, 0xE7, 0x39, 0xC6, 0x31, 0x8E, 0x07, 0xC1, 0xF0,
  0x7C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C,
  0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x1F,
  0x0F, 0xC0, 0x01, 0x00, 0x70, 0x1E, 0x03, 0xC0, 0xF8, 0x3B, 0x86, 0x71,
  0xC6, 0x30, 0xCE, 0x1F, 0x83, 0x80, 0xFF, 0xFF, 0xEE, 0x73, 0x1E, 0xE7,
  0xF9, 0xEF, 0x38, 0xE7, 0x1D, 0xC3, 0xB8, 0x67, 0x1C, 0xE3, 0x98, 0x73,
  0x1C, 0x77, 0x8F, 0xF0, 0xEE, 0x00, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01,
  0xC0, 0x38, 0x06, 0xF0, 0xFF, 0x3C, 0xE7, 0x1C, 0xE3, 0x98, 0x77, 0x0E,
  0xE1, 0xDC, 0x73, 0x8E, 0x71, 0xDE, 0x73, 0xFC, 0x6F, 0x00, 0x1F, 0x9F,
  0x9E, 0x4E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x38, 0x1C, 0x8F,
  0xC3, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x1E,
  0xE3, 0xFC, 0x7B, 0xC7, 0x1C, 0x61, 0xCE, 0x1C, 0xE1, 0x8E, 0x38, 0xC3,
  0x8C, 0x38, 0xC7, 0x0E, 0xF0, 0xFB, 0x07, 0x30, 0x1F, 0x1F, 0xDC, 0x6E,
  0x3E, 0x3F, 0x3B, 0xFD, 0xF8, 0xC0, 0x60, 0x30, 0x1C, 0x4F, 0xE3, 0xF0,
  0x00, 0x78, 0x07, 0x80, 0x7C, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1F, 0x81,
  0xFC, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x07, 0xB8, 0x7F, 0x87, 0xBC,
  0x38, 0xE1, 0x87, 0x1C, 0x38, 0xE3, 0x87, 0x1C, 0x38, 0xE1, 0x87, 0x0C,
  0x70, 0x77, 0x83, 0xFC, 0x1E, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x86, 0x3C,
  0x3F, 0xC0, 0xFC, 0x00, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0xF0, 0xFF, 0x3C, 0xE7, 0x1C, 0xE3, 0x9C, 0x67, 0x1C, 0xE3, 0x9C,
  0x73, 0x8E, 0x61, 0x9C, 0x73, 0x8E, 0x71, 0xC0, 0x04, 0x1C, 0x78, 0x60,
  0x00, 0x07, 0x0C, 0x38, 0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0x38, 0x61, 0xC3,
  0x87, 0x00, 0x00, 0x80, 0x70, 0x3C, 0x06, 0x00, 0x00, 0x00, 0x38, 0x0C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0xF0, 0x3C, 0x00, 0x0E,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0xF1, 0x8E, 0x39,
  0xC3, 0xB8, 0x3F, 0x03, 0x70, 0x7E, 0x07, 0xF0, 0x77, 0x07, 0x70, 0x67,
  0x0E, 0x30, 0xE3, 0x8E, 0x38, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x87, 0x0C,
  0x38, 0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x87, 0x00, 0x1B,
  0xDF, 0x1F, 0xFF, 0x3C, 0xF7, 0x38, 0xE7, 0x38, 0xC7, 0x31, 0xC7, 0x71,
  0xC7, 0x71, 0xC6, 0x71, 0xCE, 0x71, 0x8E, 0x63, 0x8E, 0xE3, 0x8E, 0xE3,
  0x8C, 0xE3, 0x1C, 0x1B, 0xC3, 0xFC, 0xF3, 0x9C, 0x73, 0x8E, 0x71, 0x9C,
  0x73, 0x8E, 0x71, 0xCE, 0x39, 0x86, 0x71, 0xCE, 0x39, 0xC7, 0x00, 0x1F,
  0x0F, 0xE7, 0xB9, 0xC7, 0xE1, 0xF8, 0x7E, 0x1B, 0x8E, 0xC3, 0xB0, 0xEC,
  0x73, 0xBC, 0xFE, 0x1F, 0x00, 0x0D, 0xE0, 0xFF, 0x1E, 0x71, 0xC7, 0x1C,
  0x71, 0x87, 0x38, 0x73, 0x87, 0x38, 0xE3, 0x8E, 0x38, 0xE7, 0x9C, 0x7F,
  0x87, 0x70, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x1E,
  0xE7, 0xF9, 0xEF, 0x38, 0xE6, 0x1D, 0xC3, 0xB8, 0x67, 0x1C, 0xC3, 0x98,
  0x73, 0x1C, 0x77, 0x8F, 0xF1, 0xEE, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x1B, 0x8F, 0xCF, 0xC7, 0x83, 0x81, 0xC1, 0xC0, 0xE0,
  0x70, 0x38, 0x18, 0x1C, 0x0E, 0x07, 0x00, 0x1F, 0x9F, 0xCE, 0x4E, 0x07,
  0x81, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xD1, 0xCF, 0xE7, 0xE0, 0x18,
  0x30, 0xE3, 0xFF, 0xEE, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x7C, 0xF8, 0x38, 0xDC, 0x77, 0x1D, 0xC7, 0x71, 0x98, 0x6E, 0x3B, 0x8E,
  0xE3, 0xB8, 0xCC, 0x73, 0xBC, 0xFF, 0x3D, 0xC0, 0xC3, 0xE1, 0xB1, 0xD8,
  0xEC, 0xE6, 0x73, 0x31, 0xB8, 0xD8, 0x7C, 0x3C, 0x1E, 0x0E, 0x07, 0x00,
  0x63, 0xC7, 0x63, 0xCE, 0x63, 0xCE, 0x67, 0x9C, 0x67, 0x9C, 0x6F, 0x98,
  0x6D, 0xB8, 0xED, 0xB8, 0xF9, 0xB0, 0xF9, 0xF0, 0xF9, 0xE0, 0xF1, 0xE0,
  0xF1, 0xE0, 0xF1, 0xC0, 0x1C, 0x71, 0xCE, 0x1C, 0xC0, 0xDC, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xB0, 0x3B, 0x07, 0x38, 0x73, 0x8E,
  0x38, 0x0C, 0x38, 0x61, 0xC3, 0x1C, 0x18, 0xE0, 0xCE, 0x06, 0x70, 0x33,
  0x01, 0xB8, 0x0D, 0x80, 0x6C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x3E, 0x01, 0xE0, 0x00, 0x1F, 0xC7,
  0xF0, 0x38, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x01,
  0xC0, 0xFF, 0x3F, 0x80, 0x00, 0x40, 0xF0, 0x7C, 0x1C, 0x07, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x07, 0x07, 0xC1, 0xC0, 0xF8, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x04, 0x01, 0xC0, 0xF8, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x3C, 0x07, 0x07, 0xC1,
  0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x3E, 0x0F, 0x00,
  0x78, 0x7F, 0xFC, 0xFE, 0x0E,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 7, 19, 6, 0, -19 },
  { 18, 8, 7, 10, 3, -19 },
  { 25, 13, 19, 12, 0, -19 },
  { 56, 11, 22, 11, 0, -20 },
  { 87, 16, 19, 17, 1, -19 },
  { 125, 12, 19, 13, 0, -19 },
  { 154, 4, 7, 6, 3, -19 },
  { 158, 9, 23, 7, 0, -19 },
  { 184, 8, 23, 7, -2, -19 },
  { 207, 9, 10, 10, 2, -20 },
  { 219, 10, 12, 12, 1, -15 },
  { 234, 5, 7, 6, -1, -3 },
  { 239, 7, 2, 7, 0, -8 },
  { 241, 4, 4, 6, 0, -4 },
  { 243, 12, 19, 9, -1, -19 },
  { 272, 10, 19, 11, 1, -19 },
  { 296, 7, 19, 11, 3, -19 },
  { 313, 12, 19, 11, -1, -19 },
  { 342, 11, 19, 11, 0, -19 },
  { 369, 11, 19, 11, 0, -19 },
  { 396, 11, 19, 11, 0, -19 },
  { 423, 11, 19, 11, 1, -19 },
  { 450, 11, 19, 11, 1, -19 },
  { 477, 11, 19, 11, 0, -19 },
  { 504, 11, 19, 11, 0, -19 },
  { 531, 6, 14, 6, 0, -14 },
  { 542, 7, 18, 6, -1, -14 },
  { 558, 10, 12, 12, 1, -15 },
  { 573, 10, 8, 12, 1, -13 },
  { 583, 10, 12, 12, 1, -15 },
  { 598, 8, 19, 8, 1, -19 },
  { 617, 15, 21, 16, 1, -19 },
  { 657, 12, 19, 12, -2, -19 },
  { 686, 12, 19, 12, 0, -19 },
  { 715, 12, 19, 11, 1, -19 },
  { 744, 13, 19, 13, 0, -19 },
  { 775, 11, 19, 10, 0, -19 },
  { 802, 11, 19, 10, 0, -19 },
  { 829, 13, 19, 13, 1, -19 },
  { 860, 14, 19, 13, 0, -19 },
  { 894, 11, 19, 8, -1, -19 },
  { 921, 11, 24, 6, -4, -19 },
  { 954, 14, 19, 11, 0, -19 },
  { 988, 8, 19, 10, 0, -19 },
  { 1007, 18, 19, 18, 0, -19 },
  { 1050, 15, 19, 14, 0, -19 },
  { 1086, 12, 19, 14, 1, -19 },
  { 1115, 12, 19, 11, 0, -19 },
  { 1144, 12, 23, 14, 1, -19 },
  { 1179, 12, 19, 12, 0, -19 },
  { 1208, 12, 19, 10, -1, -19 },
  { 1237, 10, 19, 10, 2, -19 },
  { 1261, 13, 19, 13, 1, -19 },
  { 1292, 12, 19, 11, 2, -19 },
  { 1321, 18, 19, 18, 2, -19 },
  { 1364, 15, 19, 11, -2, -19 },
  { 1400, 11, 19, 10, 2, -19 },
  { 1427, 12, 19, 10, -1, -19 },
  { 1456, 10, 23, 7, -1, -19 },
  { 1485, 5, 19, 9, 3, -19 },
  { 1497, 10, 23, 7, -2, -19 },
  { 1526, 11, 11, 11, 0, -19 },
  { 1542, 8, 2, 8, -2, 2 },
  { 1544, 4, 4, 7, 4, -20 },
  { 1546, 11, 14, 12, 1, -14 },
  { 1566, 11, 20, 12, 0, -20 },
  { 1594, 9, 14, 9, 1, -14 },
  { 1610, 12, 20, 12, 1, -20 },
  { 1640, 9, 14, 11, 1, -14 },
  { 1656, 13, 26, 7, -3, -20 },
  { 1699, 13, 20, 12, -1, -14 },
  { 1732, 11, 20, 11, 0, -20 },
  { 1760, 7, 20, 6, 0, -20 },
  { 1778, 10, 26, 6, -3, -20 },
  { 1811, 12, 20, 10, 0, -20 },
  { 1841, 7, 20, 6, 0, -20 },
  { 1859, 16, 14, 17, 0, -14 },
  { 1887, 11, 14, 11, 0, -14 },
  { 1907, 10, 14, 11, 1, -14 },
  { 1925, 12, 20, 12, -1, -14 },
  { 1955, 11, 20, 12, 1, -14 },
  { 1983, 9, 14, 8, 0, -14 },
  { 1999, 9, 14, 9, 0, -14 },
  { 2015, 7, 17, 7, 1, -17 },
  { 2030, 10, 14, 11, 1, -14 },
  { 2048, 9, 14, 10, 2, -14 },
  { 2064, 16, 14, 15, 1, -14 },
  { 2092, 12, 14, 10, -1, -14 },
  { 2113, 13, 20, 10, -2, -14 },
  { 2146, 10, 14, 8, -1, -14 },
  { 2164, 10, 23, 9, 0, -19 },
  { 2193, 3, 26, 10, 3, -20 },
  { 2203, 10, 23, 9, -2, -19 },
  { 2232, 10, 4, 12, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC26PT7B_H_
