#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC63PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x01, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0,
  0x00, 0x80, 0x00, 0x3F, 0xC7, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF8,
  0x7F, 0x3F, 0x87, 0xE3, 0xF0, 0xFE, 0x3F, 0x0F, 0xE7, 0xF0, 0xFC, 0x7E,
  0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x1F, 0x87,
  0xC1, 0xF8, 0xFC, 0x1F, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C,
  0x00, 0x07, 0xC1, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8,
  0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0x81, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0x67,
  0xC0, 0x3F, 0x8C, 0x38, 0x07, 0xE3, 0x82, 0x00, 0xFC, 0x70, 0x00, 0x1F,
  0x8E, 0x00, 0x03, 0xF1, 0x80, 0x00, 0x7E, 0x30, 0x00, 0x0F, 0xEE, 0x00,
  0x01, 0xFD, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0x7F, 0x80, 0x00, 0x67, 0xF0, 0x00, 0x1C, 0xFE, 0x00,
  0x03, 0x8F, 0xC0, 0x00, 0x71, 0xF8, 0x00, 0x0C, 0x7F, 0x04, 0x01, 0x8F,
  0xE0, 0xE0, 0x73, 0xFC, 0x1F, 0x0E, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x7C, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x7F,
  0xF8, 0x03, 0xE0, 0x07, 0xE7, 0xC0, 0x1F, 0x00, 0x3E, 0x3E, 0x01, 0xF0,
  0x03, 0xE1, 0xF0, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x7C,
  0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x07, 0xE0, 0x07,
  0xC0, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0x7E, 0x1F,
  0x00, 0x0F, 0x83, 0xE1, 0xF0, 0x00, 0xFC, 0x1F, 0x0F, 0x80, 0x07, 0xC0,
  0xF8, 0xF8, 0x00, 0x3E, 0x0F, 0xC7, 0xC0, 0xC1, 0xF0, 0x7C, 0x7C, 0x1F,
  0xCF, 0x83, 0xE3, 0xE3, 0xFF, 0x7C, 0x3E, 0x3E, 0x3F, 0xFB, 0xE1, 0xF1,
  0xF1, 0xFF, 0xFF, 0x9F, 0x1F, 0x1F, 0xBF, 0x7F, 0xF9, 0xF9, 0xF8, 0xFB,
  0xFF, 0x8F, 0x8F, 0x87, 0xCF, 0xF8, 0xFC, 0x7C, 0x3E, 0x3F, 0x87, 0xC7,
  0xC1, 0xF0, 0x20, 0x7E, 0x3E, 0x0F, 0x80, 0x03, 0xE3, 0xF0, 0x7C, 0x00,
  0x3E, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xC1,
  0xF8, 0x00, 0xF8, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x7C, 0x00, 0x7C,
  0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x3F, 0x00, 0x3E, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x0F,
  0x87, 0xC0, 0x1F, 0x80, 0x7E, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0x0F,
  0xC0, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x07, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x7F,
  0x03, 0xFF, 0xC1, 0xFC, 0x1F, 0xFF, 0x07, 0xE0, 0xFE, 0xFE, 0x3F, 0x87,
  0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x1F, 0xDF, 0xC7, 0xF0,
  0x7F, 0x7E, 0x1F, 0xC1, 0xFF, 0xF8, 0xFE, 0x03, 0xFF, 0xC3, 0xF8, 0x0F,
  0xFF, 0x0F, 0xE0, 0x3F, 0xF8, 0x3F, 0x80, 0x7F, 0xC0, 0xFE, 0x01, 0xFF,
  0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xF0, 0x3F, 0x81, 0xFF, 0xC0,
  0xFF, 0x9F, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xCF, 0xF0, 0x3F, 0xFE, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0x38,
  0x00, 0x00, 0x00, 0x1F, 0xC7, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0,
  0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0xC1, 0xF8,
  0x03, 0xC7, 0xE0, 0x1F, 0xDF, 0x07, 0x7F, 0xFD, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0x7E, 0x07, 0xF8, 0xFC,
  0x0F, 0xC3, 0xF0, 0x1F, 0x0F, 0xE0, 0x38, 0x1F, 0x00, 0x40, 0x70, 0x00,
  0x00, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x00,
  0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x80,
  0x06, 0x1F, 0x9F, 0xEF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFE, 0x7E, 0x08, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0x81,
  0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7F, 0x01, 0xF8,
  0x7F, 0x00, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F,
  0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03,
  0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x7F, 0x00,
  0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0,
  0x0F, 0xE3, 0xF0, 0x07, 0xF3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE,
  0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7E, 0x0F,
  0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0xFE, 0x3F, 0xC0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFE, 0xFE,
  0x7F, 0x9F, 0x87, 0xE7, 0xF0, 0x78, 0xFE, 0x06, 0x1F, 0xC0, 0x83, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xE0,
  0xFF, 0x00, 0x78, 0x07, 0xF0, 0x03, 0x00, 0x7F, 0x00, 0x20, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x20, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0x81, 0xFF, 0x00, 0x60, 0x0F, 0xF0, 0x04, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x80, 0x03, 0xFC, 0x0E, 0x00, 0x7F, 0xC0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0x9F, 0x80, 0x00, 0xFB, 0xF8,
  0x00, 0x1F, 0x3F, 0x80, 0x01, 0xF3, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x7C, 0x7F, 0x00, 0x0F, 0x87, 0xF0, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xFE, 0x00, 0x3E, 0x0F, 0xE0, 0x07,
  0xC0, 0xFE, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x1F,
  0xC0, 0x3F, 0x01, 0xFC, 0x03, 0xE0, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x10, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0x00, 0x0F, 0xF0, 0x38, 0x07, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x78,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE1, 0xF0, 0x03,
  0xF9, 0xFF, 0x00, 0xFE, 0xFF, 0xE0, 0x3F, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0x8F, 0xF0, 0x7F, 0x81, 0xFC, 0x3F, 0xE0,
  0x7F, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xFC,
  0x3F, 0x00, 0xFF, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x07,
  0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x7F, 0x80, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F,
  0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x3F,
  0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE,
  0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xF7, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xCF,
  0xE0, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x1F,
  0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F,
  0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x87, 0xF8,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0x03,
  0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F,
  0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xFC, 0x7F,
  0x00, 0xFF, 0x1F, 0xC0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x0F, 0xF8,
  0x3F, 0xC7, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFD, 0xFC, 0x03, 0xFE, 0x7F, 0x00, 0x3C, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xF9, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x03, 0xE0, 0x1F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0xC0, 0x7F, 0x01, 0xFE, 0x0F, 0xF8,
  0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x07, 0xE0, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7E, 0x7F, 0xC1, 0xC0, 0xFF,
  0x04, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x1F,
  0xF0, 0x7C, 0x0F, 0x81, 0xFF, 0xE1, 0xF0, 0x7C, 0x0F, 0xFF, 0x87, 0xC1,
  0xE0, 0x7F, 0xFE, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87,
  0xC1, 0xF1, 0xF0, 0x7C, 0x1F, 0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x1F, 0x1E,
  0x0F, 0x81, 0xF0, 0x78, 0xF8, 0x3E, 0x0F, 0x81, 0xE3, 0xE0, 0xF0, 0x3E,
  0x0F, 0x8F, 0x87, 0xC0, 0xF8, 0x3E, 0x3C, 0x1F, 0x03, 0xE0, 0xF9, 0xF0,
  0x7C, 0x1F, 0x03, 0xC7, 0xC3, 0xE0, 0x7C, 0x1F, 0x1F, 0x0F, 0x81, 0xF0,
  0x7C, 0x7C, 0x3E, 0x0F, 0xC1, 0xE1, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0x83,
  0xE0, 0xF8, 0x3C, 0x1E, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x3E, 0x3F, 0x87,
  0x83, 0xE0, 0xFD, 0xFF, 0x7E, 0x0F, 0x81, 0xFF, 0x3F, 0xF0, 0x3E, 0x07,
  0xFC, 0xFF, 0x80, 0xF8, 0x0F, 0xE1, 0xFC, 0x01, 0xE0, 0x0E, 0x03, 0xC0,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0x00, 0x00, 0x3F, 0xC0,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x87, 0xF0,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F,
  0xC0, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF7, 0xF8, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xF8,
  0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x01, 0xFC, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xE1, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0xC1,
  0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0x03, 0xF8,
  0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xF0,
  0x38, 0x01, 0xFF, 0x00, 0x40, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x40, 0x0F, 0xF8, 0x0C, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0x8F, 0xFE, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8,
  0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x80, 0xFE,
  0x01, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x7F, 0xE0, 0x1F, 0xCF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x3C, 0x01, 0xFF, 0x00, 0x08, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0xFF, 0xF8, 0x7F, 0x80, 0xFF, 0xF0, 0x7F, 0x80, 0xFF, 0xF0, 0x7F, 0x00,
  0xFF, 0xF0, 0x7F, 0x00, 0xFF, 0xF0, 0x7F, 0x01, 0xFF, 0xF0, 0xFF, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0xE0,
  0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x19, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x17, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x3F, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0,
  0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFC,
  0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0xFD, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x0F,
  0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0xFE, 0x00, 0xFD, 0xF8, 0x03, 0xF7,
  0xE0, 0x1F, 0xBF, 0x80, 0x3F, 0x7E, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xE0,
  0x3F, 0x3F, 0x80, 0x7F, 0x7E, 0x03, 0xF3, 0xF0, 0x07, 0xF7, 0xE0, 0x3F,
  0x7F, 0x00, 0x7E, 0x7E, 0x07, 0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x7E, 0x7F,
  0x00, 0xFE, 0x3E, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xE0, 0xFC, 0x7E, 0x00,
  0xFC, 0x3E, 0x1F, 0x8F, 0xE0, 0x0F, 0xC3, 0xE1, 0xF8, 0xFE, 0x00, 0xFC,
  0x3F, 0x3F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF3, 0xF0, 0xFC, 0x01, 0xFC, 0x3F,
  0x3E, 0x0F, 0xC0, 0x1F, 0x83, 0xF7, 0xE1, 0xFC, 0x01, 0xF8, 0x3F, 0x7E,
  0x1F, 0xC0, 0x1F, 0x83, 0xFF, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0xFC, 0x1F,
  0x80, 0x3F, 0x83, 0xFF, 0x83, 0xF8, 0x03, 0xF0, 0x3F, 0xF8, 0x3F, 0x80,
  0x3F, 0x03, 0xFF, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0xF0, 0x3F, 0x80, 0x7F,
  0x03, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0x00, 0x7E, 0x03,
  0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xFC,
  0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x07,
  0xE0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x0F, 0xFC,
  0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0xFE, 0x01, 0xFC, 0x01,
  0xFF, 0xE0, 0x1F, 0xC0, 0x1F, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x1F,
  0x80, 0x1F, 0xBF, 0x01, 0xF8, 0x03, 0xFB, 0xF0, 0x3F, 0x80, 0x3F, 0x3F,
  0x03, 0xF8, 0x03, 0xF3, 0xF0, 0x3F, 0x80, 0x3F, 0x3F, 0x03, 0xF0, 0x03,
  0xF3, 0xF0, 0x3F, 0x00, 0x7F, 0x1F, 0x87, 0xF0, 0x07, 0xF1, 0xF8, 0x7F,
  0x00, 0x7E, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x7E, 0x00, 0xFE, 0x1F,
  0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0xFE, 0x00, 0xFC, 0x0F, 0xCF, 0xE0, 0x0F,
  0xC0, 0xFC, 0xFC, 0x00, 0xFC, 0x0F, 0xCF, 0xC0, 0x1F, 0xC0, 0xFC, 0xFC,
  0x01, 0xFC, 0x0F, 0xDF, 0xC0, 0x1F, 0x80, 0xFD, 0xFC, 0x01, 0xF8, 0x07,
  0xFF, 0x80, 0x1F, 0x80, 0x7F, 0xF8, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0x3F,
  0x80, 0x7F, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0xF0,
  0x03, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x07, 0xF0, 0x03,
  0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0xFF,
  0x00, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xCF, 0xF0,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x03,
  0xFC, 0x7F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8,
  0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xE1, 0xFF, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x00,
  0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F,
  0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x1F,
  0xC1, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0x83, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0,
  0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0,
  0x01, 0xFE, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x00,
  0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xE1, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xF8, 0x7F, 0xC0,
  0x1F, 0xC1, 0xFE, 0x00, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0x7F,
  0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x01, 0xFC, 0x1F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01,
  0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x7C, 0x01,
  0xFE, 0x00, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x20, 0x01, 0xFE, 0x01,
  0xC0, 0x0F, 0xF0, 0x1F, 0x81, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8,
  0x01, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x07, 0xF0,
  0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0,
  0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80,
  0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0xFF, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xEF,
  0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x03,
  0xF8, 0xFC, 0x00, 0xFF, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0x7E,
  0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFE,
  0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0,
  0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x80,
  0x3F, 0x07, 0xF0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x8F,
  0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xCF, 0xE0, 0x01,
  0xF9, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFD, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF3,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE7, 0xF0,
  0x01, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03,
  0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xFC,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xFC, 0x03,
  0xF8, 0x7F, 0x00, 0xFF, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xF8, 0x07, 0xF0,
  0x7F, 0x01, 0xFF, 0x80, 0x7E, 0x07, 0xF0, 0x1F, 0xF8, 0x0F, 0xE0, 0x7F,
  0x03, 0xFF, 0x80, 0xFE, 0x07, 0xF0, 0x3E, 0xF8, 0x1F, 0xC0, 0x7F, 0x07,
  0xEF, 0x81, 0xFC, 0x07, 0xF0, 0x7E, 0xF8, 0x1F, 0x80, 0x7F, 0x07, 0xCF,
  0x83, 0xF8, 0x07, 0xF0, 0xFC, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xCF, 0x87,
  0xF0, 0x07, 0xE1, 0xF8, 0xF8, 0x7F, 0x00, 0x7E, 0x1F, 0x9F, 0x87, 0xE0,
  0x07, 0xE1, 0xF1, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x1F, 0x8F, 0xE0, 0x07,
  0xE3, 0xF1, 0xF8, 0xFC, 0x00, 0x7E, 0x3E, 0x1F, 0x9F, 0xC0, 0x07, 0xE7,
  0xE1, 0xF9, 0xFC, 0x00, 0x7E, 0x7E, 0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xC1,
  0xFB, 0xF8, 0x00, 0x7E, 0xFC, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0x81, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x81, 0xF7, 0xE0,
  0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xDF, 0xC0,
  0x0F, 0xE7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x8F,
  0xE0, 0x0F, 0xE3, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x3F,
  0xBF, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x07,
  0xE3, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xF0, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0x0F, 0xE1, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x03, 0xF0, 0x7E,
  0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF8, 0xFC, 0x03, 0xFF,
  0x9F, 0x80, 0xFF, 0xF3, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0x3F, 0xF0, 0x3F, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x07,
  0xF8, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0x7F, 0x80, 0x7F,
  0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x07, 0xF0,
  0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x0F, 0xF0,
  0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x83,
  0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x3F, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xEF, 0xC0, 0x3F, 0xF9, 0xF8, 0x07, 0xFE, 0x3F, 0x00, 0x7F, 0x87,
  0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x78, 0x00, 0x7E, 0x3F, 0xC0, 0x0F, 0xCF, 0xFC, 0x03,
  0xFB, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x1F,
  0xE0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0x87, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x87, 0xF0,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xF0,
  0x7E, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0x7F, 0x81, 0xFE, 0x0F,
  0xF8, 0x3F, 0x81, 0xFF, 0x8F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xDF, 0xFF,
  0x01, 0xFB, 0xFF, 0xC0, 0x3F, 0x3F, 0xF0, 0x07, 0xC3, 0xFC, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0x0E, 0x03,
  0xFC, 0x08, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x04, 0x07,
  0xF0, 0x18, 0x0F, 0xF9, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x38, 0x1F, 0x80, 0x03, 0xFC, 0x7E, 0x00, 0x3F, 0xFB, 0xF8, 0x01,
  0xFF, 0xEF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0x3F, 0xF0, 0x07, 0xF0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x01,
  0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F,
  0x00, 0x7E, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x80,
  0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFD, 0xF8, 0x00,
  0xFF, 0xF7, 0xE0, 0x03, 0xFF, 0x9F, 0x00, 0x03, 0xF8, 0x7C, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xF8, 0x7F,
  0x07, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x7F,
  0x1F, 0x80, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x03, 0xFC,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x20, 0x7F, 0x80, 0xE0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0xE3, 0xF0, 0x01, 0xFF, 0xCF, 0xC0, 0x0F, 0xFF, 0x3F, 0x00,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xF9, 0xFF, 0x80, 0x3F,
  0x83, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0,
  0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x07,
  0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF, 0x80, 0x3F, 0xCF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0x00,
  0x1F, 0xF9, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x38, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x0C, 0x00, 0x7F,
  0x80, 0x3C, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x0F, 0x00, 0x1F, 0x8F, 0xF0, 0x07, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFD, 0xFF, 0x03, 0xFC, 0x1F,
  0xC1, 0xFE, 0x07, 0xF0, 0x7F, 0x81, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0,
  0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0xFE, 0x0F,
  0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFC,
  0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x01,
  0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1, 0xFC,
  0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1,
  0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x3F,
  0x83, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x87,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x07,
  0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x03,
  0xF0, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x1F,
  0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE7, 0xF0, 0x00,
  0x7E, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFC,
  0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x07, 0xF0,
  0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7E,
  0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xE3, 0xFE, 0x0F, 0xF0,
  0x07, 0xCF, 0xFE, 0x3F, 0xF0, 0x1F, 0xBF, 0xFC, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFB, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x8F, 0xFE, 0x7F,
  0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0x7E, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x07,
  0xF0, 0xFE, 0x03, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x1F, 0x83, 0xF8,
  0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x01,
  0xFC, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0xFE,
  0x03, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xF0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x3F, 0xC0,
  0x1F, 0x3F, 0xF8, 0x0F, 0xCF, 0xFE, 0x03, 0xF7, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xF3, 0xFC, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x1F, 0xC1, 0xFE,
  0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0xC3,
  0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F,
  0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0,
  0x7F, 0x07, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xF8, 0x3F,
  0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0,
  0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0xC3, 0xF8, 0x07,
  0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0xF3, 0xFC, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07,
  0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7E, 0x00,
  0x7F, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0,
  0x0F, 0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xF3, 0xF8, 0x03, 0xF9, 0xFC,
  0x01, 0xFC, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0xFF, 0x0F,
  0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x83, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x7F, 0x80,
  0x03, 0xE3, 0xFF, 0x00, 0x1F, 0x9F, 0xFC, 0x00, 0x7E, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x3F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0xFF,
  0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F, 0xF3, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xDF, 0xFC, 0x00, 0x7F, 0x7F, 0xE0, 0x01,
  0xFC, 0xFF, 0x00, 0x07, 0xE0, 0x60, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0xF8, 0xFC, 0x01, 0xFF, 0x9F, 0x80, 0x7F,
  0xFB, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x3F, 0xF0,
  0x3F, 0x83, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x7F, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xF0,
  0x7F, 0x80, 0xFF, 0x3F, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFB, 0xF8, 0x07, 0xFE, 0x7E, 0x00, 0x7F, 0x8F, 0xC0, 0x01, 0x83,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x07, 0xC7, 0xF0, 0x1F, 0x3F, 0xC0, 0xFC, 0xFE,
  0x03, 0xF7, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFE, 0x0F, 0x03, 0xF8,
  0x04, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x84, 0x00, 0x7F, 0x0E, 0x01,
  0xFE, 0x1F, 0xDF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE7,
  0xFF, 0xF0, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xE2, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x01, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x01,
  0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x0F, 0xE0, 0x7E, 0x01, 0xFC, 0x0F,
  0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x3F,
  0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x81, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0,
  0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0x80,
  0x7F, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03,
  0xF8, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F,
  0xE0, 0x7F, 0x87, 0xFC, 0x0F, 0xF9, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xDF, 0x80, 0x3F, 0xF3, 0xF0, 0x03, 0xFC, 0x7E,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFB, 0xF0,
  0x07, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x7E, 0x3F, 0x01,
  0xFC, 0x7E, 0x03, 0xF8, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F,
  0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0,
  0x7E, 0x1F, 0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF8, 0x07,
  0xE7, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x01, 0xFE, 0x03, 0xFB,
  0xF0, 0x0F, 0xF0, 0x1F, 0x9F, 0x80, 0xFF, 0x80, 0xFC, 0xFC, 0x07, 0xFC,
  0x0F, 0xE7, 0xE0, 0x7F, 0xE0, 0x7E, 0x3F, 0x03, 0xFE, 0x07, 0xF1, 0xF8,
  0x1F, 0xF0, 0x3F, 0x0F, 0xC1, 0xFF, 0x81, 0xF8, 0x7E, 0x0F, 0xFC, 0x1F,
  0xC3, 0xF0, 0x7F, 0xE0, 0xFC, 0x1F, 0x87, 0xDF, 0x07, 0xE0, 0xFC, 0x3E,
  0xF8, 0x7E, 0x07, 0xE3, 0xF7, 0xC3, 0xF0, 0x3F, 0x1F, 0x3E, 0x3F, 0x81,
  0xF8, 0xF9, 0xF1, 0xF8, 0x0F, 0xCF, 0xCF, 0x8F, 0xC0, 0x7E, 0x7C, 0x7C,
  0xFC, 0x03, 0xF7, 0xE3, 0xE7, 0xE0, 0x1F, 0xBF, 0x1F, 0x3F, 0x00, 0xFD,
  0xF1, 0xFB, 0xF0, 0x07, 0xFF, 0x8F, 0xDF, 0x80, 0x3E, 0xF8, 0x7F, 0xF8,
  0x01, 0xF7, 0xC3, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x03,
  0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7E,
  0x1F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07,
  0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x00, 0xFC,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x4F, 0xFE, 0x00, 0x37, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFB, 0x80, 0x3F, 0xFC, 0x80,
  0x03, 0xFE, 0x20, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 17, 46, 15, 0, -45 },
  { 99, 20, 16, 24, 6, -45 },
  { 139, 30, 45, 29, 0, -45 },
  { 308, 27, 52, 26, 0, -48 },
  { 484, 37, 47, 42, 3, -46 },
  { 702, 30, 47, 30, 0, -46 },
  { 879, 10, 16, 14, 6, -45 },
  { 899, 20, 55, 17, 1, -45 },
  { 1037, 21, 56, 17, -5, -46 },
  { 1184, 22, 24, 25, 5, -48 },
  { 1250, 24, 30, 28, 3, -37 },
  { 1340, 13, 17, 14, -3, -8 },
  { 1368, 15, 6, 17, 1, -20 },
  { 1380, 9, 10, 14, 0, -9 },
  { 1392, 31, 45, 23, -3, -45 },
  { 1567, 25, 47, 26, 1, -46 },
  { 1714, 19, 45, 26, 6, -45 },
  { 1821, 28, 46, 26, -2, -46 },
  { 1982, 28, 47, 26, -1, -46 },
  { 2147, 28, 45, 26, -1, -45 },
  { 2305, 27, 46, 26, 0, -45 },
  { 2461, 26, 47, 26, 2, -46 },
  { 2614, 27, 45, 26, 2, -45 },
  { 2766, 27, 47, 26, 0, -46 },
  { 2925, 26, 47, 26, 0, -46 },
  { 3078, 14, 36, 14, 0, -35 },
  { 3141, 17, 44, 14, -3, -35 },
  { 3235, 25, 29, 28, 2, -37 },
  { 3326, 25, 18, 28, 2, -31 },
  { 3383, 24, 29, 28, 3, -37 },
  { 3470, 22, 47, 20, 1, -46 },
  { 3600, 38, 50, 39, 1, -45 },
  { 3838, 28, 45, 28, -4, -45 },
  { 3996, 29, 45, 29, 0, -45 },
  { 4160, 29, 47, 26, 2, -46 },
  { 4331, 31, 45, 31, 0, -45 },
  { 4506, 27, 45, 24, 0, -45 },
  { 4658, 27, 45, 23, 0, -45 },
  { 4810, 32, 47, 32, 2, -46 },
  { 4998, 34, 45, 32, 0, -45 },
  { 5190, 26, 45, 19, -3, -45 },
  { 5337, 27, 58, 14, -10, -45 },
  { 5533, 33, 45, 28, 0, -45 },
  { 5719, 19, 45, 23, 0, -45 },
  { 5826, 44, 45, 43, 0, -45 },
  { 6074, 36, 45, 34, 0, -45 },
  { 6277, 31, 47, 33, 2, -46 },
  { 6460, 30, 45, 28, 0, -45 },
  { 6629, 31, 57, 33, 2, -46 },
  { 6850, 29, 45, 28, 0, -45 },
  { 7014, 29, 47, 25, -1, -46 },
  { 7185, 25, 45, 24, 4, -45 },
  { 7326, 32, 46, 31, 2, -45 },
  { 7510, 27, 45, 28, 6, -45 },
  { 7662, 44, 45, 43, 4, -45 },
  { 7910, 35, 45, 26, -4, -45 },
  { 8107, 26, 45, 25, 5, -45 },
  { 8254, 30, 45, 23, -3, -45 },
  { 8423, 24, 55, 18, -2, -45 },
  { 8588, 12, 45, 23, 6, -45 },
  { 8656, 24, 55, 18, -4, -45 },
  { 8821, 26, 26, 26, 0, -45 },
  { 8906, 21, 4, 20, -6, 5 },
  { 8917, 11, 10, 18, 9, -48 },
  { 8931, 27, 36, 28, 1, -35 },
  { 9053, 27, 49, 28, 0, -48 },
  { 9219, 23, 36, 22, 1, -35 },
  { 9323, 30, 49, 28, 1, -48 },
  { 9507, 24, 36, 26, 1, -35 },
  { 9615, 31, 63, 16, -7, -48 },
  { 9860, 30, 50, 28, -2, -35 },
  { 10048, 26, 48, 28, 0, -48 },
  { 10204, 16, 47, 14, 0, -47 },
  { 10298, 24, 62, 14, -8, -47 },
  { 10484, 28, 48, 25, 0, -48 },
  { 10652, 17, 48, 13, 0, -48 },
  { 10754, 39, 35, 41, 0, -35 },
  { 10925, 26, 35, 28, 0, -35 },
  { 11039, 25, 36, 27, 1, -35 },
  { 11152, 30, 50, 28, -3, -35 },
  { 11340, 27, 50, 28, 1, -35 },
  { 11509, 22, 35, 19, 0, -35 },
  { 11606, 23, 36, 22, -1, -35 },
  { 11710, 17, 43, 17, 2, -42 },
  { 11802, 27, 35, 28, 1, -34 },
  { 11921, 23, 34, 24, 4, -34 },
  { 12019, 37, 34, 37, 3, -34 },
  { 12177, 30, 34, 24, -3, -34 },
  { 12305, 32, 49, 24, -5, -34 },
  { 12501, 24, 34, 20, -2, -34 },
  { 12603, 24, 55, 21, 1, -45 },
  { 12768, 6, 63, 23, 8, -48 },
  { 12816, 24, 55, 21, -4, -45 },
  { 12981, 26, 10, 28, 2, -27 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC63PT7B_H_
