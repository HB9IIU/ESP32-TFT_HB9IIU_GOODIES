#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC48PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x07, 0xC0,
  0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x03, 0xC0, 0x00, 0x7E, 0x3E, 0xF8,
  0xFD, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F, 0xBE, 0x1E, 0x7C, 0x7C,
  0xF8, 0xF9, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x80, 0x00, 0x1E, 0x1E, 0x00,
  0x38, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xC0, 0x03, 0x87, 0x80, 0x0F,
  0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xF0, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x3C, 0x38,
  0x00, 0x70, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x3C, 0x38, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x0E, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0x78, 0x70, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xEC, 0xE0, 0x3E, 0x61,
  0x03, 0xE3, 0x00, 0x1F, 0x30, 0x00, 0xF9, 0x80, 0x07, 0xEC, 0x00, 0x3F,
  0x60, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xBF, 0x00, 0x0D,
  0xF8, 0x00, 0x67, 0xC0, 0x06, 0x3E, 0x10, 0x33, 0xF0, 0x81, 0x9F, 0x07,
  0x0D, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x40, 0x1F, 0x80, 0x3C,
  0x01, 0xFE, 0x01, 0xE0, 0x1F, 0xF0, 0x1E, 0x01, 0xE7, 0x80, 0xF0, 0x0F,
  0x1C, 0x0F, 0x00, 0xF0, 0xE0, 0x78, 0x07, 0x87, 0x07, 0x80, 0x38, 0x78,
  0x78, 0x03, 0xC3, 0xC3, 0xC0, 0x1E, 0x1E, 0x3C, 0x00, 0xF0, 0xF1, 0xE0,
  0x07, 0x87, 0x9E, 0x00, 0x38, 0x78, 0xF0, 0x03, 0xC3, 0xCF, 0x0F, 0x1E,
  0x1E, 0x79, 0xFE, 0xF1, 0xE7, 0x8F, 0xF7, 0xCF, 0x3C, 0xFF, 0x9F, 0xF3,
  0xCF, 0x1E, 0xFF, 0x1E, 0x78, 0xF3, 0xF1, 0xE7, 0x87, 0x86, 0x0F, 0x3C,
  0x3C, 0x00, 0xF1, 0xE1, 0xE0, 0x0F, 0x1E, 0x1E, 0x00, 0x78, 0xF0, 0xF0,
  0x07, 0x87, 0x87, 0x80, 0x3C, 0x3C, 0x3C, 0x03, 0xC1, 0xE3, 0xC0, 0x1E,
  0x0E, 0x1E, 0x01, 0xE0, 0x70, 0xF0, 0x0F, 0x03, 0x8F, 0x00, 0xF0, 0x1E,
  0xF8, 0x07, 0x80, 0xFF, 0x80, 0x78, 0x07, 0xF8, 0x07, 0xC0, 0x1F, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x1F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF0, 0x03,
  0xE1, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x3E, 0x00, 0x3E,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0xF8, 0xFF, 0xE3, 0xE1, 0xF7, 0xC7,
  0xC7, 0xCF, 0xDF, 0x9F, 0x0F, 0xBE, 0x3E, 0x1F, 0x7C, 0xFC, 0x3F, 0xF1,
  0xF0, 0x3F, 0xE3, 0xE0, 0x7F, 0x87, 0xC0, 0xFE, 0x0F, 0x80, 0xFC, 0x1F,
  0x03, 0xF8, 0x3F, 0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFB, 0xE0, 0xFF,
  0xE7, 0xE0, 0x7F, 0x0F, 0xC0, 0x3E, 0xFD, 0xF3, 0xE7, 0xCF, 0x9E, 0x7C,
  0xF9, 0xF3, 0xC7, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x02, 0x1E, 0x03,
  0xCF, 0x01, 0xFF, 0x9D, 0xFF, 0xFE, 0xFF, 0xFF, 0x87, 0xFF, 0xC1, 0xFF,
  0xE1, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xF9, 0xE0, 0x78, 0xF8, 0x18,
  0x7C, 0x04, 0x18, 0x00, 0x08, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x87, 0xC7, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3C, 0x3E, 0x1E,
  0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xC0, 0x08, 0xF9, 0xFF,
  0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xCF, 0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0x83, 0xE3, 0xF0,
  0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF3, 0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x81,
  0xFB, 0xF0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07,
  0xEF, 0xC0, 0xF9, 0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xFC, 0xF8, 0x1F,
  0x1F, 0x03, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8,
  0x3F, 0x7F, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF8, 0x7F, 0xE3,
  0xFF, 0x1F, 0xFC, 0xFD, 0xF1, 0xC7, 0xC6, 0x3F, 0x08, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFE,
  0x01, 0xFF, 0xFC, 0x07, 0xC3, 0xF0, 0x0E, 0x0F, 0xC0, 0x20, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0x07, 0xE0, 0x18, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x82, 0x00, 0x7E,
  0x0F, 0x0F, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xBE,
  0x00, 0x3D, 0xF0, 0x01, 0xDF, 0x00, 0x1E, 0xF8, 0x01, 0xE7, 0xC0, 0x0F,
  0x3E, 0x00, 0xF3, 0xF0, 0x0F, 0x1F, 0x00, 0x78, 0xF8, 0x07, 0x87, 0xC0,
  0x38, 0x3E, 0x03, 0xC3, 0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0xF8, 0x1E, 0x07,
  0xC1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x61, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x08, 0x07,
  0xF0, 0x78, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF3, 0xE0, 0x3E, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF8,
  0x7F, 0x0F, 0x87, 0xE0, 0xFC, 0x7E, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F,
  0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0x81,
  0xF0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7E, 0xFE, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x03, 0xF0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x3F, 0x0F, 0x81,
  0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x87, 0xE0, 0x7C, 0x3E, 0x03,
  0xF7, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xF9, 0xF0, 0x1F, 0x8F, 0xC1, 0xF8,
  0x3E, 0x0F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1,
  0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x1E, 0x00,
  0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7E, 0x3F,
  0x0F, 0xC3, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF1, 0xF8, 0x1F, 0x1F, 0x01,
  0xF1, 0xF0, 0x1F, 0x1F, 0x03, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xF1, 0xF0,
  0x7E, 0x1F, 0x07, 0xE1, 0xF8, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFE, 0x7C, 0x03, 0x8F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x81, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xC0, 0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x0F, 0x80, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x07, 0xC0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F,
  0x00, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x03, 0xE0,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0E,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xFC, 0x1F, 0xFE, 0x1F,
  0xFF, 0x1F, 0xFF, 0x0C, 0x1F, 0x08, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70,
  0x3C, 0x00, 0x03, 0x83, 0xC0, 0xFF, 0x1E, 0x1C, 0x1F, 0xF8, 0xF1, 0xE1,
  0xFF, 0xC7, 0x8E, 0x0F, 0x1C, 0x3C, 0xF0, 0xF1, 0xE1, 0xE7, 0x8F, 0x0F,
  0x0E, 0x38, 0x78, 0x78, 0x73, 0xC3, 0x83, 0xC3, 0x9E, 0x3C, 0x3C, 0x3C,
  0xF1, 0xE1, 0xE1, 0xE7, 0x0F, 0x0F, 0x0E, 0x38, 0x70, 0x78, 0x73, 0xC7,
  0x87, 0x87, 0x9E, 0x3C, 0x3C, 0x38, 0xF1, 0xE3, 0xE3, 0xC7, 0x8F, 0x1F,
  0x1C, 0x3C, 0x3F, 0xFF, 0xC1, 0xE1, 0xFD, 0xFE, 0x0F, 0x07, 0xC7, 0xE0,
  0x78, 0x08, 0x08, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x10, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x03, 0xFF, 0x00, 0x1E,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80,
  0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87,
  0xC0, 0xFC, 0x3E, 0x07, 0xC1, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3E,
  0x3E, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0xC0,
  0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xE1, 0xFC, 0x0F, 0x83, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C,
  0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xF0, 0xFE, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0x80,
  0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x01, 0xF8,
  0x7C, 0x0F, 0xC1, 0xF1, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x80, 0x3F,
  0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFC, 0x30, 0x1F, 0x80, 0x81,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x01, 0x01,
  0xFE, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7C, 0x1F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0,
  0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x3F, 0x0F,
  0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF0,
  0x0F, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3E, 0x03,
  0xF0, 0x7C, 0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xC3, 0xFC,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x3C, 0x07, 0xF0, 0x04,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x0F, 0xF8, 0xFC, 0x0F, 0xF8, 0xFC, 0x0F, 0xF8,
  0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0xFC, 0x03, 0xE0,
  0xFC, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x8F, 0xC0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0,
  0x3E, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xF0,
  0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x03,
  0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x7E,
  0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00,
  0xFC, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x3E,
  0x01, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x07,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x87, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x1F,
  0x80, 0x7C, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x07,
  0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xE3,
  0xF0, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7D,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00,
  0xF9, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xC0, 0xF8,
  0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0xFF, 0xDF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3D, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xBE, 0x07, 0xBE, 0x03, 0xEF, 0x83, 0xEF, 0x80, 0xFB, 0xE0, 0xF3,
  0xE0, 0x3E, 0xF8, 0x7D, 0xF8, 0x0F, 0xBE, 0x1E, 0x7C, 0x07, 0xCF, 0x87,
  0x9F, 0x01, 0xF3, 0xE3, 0xE7, 0xC0, 0x7C, 0xF8, 0xF1, 0xF0, 0x1F, 0x3E,
  0x7C, 0xF8, 0x07, 0x8F, 0x9E, 0x3E, 0x03, 0xE3, 0xEF, 0x8F, 0x80, 0xF8,
  0x7B, 0xC3, 0xE0, 0x3E, 0x1F, 0xF0, 0xF8, 0x0F, 0x87, 0xF8, 0x7C, 0x03,
  0xC1, 0xFE, 0x1F, 0x01, 0xF0, 0x7F, 0x87, 0xC0, 0x7C, 0x1F, 0xC1, 0xF0,
  0x1F, 0x07, 0xF0, 0xFC, 0x07, 0xC1, 0xF8, 0x3E, 0x03, 0xE0, 0x7E, 0x0F,
  0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF8,
  0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xF0, 0x0F, 0x81, 0xFE, 0x01, 0xF0,
  0x3F, 0xC0, 0x7C, 0x07, 0xF8, 0x0F, 0x80, 0xFF, 0x01, 0xF0, 0x1F, 0xE0,
  0x3E, 0x07, 0xFE, 0x07, 0xC0, 0xFF, 0xC1, 0xF0, 0x1F, 0xF8, 0x3E, 0x03,
  0xCF, 0x07, 0xC0, 0xF9, 0xE0, 0xF8, 0x1F, 0x3C, 0x1F, 0x03, 0xE7, 0xC7,
  0xC0, 0x7C, 0xF8, 0xF8, 0x0F, 0x9F, 0x1F, 0x03, 0xE1, 0xE3, 0xE0, 0x7C,
  0x3C, 0x78, 0x0F, 0x87, 0x9F, 0x01, 0xF0, 0xFB, 0xE0, 0x3C, 0x1F, 0x7C,
  0x0F, 0x83, 0xEF, 0x81, 0xF0, 0x3D, 0xE0, 0x3E, 0x07, 0xFC, 0x07, 0xC0,
  0xFF, 0x80, 0xF0, 0x1F, 0xF0, 0x3E, 0x03, 0xFE, 0x07, 0xC0, 0x7F, 0x80,
  0xF8, 0x07, 0xF0, 0x1F, 0x00, 0xFE, 0x07, 0xC0, 0x1F, 0xC0, 0xF8, 0x03,
  0xF0, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0x81, 0xF8,
  0x3F, 0x07, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x01,
  0xF9, 0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F,
  0xBF, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7,
  0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0x9F, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0x7C,
  0x00, 0xFC, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x1F, 0x87, 0xE0,
  0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0xDF, 0xE0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0x7F,
  0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x7C,
  0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC1, 0xFC, 0x0F, 0x9F, 0xF0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x3F, 0x1F,
  0x80, 0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xE0,
  0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3E, 0x7C, 0x00,
  0x7D, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F,
  0x9F, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0xF8, 0x03, 0xF1,
  0xF0, 0x07, 0xE3, 0xE0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F,
  0x83, 0xF8, 0x3F, 0xDF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0xFF, 0xFE, 0x03, 0xE3, 0xF8, 0x0F, 0x83, 0xF0, 0x3E, 0x0F, 0xC0,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0,
  0x3E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xE0, 0xF8, 0x3F, 0x03, 0xE3, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F,
  0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F,
  0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xF3, 0xE0, 0x7F, 0x01, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x40, 0x1F, 0x81, 0x80, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E,
  0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xF8,
  0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0,
  0x7E, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0,
  0x7C, 0x03, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xF8, 0x07, 0xC0,
  0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x1F, 0x80,
  0xFC, 0x1F, 0x80, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7D, 0xF8, 0x07, 0xEF, 0xC0, 0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF0,
  0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x0F, 0xC0,
  0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x9F,
  0x00, 0x7C, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x7C, 0x00, 0x7B, 0xE0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0xDF, 0x00, 0x7C, 0x03, 0xE7, 0xC0, 0x3F, 0x01,
  0xF9, 0xF0, 0x0F, 0xC0, 0x7C, 0x7C, 0x07, 0xF0, 0x1F, 0x1F, 0x01, 0xFC,
  0x0F, 0xC7, 0xC0, 0x7F, 0x03, 0xE1, 0xF0, 0x3F, 0x81, 0xF8, 0x7C, 0x0F,
  0xE0, 0x7C, 0x1F, 0x07, 0xF8, 0x1F, 0x07, 0xC1, 0xFE, 0x0F, 0xC1, 0xF0,
  0x7F, 0x83, 0xE0, 0x7C, 0x3F, 0xE0, 0xF8, 0x1F, 0x0F, 0x78, 0x7C, 0x07,
  0xC7, 0xDE, 0x1F, 0x01, 0xF1, 0xE7, 0x8F, 0xC0, 0x7C, 0x79, 0xE3, 0xE0,
  0x1F, 0x3E, 0x78, 0xF8, 0x07, 0xCF, 0x1E, 0x7C, 0x01, 0xF7, 0xC7, 0x9F,
  0x00, 0x7D, 0xF1, 0xEF, 0xC0, 0x1E, 0x78, 0x7B, 0xE0, 0x07, 0xBE, 0x1E,
  0xF8, 0x01, 0xEF, 0x07, 0xFC, 0x00, 0x7B, 0xC1, 0xFF, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xE0, 0x07, 0xC1, 0xF8, 0x01,
  0xF0, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC7, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xF9,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xE0, 0x07,
  0xC1, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xE0,
  0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0xF9, 0xF0, 0x3F, 0x3E,
  0x07, 0xC7, 0xC1, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C,
  0x7E, 0x0F, 0x8F, 0x81, 0xF3, 0xF0, 0x1F, 0x7C, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF0,
  0x78, 0x3C, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x87, 0xC3, 0xE0, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xE7, 0x80, 0x3E, 0x7C, 0x03,
  0xC7, 0xC0, 0x7C, 0x3C, 0x0F, 0x83, 0xC0, 0xF0, 0x3E, 0x1F, 0x03, 0xE3,
  0xE0, 0x1E, 0x3E, 0x01, 0xE7, 0xC0, 0x1F, 0x78, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0xFC, 0x7C, 0x7E, 0x3E, 0x1E,
  0x1F, 0x0F, 0x00, 0x20, 0x00, 0x0F, 0xC7, 0xC0, 0xFF, 0x3C, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xE3, 0xF8, 0x7E, 0x1F, 0x83, 0xE0, 0xFC, 0x3F,
  0x07, 0xE1, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xC0, 0x7C,
  0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xC0,
  0x7C, 0x3E, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0x7E, 0x1F, 0x83,
  0xF1, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xDF, 0x03, 0xFC, 0xF0, 0x0F, 0xC7,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x10, 0x07, 0xCF, 0xC0, 0x7D, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x0F, 0xE3, 0xF0, 0xFC, 0x1F, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x1F, 0x81,
  0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF3, 0xE0,
  0x3F, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7E, 0x7E,
  0x07, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0x87, 0xF1, 0xF8, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0xF3, 0xFC, 0x0F, 0x1F, 0x80, 0x00, 0x10, 0x00, 0x7F, 0x80,
  0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0x10, 0x7E, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x43, 0xF8, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x1F, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x41, 0xF0, 0x07, 0xE7,
  0xC0, 0x1F, 0xEF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xF1, 0xFC,
  0x0F, 0xC3, 0xF0, 0x1F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x83,
  0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x7E,
  0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0xC0, 0x7E, 0x3F,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x78, 0x01, 0xF8, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFF, 0x0F, 0x87,
  0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0x9F, 0x03, 0xE7,
  0xC3, 0xF1, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF8, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x01, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFE, 0x7C, 0x03, 0xFC, 0xF0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7E, 0x3F, 0x81, 0xF8, 0x7E, 0x03,
  0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0xFC,
  0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0x81,
  0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F,
  0x03, 0xE0, 0xFE, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xF7, 0xC0, 0x3F, 0xDF, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x80,
  0x3F, 0x01, 0xC0, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x10, 0x07, 0xCF, 0xC0,
  0x7D, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xE3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x1F, 0x83, 0xF1, 0xF8, 0x3E, 0x1F, 0x03,
  0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE3, 0xF0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0,
  0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0xFC, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x09, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x0F, 0xC1, 0xF0, 0x7C, 0x07, 0xC3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8,
  0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0x7C, 0x00, 0xF3, 0xE0,
  0x07, 0xDF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0x0F,
  0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0,
  0x78, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x02,
  0x00, 0x40, 0x1E, 0x3F, 0x0F, 0xC0, 0x7B, 0xFE, 0x7F, 0x81, 0xEF, 0xFB,
  0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0x8F, 0xF3, 0xF0, 0xFC, 0x3F, 0x87,
  0xC3, 0xE0, 0xFC, 0x1F, 0x0F, 0x83, 0xF0, 0x7C, 0x7E, 0x0F, 0x81, 0xF1,
  0xF0, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x1F, 0x07, 0xC0, 0xF8, 0x7C,
  0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x3E, 0x07,
  0xC1, 0xF0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0xF8, 0x1F, 0x1F, 0x03, 0xE0,
  0xF8, 0x7C, 0x0F, 0x83, 0xE1, 0xF0, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x3E,
  0x1F, 0x07, 0xC0, 0xF8, 0xF8, 0x1F, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x0F,
  0x83, 0xF0, 0x7C, 0x00, 0x00, 0x02, 0x00, 0x78, 0xFC, 0x07, 0x9F, 0xE0,
  0x7B, 0xFF, 0x07, 0xFF, 0xF0, 0xFE, 0x3F, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F,
  0x0F, 0x81, 0xF0, 0xF8, 0x3F, 0x1F, 0x83, 0xE1, 0xF0, 0x3E, 0x1F, 0x03,
  0xE1, 0xF0, 0x3E, 0x3F, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0,
  0x7C, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x00,
  0x00, 0x10, 0x00, 0x1F, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xFC,
  0x1F, 0x9F, 0x87, 0xE1, 0xF1, 0xF8, 0x3F, 0x3E, 0x07, 0xE7, 0xC0, 0xFD,
  0xF8, 0x1F, 0xBE, 0x03, 0xF7, 0xC0, 0x7C, 0xF8, 0x0F, 0xBF, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x0F, 0xDF, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0xCF,
  0x81, 0xF1, 0xF8, 0x7E, 0x1F, 0x1F, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x07,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x20, 0x01, 0xE3, 0xF0, 0x03,
  0xCF, 0xF0, 0x07, 0xBF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0x8F, 0xC0, 0x7E,
  0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x80,
  0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F,
  0x83, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xF0,
  0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xF9, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0x7F, 0xC0, 0x3E, 0xFF, 0x00, 0x7C, 0xFC, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xE7,
  0xC0, 0xFF, 0x3C, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE3, 0xF8, 0x7E,
  0x1F, 0x83, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8,
  0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x80,
  0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x0F,
  0x81, 0xF0, 0x7E, 0x1F, 0x83, 0xF1, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xDF,
  0x03, 0xFD, 0xF0, 0x0F, 0xCF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0x03, 0xC7, 0xC1, 0xE7, 0xC0, 0xF7, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x20, 0x01,
  0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF1, 0xFF, 0xF0, 0xFC, 0x18, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC4, 0x07, 0xE3, 0x87, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0xFF, 0xCF, 0xFE, 0x3F, 0xF8, 0xFF,
  0xE4, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xFF, 0x81, 0xFE, 0x07,
  0xF8, 0x0F, 0xE0, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0,
  0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x7E, 0x3E,
  0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x0F, 0x87,
  0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xC1, 0xF0,
  0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x0F, 0xC7, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFD, 0xE0, 0x7F, 0x9E, 0x03, 0xF1, 0xE0, 0xF8, 0x0F, 0xFE, 0x03,
  0xEF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xC0, 0xF9,
  0xF0, 0x3E, 0x78, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0xC1, 0xFB, 0xE0,
  0xFE, 0x0F, 0x9F, 0x07, 0xE0, 0x7C, 0xF8, 0x3F, 0x07, 0xC7, 0xC3, 0xF8,
  0x3E, 0x3E, 0x1F, 0xC3, 0xE1, 0xF1, 0xFE, 0x1F, 0x0F, 0x8F, 0xF0, 0xF8,
  0x7C, 0x7F, 0x8F, 0x83, 0xE7, 0xBC, 0x7C, 0x1F, 0x3D, 0xE3, 0xC0, 0xFB,
  0xEF, 0x3E, 0x07, 0xDE, 0x79, 0xF0, 0x3C, 0xF3, 0xDF, 0x01, 0xEF, 0x1E,
  0xF8, 0x0F, 0x78, 0xF7, 0x80, 0x7B, 0xC7, 0xFC, 0x03, 0xFC, 0x3F, 0xE0,
  0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xF8, 0x3F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x0F, 0x83, 0xE0,
  0x3E, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x1F,
  0x7C, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xF9, 0xE0, 0x03, 0xE7,
  0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xE0,
  0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x83,
  0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x07,
  0x9F, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF7, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xF0,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x08,
  0x00, 0x2F, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xE0, 0x1F, 0xF4, 0x00, 0x30,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 13, 34, 12, 0, -34 },
  { 57, 15, 12, 18, 5, -34 },
  { 80, 23, 34, 22, 0, -34 },
  { 178, 21, 39, 20, 0, -36 },
  { 281, 29, 35, 32, 2, -35 },
  { 408, 23, 35, 23, 0, -35 },
  { 509, 7, 12, 11, 5, -34 },
  { 520, 15, 42, 13, 1, -34 },
  { 599, 16, 43, 13, -4, -35 },
  { 685, 17, 19, 19, 4, -37 },
  { 726, 19, 22, 22, 2, -28 },
  { 779, 9, 12, 11, -2, -6 },
  { 793, 12, 5, 13, 1, -15 },
  { 801, 7, 7, 11, 0, -7 },
  { 808, 24, 35, 17, -3, -35 },
  { 913, 19, 35, 20, 1, -35 },
  { 997, 14, 34, 20, 5, -34 },
  { 1057, 22, 35, 20, -2, -35 },
  { 1154, 22, 35, 20, -1, -35 },
  { 1251, 21, 34, 20, -1, -34 },
  { 1341, 21, 34, 20, 0, -34 },
  { 1431, 20, 35, 20, 1, -35 },
  { 1519, 21, 34, 20, 1, -34 },
  { 1609, 21, 35, 20, 0, -35 },
  { 1701, 20, 35, 20, 0, -35 },
  { 1789, 11, 26, 11, 0, -26 },
  { 1825, 14, 32, 11, -3, -26 },
  { 1881, 19, 22, 22, 2, -28 },
  { 1934, 19, 14, 22, 2, -24 },
  { 1968, 19, 22, 22, 2, -28 },
  { 2021, 16, 35, 15, 1, -35 },
  { 2091, 29, 39, 30, 1, -35 },
  { 2233, 21, 34, 21, -3, -34 },
  { 2323, 22, 34, 22, 0, -34 },
  { 2417, 21, 35, 20, 2, -35 },
  { 2509, 23, 34, 24, 0, -34 },
  { 2607, 21, 34, 19, 0, -34 },
  { 2697, 21, 34, 18, 0, -34 },
  { 2787, 24, 35, 25, 2, -35 },
  { 2892, 26, 34, 25, 0, -34 },
  { 3003, 20, 34, 14, -2, -34 },
  { 3088, 20, 44, 11, -7, -34 },
  { 3198, 25, 34, 21, 0, -34 },
  { 3305, 15, 34, 18, 0, -34 },
  { 3369, 34, 34, 33, 0, -34 },
  { 3514, 27, 34, 26, 0, -34 },
  { 3629, 23, 35, 25, 2, -35 },
  { 3730, 23, 34, 21, 0, -34 },
  { 3828, 23, 43, 25, 2, -35 },
  { 3952, 22, 34, 21, 0, -34 },
  { 4046, 22, 35, 19, -1, -35 },
  { 4143, 19, 34, 18, 3, -34 },
  { 4224, 24, 34, 24, 2, -34 },
  { 4326, 21, 34, 21, 4, -34 },
  { 4416, 34, 34, 33, 3, -34 },
  { 4561, 26, 34, 20, -3, -34 },
  { 4672, 19, 34, 19, 4, -34 },
  { 4753, 23, 34, 18, -2, -34 },
  { 4851, 19, 42, 14, -2, -34 },
  { 4951, 9, 35, 17, 5, -35 },
  { 4991, 18, 42, 14, -3, -34 },
  { 5086, 20, 20, 20, 0, -34 },
  { 5136, 15, 3, 15, -4, 4 },
  { 5142, 8, 8, 13, 7, -37 },
  { 5150, 21, 27, 21, 1, -27 },
  { 5221, 20, 36, 21, 0, -36 },
  { 5311, 17, 27, 17, 1, -27 },
  { 5369, 23, 36, 21, 1, -36 },
  { 5473, 18, 26, 20, 1, -26 },
  { 5532, 24, 49, 12, -6, -37 },
  { 5679, 23, 39, 21, -1, -27 },
  { 5792, 20, 36, 21, 0, -36 },
  { 5882, 12, 36, 10, 0, -36 },
  { 5936, 18, 48, 10, -6, -36 },
  { 6044, 22, 36, 19, 0, -36 },
  { 6143, 13, 36, 10, 0, -36 },
  { 6202, 30, 27, 31, 0, -27 },
  { 6304, 20, 27, 21, 0, -27 },
  { 6372, 19, 27, 21, 1, -27 },
  { 6437, 23, 38, 21, -3, -27 },
  { 6547, 21, 38, 21, 1, -27 },
  { 6647, 17, 27, 15, 0, -27 },
  { 6705, 17, 27, 16, 0, -27 },
  { 6763, 14, 32, 13, 1, -32 },
  { 6819, 20, 26, 21, 1, -26 },
  { 6884, 18, 26, 18, 3, -26 },
  { 6943, 29, 26, 28, 2, -26 },
  { 7038, 22, 26, 18, -2, -26 },
  { 7110, 25, 38, 18, -4, -26 },
  { 7229, 19, 26, 15, -2, -26 },
  { 7291, 18, 42, 16, 1, -34 },
  { 7386, 5, 48, 18, 6, -37 },
  { 7416, 18, 42, 16, -3, -34 },
  { 7511, 19, 8, 22, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC48PT7B_H_
