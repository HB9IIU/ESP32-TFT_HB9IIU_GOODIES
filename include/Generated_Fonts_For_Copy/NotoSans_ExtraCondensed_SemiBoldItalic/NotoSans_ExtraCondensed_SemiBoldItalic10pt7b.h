#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC10PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x24, 0x20, 0xB4, 0x29, 0x9E, 0xAF, 0x52, 0x80, 0x13, 0x76,
  0x23, 0xB4, 0x40, 0x6D, 0xAB, 0x1F, 0x2C, 0xB4, 0xC0, 0x32, 0x98, 0xDB,
  0x5B, 0xC0, 0xE0, 0x29, 0x29, 0x24, 0x40, 0x24, 0x92, 0x52, 0x80, 0x5D,
  0xD0, 0x22, 0xF2, 0x20, 0x78, 0xE0, 0x80, 0x08, 0x84, 0x42, 0x23, 0x00,
  0x35, 0x59, 0x9A, 0xE0, 0x75, 0x24, 0xB0, 0x71, 0x12, 0x4C, 0xE0, 0x71,
  0x16, 0x32, 0xE0, 0x13, 0x56, 0xAF, 0x20, 0x74, 0x47, 0x12, 0xE0, 0x34,
  0x6D, 0x9B, 0x60, 0x78, 0x84, 0x42, 0x23, 0x00, 0x75, 0x56, 0x99, 0xE0,
  0x75, 0x57, 0x12, 0xC0, 0x40, 0x80, 0x20, 0x15, 0x80, 0x13, 0xC3, 0x10,
  0xF0, 0xF0, 0x86, 0x16, 0x80, 0x71, 0x24, 0x40, 0xC0, 0x3D, 0x17, 0xEB,
  0xB6, 0xA8, 0x1C, 0x18, 0xCA, 0x57, 0xA7, 0x20, 0x72, 0x54, 0xE5, 0x4B,
  0x80, 0x3A, 0x11, 0x8C, 0x61, 0x80, 0x72, 0x52, 0x95, 0x4B, 0x80, 0x74,
  0x47, 0x48, 0xE0, 0x74, 0x47, 0x48, 0x80, 0x3A, 0x11, 0xBD, 0xE9, 0xC0,
  0x6A, 0x52, 0xF5, 0x4A, 0x40, 0x76, 0x44, 0x44, 0xC0, 0x18, 0x84, 0x21,
  0x10, 0x84, 0xC0, 0x6A, 0x98, 0xC6, 0x5A, 0x40, 0x69, 0x25, 0x38, 0x66,
  0xCD, 0xBB, 0x67, 0x56, 0xAB, 0x00, 0x65, 0xA6, 0x9A, 0x5A, 0x69, 0x00,
  0x3A, 0x53, 0x9C, 0xE9, 0xC0, 0x72, 0x56, 0xE4, 0x42, 0x00, 0x3A, 0x53,
  0x9C, 0xE9, 0xC4, 0x30, 0x72, 0xD4, 0xE6, 0x52, 0x40, 0x74, 0x46, 0x22,
  0xE0, 0xF4, 0x4C, 0x88, 0x80, 0x6A, 0x52, 0xBD, 0x49, 0x80, 0x9B, 0xAA,
  0xCC, 0x80, 0x97, 0x6A, 0xD6, 0xCD, 0x9A, 0x24, 0x00, 0x2C, 0xA3, 0x0C,
  0x31, 0x4D, 0x00, 0xBA, 0xCC, 0x88, 0x80, 0x71, 0x26, 0x48, 0xE0, 0x74,
  0x44, 0x48, 0x88, 0xC0, 0xAA, 0x54, 0x31, 0x12, 0x22, 0x22, 0xC0, 0x23,
  0x59, 0xE0, 0xD0, 0x2A, 0x95, 0x2B, 0x70, 0x24, 0x57, 0x5D, 0x9E, 0x25,
  0x48, 0x8E, 0x08, 0x4E, 0xA5, 0x4A, 0x5C, 0x25, 0x5E, 0x86, 0x19, 0x88,
  0xE2, 0x11, 0x08, 0x46, 0x00, 0x2A, 0x95, 0x2B, 0x70, 0x9C, 0x24, 0x57,
  0x5D, 0x9A, 0x28, 0x25, 0xA4, 0x12, 0x02, 0x26, 0x44, 0x4C, 0x24, 0x45,
  0x6E, 0xAA, 0x29, 0x25, 0xA4, 0x15, 0xF5, 0x75, 0xB6, 0xA0, 0x17, 0x5D,
  0x9A, 0x25, 0x59, 0x96, 0x09, 0xCA, 0xD4, 0xB9, 0x18, 0x2A, 0x95, 0x29,
  0x70, 0x84, 0x16, 0x4C, 0x88, 0x36, 0x46, 0x2E, 0x29, 0xA5, 0x30, 0x55,
  0xDB, 0xE0, 0xBB, 0x68, 0xAF, 0x7D, 0x6A, 0x00, 0x56, 0x6E, 0xA0, 0x29,
  0x8C, 0x62, 0x13, 0x00, 0x6D, 0x4E, 0x32, 0x24, 0xC4, 0x44, 0x40, 0xFF,
  0xC0, 0x31, 0x22, 0x32, 0x24, 0x80, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 2, 0, -7 },
  { 4, 3, 2, 4, 1, -7 },
  { 5, 5, 7, 5, 0, -7 },
  { 10, 4, 9, 4, 0, -8 },
  { 15, 6, 7, 7, 0, -7 },
  { 21, 5, 7, 5, 0, -7 },
  { 26, 2, 2, 2, 1, -7 },
  { 27, 3, 9, 3, 0, -7 },
  { 31, 3, 9, 3, -1, -7 },
  { 35, 3, 4, 4, 1, -8 },
  { 37, 4, 5, 5, 0, -6 },
  { 40, 3, 2, 2, -1, -1 },
  { 41, 3, 1, 3, 0, -3 },
  { 42, 1, 1, 2, 0, -1 },
  { 43, 5, 7, 4, -1, -7 },
  { 48, 4, 7, 4, 0, -7 },
  { 52, 3, 7, 4, 1, -7 },
  { 55, 4, 7, 4, 0, -7 },
  { 59, 4, 7, 4, 0, -7 },
  { 63, 4, 7, 4, 0, -7 },
  { 67, 4, 7, 4, 0, -7 },
  { 71, 4, 7, 4, 0, -7 },
  { 75, 5, 7, 4, 0, -7 },
  { 80, 4, 7, 4, 0, -7 },
  { 84, 4, 7, 4, 0, -7 },
  { 88, 2, 5, 2, 0, -5 },
  { 90, 3, 6, 2, -1, -5 },
  { 93, 4, 5, 5, 0, -6 },
  { 96, 4, 3, 5, 0, -5 },
  { 98, 4, 5, 5, 0, -6 },
  { 101, 4, 7, 3, 0, -7 },
  { 105, 6, 8, 6, 0, -7 },
  { 111, 5, 7, 4, -1, -7 },
  { 116, 5, 7, 5, 0, -7 },
  { 121, 5, 7, 4, 0, -7 },
  { 126, 5, 7, 5, 0, -7 },
  { 131, 4, 7, 4, 0, -7 },
  { 135, 4, 7, 4, 0, -7 },
  { 139, 5, 7, 5, 0, -7 },
  { 144, 5, 7, 5, 0, -7 },
  { 149, 4, 7, 3, 0, -7 },
  { 153, 5, 9, 2, -2, -7 },
  { 159, 5, 7, 4, 0, -7 },
  { 164, 3, 7, 4, 0, -7 },
  { 167, 7, 7, 7, 0, -7 },
  { 174, 6, 7, 5, 0, -7 },
  { 180, 5, 7, 5, 0, -7 },
  { 185, 5, 7, 4, 0, -7 },
  { 190, 5, 9, 5, 0, -7 },
  { 196, 5, 7, 4, 0, -7 },
  { 201, 4, 7, 4, 0, -7 },
  { 205, 4, 7, 4, 1, -7 },
  { 209, 5, 7, 5, 0, -7 },
  { 214, 4, 7, 4, 1, -7 },
  { 218, 7, 7, 7, 1, -7 },
  { 225, 6, 7, 4, -1, -7 },
  { 231, 4, 7, 4, 1, -7 },
  { 235, 4, 7, 4, 0, -7 },
  { 239, 4, 9, 3, 0, -7 },
  { 244, 2, 7, 4, 1, -7 },
  { 246, 4, 9, 3, -1, -7 },
  { 251, 4, 4, 4, 0, -7 },
  { 253, 3, 1, 3, -1, 1 },
  { 254, 2, 2, 3, 1, -8 },
  { 255, 5, 6, 4, 0, -6 },
  { 259, 4, 8, 4, 0, -8 },
  { 263, 4, 6, 3, 0, -6 },
  { 266, 5, 8, 4, 0, -8 },
  { 271, 4, 6, 4, 0, -6 },
  { 274, 5, 10, 3, -1, -8 },
  { 281, 5, 8, 4, 0, -6 },
  { 286, 4, 8, 4, 0, -8 },
  { 290, 3, 8, 2, 0, -8 },
  { 293, 4, 10, 2, -1, -8 },
  { 298, 4, 8, 4, 0, -8 },
  { 302, 3, 8, 2, 0, -8 },
  { 305, 6, 6, 6, 0, -6 },
  { 310, 4, 6, 4, 0, -6 },
  { 313, 4, 6, 4, 0, -6 },
  { 316, 5, 8, 4, -1, -6 },
  { 321, 5, 8, 4, 0, -6 },
  { 326, 4, 6, 3, 0, -6 },
  { 329, 4, 6, 3, 0, -6 },
  { 332, 3, 7, 3, 0, -7 },
  { 335, 4, 5, 4, 0, -5 },
  { 338, 3, 5, 4, 1, -5 },
  { 340, 5, 5, 6, 1, -5 },
  { 344, 4, 5, 4, 0, -5 },
  { 347, 5, 7, 4, -1, -5 },
  { 352, 3, 5, 3, 0, -5 },
  { 354, 4, 9, 3, 0, -7 },
  { 359, 1, 10, 4, 1, -8 },
  { 361, 4, 9, 3, -1, -7 },
  { 366, 4, 1, 5, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC10PT7B_H_
