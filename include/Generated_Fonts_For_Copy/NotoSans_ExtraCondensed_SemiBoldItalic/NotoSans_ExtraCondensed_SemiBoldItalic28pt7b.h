#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC28PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38,
  0x38, 0x38, 0x30, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xE0, 0x77, 0xBB, 0xB9,
  0xDC, 0xEE, 0x77, 0x33, 0x38, 0x03, 0x98, 0x0C, 0xE0, 0x33, 0x01, 0xCC,
  0x06, 0x30, 0x19, 0x93, 0xFF, 0x8F, 0xFE, 0x0C, 0xE0, 0x33, 0x01, 0x8C,
  0x06, 0x70, 0xFF, 0xF3, 0xFF, 0x83, 0x38, 0x0C, 0xC0, 0x73, 0x01, 0x9C,
  0x06, 0x60, 0x39, 0x80, 0x00, 0x80, 0x08, 0x07, 0xE0, 0xFF, 0x1F, 0xE1,
  0xD2, 0x39, 0x03, 0xB0, 0x1E, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x5C, 0x05, 0xC8, 0x5C, 0xC5, 0xCF, 0xF8, 0xFF, 0x83, 0xE0, 0x08, 0x00,
  0x80, 0x10, 0x00, 0x1E, 0x06, 0x1F, 0x86, 0x0C, 0xC7, 0x0E, 0x63, 0x06,
  0x33, 0x83, 0x39, 0x81, 0x9D, 0xC1, 0xCC, 0xC0, 0xE6, 0xEF, 0x77, 0x6F,
  0xDF, 0x76, 0x6F, 0x37, 0x30, 0x33, 0x18, 0x19, 0x9C, 0x19, 0xCC, 0x1C,
  0xE6, 0x0C, 0x63, 0x0E, 0x3B, 0x06, 0x1F, 0x87, 0x07, 0x80, 0x03, 0xC0,
  0x3F, 0x03, 0x98, 0x1C, 0xC0, 0xCE, 0x06, 0x70, 0x33, 0x01, 0xF8, 0x0F,
  0x80, 0x78, 0x0F, 0xCE, 0x7E, 0x77, 0x3F, 0x71, 0xFB, 0x8F, 0x9C, 0x3C,
  0xE3, 0xC7, 0xBF, 0x3F, 0xF8, 0xF9, 0xE0, 0x77, 0xEE, 0xEE, 0xC0, 0x03,
  0x81, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x81,
  0xC0, 0xE0, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x07, 0x03,
  0x83, 0x81, 0xC1, 0xC1, 0xC0, 0x0E, 0x03, 0x86, 0xE1, 0xFF, 0xFF, 0xC7,
  0xF3, 0xE1, 0xFC, 0x73, 0x88, 0xC0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x3F, 0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x00, 0x39, 0xCE, 0xE7, 0x73, 0x98, 0x7E, 0xFF, 0xF8, 0x6F, 0xFE,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x81, 0xF8,
  0x7F, 0x1C, 0x73, 0x8E, 0xE1, 0xDC, 0x3B, 0x8E, 0xF1, 0xDC, 0x3B, 0x87,
  0x70, 0xEE, 0x3D, 0xC7, 0x38, 0xE6, 0x38, 0xE7, 0x1F, 0xC3, 0xF8, 0x3E,
  0x00, 0x07, 0x0F, 0x1E, 0x7E, 0xFE, 0xEE, 0x4E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x03, 0xE0, 0x7F,
  0x83, 0xFE, 0x18, 0xF0, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78,
  0x03, 0xFE, 0x3F, 0xF1, 0xFF, 0x80, 0x0F, 0xE1, 0xFE, 0x1F, 0xF1, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x0F, 0xC1, 0xF0, 0x1F, 0x80, 0x3C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x83, 0x8F, 0xF8, 0xFF, 0x0F, 0xE0,
  0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x6E, 0x06, 0xE0, 0xDC,
  0x1D, 0xC1, 0x9C, 0x31, 0xC7, 0x18, 0x63, 0x8F, 0xFE, 0xFF, 0xEF, 0xFC,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0xF0, 0xFF, 0x0F, 0xE1, 0xC0,
  0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x3F, 0x83, 0xFC, 0x23, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x83, 0x8F, 0xF8, 0xFF, 0x0F, 0xE0,
  0x03, 0xE0, 0xFC, 0x3C, 0x8E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0xB8, 0x7F,
  0x9F, 0xFB, 0xCF, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0xE7, 0x1C, 0xE7, 0x9F,
  0xE3, 0xFC, 0x3E, 0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0xE0,
  0xFF, 0x1E, 0xF1, 0xC7, 0x18, 0x71, 0x87, 0x1C, 0xE1, 0xDE, 0x0F, 0xC0,
  0xF0, 0x1F, 0x83, 0xBC, 0x71, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCF,
  0x38, 0x7F, 0x83, 0xF0, 0x07, 0xC0, 0xFE, 0x1F, 0xE1, 0xCF, 0x38, 0x73,
  0x87, 0x38, 0xF3, 0x8E, 0x78, 0xE3, 0x9E, 0x3F, 0xE3, 0xEE, 0x1D, 0xC0,
  0x1C, 0x01, 0xC0, 0x38, 0x07, 0x8D, 0xF0, 0xFE, 0x0F, 0xC0, 0x1C, 0x73,
  0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xF3, 0xCE, 0x00, 0x0E, 0x1C,
  0x38, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x8F, 0x1C, 0x38,
  0xE1, 0xC3, 0x00, 0x00, 0x60, 0x3C, 0x1F, 0x8F, 0xC7, 0xE1, 0xF0, 0x3E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0x80, 0x30, 0x02, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1E, 0x03, 0xF0,
  0x1F, 0x80, 0x7C, 0x03, 0xC0, 0x78, 0x3E, 0x3F, 0x1F, 0x83, 0xC0, 0x60,
  0x08, 0x00, 0x3F, 0x3F, 0xCD, 0xE8, 0x70, 0x38, 0x1C, 0x1C, 0x1E, 0x0E,
  0x0E, 0x0E, 0x06, 0x07, 0x03, 0x80, 0x00, 0x00, 0x60, 0x70, 0x38, 0x1C,
  0x00, 0x01, 0xF8, 0x03, 0xFE, 0x0E, 0x06, 0x0C, 0x03, 0x18, 0x03, 0x30,
  0xFB, 0x31, 0xF3, 0x63, 0x33, 0x66, 0x33, 0x66, 0x73, 0xCE, 0x63, 0xCC,
  0x67, 0xCC, 0x66, 0xCC, 0xE6, 0xCC, 0xEC, 0xCF, 0x78, 0xC6, 0x30, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x20, 0x7F, 0xC0, 0x1F, 0xC0, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x03, 0xF0, 0x1B, 0x81, 0xDC, 0x0E, 0xE0, 0xE7, 0x07, 0x38,
  0x39, 0xC3, 0x8E, 0x1C, 0x71, 0xFF, 0x8F, 0xFC, 0x70, 0xE7, 0x07, 0x38,
  0x3B, 0xC1, 0xDC, 0x0F, 0xE0, 0xF0, 0x0F, 0xE0, 0x7F, 0x83, 0xFE, 0x38,
  0x71, 0xC3, 0x8E, 0x1C, 0x71, 0xE3, 0x8E, 0x3F, 0xE1, 0xFC, 0x0F, 0xF8,
  0x71, 0xC3, 0x8E, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x71, 0xE7, 0xFE, 0x3F,
  0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x3C, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x87, 0x9E, 0x1C, 0x38, 0x70, 0xF1, 0xC3,
  0xC7, 0x0F, 0x3C, 0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x79, 0xC1,
  0xC7, 0x0F, 0x1C, 0x38, 0x71, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF1, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3F,
  0xC3, 0xFC, 0x3F, 0xC3, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xFC, 0x3F, 0xC3, 0xF8, 0x38,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x03,
  0xF8, 0x1F, 0xF0, 0xFF, 0x87, 0x82, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0xC7, 0xEF, 0x1F, 0x38, 0x7C, 0xE0, 0x73, 0x81, 0xCE,
  0x0E, 0x3C, 0x38, 0xF0, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0x0E, 0x0E,
  0x1C, 0x1C, 0x38, 0x78, 0xF0, 0xE1, 0xC1, 0xC3, 0x83, 0x87, 0x07, 0x0E,
  0x1E, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xC1, 0xC3, 0x87, 0x8E, 0x0E,
  0x1C, 0x1C, 0x38, 0x38, 0x70, 0x71, 0xE1, 0xC3, 0x83, 0x87, 0x07, 0x00,
  0x0F, 0xE1, 0xFC, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x03, 0xF8, 0x7F, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x07,
  0xE0, 0xF8, 0x1E, 0x00, 0x0E, 0x1E, 0x1C, 0x78, 0x38, 0xE0, 0xE3, 0x81,
  0xCF, 0x03, 0x9C, 0x07, 0x70, 0x0F, 0xE0, 0x3B, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xB8, 0x0E, 0x70, 0x1C, 0xF0, 0x38, 0xE0, 0x71, 0xC1,
  0xE3, 0x83, 0x87, 0x07, 0x0F, 0x00, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0xFF,
  0xFF, 0xFF, 0x0F, 0x01, 0xF0, 0xF0, 0x1E, 0x0F, 0x03, 0xE1, 0xF0, 0x3E,
  0x1F, 0x07, 0xE1, 0xF0, 0x7E, 0x1F, 0x07, 0xC1, 0xB8, 0xFC, 0x3B, 0x8D,
  0xC3, 0xB9, 0xDC, 0x3B, 0x99, 0xC3, 0xBB, 0xB8, 0x33, 0xB3, 0x87, 0x3F,
  0x38, 0x73, 0xF3, 0x87, 0x3E, 0x70, 0x73, 0xE7, 0x0E, 0x3C, 0x70, 0xE3,
  0xC7, 0x0E, 0x38, 0x70, 0x0F, 0x07, 0x0F, 0x07, 0x0F, 0x06, 0x1F, 0x0E,
  0x1F, 0x0E, 0x1F, 0x8E, 0x1F, 0x8E, 0x1B, 0x9C, 0x3B, 0x9C, 0x39, 0x9C,
  0x39, 0x9C, 0x39, 0xDC, 0x31, 0xD8, 0x71, 0xF8, 0x71, 0xF8, 0x70, 0xF8,
  0x70, 0xF8, 0xE0, 0xF0, 0xE0, 0xF0, 0xE0, 0xF0, 0x03, 0xE0, 0x7F, 0x87,
  0xFE, 0x38, 0x73, 0xC3, 0x9C, 0x1D, 0xE0, 0xEE, 0x07, 0x70, 0x3F, 0x81,
  0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0x70, 0x3B, 0x83, 0xDC, 0x1C, 0xF1, 0xE7,
  0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x83, 0xFE, 0x3C, 0x71,
  0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x8F, 0x3C, 0x71, 0xC7, 0x8F, 0xF8, 0x7F,
  0x83, 0xF0, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x38, 0x73, 0xC3, 0x9C, 0x1D,
  0xE0, 0xEE, 0x07, 0x70, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0x70,
  0x3B, 0x83, 0xDC, 0x1C, 0xF1, 0xE7, 0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x0F, 0xC0, 0x7F, 0x83, 0xFC,
  0x38, 0xF1, 0xC7, 0x8E, 0x3C, 0x71, 0xE3, 0x8E, 0x38, 0xF1, 0xFF, 0x0F,
  0xF0, 0x7F, 0x03, 0xB8, 0x39, 0xC1, 0xCE, 0x0E, 0x78, 0x71, 0xC7, 0x8E,
  0x38, 0x71, 0xC3, 0xC0, 0x03, 0xF8, 0x3F, 0xC3, 0xFE, 0x1C, 0x21, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x41, 0xC3, 0xFE, 0x3F, 0xE0, 0xFE,
  0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x1E, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x1C, 0x70, 0xF1, 0xC3, 0x8F, 0x0E,
  0x38, 0x38, 0xE0, 0xE3, 0x87, 0x9E, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x0F,
  0x1C, 0x38, 0xF0, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0xFF,
  0x07, 0xF8, 0x0F, 0xC0, 0xF0, 0x7F, 0x83, 0x9C, 0x3C, 0xE1, 0xC7, 0x0E,
  0x38, 0xE1, 0xC7, 0x0E, 0x78, 0x63, 0x83, 0x1C, 0x19, 0xC0, 0xCE, 0x06,
  0xE0, 0x37, 0x01, 0xB8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x00, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x87, 0x70, 0xF0, 0xEE, 0x1E,
  0x1D, 0xC7, 0xC7, 0x38, 0xF8, 0xE7, 0x1B, 0x3C, 0xE7, 0xE7, 0x1C, 0xDC,
  0xE3, 0x9B, 0xB8, 0x77, 0x77, 0x0E, 0xCE, 0xE1, 0xF9, 0xF8, 0x3F, 0x3F,
  0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1E, 0x1F, 0x03, 0xC3, 0xC0, 0x78, 0x78,
  0x00, 0x07, 0x0F, 0x07, 0x0E, 0x07, 0x1C, 0x03, 0x9C, 0x03, 0xB8, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x38,
  0xE0, 0x70, 0xE0, 0xF0, 0xF0, 0xF0, 0xF7, 0x0E, 0x71, 0xC7, 0x1C, 0x73,
  0x87, 0x38, 0x77, 0x07, 0x70, 0x7E, 0x03, 0xE0, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0xFE, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xE0, 0xFC, 0x1C,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x3F, 0x07, 0xE0, 0xE7, 0x39, 0xCE, 0x31, 0x8C, 0x73, 0x9C,
  0xE7, 0x18, 0xC6, 0x39, 0xCE, 0x70, 0x07, 0xE0, 0xFC, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18,
  0x3F, 0x07, 0xE0, 0x01, 0x80, 0x38, 0x03, 0xC0, 0x7C, 0x0F, 0xC0, 0xCC,
  0x1C, 0xE3, 0x8E, 0x38, 0xE7, 0x06, 0x60, 0x7E, 0x07, 0x7F, 0xFF, 0xE0,
  0xF3, 0x8C, 0x70, 0x1F, 0x73, 0xFE, 0x39, 0xE7, 0x1E, 0x71, 0xEF, 0x1C,
  0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x3C, 0xE3, 0x8E, 0x38, 0xE7, 0x8F, 0xF8,
  0x7B, 0x80, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1D,
  0xE1, 0xFF, 0x3E, 0xF3, 0xC7, 0x38, 0x73, 0x87, 0x38, 0x77, 0x0F, 0x70,
  0xE7, 0x0E, 0x71, 0xE7, 0x1C, 0xFB, 0xCF, 0xF8, 0xCF, 0x00, 0x0F, 0xCF,
  0xE3, 0x89, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xF6, 0x3F, 0x87, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x7F, 0x87, 0xFC, 0x39, 0xE3, 0x8F, 0x1C, 0x79, 0xE3,
  0x8E, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE3, 0x87, 0x1C, 0x39, 0xE1,
  0xFF, 0x07, 0xB0, 0x00, 0x0F, 0x8F, 0xF3, 0x9D, 0xC7, 0x71, 0xF8, 0xEF,
  0xFB, 0xF8, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE1, 0x3F, 0xC7, 0xE0, 0x00,
  0xFC, 0x03, 0xE0, 0x1E, 0x80, 0x70, 0x01, 0xC0, 0x0E, 0x40, 0x7E, 0x03,
  0xF8, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x03, 0xE0, 0x0F, 0x00, 0x38, 0x00,
  0x07, 0xDC, 0x3F, 0xE0, 0xE7, 0x87, 0x1E, 0x1C, 0x78, 0xF1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE3, 0xC3, 0x8E, 0x0E, 0x78, 0x3B, 0xE0, 0xFF,
  0x81, 0xFE, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x08, 0x38, 0x3F, 0xE0, 0xFF,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x1F, 0xE1, 0xFE, 0x1E, 0xF3, 0xC7, 0x38, 0xE3, 0x8E, 0x38, 0xE7, 0x0E,
  0x70, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0xE1, 0xCE, 0x1C, 0xE3, 0x80, 0x0E,
  0x1C, 0x38, 0x20, 0x00, 0x07, 0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x8F, 0x1C,
  0x38, 0x70, 0xE3, 0x87, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x20,
  0x00, 0x00, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x1F, 0x83, 0xE0, 0x78, 0x00, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x04, 0x71, 0xC3, 0x9C, 0x19, 0xE1,
  0xCE, 0x0E, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0E, 0xF0, 0x73,
  0x83, 0x1C, 0x38, 0xE1, 0xC7, 0x0E, 0x3C, 0x00, 0x0E, 0x1C, 0x38, 0x71,
  0xC3, 0x87, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x8F, 0x1C, 0x38, 0x70, 0xE3,
  0x87, 0x0E, 0x00, 0x1B, 0xEF, 0x87, 0xFF, 0xE1, 0xEF, 0xBC, 0xF3, 0xCE,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x39, 0xC3, 0x8E, 0x71, 0xC3, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xE1, 0xC7, 0x38, 0xE3, 0x8E, 0x38,
  0xE0, 0x1B, 0xE1, 0xBE, 0x1E, 0xF3, 0xC7, 0x38, 0xE3, 0x8E, 0x38, 0xE7,
  0x0E, 0x70, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0xE1, 0xCE, 0x1C, 0xE3, 0x80,
  0x1F, 0x8F, 0xF3, 0x9D, 0xC7, 0x71, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x3B, 0x8E, 0xFF, 0x3F, 0xC7, 0xE0, 0x06, 0x78, 0x1B, 0xF0, 0x7B,
  0xC3, 0xC7, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x0F, 0x1C, 0x38, 0x70,
  0xE1, 0xC7, 0x87, 0x1C, 0x3E, 0xF0, 0xFF, 0x83, 0xBC, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x00, 0x1F, 0x73,
  0xF6, 0x39, 0xE7, 0x1E, 0x71, 0xEF, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE,
  0x1C, 0xE3, 0x8E, 0x38, 0xEF, 0x8F, 0xF8, 0x7B, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1B, 0xC6, 0xE3, 0xF8, 0xF0,
  0x38, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38,
  0x0E, 0x00, 0x1F, 0xCF, 0xF3, 0x88, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xC0, 0x70, 0x1C, 0xDF, 0x3F, 0x8F, 0xC0, 0x1C, 0x30, 0x63,
  0xF7, 0xF7, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0x38, 0x74, 0xF9,
  0xF0, 0x38, 0xE7, 0x1D, 0xC3, 0xB8, 0x77, 0x1C, 0xE3, 0x9C, 0x77, 0x0E,
  0xE1, 0x9C, 0x73, 0x8E, 0x73, 0xCE, 0xF9, 0xFE, 0x3E, 0xC0, 0xE1, 0xF8,
  0xEE, 0x3B, 0x9C, 0xE7, 0x39, 0x8E, 0xE3, 0xB8, 0xFC, 0x37, 0x0D, 0x83,
  0xE0, 0xF0, 0x3C, 0x0E, 0x00, 0x71, 0xC3, 0xB9, 0xE3, 0x9C, 0xF1, 0xCE,
  0x78, 0xC6, 0x7C, 0xE3, 0x36, 0x71, 0x9B, 0x70, 0xDD, 0xB8, 0x6C, 0xD8,
  0x3E, 0x7C, 0x1E, 0x3E, 0x0F, 0x1E, 0x0F, 0x9F, 0x07, 0x8F, 0x03, 0xC7,
  0x80, 0x1C, 0x78, 0xE3, 0x83, 0xB8, 0x1D, 0xC0, 0xFC, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0xFC, 0x0E, 0xE0, 0x77, 0x07, 0x38, 0x39, 0xC3,
  0x87, 0x00, 0x0E, 0x1C, 0x38, 0xE0, 0xE3, 0x83, 0x9C, 0x0E, 0x70, 0x39,
  0xC0, 0xEE, 0x03, 0xB8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x3E,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x1F, 0xE3, 0xF8, 0x07, 0x01, 0xC0, 0x38,
  0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0xE0, 0x7C, 0x0F, 0x83, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x70, 0x3E, 0x07, 0x01, 0xF0, 0x07, 0x00, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0xF0, 0x1F, 0x01, 0xE0,
  0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xF0, 0x1E,
  0x0F, 0x81, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x78,
  0x3E, 0x07, 0xC0, 0x78, 0x3F, 0xEF, 0xFF, 0xC1, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 8, 20, 7, 0, -20 },
  { 21, 9, 7, 10, 3, -20 },
  { 29, 14, 20, 13, 0, -20 },
  { 64, 12, 23, 12, 0, -21 },
  { 99, 17, 20, 19, 1, -20 },
  { 142, 13, 20, 14, 0, -20 },
  { 175, 4, 7, 6, 3, -20 },
  { 179, 9, 24, 7, 0, -20 },
  { 206, 9, 24, 7, -2, -20 },
  { 233, 10, 10, 11, 2, -21 },
  { 246, 11, 14, 13, 1, -17 },
  { 266, 5, 8, 6, -1, -4 },
  { 271, 7, 3, 8, 0, -9 },
  { 274, 4, 4, 6, 0, -4 },
  { 276, 13, 20, 10, -1, -20 },
  { 309, 11, 20, 12, 1, -20 },
  { 337, 8, 20, 12, 3, -20 },
  { 357, 13, 20, 12, -1, -20 },
  { 390, 12, 20, 12, 0, -20 },
  { 420, 12, 20, 12, 0, -20 },
  { 450, 12, 20, 12, 0, -20 },
  { 480, 11, 20, 12, 1, -20 },
  { 508, 12, 20, 12, 1, -20 },
  { 538, 12, 20, 12, 0, -20 },
  { 568, 12, 20, 12, 0, -20 },
  { 598, 6, 15, 6, 0, -15 },
  { 610, 7, 19, 6, -1, -15 },
  { 627, 11, 13, 13, 1, -16 },
  { 645, 11, 8, 13, 1, -14 },
  { 656, 11, 13, 13, 1, -16 },
  { 674, 9, 20, 9, 1, -20 },
  { 697, 16, 22, 18, 1, -20 },
  { 741, 13, 20, 12, -2, -20 },
  { 774, 13, 20, 13, 0, -20 },
  { 807, 13, 20, 12, 1, -20 },
  { 840, 14, 20, 14, 0, -20 },
  { 875, 12, 20, 11, 0, -20 },
  { 905, 12, 20, 10, 0, -20 },
  { 935, 14, 20, 14, 1, -20 },
  { 970, 15, 20, 14, 0, -20 },
  { 1008, 11, 20, 8, -1, -20 },
  { 1036, 11, 26, 6, -4, -20 },
  { 1072, 15, 20, 12, 0, -20 },
  { 1110, 8, 20, 10, 0, -20 },
  { 1130, 20, 20, 19, 0, -20 },
  { 1180, 16, 20, 15, 0, -20 },
  { 1220, 13, 20, 15, 1, -20 },
  { 1253, 13, 20, 12, 0, -20 },
  { 1286, 13, 25, 15, 1, -20 },
  { 1327, 13, 20, 12, 0, -20 },
  { 1360, 13, 20, 11, -1, -20 },
  { 1393, 11, 20, 11, 2, -20 },
  { 1421, 14, 20, 14, 1, -20 },
  { 1456, 13, 20, 12, 2, -20 },
  { 1489, 19, 20, 19, 2, -20 },
  { 1537, 16, 20, 12, -2, -20 },
  { 1577, 12, 20, 11, 2, -20 },
  { 1607, 13, 20, 10, -1, -20 },
  { 1640, 11, 24, 8, -1, -20 },
  { 1673, 5, 20, 10, 3, -20 },
  { 1686, 11, 24, 8, -2, -20 },
  { 1719, 12, 12, 12, 0, -20 },
  { 1737, 10, 2, 9, -3, 2 },
  { 1740, 5, 4, 8, 4, -21 },
  { 1743, 12, 15, 13, 1, -15 },
  { 1766, 12, 21, 12, 0, -21 },
  { 1798, 10, 15, 10, 1, -15 },
  { 1817, 13, 21, 13, 1, -21 },
  { 1852, 10, 15, 11, 1, -15 },
  { 1871, 14, 28, 7, -3, -21 },
  { 1920, 14, 22, 13, -1, -15 },
  { 1959, 12, 21, 12, 0, -21 },
  { 1991, 7, 21, 6, 0, -21 },
  { 2010, 11, 28, 6, -4, -21 },
  { 2049, 13, 21, 11, 0, -21 },
  { 2084, 7, 21, 6, 0, -21 },
  { 2103, 18, 15, 18, 0, -15 },
  { 2137, 12, 15, 12, 0, -15 },
  { 2160, 10, 15, 12, 1, -15 },
  { 2179, 14, 22, 12, -2, -15 },
  { 2218, 12, 22, 12, 1, -15 },
  { 2251, 10, 15, 9, 0, -15 },
  { 2270, 10, 15, 10, 0, -15 },
  { 2289, 7, 18, 8, 1, -18 },
  { 2305, 11, 15, 12, 1, -15 },
  { 2326, 10, 15, 11, 2, -15 },
  { 2345, 17, 15, 16, 1, -15 },
  { 2377, 13, 15, 11, -1, -15 },
  { 2402, 14, 22, 11, -2, -15 },
  { 2441, 11, 15, 9, -1, -15 },
  { 2462, 11, 24, 9, 0, -20 },
  { 2495, 2, 27, 10, 4, -21 },
  { 2502, 11, 24, 9, -2, -20 },
  { 2535, 11, 4, 13, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC28PT7B_H_
