#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC56PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x7C, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0x3E, 0x00, 0x30, 0x00, 0x1F, 0x8F, 0xE7, 0xF1, 0xF8, 0xFC,
  0x3F, 0x1F, 0x87, 0xE3, 0xF1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xE3, 0xF0,
  0xF8, 0x7E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xC3,
  0xE1, 0xF0, 0x7C, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF8, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x1F,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0xF0, 0x78, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x00, 0xF0,
  0x78, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0xF8,
  0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFB, 0x7E, 0x03, 0xF3, 0x0C, 0x07, 0xE3, 0x00, 0x07, 0xE7,
  0x00, 0x07, 0xE6, 0x00, 0x07, 0xE6, 0x00, 0x07, 0xE6, 0x00, 0x07, 0xF6,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3B, 0xF8, 0x00, 0x3B, 0xF8, 0x00, 0x31,
  0xF8, 0x00, 0x31, 0xF8, 0x00, 0x31, 0xF8, 0x40, 0x73, 0xF0, 0x60, 0x63,
  0xF0, 0x78, 0x67, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7C, 0x01, 0xFF, 0x00,
  0x3C, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xE0, 0x1E, 0x00, 0xF9, 0xF0,
  0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x00, 0x7C, 0x3C, 0x0F, 0x80, 0x3C, 0x3E,
  0x07, 0x80, 0x3E, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x87, 0xC0, 0x0F, 0x07,
  0xC3, 0xE0, 0x07, 0x83, 0xE3, 0xE0, 0x07, 0xC1, 0xE1, 0xF0, 0x03, 0xE1,
  0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0xF0, 0x00, 0xF0, 0x7C, 0xF8, 0x10, 0x78,
  0x3C, 0x78, 0x7F, 0x3C, 0x3E, 0x7C, 0x7F, 0xDE, 0x1E, 0x3C, 0x7F, 0xEF,
  0x9F, 0x3E, 0x7F, 0xF7, 0xFF, 0x1E, 0x3C, 0x7F, 0xFF, 0x9F, 0x3E, 0x3E,
  0xFF, 0x8F, 0x1E, 0x1F, 0x3F, 0x0F, 0x9F, 0x0F, 0x82, 0x0F, 0x8F, 0x87,
  0xC0, 0x07, 0xC7, 0x83, 0xE0, 0x07, 0xC7, 0xC1, 0xE0, 0x03, 0xE3, 0xE0,
  0xF0, 0x03, 0xE1, 0xF0, 0xF8, 0x01, 0xE0, 0xF0, 0x7C, 0x01, 0xF0, 0x78,
  0x3E, 0x00, 0xF0, 0x3C, 0x1E, 0x00, 0xF8, 0x1E, 0x1F, 0x00, 0x78, 0x0F,
  0x0F, 0x80, 0x7C, 0x07, 0x8F, 0x80, 0x3C, 0x03, 0xC7, 0xC0, 0x3E, 0x01,
  0xFF, 0xC0, 0x1E, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x3F, 0xC0, 0x1F, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xC7, 0xE0,
  0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7C, 0x00,
  0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x7E, 0x1F, 0xFE, 0x1F, 0x87, 0xFF, 0xE3,
  0xF0, 0xFC, 0xFC, 0x7C, 0x3F, 0x1F, 0x9F, 0x8F, 0xC3, 0xFB, 0xF1, 0xF8,
  0x3F, 0xFC, 0x3F, 0x07, 0xFF, 0x8F, 0xC0, 0xFF, 0xE1, 0xF8, 0x0F, 0xF8,
  0x3F, 0x01, 0xFF, 0x07, 0xE0, 0x3F, 0xC0, 0xFC, 0x07, 0xF8, 0x1F, 0x81,
  0xFF, 0x03, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFD, 0xFC, 0x0F, 0xFF, 0x3F, 0x80, 0xFF, 0x83, 0xF8, 0x01, 0x00,
  0x00, 0x00, 0x3F, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC,
  0xF8, 0xF8, 0xF8, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x04, 0x0F, 0x80,
  0xE1, 0xF0, 0x1F, 0x3C, 0x0B, 0xF7, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFF, 0x01,
  0xFB, 0xE0, 0x7F, 0x3E, 0x0F, 0xC7, 0xE0, 0xF0, 0xFE, 0x0E, 0x0F, 0x00,
  0x81, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3E,
  0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x00, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xC0, 0x0C, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7C, 0x10, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x7E,
  0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03,
  0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7,
  0xE0, 0x1F, 0x9F, 0x80, 0xFE, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0,
  0x3F, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE,
  0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x3F,
  0x9F, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F,
  0xFC, 0xFE, 0xFC, 0xFC, 0xFC, 0x78, 0xFC, 0x71, 0xF8, 0x21, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F,
  0xC3, 0xF8, 0x03, 0xC0, 0x7E, 0x00, 0x60, 0x1F, 0xC0, 0x10, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x03, 0xC1, 0xFE, 0x01, 0x80, 0x7F, 0x00, 0x80, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x20, 0x03, 0xFC, 0x1E, 0x03, 0xFC, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xDF, 0x80, 0x03, 0xCF, 0x80, 0x01, 0xEF, 0xC0, 0x01, 0xE7,
  0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xF1, 0xF8, 0x00, 0xF1, 0xF8, 0x00, 0xF8,
  0xFC, 0x00, 0x78, 0x7E, 0x00, 0x78, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x3C,
  0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x1E, 0x03, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0x1F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x80, 0x1F, 0xE0, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x83,
  0x00, 0x1F, 0x9F, 0xC0, 0x1F, 0x7F, 0xE0, 0x3F, 0x7F, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xC3, 0xF0, 0x7F, 0x83, 0xF8, 0x7F, 0x03,
  0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0xFE, 0x03,
  0xF0, 0xFE, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07,
  0xE0, 0xFC, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0xFC, 0x03, 0xF1, 0xFC, 0x03, 0xFB, 0xF8, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xEF, 0xE0, 0x1F, 0xC7, 0xE0, 0x3F, 0x87,
  0xF0, 0x7F, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFE, 0x3F, 0x83, 0xF8, 0x3F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0,
  0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F,
  0x80, 0xFE, 0x3F, 0x01, 0xFC, 0x7E, 0x07, 0xF8, 0xFC, 0x0F, 0xE1, 0xFC,
  0x3F, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFD,
  0xF8, 0x0F, 0xF3, 0xF0, 0x07, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x04, 0x07, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x28,
  0x00, 0x00, 0x00, 0xE0, 0x0F, 0x80, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0x7C, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x3E, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xE0, 0x7F, 0x01, 0xF0, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC3, 0x81, 0xF8, 0x20, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x3F, 0x80, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xF0, 0x03, 0xE0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x78, 0x1F, 0x03, 0xFF, 0x1F, 0x07, 0x81, 0xFF, 0xC7, 0xC3, 0xC0,
  0xFF, 0xF1, 0xF0, 0xF0, 0x7C, 0x78, 0x7C, 0x7C, 0x3E, 0x1E, 0x1F, 0x1E,
  0x0F, 0x0F, 0x87, 0x8F, 0x87, 0x83, 0xE1, 0xE3, 0xC1, 0xE0, 0xF0, 0x78,
  0xF0, 0xF8, 0x3C, 0x1E, 0x3C, 0x3C, 0x1F, 0x07, 0x9F, 0x0F, 0x07, 0xC3,
  0xC7, 0x87, 0xC1, 0xE0, 0xF1, 0xE1, 0xF0, 0x78, 0x3C, 0x78, 0x78, 0x3E,
  0x0F, 0x1E, 0x1E, 0x0F, 0x87, 0x87, 0x87, 0x83, 0xC1, 0xE3, 0xE1, 0xE1,
  0xF0, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x3E, 0x1F, 0x3F, 0x9E, 0x0F, 0x07,
  0xFD, 0xFF, 0x03, 0xC0, 0xFE, 0x7F, 0x80, 0xF8, 0x3F, 0x0F, 0xC0, 0x3E,
  0x01, 0x80, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x20, 0x00, 0x1F, 0xE0, 0xF8, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x01,
  0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0x7C, 0x00,
  0x7E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x87, 0xC0,
  0x0F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0x7E, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0x00,
  0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xE0,
  0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF8,
  0x00, 0xFD, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7E, 0x0F, 0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0x03,
  0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x81, 0xFC,
  0x07, 0xE1, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFC, 0x1F, 0xC0, 0x7E,
  0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0,
  0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F,
  0xC0, 0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0x80, 0xFE, 0x07, 0xE0,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x07, 0xF8, 0x38, 0x07, 0xF8, 0x04, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x20, 0x0F, 0xF0, 0x70, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x7E, 0x0F, 0xF0, 0x0F, 0xC0, 0xFF, 0x01, 0xF8, 0x0F,
  0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x3F,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7F,
  0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0,
  0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xF0,
  0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00,
  0xFE, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x0F,
  0xC0, 0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE1, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x03, 0xC0, 0x3F, 0xC0,
  0x0C, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xF8, 0x7E, 0x03, 0xFF, 0x87, 0xE0,
  0x3F, 0xF8, 0xFE, 0x03, 0xFF, 0x8F, 0xE0, 0x7F, 0xF0, 0xFE, 0x00, 0x3F,
  0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0xFE,
  0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x07,
  0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFC,
  0x01, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x7E, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F,
  0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F,
  0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x08, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x01, 0xF8,
  0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFB, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xF0,
  0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x7E, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x7F, 0xF8, 0x03, 0xEF, 0x80,
  0x7D, 0xF8, 0x07, 0xEF, 0x80, 0xFD, 0xF0, 0x07, 0xEF, 0x80, 0xFB, 0xF0,
  0x07, 0xEF, 0x81, 0xFB, 0xF0, 0x07, 0xCF, 0x81, 0xF3, 0xF0, 0x0F, 0xCF,
  0x81, 0xF3, 0xF0, 0x0F, 0xCF, 0x83, 0xE7, 0xE0, 0x0F, 0xCF, 0x83, 0xE7,
  0xE0, 0x0F, 0xCF, 0x87, 0xE7, 0xE0, 0x0F, 0x8F, 0x87, 0xC7, 0xE0, 0x1F,
  0x8F, 0x8F, 0xC7, 0xE0, 0x1F, 0x8F, 0x8F, 0x8F, 0xC0, 0x1F, 0x8F, 0x9F,
  0x8F, 0xC0, 0x1F, 0x8F, 0x9F, 0x0F, 0xC0, 0x1F, 0x0F, 0x9F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xBE, 0x0F, 0x80, 0x3F, 0x0F, 0xFE, 0x1F, 0x80, 0x3F, 0x0F,
  0xFE, 0x1F, 0x80, 0x3E, 0x0F, 0xFC, 0x1F, 0x80, 0x3E, 0x0F, 0xFC, 0x1F,
  0x80, 0x7E, 0x0F, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xF8, 0x3F, 0x00, 0x7E,
  0x07, 0xF0, 0x3F, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x3F,
  0x00, 0xFF, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x7E,
  0x01, 0xFF, 0x00, 0x7E, 0x01, 0xFF, 0x80, 0x7C, 0x01, 0xFF, 0x80, 0xFC,
  0x03, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0x80, 0xFC, 0x03, 0xEF, 0x80, 0xFC,
  0x03, 0xEF, 0x80, 0xF8, 0x03, 0xEF, 0xC1, 0xF8, 0x07, 0xEF, 0xC1, 0xF8,
  0x07, 0xE7, 0xC1, 0xF8, 0x07, 0xE7, 0xC1, 0xF8, 0x07, 0xC7, 0xC3, 0xF0,
  0x0F, 0xC7, 0xC3, 0xF0, 0x0F, 0xC7, 0xE3, 0xF0, 0x0F, 0xC7, 0xE3, 0xF0,
  0x0F, 0xC3, 0xE3, 0xE0, 0x0F, 0x83, 0xE7, 0xE0, 0x1F, 0x83, 0xE7, 0xE0,
  0x1F, 0x83, 0xE7, 0xE0, 0x1F, 0x83, 0xF7, 0xE0, 0x1F, 0x03, 0xF7, 0xC0,
  0x1F, 0x01, 0xF7, 0xC0, 0x3F, 0x01, 0xFF, 0xC0, 0x3F, 0x01, 0xFF, 0xC0,
  0x3F, 0x01, 0xFF, 0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x3E, 0x01, 0xFF, 0x80,
  0x7E, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0xFF, 0x00,
  0x7C, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0x8F, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE,
  0x3F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80,
  0x0F, 0xE7, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE7,
  0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00,
  0xFE, 0xFE, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F,
  0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F,
  0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x81, 0xFC,
  0x0F, 0xE0, 0x3F, 0xC7, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0x81,
  0xFC, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F,
  0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC1, 0xFC, 0x07, 0xF0,
  0x7F, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x1F,
  0xE0, 0xFE, 0x0F, 0xF0, 0x3F, 0x0F, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0x8F, 0xF0,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x3F, 0x87, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xCF,
  0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xE0, 0x01,
  0xFD, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE7, 0xF0, 0x01, 0xFC, 0xFC,
  0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F,
  0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0x8F, 0xE0,
  0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x3F, 0xC7,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xC7, 0xFC,
  0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x0F,
  0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x81,
  0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7F, 0x03, 0xF0,
  0x7F, 0x03, 0xF8, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x8F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xFC, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xF0,
  0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F,
  0x07, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0x00, 0x00,
  0x40, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFB, 0xF0, 0x0F, 0xF0, 0x18,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x10, 0x01, 0xFC,
  0x07, 0x00, 0xFE, 0x03, 0xF9, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7F,
  0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F,
  0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F,
  0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xFC, 0x01,
  0xF8, 0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x03,
  0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00,
  0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xE0,
  0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x0F, 0xE0,
  0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF,
  0x1F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0,
  0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFD, 0xF8, 0x00,
  0xFD, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFB, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0x01, 0xF9, 0xF8, 0x03,
  0xF0, 0x03, 0xF3, 0xF0, 0x07, 0xE0, 0x0F, 0xE7, 0xE0, 0x0F, 0xC0, 0x1F,
  0x8F, 0xC0, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x3F, 0x01,
  0xFE, 0x01, 0xF8, 0x7E, 0x03, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF8, 0x0F,
  0xC1, 0xF8, 0x1F, 0xF0, 0x1F, 0x83, 0xE0, 0x3F, 0xE0, 0x7E, 0x07, 0xC0,
  0xFF, 0xC0, 0xFC, 0x0F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0x03, 0xFF, 0x07,
  0xE0, 0x3E, 0x0F, 0xBE, 0x0F, 0xC0, 0x7C, 0x1F, 0x7C, 0x3F, 0x01, 0xF8,
  0x7E, 0xF8, 0x7E, 0x03, 0xF0, 0xF9, 0xF0, 0xFC, 0x07, 0xE1, 0xF3, 0xE3,
  0xF0, 0x0F, 0xC7, 0xC7, 0xC7, 0xE0, 0x1F, 0x8F, 0x8F, 0x9F, 0x80, 0x3F,
  0x3F, 0x1F, 0x3F, 0x00, 0x7E, 0x7C, 0x3E, 0x7E, 0x00, 0xFC, 0xF8, 0x7D,
  0xF8, 0x01, 0xFB, 0xE0, 0xFB, 0xF0, 0x03, 0xF7, 0xC1, 0xF7, 0xE0, 0x07,
  0xEF, 0x83, 0xDF, 0x80, 0x0F, 0xFE, 0x07, 0xBF, 0x00, 0x1F, 0xFC, 0x0F,
  0x7C, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x01, 0xF9, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x01,
  0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8,
  0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFF,
  0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFC, 0xFE, 0x03, 0xF1, 0xF8,
  0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E,
  0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF9, 0xF8, 0x03,
  0xE7, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x40, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0,
  0x7C, 0x1F, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xFD, 0xF0, 0x00,
  0xF9, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07,
  0xE0, 0xF8, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0x7C, 0x1F,
  0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x7F, 0x1F,
  0xC7, 0xE3, 0xF0, 0xF8, 0x7E, 0x1F, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xFF, 0x1F, 0x01, 0xFF, 0xBF, 0x03, 0xFF, 0xBF, 0x07, 0xFF, 0xFE, 0x07,
  0xFB, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F,
  0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7F,
  0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0xFE, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFC,
  0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xF7, 0xE0, 0x7F, 0xF7, 0xC0, 0x3F,
  0xE7, 0xC0, 0x1F, 0xC7, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF1, 0xF0, 0x03,
  0xF3, 0xF8, 0x03, 0xF7, 0xFC, 0x03, 0xEF, 0xFE, 0x07, 0xFF, 0xFE, 0x07,
  0xFC, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0x0F,
  0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x7F, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F,
  0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x7F,
  0x87, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xF9,
  0xFF, 0x80, 0xF8, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0x80, 0x07,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x9C, 0x0F,
  0xE0, 0x41, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x02, 0x07, 0xF0,
  0x60, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xC3, 0xF0,
  0x01, 0xFE, 0x7E, 0x00, 0x7F, 0xEF, 0xC0, 0x1F, 0xFD, 0xF8, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0x87, 0xF8, 0x07, 0xE0, 0x7F, 0x01,
  0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7C,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0xC0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xF7, 0xC0, 0x07, 0xFC,
  0xF8, 0x00, 0x7F, 0x1F, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF0,
  0xFC, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x0F, 0xCF,
  0xC0, 0x7E, 0x7E, 0x07, 0xE3, 0xE0, 0x7F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x0C, 0x1F, 0xE3, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x34, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xEC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF1, 0xF0, 0x07, 0xFE, 0xFC, 0x03,
  0xFF, 0xBF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xE0, 0x3F, 0x87, 0xF8,
  0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x1F, 0xC1, 0xF8,
  0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x83,
  0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xC0, 0x7F,
  0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFE, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x02, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x20, 0x07, 0xF0, 0x0E, 0x03, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x1F, 0x00, 0x7E, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xF7, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xE1, 0xF8, 0x3F, 0x83, 0xF0, 0x7E, 0x07,
  0xE1, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x81, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0,
  0x7E, 0x1F, 0x81, 0xF8, 0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F,
  0xC3, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x81, 0xFC, 0x0F, 0xC1, 0xFC, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0xFE, 0x01, 0xF8, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7E,
  0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xBF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xF0, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0xC0,
  0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x7C, 0xFF, 0x0F, 0xF0, 0x0F, 0xBF, 0xF3, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFB, 0xFF, 0xBF, 0xC1, 0xFC, 0x3F,
  0xC1, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE1, 0xF8,
  0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0x1F, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0x87, 0xE0, 0x3E, 0x03,
  0xF0, 0xFC, 0x0F, 0xC0, 0x7C, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xE0, 0x3F,
  0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0xF8, 0x0F, 0xC3, 0xF0,
  0x3F, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0xFC, 0x0F, 0xC3,
  0xF0, 0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x07,
  0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x07, 0xE1, 0xF8, 0x1F, 0x80, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x07, 0xC7, 0xF8, 0x0F, 0xBF, 0xF0, 0x1E, 0x7F, 0xF0, 0x7D,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFE, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xE0,
  0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F,
  0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC,
  0x3F, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87,
  0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC,
  0x07, 0xE1, 0xF8, 0x0F, 0x83, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xEF, 0xE0, 0xFE, 0x1F,
  0xC7, 0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x3F, 0x3F, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80,
  0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFE,
  0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x3F, 0x01, 0xF8, 0xFE,
  0x0F, 0xE1, 0xF8, 0x7F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x0F, 0x8F, 0xF0, 0x01, 0xF3, 0xFE, 0x00, 0x3E, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x3F,
  0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01,
  0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x1F,
  0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFB, 0xFF, 0x80, 0x3F,
  0x7F, 0xE0, 0x07, 0xE7, 0xF0, 0x00, 0xFC, 0x10, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x1F, 0x01, 0xFF, 0xBF, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFB, 0xFE, 0x0F, 0xE1, 0xFE, 0x0F,
  0xC0, 0xFE, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0xFE, 0x01, 0xF0, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC,
  0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xEF, 0xC0, 0x1F, 0xCF, 0xC0, 0x04,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x3E, 0x7E, 0x03, 0xEF, 0xE0, 0x3E, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0x1C, 0x1F,
  0xC0, 0x41, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x80, 0x7F, 0x0C, 0x0F,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0xA0, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xFF, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF,
  0xF3, 0xFF, 0xE1, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7E, 0x00, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x07,
  0xFC, 0x01, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7C, 0x0F, 0x80,
  0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01,
  0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0xFC, 0x0F,
  0xE0, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xF7,
  0xC0, 0x7F, 0xF7, 0xC0, 0x7F, 0xE7, 0xC0, 0x3F, 0xC7, 0x80, 0x06, 0x00,
  0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x0F, 0xCF,
  0xC0, 0x7E, 0x7E, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF0, 0x7C, 0x1F,
  0x83, 0xE0, 0xFC, 0x1F, 0x0F, 0xC0, 0xF8, 0x7E, 0x07, 0xC7, 0xE0, 0x3E,
  0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0x9F, 0x80, 0x7C, 0xF8, 0x03, 0xEF, 0xC0,
  0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x07, 0xF0, 0x1F,
  0xBE, 0x03, 0xF8, 0x1F, 0x9F, 0x03, 0xFC, 0x0F, 0xDF, 0x81, 0xFE, 0x0F,
  0xCF, 0xC1, 0xFF, 0x07, 0xE7, 0xE0, 0xFF, 0x83, 0xE3, 0xF0, 0x7F, 0xC3,
  0xF1, 0xF8, 0x7F, 0xE1, 0xF8, 0xFC, 0x3F, 0xF1, 0xF8, 0x7E, 0x3E, 0xF0,
  0xFC, 0x3F, 0x1F, 0x78, 0x7C, 0x1F, 0x8F, 0x3C, 0x7E, 0x0F, 0xCF, 0x9E,
  0x3F, 0x07, 0xE7, 0xDF, 0x1F, 0x03, 0xF3, 0xCF, 0x9F, 0x81, 0xFB, 0xE7,
  0xCF, 0x80, 0xFD, 0xF3, 0xEF, 0xC0, 0x7F, 0xF1, 0xF7, 0xE0, 0x3E, 0xF8,
  0xFB, 0xE0, 0x1F, 0x78, 0x7F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE,
  0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x3F, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xF0,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x7E,
  0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x7C, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8,
  0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF1, 0xF8,
  0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x04, 0xFF, 0x80, 0x17, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFC, 0x80, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 15, 41, 14, 0, -40 },
  { 78, 19, 14, 21, 5, -40 },
  { 112, 27, 40, 26, 0, -40 },
  { 247, 24, 46, 23, 0, -43 },
  { 385, 33, 42, 37, 3, -41 },
  { 559, 27, 41, 27, 0, -40 },
  { 698, 8, 14, 12, 6, -40 },
  { 712, 18, 49, 15, 1, -40 },
  { 823, 18, 50, 15, -4, -41 },
  { 936, 19, 22, 22, 5, -43 },
  { 989, 22, 27, 25, 2, -33 },
  { 1064, 12, 15, 13, -3, -7 },
  { 1087, 14, 6, 16, 1, -18 },
  { 1098, 8, 9, 13, 0, -8 },
  { 1107, 28, 40, 20, -3, -40 },
  { 1247, 22, 42, 23, 1, -41 },
  { 1363, 16, 40, 23, 6, -40 },
  { 1443, 26, 41, 23, -2, -41 },
  { 1577, 25, 42, 23, -1, -41 },
  { 1709, 25, 40, 23, -1, -40 },
  { 1834, 24, 41, 23, 0, -40 },
  { 1957, 24, 42, 23, 1, -41 },
  { 2083, 24, 40, 23, 2, -40 },
  { 2203, 24, 42, 23, 0, -41 },
  { 2329, 23, 42, 23, 0, -41 },
  { 2450, 13, 32, 13, 0, -31 },
  { 2502, 16, 39, 13, -3, -31 },
  { 2580, 22, 26, 25, 2, -33 },
  { 2652, 22, 17, 25, 2, -28 },
  { 2699, 22, 26, 25, 2, -33 },
  { 2771, 19, 42, 18, 1, -41 },
  { 2871, 34, 45, 35, 1, -40 },
  { 3063, 25, 40, 25, -4, -40 },
  { 3188, 26, 40, 26, 0, -40 },
  { 3318, 25, 42, 23, 2, -41 },
  { 3450, 27, 40, 28, 0, -40 },
  { 3585, 24, 40, 22, 0, -40 },
  { 3705, 24, 40, 21, 0, -40 },
  { 3825, 28, 42, 29, 2, -41 },
  { 3972, 30, 40, 29, 0, -40 },
  { 4122, 24, 40, 17, -3, -40 },
  { 4242, 23, 51, 13, -8, -40 },
  { 4389, 30, 40, 25, 0, -40 },
  { 4539, 17, 40, 21, 0, -40 },
  { 4624, 40, 40, 38, 0, -40 },
  { 4824, 32, 40, 30, 0, -40 },
  { 4984, 27, 42, 29, 2, -41 },
  { 5126, 26, 40, 25, 0, -40 },
  { 5256, 27, 51, 29, 2, -41 },
  { 5429, 25, 40, 25, 0, -40 },
  { 5554, 26, 42, 22, -1, -41 },
  { 5691, 21, 40, 21, 4, -40 },
  { 5796, 28, 41, 28, 2, -40 },
  { 5940, 24, 40, 25, 5, -40 },
  { 6060, 39, 40, 38, 4, -40 },
  { 6255, 30, 40, 23, -3, -40 },
  { 6405, 22, 40, 22, 5, -40 },
  { 6515, 26, 40, 21, -2, -40 },
  { 6645, 22, 49, 16, -2, -40 },
  { 6780, 10, 40, 20, 6, -40 },
  { 6830, 22, 49, 16, -4, -40 },
  { 6965, 24, 23, 24, 0, -40 },
  { 7034, 18, 3, 18, -5, 5 },
  { 7041, 9, 9, 16, 8, -43 },
  { 7052, 24, 32, 25, 1, -31 },
  { 7148, 24, 44, 25, 0, -43 },
  { 7280, 20, 32, 19, 1, -31 },
  { 7360, 27, 44, 25, 1, -43 },
  { 7509, 21, 32, 23, 1, -31 },
  { 7593, 28, 56, 15, -7, -43 },
  { 7789, 26, 44, 25, -1, -31 },
  { 7932, 23, 43, 25, 0, -43 },
  { 8056, 14, 42, 12, 0, -42 },
  { 8130, 21, 55, 12, -7, -42 },
  { 8275, 25, 43, 22, 0, -43 },
  { 8410, 15, 43, 12, 0, -43 },
  { 8491, 35, 31, 36, 0, -31 },
  { 8627, 23, 31, 25, 0, -31 },
  { 8717, 22, 32, 24, 1, -31 },
  { 8805, 27, 44, 25, -3, -31 },
  { 8954, 24, 44, 25, 1, -31 },
  { 9086, 20, 31, 17, 0, -31 },
  { 9164, 20, 32, 19, 0, -31 },
  { 9244, 15, 38, 15, 2, -37 },
  { 9316, 24, 31, 24, 1, -30 },
  { 9409, 21, 30, 21, 3, -30 },
  { 9488, 33, 30, 33, 3, -30 },
  { 9612, 27, 30, 21, -3, -30 },
  { 9714, 29, 43, 21, -5, -30 },
  { 9870, 22, 30, 18, -2, -30 },
  { 9953, 22, 49, 19, 1, -40 },
  { 10088, 6, 56, 21, 7, -43 },
  { 10130, 21, 49, 19, -3, -40 },
  { 10259, 22, 9, 25, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC56PT7B_H_
