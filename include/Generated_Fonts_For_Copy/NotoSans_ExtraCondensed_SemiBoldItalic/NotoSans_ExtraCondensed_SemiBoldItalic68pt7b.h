#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC68PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x00,
  0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xE3, 0xF8, 0x7F, 0x8F, 0xE1, 0xFE, 0x3F,
  0x87, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07,
  0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFE, 0x1F, 0x83, 0xF8, 0xFE, 0x0F, 0xC3,
  0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0xF8,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x03,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0x77, 0xE0, 0x07, 0xF1, 0xC3, 0x80, 0x1F, 0xC6, 0x04, 0x00, 0xFE, 0x38,
  0x00, 0x03, 0xF8, 0xE0, 0x00, 0x0F, 0xE3, 0x80, 0x00, 0x3F, 0x8E, 0x00,
  0x00, 0xFE, 0x30, 0x00, 0x03, 0xFD, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x19, 0xFE, 0x00, 0x00, 0xE7, 0xF8,
  0x00, 0x03, 0x8F, 0xE0, 0x00, 0x0E, 0x3F, 0x80, 0x00, 0x38, 0xFE, 0x00,
  0x00, 0xC3, 0xF8, 0x18, 0x07, 0x1F, 0xE0, 0x70, 0x1C, 0x7F, 0x01, 0xF0,
  0x73, 0xFC, 0x07, 0xFD, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x07, 0xC7, 0xE0, 0x0F,
  0x80, 0x0F, 0xC7, 0xE0, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x1F, 0x00, 0x1F,
  0x87, 0xE0, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x07, 0xE0,
  0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x07, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xC1, 0xF8, 0x00, 0x7E, 0x0F,
  0xC3, 0xF0, 0x00, 0x7C, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x0F, 0xC7, 0xE0,
  0x00, 0x7C, 0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x1F, 0x8F, 0xC0, 0xF0, 0xFC,
  0x1F, 0x8F, 0x83, 0xFC, 0xFC, 0x1F, 0x1F, 0x87, 0xFE, 0xFC, 0x3F, 0x1F,
  0x0F, 0xFE, 0xFC, 0x3E, 0x3F, 0x1F, 0xFF, 0x7C, 0x7E, 0x3E, 0x3F, 0xBF,
  0x7F, 0xFC, 0x7E, 0x3E, 0x1F, 0x7F, 0xFC, 0x7C, 0x7E, 0x1F, 0x3F, 0xF8,
  0xFC, 0x7C, 0x1F, 0x3F, 0xF1, 0xF8, 0xFC, 0x1F, 0x0F, 0xC1, 0xF8, 0xF8,
  0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x1F, 0x00, 0x03, 0xF1, 0xF8, 0x1F, 0x00,
  0x07, 0xE1, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x3F, 0x00, 0x0F, 0xC1,
  0xF0, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x3E,
  0x00, 0x1F, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x7E, 0x00, 0x3E,
  0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x03, 0xE0,
  0xFC, 0x00, 0xFC, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x03, 0xF1, 0xF8, 0x01,
  0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x01,
  0xFF, 0xE0, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x7F, 0x07, 0xFF, 0xF0, 0x7F, 0x0F, 0xFF, 0xF0, 0xFE, 0x0F, 0xE7, 0xF0,
  0xFE, 0x1F, 0xC7, 0xF9, 0xFE, 0x3F, 0xC7, 0xF9, 0xFC, 0x3F, 0x83, 0xF9,
  0xFC, 0x7F, 0x03, 0xFF, 0xF8, 0x7F, 0x01, 0xFF, 0xF8, 0xFF, 0x01, 0xFF,
  0xF0, 0xFE, 0x01, 0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0xE0, 0xFE, 0x00, 0xFF,
  0xE0, 0xFE, 0x00, 0xFF, 0xC0, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x9F,
  0xF0, 0x1F, 0xFF, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xE0, 0x00,
  0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF9, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x04, 0x07, 0xE0, 0x0E,
  0x0F, 0x80, 0x3F, 0x1F, 0x00, 0x7F, 0x3E, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0x7F,
  0x01, 0xFE, 0x7E, 0x07, 0xF8, 0xFE, 0x07, 0xE0, 0xFC, 0x07, 0xC1, 0xFC,
  0x07, 0x03, 0xF0, 0x04, 0x03, 0x80, 0x00, 0x04, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F,
  0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x00, 0x7F,
  0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB,
  0xFF, 0xF8, 0x1F, 0x8F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xF9, 0xFC,
  0x7E, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xF8, 0x7F, 0x01,
  0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x07,
  0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x7F,
  0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x3F,
  0x8F, 0xE0, 0x0F, 0xF1, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF0,
  0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xF9,
  0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00,
  0xFF, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F,
  0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0xE1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x7F,
  0x07, 0xF8, 0x0F, 0xE1, 0xFE, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xDF,
  0xC7, 0xFB, 0xF8, 0xFF, 0x3F, 0x8F, 0xE3, 0xF8, 0x7C, 0x3F, 0x83, 0x87,
  0xF8, 0x10, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0xF7, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x3C, 0x03, 0xFC, 0x00,
  0x70, 0x03, 0xFC, 0x00, 0x40, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFB, 0xFF,
  0xC0, 0x0F, 0x01, 0xFF, 0x00, 0x30, 0x03, 0xFC, 0x00, 0x80, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x80, 0x01, 0xFF, 0x03, 0x00, 0x0F, 0xF8, 0x0F,
  0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7D, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xBF, 0x80, 0x00,
  0x7C, 0xFE, 0x00, 0x01, 0xF3, 0xF8, 0x00, 0x0F, 0x9F, 0xE0, 0x00, 0x7E,
  0x7F, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0x0F, 0x87, 0xF0, 0x00, 0x7E, 0x1F,
  0xC0, 0x01, 0xF0, 0xFE, 0x00, 0x0F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xE0,
  0x01, 0xF0, 0x3F, 0x80, 0x0F, 0xC1, 0xFE, 0x00, 0x7E, 0x07, 0xF0, 0x01,
  0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xF8,
  0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0xFE, 0x11, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1C, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x80,
  0x03, 0xFE, 0x06, 0x00, 0x3F, 0xE0, 0x3E, 0x07, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xF8,
  0xE0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0xFF, 0xC0, 0x3F, 0x9F,
  0xFC, 0x03, 0xFB, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xF1, 0xFF, 0x07, 0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x0F, 0xF8,
  0x07, 0xF0, 0xFF, 0x80, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F,
  0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE,
  0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F,
  0xF0, 0x7F, 0x80, 0xFF, 0x8F, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x02, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFC, 0x3F,
  0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC,
  0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x01, 0xFC, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xF8,
  0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0,
  0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x0F,
  0xE0, 0x1F, 0xF0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0x07,
  0xFE, 0x0F, 0xF0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFD, 0xFC, 0x07, 0xFF, 0xDF, 0xC0, 0x3F, 0xFB, 0xFC, 0x01, 0xFE,
  0x3F, 0x80, 0x03, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x80, 0x3F, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xFC,
  0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x01,
  0xF8, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xF8, 0x07, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xE3, 0xFE, 0x03, 0x00, 0xFF, 0x02, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0x0F, 0xF0, 0x1F, 0x07, 0xE0,
  0x3F, 0xFE, 0x1F, 0x07, 0xC0, 0x7F, 0xFE, 0x1F, 0x0F, 0xC0, 0xFF, 0xFC,
  0x1F, 0x0F, 0x81, 0xFC, 0xFC, 0x1F, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x1F,
  0x03, 0xE0, 0xFC, 0x1F, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x3E, 0x0F, 0xC0, 0xF8, 0x3E, 0x3E, 0x0F, 0x81, 0xF8, 0x3E,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x7C, 0x1F, 0x81, 0xF0, 0x3E, 0x7C, 0x1F,
  0x01, 0xF0, 0x3E, 0x7C, 0x1F, 0x03, 0xF0, 0x7C, 0xFC, 0x3F, 0x03, 0xE0,
  0x7C, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0xF8, 0x3E, 0x07, 0xE0, 0x78, 0xF8,
  0x3E, 0x07, 0xE0, 0xF8, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0xF8, 0x3E, 0x0F,
  0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0xF8, 0x3F, 0x1F, 0xC3, 0xE0,
  0xF8, 0x3F, 0x3F, 0xE7, 0xC0, 0xF8, 0x3F, 0xFB, 0xFF, 0xC0, 0xF8, 0x1F,
  0xF9, 0xFF, 0x80, 0xF8, 0x1F, 0xF1, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0xFC,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x40, 0x00,
  0x3F, 0x80, 0x01, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x03,
  0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07,
  0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0x01, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFE,
  0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F,
  0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFD,
  0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0x03, 0xFE, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x01,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x03,
  0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F,
  0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F,
  0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0xC0, 0x7F, 0x87, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F,
  0xE0, 0x18, 0x00, 0xFF, 0x80, 0x10, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x10, 0x00, 0xFF, 0xC3, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8,
  0x1F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F,
  0xF0, 0x3F, 0x80, 0x0F, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03,
  0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xC0, 0x3F, 0x80, 0xFF, 0xC0, 0x3F, 0xC1,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x78, 0x00, 0xFF, 0xC0, 0x03, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xFF, 0x81, 0xFE, 0x01, 0xFF,
  0xF0, 0x7F, 0x80, 0x7F, 0xFE, 0x0F, 0xF0, 0x0F, 0xFF, 0x81, 0xFE, 0x01,
  0xFF, 0xF0, 0x3F, 0xC0, 0x3F, 0xFE, 0x07, 0xF8, 0x07, 0xFF, 0xC0, 0xFF,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x04, 0x1F,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xCF, 0xF0, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x03, 0xFB, 0xFC,
  0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x01, 0xFB, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01,
  0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x03,
  0xFB, 0xF8, 0x07, 0xE7, 0xF0, 0x03, 0xFB, 0xF8, 0x0F, 0xE7, 0xF0, 0x03,
  0xFB, 0xF8, 0x0F, 0xEF, 0xF0, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xE0, 0x07,
  0xF1, 0xF8, 0x1F, 0xCF, 0xE0, 0x07, 0xF1, 0xF8, 0x1F, 0x8F, 0xE0, 0x07,
  0xF1, 0xF8, 0x3F, 0x9F, 0xE0, 0x07, 0xF1, 0xF8, 0x3F, 0x1F, 0xC0, 0x0F,
  0xE1, 0xF8, 0x7F, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0x7E, 0x1F, 0xC0, 0x0F,
  0xE1, 0xF8, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0xFC, 0x3F, 0xC0, 0x0F,
  0xE1, 0xF8, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xF9, 0xFC, 0x3F, 0x80, 0x1F,
  0xC1, 0xF9, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFB, 0xF8, 0x3F, 0x80, 0x1F,
  0xC1, 0xFB, 0xF0, 0x7F, 0x80, 0x1F, 0xC1, 0xFF, 0xF0, 0x7F, 0x00, 0x3F,
  0x81, 0xFF, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFF, 0xE0, 0x7F, 0x00, 0x3F,
  0x81, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0x81, 0xFF, 0xC0, 0xFE, 0x00, 0x3F,
  0x01, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0x80, 0xFE, 0x00, 0x7F,
  0x01, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0x01, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFE,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x80,
  0x07, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xC0,
  0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xFF,
  0x80, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x7E, 0x01, 0xFC,
  0x00, 0xFE, 0xFC, 0x03, 0xF8, 0x01, 0xFD, 0xF8, 0x0F, 0xE0, 0x03, 0xF3,
  0xF0, 0x1F, 0xC0, 0x0F, 0xE7, 0xF0, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x7F,
  0x00, 0x3F, 0x8F, 0xC0, 0xFE, 0x00, 0x7F, 0x1F, 0x83, 0xF8, 0x00, 0xFC,
  0x3F, 0x07, 0xF0, 0x03, 0xF8, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x1F,
  0xC0, 0x0F, 0xE1, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0xFE, 0x00, 0x7F,
  0x03, 0xF1, 0xFC, 0x00, 0xFE, 0x07, 0xE3, 0xF8, 0x01, 0xFC, 0x0F, 0xE7,
  0xF0, 0x03, 0xF8, 0x1F, 0xCF, 0xE0, 0x07, 0xF0, 0x3F, 0xBF, 0x80, 0x1F,
  0xC0, 0x3F, 0x7F, 0x00, 0x3F, 0x80, 0x7E, 0xFE, 0x00, 0x7F, 0x00, 0xFD,
  0xFC, 0x00, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x07,
  0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xF0, 0x00,
  0xFF, 0xC0, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00,
  0x7F, 0x00, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0x07, 0xFE, 0x00, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x03,
  0xFC, 0x03, 0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x1F,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x3F,
  0xE7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07,
  0xF9, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01,
  0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0x83, 0xFE,
  0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0x80, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x80, 0x7F, 0x80, 0x7F, 0x01, 0xFF, 0x00, 0xFE, 0x0F, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x7F,
  0x80, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0,
  0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x0F,
  0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x7C, 0x01, 0xFF,
  0x80, 0x30, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x20, 0x00,
  0x7F, 0x80, 0x60, 0x01, 0xFF, 0x00, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFA, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x1F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x1F,
  0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xFE, 0x3F, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F,
  0xF3, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x07, 0xF8,
  0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x03, 0xF8,
  0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFD, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE7, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F,
  0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xE1, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0x83, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xFE,
  0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0xF8,
  0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF7, 0xE0,
  0x7F, 0x80, 0xFE, 0x07, 0xEF, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xDF, 0x81,
  0xFC, 0x07, 0xF8, 0x3F, 0xBF, 0x07, 0xF8, 0x0F, 0xF0, 0x7E, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC0, 0xFD, 0xF8, 0x3F, 0xC0, 0x3F, 0x83, 0xF3, 0xF0, 0x7F,
  0x00, 0x7F, 0x07, 0xE7, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xCF, 0xC3, 0xFC,
  0x01, 0xFC, 0x3F, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7E, 0x3F, 0x0F, 0xE0,
  0x07, 0xF1, 0xF8, 0x7E, 0x3F, 0xC0, 0x0F, 0xE3, 0xF0, 0xFC, 0x7F, 0x00,
  0x1F, 0xCF, 0xE1, 0xF9, 0xFE, 0x00, 0x3F, 0x9F, 0x83, 0xF3, 0xF8, 0x00,
  0x7F, 0x3F, 0x07, 0xE7, 0xF0, 0x00, 0xFE, 0xFE, 0x0F, 0xDF, 0xE0, 0x01,
  0xFD, 0xF8, 0x1F, 0xBF, 0x80, 0x03, 0xFB, 0xF0, 0x3F, 0x7F, 0x00, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xCF, 0xF0,
  0x07, 0xF8, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0,
  0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81,
  0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFC, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x7E, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0xC3, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0,
  0x3F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF1,
  0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xFF, 0x1F,
  0x80, 0x3F, 0xFE, 0xFE, 0x01, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0xEF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xE0,
  0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07,
  0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x07,
  0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x83, 0xFC,
  0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x01,
  0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF0, 0x3F, 0xE0, 0x1F, 0xE1, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xEF, 0xE0,
  0x0F, 0xFF, 0x3F, 0x00, 0x1F, 0xF8, 0xFC, 0x00, 0x3F, 0xC3, 0xF0, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x10, 0x00, 0x3F,
  0xC7, 0xF0, 0x01, 0xFC, 0xFF, 0xC0, 0x0F, 0xEF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0x87, 0xFC,
  0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00,
  0x7F, 0x87, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xE1, 0xFC, 0x00, 0xFE,
  0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x03, 0xFC, 0x3F,
  0x80, 0x1F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00,
  0x7F, 0x87, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE,
  0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F,
  0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFE, 0xFF,
  0xFC, 0x07, 0xE7, 0xFF, 0xC0, 0x3F, 0x1F, 0xFC, 0x01, 0xF8, 0x7F, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFC, 0x18, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x01, 0x00, 0xFF, 0x83, 0x80, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0C, 0x0F, 0xF0, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x3F, 0xF3, 0xF8, 0x00, 0x7F, 0xFD, 0xFC, 0x00, 0x3F, 0xFE,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xE1,
  0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8,
  0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x3F,
  0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0xFC, 0x00, 0x1F, 0xFE, 0x7E, 0x00, 0x07, 0xFE, 0x3F,
  0x00, 0x01, 0xFE, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0x8F, 0xF0, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0x7F,
  0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0x7E, 0x1F, 0xC0, 0x3F, 0x8F, 0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xF0, 0xFE,
  0x3F, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x03, 0x01, 0xFF, 0x83, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x60, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x23, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xC0,
  0x01, 0xFF, 0x8F, 0xC0, 0x01, 0xFF, 0xE7, 0xE0, 0x01, 0xFF, 0xF7, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x0F, 0xFC,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE,
  0x03, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F,
  0xE1, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xF0, 0x00, 0x3F, 0xF3, 0xF8, 0x00,
  0x0F, 0xF1, 0xFC, 0x00, 0x01, 0xE1, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x04, 0x00, 0x0F, 0xF0,
  0x03, 0x80, 0x0F, 0xF0, 0x01, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x04, 0x00, 0x1F, 0xE7, 0xF8, 0x01, 0xFC, 0xFF, 0xC0, 0x1F, 0xDF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xF1, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x03, 0xFC,
  0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFF,
  0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x1F,
  0xC1, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xC1, 0xFC, 0x03, 0xFC, 0x1F,
  0xC0, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x07,
  0xF8, 0x3F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x00,
  0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0,
  0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x08, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xFC,
  0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F,
  0xCF, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFD,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0xFE, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x10, 0x00, 0x3F, 0x0F, 0xF0, 0x1F, 0xE0,
  0x07, 0xE3, 0xFF, 0x0F, 0xFE, 0x00, 0xFC, 0xFF, 0xF3, 0xFF, 0xE0, 0x1F,
  0xBF, 0xFE, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0xFF, 0xF1, 0xFF, 0x03, 0xFE, 0x0F, 0xFC,
  0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x80,
  0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xC0,
  0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x1F, 0x87, 0xF8, 0x01, 0xF8, 0xFF,
  0xC0, 0x1F, 0x9F, 0xFE, 0x01, 0xFB, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0,
  0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0,
  0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFC,
  0x1F, 0xE0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC,
  0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F,
  0x83, 0xF8, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x7F,
  0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F,
  0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x1F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x0F, 0xF1,
  0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F,
  0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xDF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFB, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF,
  0x80, 0x1F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F,
  0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x0F, 0xF3, 0xF8, 0x07, 0xF8, 0xFE, 0x01,
  0xFE, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x7F, 0xC3, 0xFC, 0x3F, 0xE0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE3, 0xFF, 0x00, 0x03,
  0xF3, 0xFF, 0xC0, 0x01, 0xFB, 0xFF, 0xF0, 0x00, 0xFD, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0,
  0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFC,
  0xFF, 0xF0, 0x00, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x3F,
  0x83, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0x87,
  0xF0, 0x03, 0xFF, 0x1F, 0x80, 0x1F, 0xFE, 0x7E, 0x00, 0xFF, 0xFB, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x0F, 0xFC, 0x07,
  0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0x03, 0xF8,
  0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x01,
  0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F,
  0x03, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0x81,
  0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F,
  0x00, 0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0,
  0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xE1, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x7F, 0x00, 0x1F, 0xF9, 0xFC, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0x38, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x04, 0x01, 0xF8, 0x7F, 0x01, 0xF8,
  0xFF, 0x01, 0xF9, 0xFE, 0x01, 0xFB, 0xFE, 0x01, 0xFB, 0xFE, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xC4, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xF8, 0x1C, 0x07,
  0xF8, 0x02, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0x00, 0x3F, 0xC1, 0xE0,
  0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xE1, 0xFF, 0xF8,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x91, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x81,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xF0,
  0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xDF,
  0x80, 0x7F, 0xF9, 0xF8, 0x07, 0xFF, 0x1F, 0x00, 0x3F, 0xE3, 0xF0, 0x00,
  0x70, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xDF, 0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF3, 0xF8, 0x07,
  0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x81,
  0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x1F,
  0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF8, 0x01,
  0xFB, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFC,
  0x07, 0xF7, 0xF0, 0x1F, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xF0, 0x1F, 0xDF,
  0xC0, 0x7F, 0xE0, 0x7F, 0x3F, 0x81, 0xFF, 0xC0, 0xFE, 0x7F, 0x03, 0xFF,
  0x03, 0xF8, 0xFE, 0x07, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xFC, 0x0F, 0xE3,
  0xF8, 0x3E, 0xF8, 0x3F, 0x87, 0xF0, 0xFD, 0xF0, 0x7F, 0x0F, 0xE1, 0xFB,
  0xE0, 0xFC, 0x1F, 0xC3, 0xEF, 0xC3, 0xF8, 0x3F, 0x8F, 0xDF, 0x87, 0xF0,
  0x7F, 0x1F, 0xBF, 0x1F, 0xC0, 0xFE, 0x7E, 0x7E, 0x3F, 0x81, 0xFC, 0xFC,
  0xFC, 0x7E, 0x03, 0xF9, 0xF1, 0xF9, 0xFC, 0x07, 0xF7, 0xE3, 0xF3, 0xF8,
  0x0F, 0xCF, 0xC7, 0xE7, 0xE0, 0x1F, 0x9F, 0x0F, 0xDF, 0xC0, 0x3F, 0x7E,
  0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x3F, 0x7E, 0x00, 0xFD, 0xF0, 0x7F, 0xFC,
  0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x03, 0xFF,
  0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x9F, 0xE0,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFD, 0xFC, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x03, 0xF0, 0x1F, 0xC0,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00,
  0x7E, 0x3F, 0x80, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x10, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x27, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x80, 0x07, 0xFF, 0x90, 0x00, 0x1F,
  0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 19, 50, 17, 0, -49 },
  { 120, 22, 18, 25, 7, -49 },
  { 170, 33, 49, 31, 0, -49 },
  { 373, 30, 56, 28, 0, -52 },
  { 583, 40, 50, 45, 3, -49 },
  { 833, 32, 50, 33, 0, -49 },
  { 1033, 10, 18, 15, 7, -49 },
  { 1056, 22, 60, 18, 1, -49 },
  { 1221, 22, 60, 18, -5, -49 },
  { 1386, 23, 26, 27, 6, -52 },
  { 1461, 26, 32, 31, 3, -40 },
  { 1565, 13, 18, 15, -3, -9 },
  { 1595, 17, 7, 19, 1, -22 },
  { 1610, 10, 10, 15, 0, -9 },
  { 1623, 34, 49, 24, -4, -49 },
  { 1832, 27, 50, 28, 1, -49 },
  { 2001, 20, 49, 28, 7, -49 },
  { 2124, 31, 49, 28, -2, -49 },
  { 2314, 30, 50, 28, -1, -49 },
  { 2502, 30, 49, 28, -1, -49 },
  { 2686, 29, 50, 28, 0, -49 },
  { 2868, 28, 50, 28, 2, -49 },
  { 3043, 30, 49, 28, 2, -49 },
  { 3227, 29, 50, 28, 0, -49 },
  { 3409, 28, 50, 28, 0, -49 },
  { 3584, 15, 38, 16, 0, -37 },
  { 3656, 19, 46, 16, -4, -37 },
  { 3766, 27, 32, 31, 3, -40 },
  { 3874, 27, 20, 31, 3, -34 },
  { 3942, 27, 32, 31, 3, -40 },
  { 4050, 24, 50, 22, 1, -49 },
  { 4200, 40, 55, 43, 2, -49 },
  { 4475, 30, 49, 30, -4, -49 },
  { 4659, 32, 49, 31, 0, -49 },
  { 4855, 31, 50, 28, 2, -49 },
  { 5049, 33, 49, 34, 0, -49 },
  { 5252, 29, 49, 26, 0, -49 },
  { 5430, 29, 49, 25, 0, -49 },
  { 5608, 35, 50, 35, 2, -49 },
  { 5827, 37, 49, 35, 0, -49 },
  { 6054, 28, 49, 20, -3, -49 },
  { 6226, 28, 63, 16, -10, -49 },
  { 6447, 36, 49, 30, 0, -49 },
  { 6668, 21, 49, 25, 0, -49 },
  { 6797, 48, 49, 46, 0, -49 },
  { 7091, 39, 49, 37, 0, -49 },
  { 7330, 33, 50, 36, 2, -49 },
  { 7537, 32, 49, 30, 0, -49 },
  { 7733, 33, 61, 36, 2, -49 },
  { 7985, 31, 49, 30, 0, -49 },
  { 8175, 31, 50, 27, -1, -49 },
  { 8369, 26, 49, 26, 5, -49 },
  { 8529, 34, 50, 34, 2, -49 },
  { 8742, 30, 49, 30, 6, -49 },
  { 8926, 47, 49, 46, 5, -49 },
  { 9214, 37, 49, 28, -4, -49 },
  { 9441, 27, 49, 27, 6, -49 },
  { 9607, 33, 49, 25, -3, -49 },
  { 9810, 26, 60, 19, -2, -49 },
  { 10005, 13, 49, 25, 7, -49 },
  { 10085, 27, 60, 19, -5, -49 },
  { 10288, 29, 28, 29, 0, -49 },
  { 10390, 22, 4, 21, -6, 6 },
  { 10401, 11, 11, 19, 10, -52 },
  { 10417, 30, 39, 30, 1, -38 },
  { 10564, 29, 53, 30, 0, -52 },
  { 10757, 25, 39, 24, 1, -38 },
  { 10879, 33, 53, 30, 1, -52 },
  { 11098, 26, 38, 28, 1, -37 },
  { 11222, 34, 68, 18, -8, -52 },
  { 11511, 33, 54, 30, -2, -38 },
  { 11734, 28, 52, 30, 0, -52 },
  { 11916, 18, 51, 15, 0, -51 },
  { 12031, 27, 67, 15, -9, -51 },
  { 12258, 31, 52, 27, 0, -52 },
  { 12460, 18, 52, 14, 0, -52 },
  { 12577, 43, 38, 44, 0, -38 },
  { 12782, 28, 38, 30, 0, -38 },
  { 12915, 26, 39, 29, 2, -38 },
  { 13042, 33, 54, 30, -4, -38 },
  { 13265, 30, 54, 30, 1, -38 },
  { 13468, 24, 38, 21, 0, -38 },
  { 13582, 25, 39, 23, -1, -38 },
  { 13704, 19, 46, 19, 2, -45 },
  { 13814, 28, 38, 30, 2, -37 },
  { 13947, 25, 37, 26, 4, -37 },
  { 14063, 39, 37, 40, 4, -37 },
  { 14244, 32, 37, 26, -3, -37 },
  { 14392, 35, 53, 26, -6, -37 },
  { 14624, 27, 37, 22, -3, -37 },
  { 14749, 26, 60, 23, 1, -49 },
  { 14944, 6, 68, 25, 9, -52 },
  { 14995, 25, 60, 23, -4, -49 },
  { 15183, 27, 10, 31, 3, -29 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC68PT7B_H_
