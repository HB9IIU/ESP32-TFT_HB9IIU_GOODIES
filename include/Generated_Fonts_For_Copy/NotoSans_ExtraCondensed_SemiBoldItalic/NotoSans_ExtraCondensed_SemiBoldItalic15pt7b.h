#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC15PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x66, 0x64, 0x0C, 0xC0, 0x6A, 0xD7, 0xA0, 0x1A, 0x2C,
  0x53, 0xF2, 0x45, 0x0A, 0x7E, 0x58, 0xA2, 0x40, 0x08, 0x7C, 0xB3, 0x87,
  0x07, 0x06, 0x16, 0xA9, 0xF0, 0x81, 0x00, 0x63, 0x29, 0x25, 0x16, 0x8A,
  0x95, 0x5B, 0x56, 0x2A, 0x25, 0x36, 0x91, 0x80, 0x1C, 0x68, 0x91, 0x63,
  0x86, 0x17, 0xEE, 0xCD, 0xBB, 0xF0, 0x69, 0x60, 0x18, 0x8C, 0x46, 0x21,
  0x18, 0xC6, 0x31, 0x84, 0x00, 0x10, 0x86, 0x31, 0x8C, 0x42, 0x31, 0x88,
  0xCC, 0x00, 0x33, 0xE3, 0xDC, 0x58, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x00,
  0x2D, 0x60, 0xFF, 0xF0, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x30,
  0x20, 0x60, 0xC0, 0x1C, 0xF2, 0x59, 0x65, 0x3C, 0xF2, 0xDB, 0x67, 0x00,
  0x19, 0xFC, 0xA3, 0x18, 0xC4, 0x23, 0x18, 0x0C, 0x7C, 0x48, 0x30, 0x61,
  0x82, 0x08, 0x30, 0xC3, 0xF0, 0x3C, 0xF0, 0x41, 0x0C, 0xC1, 0x82, 0x0A,
  0x6F, 0x00, 0x04, 0x31, 0xC7, 0x29, 0xA5, 0xBF, 0xFC, 0x41, 0x00, 0x3C,
  0xF2, 0x18, 0x71, 0xE0, 0xC3, 0x0A, 0x6F, 0x00, 0x0E, 0x38, 0xC3, 0x07,
  0x8F, 0x93, 0x66, 0xC9, 0xB1, 0xC0, 0x3E, 0xFC, 0x10, 0x60, 0x83, 0x04,
  0x18, 0x20, 0xC3, 0x00, 0x1C, 0xF6, 0x59, 0x2C, 0xC7, 0xB3, 0xCB, 0x67,
  0x00, 0x18, 0xF6, 0x59, 0x4D, 0xB7, 0xC2, 0x1A, 0xCE, 0x00, 0x6C, 0x00,
  0x36, 0x13, 0x00, 0x00, 0x66, 0x4C, 0x04, 0x77, 0x30, 0xE0, 0xE0, 0xC0,
  0xFC, 0x00, 0x3F, 0x83, 0x07, 0x07, 0x3B, 0x88, 0x00, 0x3B, 0xC2, 0x11,
  0x19, 0x88, 0x02, 0x30, 0x07, 0x0C, 0xC8, 0x25, 0xD4, 0xAA, 0x95, 0x53,
  0xAA, 0x9F, 0x60, 0x10, 0x0F, 0x80, 0x0E, 0x1C, 0x38, 0xF1, 0x66, 0xCD,
  0x9F, 0x66, 0x8F, 0x18, 0x3C, 0x7C, 0x99, 0x36, 0xCF, 0x1B, 0x26, 0xCD,
  0xBB, 0xE0, 0x1C, 0xF6, 0x30, 0xC3, 0x08, 0x20, 0x83, 0x4F, 0x00, 0x3C,
  0x7C, 0x99, 0x36, 0x6C, 0xD9, 0xA3, 0xCD, 0xF3, 0xC0, 0x3E, 0x78, 0x81,
  0x06, 0x0F, 0x18, 0x20, 0xC1, 0xF3, 0xC0, 0x3E, 0x78, 0x81, 0x06, 0x0F,
  0x1E, 0x20, 0xC1, 0x83, 0x00, 0x1E, 0x7D, 0x86, 0x0C, 0x1B, 0xA7, 0x46,
  0x8D, 0x91, 0xE0, 0x33, 0x33, 0x23, 0x22, 0x62, 0x7E, 0x66, 0x46, 0xC4,
  0xCC, 0xCC, 0x3E, 0x30, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x30, 0x43, 0xC0,
  0x0C, 0x30, 0x82, 0x18, 0x61, 0x84, 0x10, 0xC3, 0x0C, 0xE3, 0x00, 0x33,
  0x36, 0x24, 0x2C, 0x78, 0x78, 0x78, 0x58, 0x48, 0xC8, 0xCC, 0x31, 0x88,
  0x46, 0x31, 0x88, 0xC6, 0x7C, 0x30, 0xE6, 0x18, 0xC7, 0x1C, 0xE7, 0xBC,
  0xF5, 0x17, 0xA2, 0xEC, 0x5D, 0x9B, 0xB3, 0x64, 0x00, 0x31, 0x98, 0x8C,
  0x47, 0x67, 0xB3, 0x51, 0x28, 0x94, 0x4E, 0x67, 0x33, 0x00, 0x1C, 0xF9,
  0x9E, 0x3C, 0x78, 0xE1, 0x46, 0x8D, 0xB3, 0xC0, 0x3C, 0x7C, 0x99, 0x36,
  0x6D, 0x9E, 0x20, 0xC1, 0x83, 0x00, 0x1C, 0xF9, 0x9E, 0x3C, 0x78, 0xE1,
  0x46, 0x8D, 0xB3, 0xC1, 0x83, 0x03, 0x00, 0x38, 0x7C, 0x99, 0x36, 0x4F,
  0x9E, 0x2C, 0x59, 0x93, 0x30, 0x1E, 0x79, 0x83, 0x07, 0x07, 0x06, 0x0C,
  0x19, 0x73, 0xC0, 0xFF, 0xF3, 0x08, 0x61, 0x86, 0x10, 0x43, 0x0C, 0x00,
  0x66, 0xCD, 0x1A, 0x2C, 0xD9, 0xB3, 0x44, 0x99, 0xB3, 0xC0, 0xC7, 0x8B,
  0x36, 0x6D, 0x9B, 0x34, 0x78, 0xE1, 0xC3, 0x80, 0xC4, 0x73, 0x3C, 0xCF,
  0x72, 0xD5, 0xB5, 0x4F, 0x73, 0x9C, 0xE6, 0x33, 0x8C, 0xC0, 0x13, 0x13,
  0x1E, 0x1C, 0x1C, 0x18, 0x18, 0x3C, 0x2C, 0x6C, 0xCC, 0xCF, 0x35, 0x96,
  0x71, 0x86, 0x18, 0x41, 0x0C, 0x00, 0x1F, 0x3E, 0x06, 0x0C, 0x08, 0x18,
  0x10, 0x30, 0x60, 0x64, 0xF8, 0x1C, 0x71, 0x04, 0x30, 0xC2, 0x08, 0x21,
  0x86, 0x10, 0xF0, 0xC9, 0x24, 0xDB, 0x24, 0x80, 0x1C, 0xF0, 0x82, 0x18,
  0x61, 0x04, 0x10, 0xC3, 0x08, 0xE0, 0x08, 0x63, 0x8B, 0x6F, 0x10, 0xF8,
  0xCC, 0x3E, 0xD9, 0x92, 0x6C, 0xD9, 0xB6, 0x34, 0x30, 0xC2, 0x0F, 0x65,
  0x94, 0x53, 0xCF, 0x6B, 0x80, 0x3D, 0x86, 0x10, 0xC3, 0x0D, 0x1C, 0x02,
  0x0C, 0x19, 0xF6, 0xCC, 0x93, 0x66, 0xCD, 0xB1, 0xA0, 0x3D, 0xB4, 0xDE,
  0xC3, 0x0C, 0x9E, 0x07, 0x0C, 0x0C, 0x1E, 0x18, 0x18, 0x18, 0x10, 0x10,
  0x30, 0x30, 0x30, 0x20, 0xE0, 0xC0, 0x3E, 0xD9, 0x92, 0x6C, 0xD9, 0xB6,
  0x34, 0x18, 0x33, 0xC3, 0x00, 0x30, 0xC2, 0x0F, 0x65, 0x94, 0xD3, 0xCB,
  0x2D, 0x80, 0x32, 0x02, 0x66, 0x64, 0xCC, 0xC0, 0x0C, 0x20, 0x02, 0x18,
  0x61, 0x84, 0x30, 0xC3, 0x08, 0x23, 0x8C, 0x00, 0x30, 0x60, 0x81, 0x36,
  0xCF, 0x1C, 0x38, 0xD9, 0xB3, 0x60, 0x33, 0x22, 0x66, 0x64, 0xCC, 0xC0,
  0x3F, 0xB7, 0x5B, 0x29, 0xB4, 0xDE, 0x4F, 0x25, 0xB2, 0x3D, 0x96, 0x53,
  0x4F, 0x2C, 0xB6, 0x3D, 0xB6, 0x53, 0xCF, 0x3D, 0x9C, 0x1E, 0x64, 0xC9,
  0x12, 0x6C, 0xDB, 0x3E, 0x40, 0x83, 0x06, 0x00, 0x3E, 0xD9, 0x92, 0x6C,
  0xD9, 0xB6, 0x34, 0x18, 0x30, 0x40, 0x80, 0x3B, 0xD8, 0xC4, 0x63, 0x18,
  0x7B, 0x58, 0xE3, 0x0A, 0xDE, 0x31, 0x5C, 0xC6, 0x31, 0x08, 0xC3, 0x00,
  0x26, 0xC9, 0xB2, 0x64, 0xD9, 0x36, 0x34, 0x8C, 0xE5, 0x6A, 0x73, 0x18,
  0x99, 0xCD, 0xAE, 0xD5, 0x4A, 0xE6, 0x63, 0x31, 0xB0, 0x36, 0x68, 0x70,
  0xC3, 0x85, 0x1A, 0x66, 0x32, 0x6C, 0xD1, 0xE3, 0x85, 0x0E, 0x18, 0x30,
  0x43, 0x84, 0x00, 0x3C, 0x31, 0x84, 0x30, 0x86, 0x3E, 0x0C, 0x71, 0x0C,
  0x30, 0xCE, 0x38, 0x61, 0x86, 0x18, 0x60, 0xFF, 0xFC, 0x10, 0xE1, 0x86,
  0x18, 0x61, 0xC6, 0x30, 0xC2, 0x18, 0xE0, 0xFE, 0x60,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 5, 4, 6, 1, -11 },
  { 10, 7, 11, 7, 0, -11 },
  { 20, 7, 12, 6, 0, -11 },
  { 31, 9, 11, 10, 1, -11 },
  { 44, 7, 11, 7, 0, -11 },
  { 54, 3, 4, 3, 1, -11 },
  { 56, 5, 13, 4, 0, -11 },
  { 65, 5, 13, 4, -1, -11 },
  { 74, 6, 5, 6, 1, -11 },
  { 78, 6, 7, 7, 1, -9 },
  { 84, 3, 4, 3, -1, -2 },
  { 86, 4, 2, 4, 0, -5 },
  { 87, 2, 2, 3, 0, -2 },
  { 88, 8, 11, 5, -1, -11 },
  { 99, 6, 11, 6, 0, -11 },
  { 108, 5, 11, 6, 1, -11 },
  { 115, 7, 11, 6, -1, -11 },
  { 125, 6, 11, 6, 0, -11 },
  { 134, 6, 11, 6, 0, -11 },
  { 143, 6, 11, 6, 0, -11 },
  { 152, 7, 11, 6, 0, -11 },
  { 162, 7, 11, 6, 0, -11 },
  { 172, 6, 11, 6, 0, -11 },
  { 181, 6, 11, 6, 0, -11 },
  { 190, 3, 8, 3, 0, -8 },
  { 193, 4, 10, 3, -1, -8 },
  { 198, 6, 7, 7, 1, -9 },
  { 204, 6, 4, 7, 1, -7 },
  { 207, 6, 7, 7, 1, -9 },
  { 213, 5, 11, 5, 0, -11 },
  { 220, 9, 12, 9, 0, -11 },
  { 234, 7, 11, 7, -1, -11 },
  { 244, 7, 11, 7, 0, -11 },
  { 254, 6, 11, 6, 1, -11 },
  { 263, 7, 11, 7, 0, -11 },
  { 273, 7, 11, 6, 0, -11 },
  { 283, 7, 11, 6, 0, -11 },
  { 293, 7, 11, 8, 1, -11 },
  { 303, 8, 11, 8, 0, -11 },
  { 314, 7, 11, 4, -1, -11 },
  { 324, 6, 14, 3, -2, -11 },
  { 335, 8, 11, 7, 0, -11 },
  { 346, 5, 11, 6, 0, -11 },
  { 353, 11, 11, 10, 0, -11 },
  { 369, 9, 11, 8, 0, -11 },
  { 382, 7, 11, 8, 1, -11 },
  { 392, 7, 11, 7, 0, -11 },
  { 402, 7, 14, 8, 1, -11 },
  { 415, 7, 11, 7, 0, -11 },
  { 425, 7, 11, 6, 0, -11 },
  { 435, 6, 11, 6, 1, -11 },
  { 444, 7, 11, 7, 1, -11 },
  { 454, 7, 11, 7, 1, -11 },
  { 464, 10, 11, 10, 1, -11 },
  { 478, 8, 11, 6, -1, -11 },
  { 489, 6, 11, 6, 1, -11 },
  { 498, 8, 11, 6, -1, -11 },
  { 509, 6, 13, 4, -1, -11 },
  { 519, 3, 11, 5, 1, -11 },
  { 524, 6, 13, 4, -1, -11 },
  { 534, 6, 6, 6, 0, -11 },
  { 539, 5, 1, 5, -1, 1 },
  { 540, 3, 2, 4, 2, -11 },
  { 541, 7, 8, 7, 0, -8 },
  { 548, 6, 11, 7, 0, -11 },
  { 557, 6, 8, 5, 0, -8 },
  { 563, 7, 11, 7, 0, -11 },
  { 573, 6, 8, 6, 0, -8 },
  { 579, 8, 15, 4, -2, -11 },
  { 594, 7, 12, 7, 0, -8 },
  { 605, 6, 11, 7, 0, -11 },
  { 614, 4, 11, 3, 0, -11 },
  { 620, 6, 15, 3, -2, -11 },
  { 632, 7, 11, 6, 0, -11 },
  { 642, 4, 11, 3, 0, -11 },
  { 648, 9, 8, 10, 0, -8 },
  { 657, 6, 8, 7, 0, -8 },
  { 663, 6, 8, 6, 0, -8 },
  { 669, 7, 12, 7, -1, -8 },
  { 680, 7, 12, 7, 0, -8 },
  { 691, 5, 8, 5, 0, -8 },
  { 696, 5, 8, 5, 0, -8 },
  { 701, 5, 10, 4, 0, -10 },
  { 708, 7, 8, 7, 0, -8 },
  { 715, 5, 8, 6, 1, -8 },
  { 720, 9, 8, 9, 1, -8 },
  { 729, 7, 8, 6, -1, -8 },
  { 736, 7, 12, 6, -1, -8 },
  { 747, 6, 8, 5, -1, -8 },
  { 753, 6, 13, 5, 0, -11 },
  { 763, 1, 14, 6, 2, -11 },
  { 765, 6, 13, 5, -1, -11 },
  { 775, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC15PT7B_H_
