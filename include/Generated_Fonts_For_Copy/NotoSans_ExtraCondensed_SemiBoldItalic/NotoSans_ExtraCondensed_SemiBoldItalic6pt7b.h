#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC6PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0xC0, 0x7B, 0xE0, 0x4D, 0x2C, 0x6D, 0x77, 0x4B, 0xF0, 0x80,
  0x6A, 0x80, 0xF8, 0xB8, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x6A, 0x40, 0x57,
  0x60, 0xF0, 0xE9, 0x60, 0xE9, 0x60, 0x7B, 0x20, 0x79, 0x60, 0x7B, 0x60,
  0x69, 0x40, 0xEB, 0x60, 0xF5, 0x60, 0xA0, 0xB0, 0x39, 0x80, 0xFC, 0x8F,
  0x00, 0xDA, 0x7F, 0xEC, 0x7F, 0x6A, 0xE0, 0x72, 0x60, 0x76, 0xE0, 0x6A,
  0x60, 0x7A, 0x40, 0x72, 0xF0, 0x6E, 0xD0, 0x5A, 0x29, 0x2C, 0x6B, 0x60,
  0x6B, 0x55, 0xFD, 0x6E, 0xD0, 0x76, 0xE0, 0x77, 0x40, 0x76, 0xE4, 0x77,
  0x60, 0xE9, 0x60, 0xE9, 0x40, 0x76, 0xE0, 0xEA, 0xBD, 0xBD, 0x40, 0x69,
  0x60, 0xA9, 0x40, 0x6A, 0x60, 0x6A, 0x80, 0xF0, 0x56, 0x80, 0x54, 0xC0,
  0x80, 0xF7, 0x00, 0x4A, 0xDC, 0xEC, 0x2E, 0xDC, 0xEC, 0x25, 0x25, 0x80,
  0xFB, 0x60, 0x4A, 0xEC, 0x4A, 0x80, 0x21, 0x25, 0x80, 0x4D, 0x6C, 0x5A,
  0x80, 0xFD, 0xD0, 0xFC, 0xFC, 0xF7, 0x40, 0xF7, 0x20, 0xE8, 0xDC, 0x6A,
  0xBB, 0x00, 0xFA, 0x00, 0xDE, 0xA0, 0xEB, 0x00, 0x76, 0x4C, 0xEC, 0x5A,
  0x80, 0xFC, 0x56, 0x80, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 4, 1, 0, -4 },
  { 2, 2, 1, 2, 1, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 2, 0, -5 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 1, 1, 1, -4 },
  { 12, 2, 5, 2, 0, -4 },
  { 14, 1, 5, 2, 0, -4 },
  { 15, 2, 3, 2, 1, -5 },
  { 16, 3, 3, 3, 0, -4 },
  { 18, 1, 2, 1, 0, -1 },
  { 19, 2, 1, 2, 0, -2 },
  { 20, 1, 1, 1, 0, -1 },
  { 21, 3, 4, 2, 0, -4 },
  { 23, 3, 4, 2, 0, -4 },
  { 25, 1, 4, 3, 1, -4 },
  { 26, 3, 4, 2, 0, -4 },
  { 28, 3, 4, 2, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 2, 0, -4 },
  { 34, 3, 4, 2, 0, -4 },
  { 36, 3, 4, 2, 0, -4 },
  { 38, 3, 4, 2, 0, -4 },
  { 40, 3, 4, 2, 0, -4 },
  { 42, 1, 3, 1, 0, -3 },
  { 43, 1, 4, 1, 0, -3 },
  { 44, 3, 3, 3, 0, -4 },
  { 46, 3, 2, 3, 0, -3 },
  { 47, 3, 3, 3, 0, -4 },
  { 49, 2, 4, 2, 0, -4 },
  { 50, 4, 4, 4, 0, -4 },
  { 52, 2, 4, 3, 0, -4 },
  { 53, 3, 4, 3, 0, -4 },
  { 55, 3, 4, 3, 0, -4 },
  { 57, 3, 4, 3, 0, -4 },
  { 59, 3, 4, 2, 0, -4 },
  { 61, 3, 4, 2, 0, -4 },
  { 63, 3, 4, 3, 0, -4 },
  { 65, 3, 4, 3, 0, -4 },
  { 67, 2, 4, 2, 0, -4 },
  { 68, 3, 5, 1, -1, -4 },
  { 70, 3, 4, 3, 0, -4 },
  { 72, 2, 4, 2, 0, -4 },
  { 73, 4, 4, 4, 0, -4 },
  { 75, 3, 4, 3, 0, -4 },
  { 77, 3, 4, 3, 0, -4 },
  { 79, 3, 4, 3, 0, -4 },
  { 81, 3, 5, 3, 0, -4 },
  { 83, 3, 4, 3, 0, -4 },
  { 85, 3, 4, 2, 0, -4 },
  { 87, 3, 4, 2, 0, -4 },
  { 89, 3, 4, 3, 0, -4 },
  { 91, 2, 4, 3, 1, -4 },
  { 92, 5, 4, 4, 0, -4 },
  { 95, 3, 4, 2, 0, -4 },
  { 97, 3, 4, 2, 0, -4 },
  { 99, 3, 4, 2, 0, -4 },
  { 101, 2, 5, 2, 0, -4 },
  { 103, 1, 4, 2, 1, -4 },
  { 104, 2, 5, 2, 0, -4 },
  { 106, 3, 2, 3, 0, -4 },
  { 107, 2, 1, 2, -1, 0 },
  { 108, 1, 1, 2, 1, -5 },
  { 109, 3, 3, 3, 0, -3 },
  { 111, 3, 5, 3, 0, -5 },
  { 113, 2, 3, 2, 0, -3 },
  { 114, 3, 5, 3, 0, -5 },
  { 116, 2, 3, 2, 0, -3 },
  { 117, 3, 6, 2, -1, -5 },
  { 120, 3, 4, 3, 0, -3 },
  { 122, 3, 5, 3, 0, -5 },
  { 124, 2, 5, 1, 0, -5 },
  { 126, 3, 6, 1, -1, -5 },
  { 129, 3, 5, 2, 0, -5 },
  { 131, 2, 5, 1, 0, -5 },
  { 133, 4, 3, 4, 0, -3 },
  { 135, 2, 3, 3, 0, -3 },
  { 136, 2, 3, 3, 0, -3 },
  { 137, 3, 4, 3, 0, -3 },
  { 139, 3, 4, 3, 0, -3 },
  { 141, 2, 3, 2, 0, -3 },
  { 142, 2, 3, 2, 0, -3 },
  { 143, 2, 4, 2, 0, -4 },
  { 144, 3, 3, 3, 0, -3 },
  { 146, 3, 3, 2, 0, -3 },
  { 148, 4, 3, 4, 0, -3 },
  { 150, 3, 3, 2, 0, -3 },
  { 152, 4, 4, 2, -1, -3 },
  { 154, 2, 3, 2, 0, -3 },
  { 155, 2, 5, 2, 0, -4 },
  { 157, 1, 6, 2, 1, -5 },
  { 158, 2, 5, 2, 0, -4 },
  { 160, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic6pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC6PT7B_H_
