#ifndef _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC17PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-SemiBoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_SemiBoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x63, 0x11, 0x8C, 0x00, 0x31, 0x80, 0xDE, 0xF5, 0x20,
  0x0B, 0x1A, 0x12, 0x7F, 0x7F, 0x34, 0x24, 0xFE, 0x68, 0x48, 0x58, 0xD0,
  0x04, 0x18, 0xF9, 0x56, 0x86, 0x0E, 0x0E, 0x1C, 0x3B, 0x77, 0xC2, 0x04,
  0x00, 0x71, 0x94, 0xCD, 0x22, 0x58, 0x94, 0x2F, 0x7E, 0xAC, 0x6B, 0x16,
  0xCD, 0xA2, 0x69, 0x8C, 0x1E, 0x36, 0x36, 0x34, 0x3C, 0x38, 0x7B, 0x5A,
  0xCE, 0xCC, 0xDE, 0x76, 0xFE, 0x0C, 0x63, 0x0C, 0x61, 0x86, 0x10, 0xC3,
  0x0C, 0x30, 0xC1, 0x06, 0x00, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x19, 0x8C,
  0x46, 0x22, 0x00, 0x19, 0x4F, 0xCF, 0x79, 0x30, 0x80, 0x30, 0xC3, 0x3F,
  0xFC, 0xC3, 0x0C, 0x36, 0x6C, 0xF0, 0xF0, 0x03, 0x03, 0x06, 0x04, 0x0C,
  0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x1E, 0x6C, 0xDB, 0x36, 0x6C,
  0xD1, 0xE6, 0xCD, 0x9B, 0xE3, 0x80, 0x3B, 0xBD, 0x63, 0x11, 0x8C, 0x63,
  0x11, 0x80, 0x1F, 0x1B, 0x13, 0x03, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x30,
  0x7E, 0xFC, 0x3E, 0x4C, 0x18, 0x30, 0xC7, 0x0F, 0x06, 0x0C, 0x1B, 0xE7,
  0x80, 0x06, 0x1C, 0x38, 0xA3, 0xC5, 0x93, 0x66, 0xFE, 0x30, 0x60, 0xC0,
  0x3E, 0x7C, 0xC1, 0x07, 0x8F, 0x83, 0x06, 0x0C, 0x1B, 0xE7, 0x80, 0x0F,
  0x19, 0x30, 0x20, 0x6C, 0x7C, 0x66, 0xC6, 0xCC, 0xCC, 0x7C, 0x78, 0x3F,
  0x3F, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0xE0, 0x1E,
  0x6C, 0x99, 0x33, 0xC7, 0x1F, 0x66, 0xCD, 0x9B, 0x33, 0xC0, 0x1E, 0x6D,
  0x9B, 0x36, 0x6D, 0xDF, 0x9E, 0x0C, 0x32, 0xE7, 0x80, 0x33, 0x00, 0x00,
  0x0C, 0xC0, 0x18, 0xC0, 0x00, 0x00, 0x0E, 0x63, 0x30, 0x04, 0x77, 0xB8,
  0xE0, 0xE0, 0xC1, 0xFC, 0x00, 0x3F, 0xFC, 0x83, 0x87, 0x87, 0x1D, 0xCC,
  0x20, 0x7C, 0xB0, 0xC3, 0x18, 0xC2, 0x18, 0x00, 0x06, 0x30, 0x0F, 0x83,
  0x08, 0xC1, 0x13, 0xB6, 0x94, 0x96, 0x96, 0x92, 0x92, 0xD6, 0x9B, 0xF1,
  0x00, 0x20, 0x03, 0xE0, 0x06, 0x0E, 0x0E, 0x0A, 0x1A, 0x12, 0x32, 0x3E,
  0x7E, 0x62, 0x62, 0xC3, 0x3E, 0x37, 0x33, 0x33, 0x26, 0x7C, 0x6E, 0x66,
  0x66, 0xC6, 0xFC, 0xF8, 0x1E, 0x65, 0x83, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0xE3, 0xC0, 0x3E, 0x3F, 0x33, 0x33, 0x23, 0x63, 0x63, 0x63, 0x66,
  0xCE, 0xFC, 0xF8, 0x3E, 0x7C, 0xC1, 0x82, 0x0F, 0x9F, 0x30, 0x61, 0x83,
  0xE7, 0xC0, 0x3E, 0x7C, 0xC1, 0x82, 0x0F, 0x9F, 0x30, 0x61, 0x83, 0x06,
  0x00, 0x1F, 0x3B, 0x60, 0x60, 0xC0, 0xCE, 0xCE, 0xC6, 0xC6, 0xCC, 0xFC,
  0x7C, 0x31, 0x98, 0xCC, 0x66, 0x22, 0x33, 0xF9, 0xFC, 0xC6, 0x66, 0x63,
  0x31, 0x98, 0xC0, 0x1E, 0x18, 0x20, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x60,
  0xC7, 0xC0, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x10, 0x60,
  0xC1, 0x86, 0x3C, 0x00, 0x31, 0x99, 0x8D, 0x87, 0x82, 0xC3, 0xC1, 0xE0,
  0xD8, 0x6C, 0x26, 0x33, 0x19, 0xC0, 0x31, 0x8C, 0x62, 0x31, 0x8C, 0x66,
  0x3F, 0xF0, 0x38, 0x73, 0x87, 0x38, 0xE2, 0x8E, 0x29, 0xE6, 0x96, 0x6B,
  0x66, 0xB4, 0x4A, 0xC4, 0xEC, 0xCC, 0xCC, 0xCC, 0x38, 0xCE, 0x23, 0x98,
  0xA6, 0x29, 0x9B, 0x66, 0xD1, 0xBC, 0x4F, 0x11, 0xCC, 0x63, 0x18, 0x1E,
  0x37, 0x63, 0x63, 0xC3, 0xC3, 0xC6, 0xC6, 0xC6, 0xCC, 0xFC, 0x78, 0x3E,
  0x3F, 0x33, 0x33, 0x23, 0x66, 0x7C, 0x70, 0x60, 0xC0, 0xC0, 0xC0, 0x1E,
  0x37, 0x63, 0x63, 0xC3, 0xC3, 0xC6, 0xC6, 0xC6, 0xCC, 0xFC, 0x78, 0x38,
  0x18, 0x18, 0x3E, 0x37, 0x33, 0x33, 0x26, 0x6E, 0x7C, 0x68, 0x6C, 0x4C,
  0xCC, 0xCC, 0x1F, 0x3E, 0x60, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x0C, 0x0C,
  0xF8, 0xF0, 0x7F, 0xF8, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x60, 0xC3, 0x06,
  0x00, 0x63, 0x63, 0x62, 0x66, 0xC6, 0xC6, 0xC6, 0xCC, 0xCC, 0xCC, 0xF8,
  0xF8, 0xC3, 0x46, 0x46, 0x44, 0x4C, 0x4C, 0x58, 0x58, 0x50, 0x70, 0x60,
  0x60, 0xC6, 0x3C, 0x62, 0xCE, 0x6C, 0xE6, 0xCE, 0xCD, 0xEC, 0xD6, 0x8F,
  0x78, 0xF7, 0x8E, 0x70, 0xE7, 0x0C, 0x60, 0x19, 0x8D, 0x86, 0xC3, 0xC0,
  0xE0, 0x60, 0x70, 0x38, 0x34, 0x32, 0x19, 0x98, 0xC0, 0xC6, 0xC9, 0xB3,
  0x47, 0x8E, 0x1C, 0x30, 0x60, 0xC1, 0x86, 0x00, 0x1F, 0x03, 0x06, 0x06,
  0x0C, 0x0C, 0x18, 0x30, 0x30, 0x60, 0x7C, 0xFC, 0x1E, 0x30, 0x60, 0x81,
  0x06, 0x0C, 0x18, 0x20, 0x41, 0x83, 0x06, 0x0E, 0x3C, 0x00, 0x9B, 0x6D,
  0x92, 0x4D, 0xB0, 0x1C, 0x30, 0xC3, 0x08, 0x21, 0x86, 0x18, 0x43, 0x0C,
  0x33, 0xCE, 0x00, 0x0C, 0x38, 0x71, 0xA6, 0x6C, 0xF1, 0x80, 0x7F, 0xF0,
  0xEC, 0x80, 0x3B, 0x36, 0x66, 0x66, 0x46, 0xC4, 0xCC, 0xFC, 0x7C, 0x10,
  0x60, 0xC1, 0x82, 0xE6, 0xD9, 0xB3, 0x66, 0x8F, 0x37, 0x6F, 0x80, 0x3C,
  0xD6, 0x18, 0x43, 0x0C, 0x1A, 0x78, 0x01, 0x03, 0x03, 0x03, 0x3E, 0x36,
  0x66, 0x66, 0x46, 0xC4, 0xCC, 0xFC, 0x7C, 0x3C, 0x4D, 0x9B, 0x67, 0x98,
  0x30, 0x34, 0x78, 0x07, 0x07, 0x0C, 0x0C, 0x1E, 0x0C, 0x18, 0x18, 0x18,
  0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0xE0, 0xE0, 0x3F, 0x36, 0x66, 0x66,
  0x46, 0xC4, 0xCC, 0xFC, 0x7C, 0x0C, 0x18, 0xF8, 0xF0, 0x10, 0x60, 0xC1,
  0x82, 0xE6, 0xD9, 0xB3, 0x66, 0x8B, 0x36, 0x6C, 0xC0, 0x13, 0x00, 0x32,
  0x66, 0x64, 0xCC, 0xC0, 0x04, 0x30, 0x00, 0x0C, 0x21, 0x86, 0x18, 0x43,
  0x0C, 0x30, 0xC2, 0x38, 0xC0, 0x10, 0x30, 0x30, 0x31, 0x26, 0x2C, 0x6C,
  0x78, 0x78, 0x78, 0xD8, 0xCC, 0xCC, 0x19, 0x8C, 0x63, 0x11, 0x8C, 0x63,
  0x31, 0x8C, 0x00, 0x2F, 0xC6, 0xCD, 0x99, 0xB3, 0x26, 0x4C, 0x99, 0xB3,
  0x36, 0x64, 0xCD, 0x80, 0x2E, 0x6D, 0x9B, 0x36, 0x68, 0xB3, 0x66, 0xCC,
  0x3C, 0x6D, 0x9B, 0x34, 0x78, 0xF3, 0x3E, 0x78, 0x17, 0x1B, 0x33, 0x33,
  0x33, 0x33, 0x66, 0x76, 0x7C, 0x60, 0x40, 0xC0, 0xC0, 0x3F, 0x36, 0x66,
  0x66, 0x46, 0xC4, 0xCC, 0xFC, 0x7C, 0x0C, 0x08, 0x18, 0x18, 0x2C, 0xE6,
  0x18, 0x61, 0x8C, 0x30, 0xC0, 0x3D, 0x96, 0x1C, 0x30, 0x61, 0xAE, 0xF0,
  0x11, 0x9E, 0x46, 0x31, 0x8C, 0x46, 0x9C, 0x32, 0x4D, 0x9B, 0x36, 0x49,
  0xB3, 0x7E, 0x7C, 0xCF, 0x2D, 0xB6, 0xF3, 0xCE, 0x38, 0xC0, 0xCC, 0xF7,
  0x6D, 0xDB, 0x74, 0xFF, 0x3B, 0xCE, 0xE3, 0x38, 0xCC, 0x00, 0x33, 0x16,
  0x1C, 0x1C, 0x18, 0x3C, 0x3C, 0x6C, 0xCC, 0x33, 0x33, 0x36, 0x36, 0x34,
  0x3C, 0x38, 0x38, 0x30, 0x30, 0x30, 0xE0, 0xC0, 0x3E, 0x08, 0x30, 0xC1,
  0x86, 0x18, 0x3C, 0xF8, 0x0E, 0x38, 0x60, 0xC1, 0x06, 0x1C, 0x70, 0x60,
  0x41, 0x83, 0x06, 0x0E, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18,
  0x70, 0xC2, 0x18, 0x61, 0xC3, 0x18, 0xC3, 0x0C, 0x23, 0x8C, 0x00, 0xF6,
  0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_SemiBoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 5, 12, 4, 0, -12 },
  { 9, 5, 4, 6, 2, -12 },
  { 12, 8, 12, 8, 0, -12 },
  { 24, 7, 14, 7, 0, -13 },
  { 37, 10, 12, 11, 1, -12 },
  { 52, 8, 12, 8, 0, -12 },
  { 64, 2, 4, 4, 2, -12 },
  { 65, 6, 15, 5, 0, -12 },
  { 77, 5, 15, 5, -1, -12 },
  { 87, 6, 7, 7, 1, -13 },
  { 93, 6, 8, 8, 1, -10 },
  { 99, 4, 4, 4, -1, -2 },
  { 101, 4, 1, 5, 0, -5 },
  { 102, 2, 2, 4, 0, -2 },
  { 103, 8, 12, 6, -1, -12 },
  { 115, 7, 12, 7, 0, -12 },
  { 126, 5, 12, 7, 2, -12 },
  { 134, 8, 12, 7, -1, -12 },
  { 146, 7, 12, 7, 0, -12 },
  { 157, 7, 12, 7, 0, -12 },
  { 168, 7, 12, 7, 0, -12 },
  { 179, 8, 12, 7, 0, -12 },
  { 191, 8, 12, 7, 0, -12 },
  { 203, 7, 12, 7, 0, -12 },
  { 214, 7, 12, 7, 0, -12 },
  { 225, 4, 9, 4, 0, -9 },
  { 230, 5, 11, 4, -1, -9 },
  { 237, 6, 8, 8, 1, -10 },
  { 243, 6, 5, 8, 1, -8 },
  { 247, 6, 8, 8, 1, -10 },
  { 253, 6, 12, 5, 0, -12 },
  { 262, 11, 13, 11, 0, -12 },
  { 280, 8, 12, 8, -1, -12 },
  { 292, 8, 12, 8, 0, -12 },
  { 304, 7, 12, 7, 1, -12 },
  { 315, 8, 12, 8, 0, -12 },
  { 327, 7, 12, 7, 0, -12 },
  { 338, 7, 12, 6, 0, -12 },
  { 349, 8, 12, 9, 1, -12 },
  { 361, 9, 12, 9, 0, -12 },
  { 375, 7, 12, 5, -1, -12 },
  { 386, 7, 15, 4, -3, -12 },
  { 400, 9, 12, 7, 0, -12 },
  { 414, 5, 12, 6, 0, -12 },
  { 422, 12, 12, 12, 0, -12 },
  { 440, 10, 12, 9, 0, -12 },
  { 455, 8, 12, 9, 1, -12 },
  { 467, 8, 12, 7, 0, -12 },
  { 479, 8, 15, 9, 1, -12 },
  { 494, 8, 12, 8, 0, -12 },
  { 506, 8, 12, 7, 0, -12 },
  { 518, 7, 12, 6, 1, -12 },
  { 529, 8, 12, 8, 1, -12 },
  { 541, 8, 12, 8, 1, -12 },
  { 553, 12, 12, 12, 1, -12 },
  { 571, 9, 12, 7, -1, -12 },
  { 585, 7, 12, 7, 1, -12 },
  { 596, 8, 12, 6, -1, -12 },
  { 608, 7, 15, 5, -1, -12 },
  { 622, 3, 12, 6, 2, -12 },
  { 627, 6, 15, 5, -1, -12 },
  { 639, 7, 7, 7, 0, -12 },
  { 646, 6, 2, 5, -2, 1 },
  { 648, 3, 3, 5, 2, -13 },
  { 650, 8, 9, 8, 0, -9 },
  { 659, 7, 13, 8, 0, -13 },
  { 671, 6, 9, 6, 0, -9 },
  { 678, 8, 13, 8, 0, -13 },
  { 691, 7, 9, 7, 0, -9 },
  { 699, 8, 17, 4, -2, -13 },
  { 716, 8, 13, 8, 0, -9 },
  { 729, 7, 13, 8, 0, -13 },
  { 741, 4, 13, 4, 0, -13 },
  { 748, 6, 17, 4, -2, -13 },
  { 761, 8, 13, 7, 0, -13 },
  { 774, 5, 13, 4, 0, -13 },
  { 783, 11, 9, 11, 0, -9 },
  { 796, 7, 9, 8, 0, -9 },
  { 804, 7, 9, 7, 0, -9 },
  { 812, 8, 13, 8, -1, -9 },
  { 825, 8, 13, 8, 0, -9 },
  { 838, 6, 9, 5, 0, -9 },
  { 845, 6, 9, 6, 0, -9 },
  { 852, 5, 11, 5, 0, -11 },
  { 859, 7, 9, 7, 0, -9 },
  { 867, 6, 9, 6, 1, -9 },
  { 874, 10, 9, 10, 1, -9 },
  { 886, 8, 9, 7, -1, -9 },
  { 895, 8, 13, 6, -1, -9 },
  { 908, 7, 9, 5, -1, -9 },
  { 916, 7, 15, 6, 0, -12 },
  { 930, 2, 17, 6, 2, -13 },
  { 935, 6, 15, 6, -1, -12 },
  { 947, 6, 2, 8, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_SemiBoldItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_SemiBoldItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_SemiBoldItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_EXTRACONDENSED_SEMIBOLDITALIC17PT7B_H_
