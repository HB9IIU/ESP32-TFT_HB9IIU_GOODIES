#ifndef _JETBRAINSMONO_SEMIBOLDITALIC10PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x88, 0xB6, 0x80, 0x35, 0xF2, 0x92, 0xF9, 0x49, 0x00, 0x10,
  0x43, 0xD5, 0x70, 0xE2, 0xBA, 0x70, 0x80, 0x77, 0x31, 0xC1, 0x03, 0xCA,
  0xA6, 0x00, 0x39, 0x02, 0x19, 0xDA, 0x4E, 0x80, 0xE0, 0x19, 0x10, 0x84,
  0x21, 0x08, 0x20, 0x62, 0x33, 0x22, 0x24, 0x80, 0x11, 0x5F, 0x8C, 0x58,
  0x21, 0x3E, 0xC4, 0x00, 0x6B, 0x40, 0xF0, 0xB0, 0x04, 0x20, 0x84, 0x30,
  0x86, 0x10, 0xC0, 0x3D, 0x14, 0xDE, 0x49, 0x27, 0x00, 0x3A, 0x84, 0x21,
  0x0B, 0xE0, 0x39, 0x30, 0x86, 0x31, 0x0F, 0x80, 0x7C, 0x63, 0x02, 0x0B,
  0x27, 0x00, 0x0C, 0x42, 0x12, 0x7B, 0xE0, 0x80, 0x7C, 0x2D, 0xA1, 0x4B,
  0x80, 0x19, 0x8C, 0xD4, 0xE5, 0xC0, 0xFC, 0xC4, 0x42, 0x23, 0x00, 0x3D,
  0x36, 0x8E, 0x49, 0x27, 0x00, 0x7C, 0x67, 0xE3, 0x33, 0x00, 0x70, 0xB0,
  0x2C, 0x06, 0xB4, 0x0B, 0xA1, 0x83, 0x00, 0xF8, 0x3C, 0x41, 0x82, 0x7E,
  0x00, 0x70, 0x84, 0xC4, 0x03, 0x00, 0x3D, 0x15, 0xE9, 0xA6, 0xA9, 0x20,
  0x60, 0x19, 0x4A, 0xD7, 0xA6, 0x20, 0x7D, 0x14, 0x9E, 0x49, 0x2F, 0x00,
  0x7C, 0x61, 0x08, 0x4B, 0x80, 0x79, 0x34, 0xD2, 0x49, 0x2F, 0x00, 0x7D,
  0x04, 0x1E, 0x41, 0x0F, 0x80, 0x7D, 0x04, 0x1E, 0x41, 0x0C, 0x00, 0x7C,
  0x61, 0x69, 0x4B, 0x80, 0x65, 0x34, 0x9E, 0x49, 0x2C, 0x80, 0x7C, 0x41,
  0x04, 0x30, 0x8F, 0x80, 0x1C, 0x20, 0x82, 0x0A, 0x27, 0x00, 0x65, 0x25,
  0x9C, 0x51, 0x2C, 0x80, 0x4C, 0xC8, 0x88, 0xF0, 0x6D, 0xB7, 0x5F, 0x4B,
  0x28, 0x80, 0x65, 0x96, 0xD6, 0x59, 0x69, 0x80, 0x74, 0xE7, 0x29, 0x4B,
  0x80, 0x7D, 0x14, 0x5E, 0x41, 0x0C, 0x00, 0x3D, 0x14, 0xD2, 0x49, 0x27,
  0x04, 0x18, 0x7D, 0x14, 0xDE, 0x51, 0x6C, 0x80, 0x3D, 0x16, 0x0E, 0x0B,
  0x27, 0x00, 0xF9, 0x08, 0x46, 0x21, 0x00, 0x65, 0x14, 0xD2, 0x49, 0x27,
  0x00, 0x8C, 0xF5, 0xA6, 0x31, 0x80, 0xAE, 0xAE, 0xBA, 0xF2, 0xCB, 0x00,
  0x6C, 0xA3, 0x0C, 0x31, 0x6C, 0x80, 0x8A, 0x94, 0xC6, 0x21, 0x00, 0x7C,
  0x21, 0x0C, 0x21, 0x0F, 0x80, 0x36, 0x44, 0x44, 0x44, 0xE0, 0xC4, 0x46,
  0x22, 0x22, 0x30, 0x71, 0x32, 0x22, 0x22, 0xE0, 0x35, 0xD9, 0xF8, 0xB0,
  0x3D, 0xA4, 0x92, 0x49, 0xE0, 0x61, 0x46, 0x92, 0x49, 0x2F, 0x00, 0x26,
  0xA1, 0x09, 0x70, 0x04, 0xF6, 0x92, 0x49, 0x27, 0x80, 0x2D, 0x9F, 0x9E,
  0x0E, 0x10, 0xF8, 0x81, 0x02, 0x04, 0x18, 0xE0, 0x7E, 0xA5, 0x2B, 0x68,
  0xDC, 0x61, 0x46, 0x92, 0x49, 0x2C, 0x80, 0x18, 0x9C, 0xE1, 0x08, 0xDF,
  0x08, 0x4E, 0xF1, 0x88, 0x42, 0x37, 0x00, 0x61, 0x14, 0x94, 0x71, 0x4C,
  0x80, 0xE6, 0x44, 0x44, 0x70, 0x69, 0x55, 0x5A, 0xAA, 0xA0, 0x51, 0xA4,
  0x92, 0x4B, 0x20, 0x2D, 0x99, 0x9E, 0x51, 0xA4, 0x92, 0x4B, 0xC8, 0x20,
  0x3D, 0xA4, 0x92, 0x49, 0xE0, 0x86, 0xF6, 0xE7, 0x08, 0x40, 0x31, 0xA4,
  0x0E, 0x89, 0xE0, 0x27, 0xFE, 0x84, 0x21, 0xC0, 0x9C, 0xA5, 0x29, 0x70,
  0x8C, 0xA5, 0x66, 0x30, 0xAD, 0x7B, 0xEB, 0x58, 0x45, 0xA3, 0x0C, 0x73,
  0x20, 0x9C, 0xA5, 0x2B, 0x28, 0xDC, 0x7D, 0xE1, 0x08, 0x43, 0xE0, 0x19,
  0x08, 0x4C, 0x10, 0x8C, 0x30, 0x55, 0x7A, 0x80, 0x30, 0x8C, 0x61, 0x90,
  0x84, 0xC0, 0x65, 0x59, 0x80,
};

const GFXglyph JetBrainsMono_SemiBoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 3, 3, 6, 2, -7 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 6, 10, 6, 0, -9 },
  { 19, 7, 7, 6, 0, -7 },
  { 26, 6, 7, 6, 0, -7 },
  { 32, 1, 3, 6, 3, -7 },
  { 33, 5, 9, 6, 1, -8 },
  { 39, 4, 9, 6, 1, -8 },
  { 44, 6, 5, 6, 0, -6 },
  { 48, 5, 5, 6, 1, -6 },
  { 52, 3, 4, 6, 1, -2 },
  { 54, 4, 1, 6, 1, -4 },
  { 55, 2, 2, 6, 2, -2 },
  { 56, 6, 9, 6, 0, -8 },
  { 63, 6, 7, 6, 0, -7 },
  { 69, 5, 7, 6, 0, -7 },
  { 74, 6, 7, 6, 0, -7 },
  { 80, 6, 7, 6, 0, -7 },
  { 86, 6, 7, 6, 0, -7 },
  { 92, 5, 7, 6, 1, -7 },
  { 97, 5, 7, 6, 0, -7 },
  { 102, 5, 7, 6, 1, -7 },
  { 107, 6, 7, 6, 0, -7 },
  { 113, 5, 7, 6, 1, -7 },
  { 118, 2, 6, 6, 2, -6 },
  { 120, 3, 8, 6, 1, -6 },
  { 123, 5, 5, 6, 1, -6 },
  { 127, 5, 3, 6, 1, -5 },
  { 129, 5, 5, 6, 0, -6 },
  { 133, 5, 7, 6, 1, -7 },
  { 138, 6, 9, 6, 0, -7 },
  { 145, 5, 7, 6, 0, -7 },
  { 150, 6, 7, 6, 0, -7 },
  { 156, 5, 7, 6, 1, -7 },
  { 161, 6, 7, 6, 0, -7 },
  { 167, 6, 7, 6, 0, -7 },
  { 173, 6, 7, 6, 0, -7 },
  { 179, 5, 7, 6, 1, -7 },
  { 184, 6, 7, 6, 0, -7 },
  { 190, 6, 7, 6, 0, -7 },
  { 196, 6, 7, 6, 0, -7 },
  { 202, 6, 7, 6, 0, -7 },
  { 208, 4, 7, 6, 1, -7 },
  { 212, 6, 7, 6, 0, -7 },
  { 218, 6, 7, 6, 0, -7 },
  { 224, 5, 7, 6, 1, -7 },
  { 229, 6, 7, 6, 0, -7 },
  { 235, 6, 9, 6, 0, -7 },
  { 242, 6, 7, 6, 0, -7 },
  { 248, 6, 7, 6, 0, -7 },
  { 254, 5, 7, 6, 1, -7 },
  { 259, 6, 7, 6, 0, -7 },
  { 265, 5, 7, 6, 1, -7 },
  { 270, 6, 7, 6, 1, -7 },
  { 276, 6, 7, 6, 0, -7 },
  { 282, 5, 7, 6, 1, -7 },
  { 287, 6, 7, 6, 0, -7 },
  { 293, 4, 9, 6, 1, -8 },
  { 298, 4, 9, 6, 1, -8 },
  { 303, 4, 9, 6, 1, -8 },
  { 308, 4, 4, 6, 1, -7 },
  { 310, 5, 1, 6, 0, 0 },
  { 311, 2, 2, 6, 3, -8 },
  { 312, 6, 6, 6, 0, -6 },
  { 317, 6, 7, 6, 0, -7 },
  { 323, 5, 6, 6, 1, -6 },
  { 327, 6, 7, 6, 0, -7 },
  { 333, 4, 6, 6, 1, -6 },
  { 336, 7, 9, 6, -1, -7 },
  { 344, 5, 8, 6, 1, -6 },
  { 349, 6, 7, 6, 0, -7 },
  { 355, 5, 8, 6, 0, -8 },
  { 360, 5, 10, 6, 0, -8 },
  { 367, 6, 7, 6, 0, -7 },
  { 373, 4, 7, 6, 1, -7 },
  { 377, 6, 6, 6, 0, -6 },
  { 382, 6, 6, 6, 0, -6 },
  { 387, 4, 6, 6, 1, -6 },
  { 390, 6, 8, 6, 0, -6 },
  { 396, 6, 8, 6, 0, -6 },
  { 402, 5, 6, 6, 1, -6 },
  { 406, 6, 6, 6, 0, -6 },
  { 411, 5, 7, 6, 1, -7 },
  { 416, 5, 6, 6, 1, -6 },
  { 420, 5, 6, 6, 1, -6 },
  { 424, 5, 6, 6, 1, -6 },
  { 428, 6, 6, 6, 0, -6 },
  { 433, 5, 8, 6, 1, -6 },
  { 438, 6, 6, 6, 0, -6 },
  { 443, 5, 9, 6, 1, -8 },
  { 449, 2, 9, 6, 2, -8 },
  { 452, 5, 9, 6, 0, -8 },
  { 458, 6, 3, 6, 0, -5 },
};

const GFXfont JetBrainsMono_SemiBoldItalic10pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic10pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC10PT7B_H_
