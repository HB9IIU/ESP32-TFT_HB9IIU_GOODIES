#ifndef _JETBRAINSMONO_SEMIBOLDITALIC63PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x01, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x7F, 0x03, 0xFD, 0xFE, 0x07, 0xFB,
  0xFC, 0x0F, 0xE7, 0xF8, 0x1F, 0xCF, 0xF0, 0x3F, 0x9F, 0xC0, 0xFF, 0x3F,
  0x81, 0xFE, 0x7F, 0x03, 0xFD, 0xFE, 0x07, 0xF3, 0xFC, 0x0F, 0xE7, 0xF0,
  0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x01,
  0xF8, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0xE7, 0xFE, 0x01,
  0xFE, 0x3C, 0x7F, 0xC0, 0x7F, 0x87, 0x87, 0xF8, 0x0F, 0xF0, 0xF0, 0x7F,
  0x01, 0xFC, 0x1E, 0x0F, 0xE0, 0x3F, 0x83, 0xC1, 0xFC, 0x0F, 0xF0, 0x70,
  0x00, 0x01, 0xFE, 0x1E, 0x00, 0x00, 0x3F, 0xC3, 0xC0, 0x00, 0x07, 0xF8,
  0x78, 0x00, 0x00, 0xFF, 0x8F, 0x00, 0x00, 0x0F, 0xF9, 0xE0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1E, 0xFF, 0xE0, 0x00, 0x03, 0xC7, 0xFC, 0x00,
  0x00, 0x78, 0x7F, 0x80, 0x00, 0x0F, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0xFE,
  0x00, 0x00, 0x78, 0x1F, 0xC0, 0x00, 0x0F, 0x03, 0xF8, 0x3F, 0x81, 0xE0,
  0x7F, 0x07, 0xF0, 0x3C, 0x1F, 0xE0, 0xFF, 0x07, 0x83, 0xF8, 0x1F, 0xE0,
  0xF0, 0xFF, 0x03, 0xFE, 0x3C, 0x3F, 0xE0, 0x7F, 0xE7, 0x9F, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF0,
  0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x3F, 0x07, 0xC0,
  0x00, 0x3F, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0x87, 0xE0, 0x00,
  0x0F, 0xC0, 0xFC, 0x7E, 0x00, 0x00, 0x7F, 0x0F, 0xE7, 0xE0, 0x00, 0x01,
  0xFF, 0xFE, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xE3, 0xE0, 0x00, 0x00, 0x3F,
  0xFE, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xFC,
  0x00, 0x00, 0x01, 0xF9, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0xFF, 0xC0,
  0x00, 0x01, 0xF8, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x8F, 0xC1, 0xF8, 0x00,
  0x00, 0xF8, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x87, 0xE0, 0x3E, 0x00, 0x00,
  0xFC, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0xC1, 0xF0, 0x0F, 0x80, 0x00, 0xFC,
  0x0F, 0x80, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x00, 0x7C, 0x07,
  0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF8,
  0x0F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x0F, 0xF1, 0xFF, 0x7F, 0x00, 0xFE, 0x1F, 0xC7, 0xF8,
  0x1F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xFC, 0x7F, 0x83, 0xF8,
  0x1F, 0xE7, 0xF0, 0x3F, 0x80, 0xFE, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xE0,
  0x7F, 0x00, 0x7F, 0xFC, 0x07, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0x3F,
  0xF8, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x9F, 0xC0, 0x3F, 0xFF, 0xF1, 0xFE, 0x01, 0xFF,
  0xFE, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3F, 0xCF, 0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F,
  0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC0,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x18, 0x01, 0xF8, 0x01, 0x8F, 0x80, 0x7C, 0x03, 0xE3, 0xFC,
  0x1F, 0x07, 0xF9, 0xFF, 0x87, 0xC7, 0xFE, 0x7F, 0xF9, 0xE3, 0xFF, 0xBF,
  0xFF, 0x7B, 0xFF, 0xF7, 0xFF, 0xED, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x81,
  0xFE, 0x3F, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE7,
  0xFC, 0x7F, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x03,
  0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x0F, 0xE1, 0xFC, 0x3E, 0x07, 0xF0, 0xFE, 0x3F, 0x83, 0xF8, 0x7F,
  0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0x87, 0xF8, 0xFE, 0x1F,
  0xC3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0x3C, 0x1F, 0xC3,
  0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x5A, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xCF, 0xE0, 0x07, 0xFE, 0x3F, 0x80, 0x1F, 0xE1, 0xFE, 0x00,
  0x7F, 0x07, 0xF8, 0x01, 0xF0, 0x1F, 0xE0, 0x07, 0x80, 0x7F, 0x00, 0x18,
  0x01, 0xFC, 0x00, 0x40, 0x07, 0xF0, 0x02, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x07,
  0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x08, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x02, 0x03, 0xFE, 0x01,
  0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x01,
  0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0xFF, 0x80, 0x07, 0xF9, 0xFF, 0xF0, 0x03, 0xF9, 0xFF, 0xFC, 0x01,
  0xFD, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0xC0, 0x03,
  0xFD, 0xFF, 0xF0, 0x03, 0xFB, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xF8, 0x03, 0xFE, 0x1F,
  0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F,
  0x80, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F,
  0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x7F,
  0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x01, 0xFC,
  0x7F, 0x80, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x04, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFF,
  0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3A, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x03,
  0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x03,
  0xFC, 0x7F, 0x80, 0x07, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0x9F, 0xC0, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x03,
  0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x1F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x1E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xE0, 0xFC, 0x1F, 0x80, 0x1F,
  0xF1, 0xF8, 0x3F, 0x00, 0x7F, 0xF3, 0xF0, 0x7E, 0x01, 0xFF, 0xF7, 0xC0,
  0xFC, 0x07, 0xFF, 0xEF, 0x81, 0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F,
  0x80, 0xFE, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x1F, 0x81, 0xFC, 0x03, 0xF8,
  0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0x1F, 0x83, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0xFE, 0x01, 0xFC, 0x1F, 0x81, 0xF8, 0x03, 0xF8, 0x3F, 0x03,
  0xF0, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x3F, 0x00, 0xFE, 0x0F, 0xC0,
  0x7E, 0x03, 0xFC, 0x1F, 0x80, 0xFF, 0x0F, 0xF0, 0x3F, 0x01, 0xFF, 0xFB,
  0xE0, 0x7E, 0x01, 0xFF, 0xE7, 0xC1, 0xFC, 0x03, 0xFF, 0x9F, 0x83, 0xF0,
  0x01, 0xFE, 0x3F, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00,
  0x3F, 0x8F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xE0,
  0x01, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x80,
  0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x9F, 0xE0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xF7, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0xF0, 0x1F, 0xE0,
  0x03, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x0F,
  0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x0F,
  0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07,
  0xF8, 0x0F, 0xE0, 0x03, 0xFF, 0x03, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x03,
  0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x07, 0xFE, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0xC0,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80,
  0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x03,
  0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x10, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFE, 0x0F,
  0xF0, 0x3F, 0xFF, 0x83, 0xFC, 0x1F, 0xFF, 0xE0, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0x81, 0xFF, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xC0,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x07, 0xF8,
  0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0xFF, 0x80, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x0F, 0x9F, 0x03, 0xEF,
  0xC0, 0x3E, 0x7C, 0x0F, 0xBF, 0x00, 0xF9, 0xF0, 0x7C, 0xFC, 0x07, 0xE7,
  0xC1, 0xF3, 0xF0, 0x1F, 0x9F, 0x0F, 0x9F, 0x80, 0x7E, 0x7C, 0x3E, 0x7E,
  0x01, 0xF9, 0xF1, 0xF9, 0xF8, 0x07, 0xE3, 0xE7, 0xC7, 0xE0, 0x1F, 0x8F,
  0x9F, 0x3F, 0x80, 0xFE, 0x3E, 0xF8, 0xFE, 0x03, 0xF8, 0xFB, 0xE3, 0xF0,
  0x0F, 0xE3, 0xFF, 0x0F, 0xC0, 0x3F, 0x8F, 0xFC, 0x7F, 0x00, 0xFC, 0x3F,
  0xE1, 0xFC, 0x03, 0xF0, 0x7F, 0x87, 0xF0, 0x1F, 0xC1, 0xFE, 0x1F, 0xC0,
  0x7F, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0x00,
  0xFC, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0xC0, 0x07, 0xF0, 0x1F, 0xF8,
  0x00, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xF0, 0x03, 0xF0, 0x1F,
  0xFE, 0x00, 0x7E, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0xF8, 0x03, 0xF8,
  0x0F, 0xFF, 0x00, 0x7F, 0x01, 0xFB, 0xF0, 0x0F, 0xE0, 0x7F, 0x7E, 0x01,
  0xFC, 0x0F, 0xEF, 0xC0, 0x3F, 0x01, 0xFD, 0xF8, 0x0F, 0xE0, 0x3F, 0x3F,
  0x01, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x80, 0xFC, 0x7E, 0x07, 0xF0, 0x3F,
  0x8F, 0xC0, 0xFE, 0x07, 0xF1, 0xF8, 0x1F, 0x80, 0xFE, 0x3F, 0x03, 0xF0,
  0x1F, 0xC3, 0xE0, 0xFE, 0x03, 0xF8, 0x7E, 0x1F, 0xC0, 0x7E, 0x0F, 0xC3,
  0xF8, 0x1F, 0xC1, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x0F, 0xC0, 0x7F, 0x07,
  0xE1, 0xF8, 0x0F, 0xE0, 0x7E, 0x7F, 0x01, 0xFC, 0x0F, 0xCF, 0xE0, 0x3F,
  0x01, 0xF9, 0xFC, 0x07, 0xE0, 0x3F, 0x3F, 0x81, 0xFC, 0x07, 0xE7, 0xE0,
  0x3F, 0x80, 0x7E, 0xFC, 0x07, 0xF0, 0x0F, 0xDF, 0x80, 0xFE, 0x01, 0xFB,
  0xF0, 0x1F, 0x80, 0x3F, 0x7E, 0x03, 0xF0, 0x07, 0xEF, 0xC0, 0xFE, 0x00,
  0x7F, 0xF8, 0x1F, 0xC0, 0x0F, 0xFE, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0x00, 0x3F, 0xF8, 0x0F, 0xE0, 0x07, 0xFF, 0x01, 0xF8, 0x00, 0x7F, 0xE0,
  0x7F, 0x00, 0x0F, 0xFC, 0x0F, 0xE0, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x5A, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x07, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFF,
  0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x01,
  0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x80,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x5F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xD0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xF1, 0xFC, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xF9, 0xF8,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0xFC,
  0x7E, 0x01, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F,
  0xC0, 0x7E, 0x3F, 0x80, 0xFF, 0x01, 0xF8, 0xFE, 0x03, 0xFC, 0x0F, 0xE3,
  0xF8, 0x1E, 0xE0, 0x3F, 0x0F, 0xC0, 0x7F, 0x80, 0xFC, 0x3F, 0x01, 0xFE,
  0x03, 0xF0, 0xFC, 0x0F, 0xF8, 0x1F, 0xC3, 0xF0, 0x3D, 0xE0, 0x7E, 0x0F,
  0xC0, 0xF7, 0x81, 0xF8, 0x3F, 0x03, 0xDE, 0x07, 0xE0, 0xFC, 0x1F, 0x78,
  0x3F, 0x83, 0xF0, 0x79, 0xE0, 0xFC, 0x0F, 0xC1, 0xE7, 0x83, 0xF0, 0x3F,
  0x07, 0x9E, 0x0F, 0xC0, 0xFC, 0x3C, 0x78, 0x7F, 0x03, 0xF0, 0xF1, 0xE1,
  0xF8, 0x0F, 0xC3, 0xC7, 0x87, 0xE0, 0x3F, 0x1F, 0x1E, 0x1F, 0x80, 0xFC,
  0x78, 0x78, 0xFC, 0x07, 0xE1, 0xE1, 0xE3, 0xF0, 0x1F, 0x87, 0x87, 0x8F,
  0xC0, 0x7E, 0x3C, 0x1E, 0x3F, 0x01, 0xF8, 0xF0, 0xF9, 0xF8, 0x07, 0xE3,
  0xC3, 0xE7, 0xE0, 0x1F, 0x9F, 0x0F, 0x1F, 0x80, 0x7E, 0x78, 0x3C, 0x7E,
  0x01, 0xF9, 0xE0, 0xF3, 0xF0, 0x07, 0xE7, 0x83, 0xCF, 0xC0, 0x1F, 0xBE,
  0x0F, 0x3F, 0x00, 0x7E, 0xF0, 0x3C, 0xF8, 0x01, 0xFB, 0xC0, 0xF7, 0xE0,
  0x07, 0xEF, 0x03, 0xDF, 0x80, 0x1F, 0xF8, 0x0F, 0x7E, 0x00, 0x7D, 0xE0,
  0x3D, 0xF0, 0x01, 0xF7, 0x80, 0xF7, 0xC0, 0x07, 0xDE, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x9F, 0xC0,
  0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0x07, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFE,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xF0, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0xE0,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xDF,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x87,
  0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xE0,
  0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xF8, 0x00,
  0x7F, 0x1F, 0xC0, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0xFC,
  0x7F, 0x00, 0xFF, 0xFE, 0x7F, 0x01, 0xFF, 0xFE, 0x7F, 0x03, 0xFF, 0xFF,
  0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0xF8, 0x03,
  0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01,
  0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01,
  0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03,
  0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07,
  0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xF0, 0x7F, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xEF,
  0xF0, 0x1F, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF, 0x8F, 0xE0, 0x07, 0xFE, 0x0F,
  0xE0, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x3F, 0x8F, 0xFF, 0x00, 0x3F,
  0xCF, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xF0, 0x0F, 0xEF, 0xFF, 0xFC, 0x07,
  0xF7, 0xFF, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8,
  0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xE0,
  0x3F, 0xE0, 0x7F, 0x7F, 0xFF, 0xF0, 0x3F, 0xBF, 0xFF, 0xF0, 0x1F, 0xDF,
  0xFF, 0xF0, 0x0F, 0xE7, 0xFF, 0xF0, 0x0F, 0xF1, 0xFF, 0xF0, 0x07, 0xF8,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x0F,
  0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F,
  0xFC, 0x7F, 0x00, 0x3F, 0xFF, 0x9F, 0xC0, 0x1F, 0xFF, 0xE7, 0xF0, 0x0F,
  0xFF, 0xFD, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0xC0,
  0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xE0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC,
  0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xFF, 0xF7,
  0xF0, 0x0F, 0xFF, 0xFD, 0xFC, 0x03, 0xFF, 0xFE, 0xFF, 0x00, 0x7F, 0xFF,
  0x3F, 0x80, 0x0F, 0xFF, 0x8F, 0xE0, 0x01, 0xFF, 0x83, 0xF8, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xE0,
  0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x7F, 0x9F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x11, 0xFC, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0xFF,
  0xF1, 0xFC, 0x07, 0xFF, 0xF3, 0xF8, 0x1F, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF,
  0xEF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0x07, 0xFF, 0x8F, 0xF8, 0x03,
  0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F,
  0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F,
  0x80, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xF1, 0xFF, 0x80, 0xFF, 0xC1, 0xFF,
  0xEF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0xFE, 0x07, 0xFF,
  0xF9, 0xFC, 0x07, 0xFF, 0xE7, 0xF8, 0x07, 0xFF, 0x8F, 0xF0, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x3F, 0x8F, 0xFF, 0x80, 0x3F,
  0xCF, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xF0, 0x0F, 0xEF, 0xFF, 0xFC, 0x07,
  0xF7, 0xFF, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8,
  0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xE3, 0xF0, 0x3F, 0x00, 0xFC, 0xFF, 0x0F, 0xF0, 0x1F, 0xBF, 0xF3,
  0xFF, 0x03, 0xFF, 0xFE, 0xFF, 0xF0, 0xFF, 0xFF, 0xDF, 0xFE, 0x1F, 0xE1,
  0xFE, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x03, 0xE0, 0x7F, 0x0F,
  0xC0, 0x7C, 0x0F, 0xE1, 0xF8, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x3F,
  0x0F, 0xE0, 0x7E, 0x07, 0xE1, 0xFC, 0x0F, 0x80, 0xFC, 0x3F, 0x81, 0xF0,
  0x3F, 0x87, 0xF0, 0x3E, 0x07, 0xF0, 0xFC, 0x07, 0xC0, 0xFE, 0x1F, 0x81,
  0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x03, 0xF0, 0xFE, 0x07, 0xC0, 0x7E, 0x1F,
  0xC0, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0x03, 0xF8, 0x7E, 0x03, 0xE0, 0x7F,
  0x0F, 0xC0, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0x81, 0xF8, 0x7F, 0x03, 0xF0,
  0x3F, 0x0F, 0xE0, 0x7C, 0x07, 0xE1, 0xFC, 0x0F, 0x81, 0xFC, 0x3F, 0x01,
  0xF0, 0x3F, 0x87, 0xE0, 0x7E, 0x07, 0xF0, 0xFC, 0x0F, 0xC0, 0xFC, 0x3F,
  0x81, 0xF8, 0x1F, 0x87, 0xF0, 0x3E, 0x03, 0xF0, 0xFE, 0x07, 0xC0, 0xFE,
  0x1F, 0xC0, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x3F, 0xE0, 0x01, 0xFC, 0x7F, 0xFC, 0x01, 0xFE, 0x7F, 0xFF, 0x00, 0xFE,
  0x7F, 0xFF, 0x80, 0x7F, 0x7F, 0xFF, 0xE0, 0x3F, 0xBF, 0xFF, 0xF0, 0x1F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xF8,
  0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0x83, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0,
  0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xF1, 0xFC, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x00,
  0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x87,
  0xFE, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0x68, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xF8, 0x00,
  0x1F, 0xC7, 0xFF, 0xC0, 0x07, 0xF9, 0xFF, 0xFC, 0x00, 0xFE, 0x7F, 0xFF,
  0x80, 0x1F, 0xDF, 0xFF, 0xF8, 0x03, 0xFB, 0xFF, 0xFF, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xC0, 0x3F, 0xBF, 0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xFE, 0x00, 0xFE,
  0xFF, 0xFF, 0x80, 0x1F, 0xCF, 0xFF, 0xE0, 0x07, 0xF8, 0xFF, 0xF8, 0x00,
  0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x38, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0xFC,
  0x7F, 0x00, 0xFF, 0xFE, 0x7F, 0x01, 0xFF, 0xFE, 0x7F, 0x03, 0xFF, 0xFF,
  0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xF8, 0x03,
  0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01,
  0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01,
  0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03,
  0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07,
  0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xF0, 0x7F, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xEF,
  0xF0, 0x1F, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF, 0x8F, 0xE0, 0x07, 0xFE, 0x0F,
  0xE0, 0x00, 0x70, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x3F,
  0xE0, 0x01, 0xFC, 0x7F, 0xFC, 0x00, 0xFE, 0x7F, 0xFF, 0x00, 0xFE, 0x7F,
  0xFF, 0xC0, 0x7F, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x87, 0xF8,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8,
  0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xF8,
  0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xF0,
  0x0F, 0xE0, 0x3F, 0x7E, 0x01, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0x80, 0xFD,
  0xF8, 0x0F, 0xF0, 0x1F, 0x3F, 0x01, 0xDE, 0x07, 0xE7, 0xE0, 0x7B, 0xC0,
  0xFC, 0xFC, 0x0F, 0x78, 0x1F, 0x1F, 0x81, 0xEF, 0x07, 0xE3, 0xF0, 0x79,
  0xE0, 0xFC, 0x7E, 0x0F, 0x3C, 0x1F, 0x0F, 0xC1, 0xE7, 0x87, 0xE1, 0xF8,
  0x78, 0xF0, 0xFC, 0x3F, 0x0F, 0x1E, 0x1F, 0x87, 0xE1, 0xE3, 0xC7, 0xE0,
  0xFC, 0x78, 0x78, 0xFC, 0x1F, 0x8F, 0x0F, 0x1F, 0x83, 0xF1, 0xE1, 0xE3,
  0xE0, 0x7E, 0x7C, 0x7C, 0xFC, 0x0F, 0xCF, 0x0F, 0x9F, 0x81, 0xF9, 0xE1,
  0xF3, 0xE0, 0x3F, 0x3C, 0x3E, 0xFC, 0x07, 0xEF, 0x07, 0x9F, 0x80, 0xFD,
  0xE0, 0xF3, 0xE0, 0x1F, 0xBC, 0x1E, 0xFC, 0x03, 0xFF, 0x03, 0xDF, 0x80,
  0x7F, 0xE0, 0x7B, 0xE0, 0x0F, 0xFC, 0x0F, 0x7C, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x0F,
  0xF3, 0xF8, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xF0,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0,
  0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0,
  0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80,
  0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80,
  0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0x7F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF7, 0xF0, 0x1F, 0xFF,
  0xE7, 0xF0, 0x1F, 0xFF, 0xEF, 0xF0, 0x0F, 0xFF, 0x8F, 0xF0, 0x03, 0xFF,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xC3, 0xFF, 0xF0,
  0x0F, 0xE3, 0xFF, 0xF8, 0x07, 0xF3, 0xFF, 0xFE, 0x03, 0xF9, 0xFF, 0xFF,
  0x81, 0xF9, 0xFC, 0x3F, 0xC0, 0xFC, 0xFC, 0x0F, 0xF0, 0xFE, 0x7E, 0x03,
  0xFF, 0xFE, 0x3F, 0x01, 0xFF, 0xFF, 0x1F, 0x80, 0x7F, 0xFF, 0x1F, 0xC0,
  0x1F, 0xFF, 0x0F, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
};

const GFXglyph JetBrainsMono_SemiBoldItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 17, 46, 38, 11, -46 },
  { 99, 23, 19, 38, 11, -46 },
  { 154, 38, 46, 38, 1, -46 },
  { 373, 35, 64, 38, 2, -55 },
  { 653, 45, 46, 38, -3, -46 },
  { 912, 36, 48, 38, 1, -47 },
  { 1128, 10, 19, 38, 17, -46 },
  { 1152, 27, 61, 38, 9, -53 },
  { 1358, 27, 61, 38, 3, -53 },
  { 1564, 34, 32, 38, 3, -38 },
  { 1700, 31, 30, 38, 4, -36 },
  { 1817, 18, 20, 38, 5, -10 },
  { 1862, 22, 7, 38, 8, -24 },
  { 1882, 12, 12, 38, 11, -11 },
  { 1900, 39, 59, 38, 0, -52 },
  { 2188, 33, 48, 38, 3, -47 },
  { 2386, 30, 46, 38, 3, -46 },
  { 2559, 34, 47, 38, 2, -47 },
  { 2759, 33, 47, 38, 3, -46 },
  { 2953, 32, 46, 38, 3, -46 },
  { 3137, 33, 47, 38, 3, -46 },
  { 3331, 32, 47, 38, 2, -46 },
  { 3519, 33, 46, 38, 6, -46 },
  { 3709, 34, 48, 38, 2, -47 },
  { 3913, 32, 47, 38, 5, -47 },
  { 4101, 16, 36, 38, 11, -35 },
  { 4173, 21, 45, 38, 6, -35 },
  { 4292, 31, 34, 38, 5, -38 },
  { 4424, 31, 22, 38, 4, -32 },
  { 4510, 31, 34, 38, 3, -38 },
  { 4642, 27, 46, 38, 8, -46 },
  { 4798, 39, 58, 38, 0, -47 },
  { 5081, 33, 46, 38, 0, -46 },
  { 5271, 35, 46, 38, 2, -46 },
  { 5473, 34, 48, 38, 3, -47 },
  { 5677, 34, 46, 38, 2, -46 },
  { 5873, 35, 46, 38, 3, -46 },
  { 6075, 35, 46, 38, 3, -46 },
  { 6277, 34, 48, 38, 3, -47 },
  { 6481, 35, 46, 38, 2, -46 },
  { 6683, 33, 46, 38, 3, -46 },
  { 6873, 36, 47, 38, 0, -46 },
  { 7085, 38, 46, 38, 2, -46 },
  { 7304, 28, 46, 38, 4, -46 },
  { 7465, 38, 46, 38, 1, -46 },
  { 7684, 35, 46, 38, 2, -46 },
  { 7886, 33, 48, 38, 3, -47 },
  { 8084, 36, 46, 38, 2, -46 },
  { 8291, 33, 58, 38, 3, -47 },
  { 8531, 35, 46, 38, 2, -46 },
  { 8733, 35, 48, 38, 2, -47 },
  { 8943, 33, 46, 38, 6, -46 },
  { 9133, 34, 47, 38, 3, -46 },
  { 9333, 33, 46, 38, 7, -46 },
  { 9523, 38, 46, 38, 3, -46 },
  { 9742, 41, 46, 38, -1, -46 },
  { 9978, 35, 46, 38, 6, -46 },
  { 10180, 35, 46, 38, 2, -46 },
  { 10382, 27, 59, 38, 8, -52 },
  { 10582, 21, 59, 38, 9, -52 },
  { 10737, 26, 59, 38, 5, -52 },
  { 10929, 29, 25, 38, 5, -46 },
  { 11020, 31, 6, 38, 0, 2 },
  { 11044, 13, 8, 38, 16, -49 },
  { 11057, 32, 36, 38, 3, -35 },
  { 11201, 33, 47, 38, 2, -46 },
  { 11395, 32, 36, 38, 3, -35 },
  { 11539, 34, 47, 38, 3, -46 },
  { 11739, 31, 36, 38, 3, -35 },
  { 11879, 43, 57, 38, -3, -46 },
  { 12186, 31, 46, 38, 4, -35 },
  { 12365, 33, 46, 38, 2, -46 },
  { 12555, 31, 49, 38, 2, -49 },
  { 12745, 33, 60, 38, 1, -49 },
  { 12993, 36, 46, 38, 2, -46 },
  { 13200, 27, 46, 38, 6, -46 },
  { 13356, 35, 35, 38, 1, -35 },
  { 13510, 33, 35, 38, 2, -35 },
  { 13655, 31, 36, 38, 3, -35 },
  { 13795, 35, 46, 38, 0, -35 },
  { 13997, 32, 46, 38, 3, -35 },
  { 14181, 33, 35, 38, 3, -35 },
  { 14326, 32, 36, 38, 3, -35 },
  { 14470, 31, 44, 38, 5, -44 },
  { 14641, 33, 36, 38, 3, -35 },
  { 14790, 32, 35, 38, 6, -35 },
  { 14930, 35, 35, 38, 4, -35 },
  { 15084, 37, 35, 38, 0, -35 },
  { 15246, 32, 46, 38, 3, -35 },
  { 15430, 33, 35, 38, 2, -35 },
  { 15575, 33, 59, 38, 5, -52 },
  { 15819, 17, 59, 38, 11, -52 },
  { 15945, 33, 59, 38, 1, -52 },
  { 16189, 33, 14, 38, 3, -29 },
};

const GFXfont JetBrainsMono_SemiBoldItalic63pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic63pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic63pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC63PT7B_H_
