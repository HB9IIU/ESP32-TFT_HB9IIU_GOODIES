#ifndef _JETBRAINSMONO_SEMIBOLDITALIC41PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC1, 0xF8, 0x3F, 0x0F, 0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0xF8, 0x7D, 0xF0,
  0xFB, 0xE1, 0xF7, 0xC7, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D,
  0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x1E,
  0x00, 0x38, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0x70, 0x3C,
  0x00, 0xF0, 0x38, 0x00, 0xF0, 0x78, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x01, 0xC0, 0xF0, 0x03, 0xC0, 0xE0, 0x03, 0x81, 0xE0,
  0x03, 0x81, 0xE0, 0x07, 0x81, 0xC0, 0x07, 0x03, 0xC0, 0x07, 0x03, 0xC0,
  0x0F, 0x03, 0x80, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x1C, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x3C, 0x0E, 0x00, 0x38, 0x1E, 0x00,
  0x38, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x70, 0x3C, 0x00, 0xF0, 0x38, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xBB, 0xF0, 0x3E, 0x73, 0xE0, 0xF8,
  0xE3, 0xC1, 0xF1, 0x87, 0x83, 0xE3, 0x00, 0x07, 0xC6, 0x00, 0x0F, 0x9C,
  0x00, 0x1F, 0xB8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3B, 0xF8,
  0x00, 0x73, 0xF0, 0x00, 0xC3, 0xE0, 0x01, 0x87, 0xC7, 0xC7, 0x0F, 0x0F,
  0x8E, 0x3E, 0x1F, 0x1C, 0x7C, 0x3F, 0x3B, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x7C, 0x07, 0xFC, 0x01, 0xC0, 0x3F, 0xF0, 0x0E,
  0x01, 0xE1, 0xC0, 0x78, 0x07, 0x07, 0x83, 0xC0, 0x1C, 0x1C, 0x1E, 0x00,
  0xF0, 0x70, 0xF0, 0x03, 0xC1, 0xC7, 0x80, 0x0F, 0x0F, 0x1C, 0x00, 0x3C,
  0x3C, 0xE0, 0x00, 0xFF, 0xE7, 0x80, 0x01, 0xFF, 0x3C, 0x00, 0x03, 0xF9,
  0xE0, 0x00, 0x01, 0x8F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x08, 0x00, 0x00, 0x79, 0xFC, 0x00, 0x03, 0xDF, 0xF8,
  0x00, 0x1E, 0x7F, 0xE0, 0x00, 0xF3, 0xC3, 0xC0, 0x07, 0x8E, 0x0F, 0x00,
  0x1C, 0x38, 0x38, 0x00, 0xE1, 0xE0, 0xE0, 0x07, 0x87, 0x83, 0x80, 0x3C,
  0x1E, 0x1E, 0x01, 0xE0, 0x78, 0x78, 0x0F, 0x00, 0xFF, 0xC0, 0x78, 0x03,
  0xFE, 0x03, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7C, 0x1F, 0x80, 0xF8, 0x1F, 0x01,
  0xE0, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xFC, 0x1F, 0x3E, 0xF8, 0x7C, 0xF8, 0xF8, 0xF1, 0xE1, 0xF3,
  0xE3, 0xC1, 0xFF, 0x87, 0x83, 0xFE, 0x1F, 0x03, 0xF8, 0x3E, 0x03, 0xF0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0xC1, 0xF0, 0x7F, 0x83, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x07, 0xFF, 0x9F, 0x03, 0xFC, 0x1F, 0x00, 0x3E, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3C, 0xF9, 0xF3, 0xE7, 0x80, 0x00, 0x00, 0x40, 0x00,
  0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x01, 0x80, 0x02, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xE0,
  0x01, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x80, 0xF0, 0x27, 0x83, 0x83, 0x9F, 0x8E,
  0x3F, 0xFF, 0x33, 0xFF, 0xFE, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x79, 0xE0, 0x03, 0xE7, 0xC0, 0x1F,
  0x1F, 0x00, 0xFC, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0x01, 0xE0, 0x18, 0x06,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF8,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x00, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xC0, 0x3E, 0x7E, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC1,
  0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78,
  0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3C, 0x30, 0xF8, 0xF1,
  0xE3, 0xC3, 0xCF, 0xCF, 0x1F, 0x3E, 0x3C, 0x7C, 0x79, 0xF1, 0xF0, 0xC7,
  0xC7, 0x80, 0x1F, 0x1E, 0x00, 0x7C, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0x8F,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC1, 0xF0, 0x3F, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFE, 0xF0, 0x1F, 0xBE,
  0x07, 0xC7, 0xC0, 0xF0, 0xF8, 0x18, 0x1F, 0x02, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8,
  0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C,
  0xF8, 0x07, 0xC7, 0xE0, 0x7E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x7E, 0x07, 0xC7, 0xE0, 0x3C, 0x7E, 0x01,
  0xE3, 0xE0, 0x1F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC3, 0x80, 0x3C, 0xFF, 0x01, 0xEF, 0xFC, 0x0F, 0xFF, 0xF0,
  0xFF, 0x3F, 0x87, 0xE0, 0x7E, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x9F,
  0x00, 0x7C, 0xF8, 0x07, 0xC3, 0xE0, 0x7E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xBF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xF8, 0xFF, 0x7E, 0x03,
  0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0xC0, 0xFC, 0x7F,
  0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3E, 0x00,
  0xF9, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0xFC, 0x1F, 0x87, 0xC0, 0x7C, 0x7C, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x1F, 0x07, 0xC0,
  0xFE, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0xF8, 0x3E, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0x80, 0x1E, 0x7C,
  0x00, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xE0, 0x7E,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xF8, 0x3F,
  0x1F, 0x00, 0xFC, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0,
  0x07, 0xDE, 0x00, 0x3C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3F, 0x01, 0xF9,
  0xFC, 0x3F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0x7C, 0x00, 0xC7,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x81, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC,
  0x1F, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01,
  0x80, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x00,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x10, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0xF8, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0x07, 0xE0, 0x7E, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x3E,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7,
  0x80, 0xF9, 0xE3, 0xC1, 0xFE, 0xE3, 0xC1, 0xFF, 0x71, 0xE0, 0xF0, 0xF8,
  0xF0, 0xF0, 0x3C, 0x78, 0x78, 0x1E, 0x3C, 0x3C, 0x0F, 0x1E, 0x1E, 0x0F,
  0x1F, 0x1F, 0x07, 0x8F, 0x0F, 0x03, 0xC7, 0x87, 0x81, 0xE3, 0xC3, 0xC0,
  0xF1, 0xE1, 0xE0, 0x78, 0xF0, 0xF0, 0x7C, 0x78, 0x7C, 0x7C, 0x78, 0x3F,
  0xEE, 0x3C, 0x0F, 0xEF, 0x1E, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFE, 0x00, 0x1E, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x79, 0xE0,
  0x07, 0xCF, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xC0, 0x1F, 0x1F, 0x00, 0xF0,
  0xF8, 0x0F, 0x87, 0xC0, 0x78, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0x81,
  0xE0, 0x3C, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7C, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0x01, 0xF8, 0x7C, 0x03, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xE1, 0xE0,
  0x0F, 0x0F, 0x80, 0x7C, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x3C, 0x1F, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F,
  0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x1E, 0x00,
  0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x3F, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x3E, 0x03, 0xE1, 0xF0,
  0x07, 0xC7, 0xC0, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0xF8,
  0x7C, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xF8, 0x7F, 0xC1, 0xF0, 0x1F, 0x83, 0xE0,
  0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x1E, 0x00, 0xF8, 0x3C, 0x01,
  0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1E,
  0x0F, 0x80, 0x7C, 0x1E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x3E,
  0x01, 0xF8, 0x7C, 0x07, 0xE0, 0xF8, 0x7F, 0x81, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8,
  0x3E, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x1E, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE3, 0xFF, 0x0F, 0x0F, 0xFC, 0x7C, 0x3F, 0xF1, 0xF0, 0xFF, 0xC7,
  0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x80,
  0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0x7C, 0x7C,
  0x01, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03,
  0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xF0, 0x07, 0x87, 0xC0,
  0x1E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E,
  0x1E, 0x00, 0xF8, 0xF8, 0x03, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E,
  0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1F, 0x00, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7E, 0x07,
  0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF8,
  0x0F, 0xC0, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x1F,
  0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xC1, 0xF0, 0x03,
  0xE1, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE0,
  0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xF0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0E, 0xE0, 0xFE, 0x0E, 0xE0,
  0xEE, 0x1E, 0xE1, 0xFE, 0x1E, 0xE1, 0xDE, 0x1E, 0xE3, 0xDE, 0x1E, 0xF3,
  0x9E, 0x1E, 0xF7, 0xBC, 0x1E, 0x77, 0x3C, 0x3E, 0x77, 0x3C, 0x3E, 0x7E,
  0x3C, 0x3C, 0x7E, 0x7C, 0x3C, 0x7E, 0x7C, 0x3C, 0x7C, 0x78, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01,
  0xE0, 0x07, 0xE0, 0x1E, 0x0F, 0xC0, 0x3C, 0x1F, 0x80, 0x78, 0x3F, 0x81,
  0xF0, 0xFF, 0x03, 0xE1, 0xFE, 0x07, 0xC3, 0xFC, 0x0F, 0x07, 0xB8, 0x1E,
  0x0F, 0x78, 0x3C, 0x1E, 0xF0, 0x78, 0x7D, 0xE1, 0xF0, 0xFB, 0xC3, 0xE1,
  0xE7, 0x87, 0x83, 0xC7, 0x8F, 0x07, 0x8F, 0x1E, 0x0F, 0x1E, 0x3C, 0x3E,
  0x3C, 0xF8, 0x7C, 0x79, 0xF0, 0xF8, 0x73, 0xC1, 0xE0, 0xF7, 0x83, 0xC1,
  0xEF, 0x07, 0x83, 0xDE, 0x0F, 0x07, 0xBC, 0x3E, 0x07, 0x78, 0x7C, 0x0F,
  0xF0, 0xF0, 0x1F, 0xC1, 0xE0, 0x3F, 0x83, 0xC0, 0x7F, 0x07, 0x80, 0xFE,
  0x1F, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x87,
  0xC0, 0x3E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3E, 0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0x7C,
  0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x78, 0x7C,
  0x03, 0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x07,
  0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x07, 0x81, 0xFE, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3E,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x1F, 0x01, 0xFC, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x7E,
  0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x1E, 0x1E, 0x00, 0xF8, 0xF8, 0x03,
  0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xC3,
  0xC0, 0x0F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0,
  0x1F, 0x1F, 0x00, 0x7C, 0x78, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E,
  0x3E, 0x00, 0xF8, 0xFC, 0x07, 0xC1, 0xF0, 0x3F, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x78, 0x1F, 0xC1, 0xF0, 0x0F, 0xC3, 0xE0, 0x0F, 0x87,
  0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0xF8,
  0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x7F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x78,
  0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07,
  0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x0F, 0x83,
  0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x3C,
  0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xFC, 0x0F, 0xC1, 0xFF, 0xFF, 0x81,
  0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x3C, 0x3E,
  0x01, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xF0, 0x07, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x1F, 0x0F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1E,
  0x1F, 0x00, 0x78, 0x7C, 0x03, 0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x3E, 0x1E,
  0x00, 0xF8, 0x7C, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0,
  0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0xC0, 0x7C, 0x1E, 0x03, 0xE0,
  0xF0, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x01, 0xF0, 0xF8, 0x0F, 0x87,
  0xC0, 0x7C, 0x3C, 0x03, 0xE3, 0xE0, 0x1F, 0x1E, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x1E, 0x78, 0x00, 0xF7, 0xC0, 0x07, 0xBC, 0x00, 0x3D, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x3C, 0x1E, 0x07, 0x9E, 0x0F, 0x07, 0x8F, 0x0F, 0x83, 0xCF,
  0x87, 0xC1, 0xE7, 0xC3, 0x60, 0xF3, 0xC1, 0xB0, 0xF1, 0xE1, 0xD8, 0x78,
  0xF0, 0xFC, 0x3C, 0x78, 0x6E, 0x1E, 0x3C, 0x77, 0x1E, 0x1E, 0x3B, 0x8F,
  0x0F, 0x1D, 0xC7, 0x87, 0x8C, 0xE3, 0x83, 0xCE, 0x73, 0xC1, 0xE7, 0x39,
  0xE0, 0xF3, 0x9C, 0xF0, 0x79, 0x8E, 0x70, 0x3D, 0xC7, 0x78, 0x1E, 0xE3,
  0xBC, 0x0E, 0x61, 0xDE, 0x07, 0x70, 0xCE, 0x03, 0xB8, 0x6F, 0x03, 0xDC,
  0x37, 0x81, 0xEC, 0x1B, 0x80, 0xFE, 0x0D, 0xC0, 0x7F, 0x07, 0xE0, 0x3F,
  0x87, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x00,
  0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8,
  0x0F, 0x80, 0x1F, 0x03, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x00,
  0x03, 0xC7, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0,
  0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x07, 0xE0,
  0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7,
  0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF1, 0xF0,
  0x03, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0x80, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x3E,
  0x3C, 0x07, 0x87, 0x81, 0xF0, 0xF0, 0x3C, 0x1F, 0x0F, 0x81, 0xE3, 0xE0,
  0x3C, 0x78, 0x07, 0x9F, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x0F, 0x83, 0xE1, 0xF0,
  0x7C, 0x00, 0xF8, 0xF8, 0x1F, 0xE7, 0xC3, 0xFF, 0xBE, 0x1F, 0xFF, 0xF1,
  0xFC, 0x7F, 0x1F, 0x81, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01,
  0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x7C, 0xF8, 0x07, 0xE7, 0xE0, 0x3E,
  0x1F, 0x03, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFB, 0xE0, 0x7F,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE3, 0xE0,
  0x0F, 0xBF, 0xE0, 0x3D, 0xFF, 0xC0, 0xF7, 0xFF, 0x87, 0xF8, 0xFE, 0x1F,
  0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1E, 0x00,
  0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x3E, 0x01, 0xF0,
  0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0x7C, 0x7E, 0x03, 0xE1, 0xFC,
  0x1F, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x79, 0xFF, 0x83, 0xE3, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1,
  0xFC, 0x7F, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x1E, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x3E,
  0x1F, 0x83, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x3E,
  0x03, 0xFC, 0xF8, 0x3F, 0xFB, 0xE0, 0xFF, 0xFF, 0x87, 0xF1, 0xFC, 0x3F,
  0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1,
  0xE0, 0x0F, 0x87, 0x80, 0x3E, 0x3E, 0x01, 0xF8, 0xFC, 0x07, 0xC1, 0xF0,
  0x3F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xF7, 0xC0, 0x7F, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0x83, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x1F, 0x3C, 0x01, 0xF7,
  0xC0, 0x1F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x3E, 0x7C, 0x07,
  0xC7, 0xFB, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x04, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xF8, 0xF8,
  0x1F, 0xF7, 0xC3, 0xFF, 0xBE, 0x1F, 0xFF, 0xF1, 0xFC, 0x7F, 0x1F, 0x81,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F,
  0x00, 0x7C, 0xF8, 0x03, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F,
  0x8F, 0x80, 0xFC, 0x7C, 0x0F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFE, 0xF0, 0x7F,
  0xEF, 0x81, 0xFE, 0x7C, 0x03, 0x83, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE3, 0xF0, 0x0F, 0xBF, 0xE0, 0x3D, 0xFF, 0xC0, 0xF7, 0xFF, 0x87, 0xF8,
  0xFE, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E,
  0x1E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0x3E,
  0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01,
  0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3,
  0xE0, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x17, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x3F, 0x1F, 0x00, 0xFC, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xC0, 0xF0,
  0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC1, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x0F,
  0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0xC0, 0x3C, 0x0F, 0x80,
  0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3F, 0x07, 0xC0, 0x3E, 0x0F,
  0x80, 0x7E, 0x1E, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0x3C, 0x3C, 0x0F, 0x7E, 0xFE, 0x0F, 0xFE, 0xFE, 0x0F,
  0xFF, 0xFE, 0x1F, 0x1F, 0x1E, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3E, 0x3E, 0x1C, 0x3E, 0x3E,
  0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x38, 0x7C, 0x7C, 0x38, 0x7C, 0x7C, 0x38, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF8, 0x70, 0xF8, 0x0F,
  0x8F, 0xC0, 0x3E, 0xFF, 0x80, 0xF7, 0xFF, 0x03, 0xDF, 0xFE, 0x1F, 0xE3,
  0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8,
  0x78, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3C, 0x3E, 0x01, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07,
  0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x8F,
  0x80, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x1F, 0xC7, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3C,
  0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xE7,
  0xC0, 0x3E, 0x78, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xE7, 0xC0, 0x7C,
  0x7C, 0x0F, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0x07, 0xC7, 0xE0, 0x0F, 0xBF, 0xE0, 0x1E, 0xFF, 0xE0, 0x3D, 0xFF,
  0xE0, 0xFF, 0x1F, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E,
  0x0F, 0x80, 0x7C, 0x1E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1,
  0xF0, 0x07, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7C, 0x3F,
  0x00, 0xF8, 0x7E, 0x03, 0xE0, 0xFE, 0x0F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0x9F, 0xF8, 0x0F, 0x1F, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0x1F, 0xE7, 0xC3, 0xFF, 0xBE,
  0x1F, 0xFD, 0xF1, 0xF8, 0x7F, 0x1F, 0x81, 0xF8, 0xF8, 0x07, 0xC7, 0xC0,
  0x3E, 0x3C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xC7,
  0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x07,
  0xE7, 0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F,
  0xFB, 0xE0, 0x7F, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x0F,
  0x0F, 0x80, 0x3C, 0xFF, 0x81, 0xF7, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE1, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE7,
  0xC0, 0x1F, 0x3E, 0x01, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0x80,
  0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x78, 0xF8, 0x07, 0xC7,
  0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03,
  0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0x7C,
  0x03, 0xC3, 0xE0, 0x3E, 0x1F, 0x83, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xBE,
  0x00, 0x7D, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03, 0xE1, 0xE0, 0x1F,
  0x0F, 0x01, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8,
  0x7C, 0x03, 0xC3, 0xE0, 0x1E, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x00,
  0x3E, 0xF8, 0x01, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x78, 0x1F, 0xC1, 0xE0,
  0xFF, 0x0F, 0x83, 0xFC, 0x3E, 0x0E, 0xF0, 0xF8, 0x7B, 0xC7, 0xE1, 0xEF,
  0x1F, 0x87, 0x3C, 0x6E, 0x3C, 0xE1, 0xB8, 0xF3, 0x8E, 0xE3, 0xCE, 0x3B,
  0x9E, 0x38, 0xCE, 0x78, 0xE7, 0x39, 0xE3, 0x9C, 0xE7, 0x0E, 0x63, 0xBC,
  0x3B, 0x8E, 0xF0, 0xEE, 0x3B, 0x83, 0xB0, 0xFE, 0x0F, 0xC3, 0xF8, 0x3F,
  0x0F, 0xC0, 0xF8, 0x3F, 0x03, 0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x00, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0xFC, 0x03,
  0xE1, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xF3, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x07,
  0xE7, 0xC0, 0x0F, 0xC7, 0xC0, 0x0F, 0x83, 0xE0, 0x1F, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x7E, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F,
  0x80, 0xFC, 0x7E, 0x0F, 0xC3, 0xFF, 0xDE, 0x1F, 0xFF, 0xF0, 0x7F, 0xEF,
  0x81, 0xFE, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xF0, 0x02, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x04, 0x7F, 0x81, 0xE3, 0xFF,
  0x07, 0x9F, 0xFE, 0x1E, 0x78, 0xF8, 0x79, 0xE1, 0xFF, 0xCF, 0x07, 0xFF,
  0x3C, 0x0F, 0xF8, 0xF0, 0x1F, 0xC0,
};

const GFXglyph JetBrainsMono_SemiBoldItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 11, 30, 25, 7, -30 },
  { 43, 15, 12, 25, 7, -30 },
  { 66, 24, 30, 25, 1, -30 },
  { 156, 23, 42, 25, 1, -36 },
  { 277, 30, 30, 25, -2, -30 },
  { 390, 23, 30, 25, 1, -30 },
  { 477, 7, 12, 25, 11, -30 },
  { 488, 18, 40, 25, 6, -35 },
  { 578, 17, 40, 25, 2, -35 },
  { 663, 22, 21, 25, 2, -25 },
  { 721, 21, 19, 25, 2, -23 },
  { 771, 12, 13, 25, 3, -6 },
  { 791, 15, 5, 25, 5, -16 },
  { 801, 8, 7, 25, 7, -7 },
  { 808, 26, 39, 25, 0, -34 },
  { 935, 22, 30, 25, 2, -30 },
  { 1018, 19, 30, 25, 2, -30 },
  { 1090, 22, 30, 25, 2, -30 },
  { 1173, 21, 30, 25, 2, -30 },
  { 1252, 21, 30, 25, 2, -30 },
  { 1331, 21, 30, 25, 2, -30 },
  { 1410, 20, 30, 25, 2, -30 },
  { 1485, 21, 30, 25, 4, -30 },
  { 1564, 21, 30, 25, 2, -30 },
  { 1643, 21, 30, 25, 3, -30 },
  { 1722, 11, 23, 25, 7, -23 },
  { 1754, 14, 30, 25, 4, -23 },
  { 1807, 21, 23, 25, 3, -25 },
  { 1868, 20, 15, 25, 3, -21 },
  { 1906, 20, 23, 25, 2, -25 },
  { 1964, 18, 30, 25, 5, -30 },
  { 2032, 25, 37, 25, 0, -30 },
  { 2148, 21, 30, 25, 0, -30 },
  { 2227, 22, 30, 25, 2, -30 },
  { 2310, 22, 30, 25, 2, -30 },
  { 2393, 23, 30, 25, 1, -30 },
  { 2480, 22, 30, 25, 2, -30 },
  { 2563, 23, 30, 25, 2, -30 },
  { 2650, 22, 30, 25, 2, -30 },
  { 2733, 22, 30, 25, 2, -30 },
  { 2816, 22, 30, 25, 2, -30 },
  { 2899, 24, 30, 25, 0, -30 },
  { 2989, 25, 30, 25, 1, -30 },
  { 3083, 18, 30, 25, 3, -30 },
  { 3151, 24, 30, 25, 1, -30 },
  { 3241, 23, 30, 25, 1, -30 },
  { 3328, 22, 30, 25, 2, -30 },
  { 3411, 24, 30, 25, 1, -30 },
  { 3501, 22, 37, 25, 2, -30 },
  { 3603, 23, 30, 25, 1, -30 },
  { 3690, 23, 30, 25, 1, -30 },
  { 3777, 22, 30, 25, 4, -30 },
  { 3860, 22, 30, 25, 2, -30 },
  { 3943, 21, 30, 25, 5, -30 },
  { 4022, 25, 30, 25, 2, -30 },
  { 4116, 27, 30, 25, -1, -30 },
  { 4218, 22, 30, 25, 4, -30 },
  { 4301, 22, 30, 25, 2, -30 },
  { 4384, 17, 39, 25, 5, -34 },
  { 4467, 13, 39, 25, 6, -34 },
  { 4531, 17, 39, 25, 3, -34 },
  { 4614, 19, 16, 25, 3, -30 },
  { 4652, 20, 4, 25, 0, 1 },
  { 4662, 9, 6, 25, 10, -32 },
  { 4669, 21, 23, 25, 2, -23 },
  { 4730, 22, 30, 25, 1, -30 },
  { 4813, 21, 23, 25, 2, -23 },
  { 4874, 22, 30, 25, 2, -30 },
  { 4957, 20, 23, 25, 2, -23 },
  { 5015, 28, 37, 25, -2, -30 },
  { 5145, 21, 30, 25, 2, -23 },
  { 5224, 22, 30, 25, 1, -30 },
  { 5307, 21, 32, 25, 1, -32 },
  { 5391, 22, 39, 25, 0, -32 },
  { 5499, 23, 30, 25, 2, -30 },
  { 5586, 18, 30, 25, 4, -30 },
  { 5654, 24, 23, 25, 0, -23 },
  { 5723, 22, 23, 25, 1, -23 },
  { 5787, 20, 23, 25, 2, -23 },
  { 5845, 23, 30, 25, 0, -23 },
  { 5932, 21, 30, 25, 2, -23 },
  { 6011, 22, 23, 25, 2, -23 },
  { 6075, 21, 23, 25, 2, -23 },
  { 6136, 20, 29, 25, 3, -29 },
  { 6209, 21, 23, 25, 2, -23 },
  { 6270, 21, 23, 25, 4, -23 },
  { 6331, 22, 23, 25, 3, -23 },
  { 6395, 24, 23, 25, 0, -23 },
  { 6464, 21, 30, 25, 2, -23 },
  { 6543, 21, 23, 25, 2, -23 },
  { 6604, 22, 39, 25, 3, -34 },
  { 6712, 11, 39, 25, 7, -34 },
  { 6766, 21, 39, 25, 1, -34 },
  { 6869, 22, 9, 25, 2, -19 },
};

const GFXfont JetBrainsMono_SemiBoldItalic41pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic41pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC41PT7B_H_
