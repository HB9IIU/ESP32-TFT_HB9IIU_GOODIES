#ifndef _JETBRAINSMONO_SEMIBOLDITALIC35PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0xF8, 0xFC, 0x3C, 0x00, 0x78, 0x7B, 0xC3, 0xDE, 0x3E,
  0xF1, 0xEF, 0x8F, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xE7, 0x87, 0x38,
  0x78, 0x00, 0x38, 0x38, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0,
  0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x81, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x03,
  0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x03, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF9, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0xE0,
  0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x03, 0x83, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x07, 0xE0, 0x03, 0xFF,
  0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xBB, 0xE1, 0xE6, 0x3C, 0x78, 0xC7,
  0x8F, 0x18, 0x01, 0xE3, 0x00, 0x3E, 0x60, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x0E, 0xF8,
  0x01, 0x8F, 0x80, 0x31, 0xE3, 0xC6, 0x3C, 0x78, 0xC7, 0x8F, 0x19, 0xF1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0,
  0x03, 0x81, 0xFC, 0x03, 0xC1, 0xFF, 0x01, 0xC0, 0xE3, 0x81, 0xC0, 0xE1,
  0xC1, 0xC0, 0x70, 0xE1, 0xC0, 0x38, 0x71, 0xC0, 0x1C, 0x39, 0xC0, 0x0E,
  0x3D, 0xE0, 0x07, 0xFC, 0xE0, 0x01, 0xFC, 0xE0, 0x00, 0x7C, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE1, 0x80, 0x00, 0xF7, 0xF0,
  0x00, 0x77, 0xFC, 0x00, 0x77, 0x8E, 0x00, 0x73, 0x87, 0x00, 0x71, 0xC3,
  0x80, 0x70, 0xE1, 0xC0, 0x70, 0x70, 0xE0, 0x78, 0x38, 0xE0, 0x38, 0x1F,
  0xF0, 0x38, 0x0F, 0xF0, 0x78, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x3F,
  0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xF8, 0x78, 0x1E, 0x07, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x01, 0xFC, 0x00, 0x7F, 0xC3, 0xDE, 0x78, 0x7B, 0xCF, 0x9E, 0x70, 0xF7,
  0x9E, 0x0F, 0xE3, 0xC1, 0xFC, 0x78, 0x1F, 0x0F, 0x03, 0xC1, 0xE0, 0x7C,
  0x3E, 0x3F, 0xC7, 0xFF, 0xF8, 0x7F, 0xEF, 0x87, 0xF0, 0xF0, 0x7B, 0xFF,
  0xFF, 0x7B, 0xDE, 0xF7, 0x38, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0x80, 0x04, 0x00, 0x0E,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x3F, 0xC0, 0x7E, 0x00, 0xF8, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x40, 0xE0,
  0x5E, 0x38, 0xFF, 0xCC, 0xFF, 0xFB, 0x7F, 0x3F, 0xFF, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x1D, 0xC0, 0x0F, 0x78, 0x07, 0x9F, 0x03, 0xC3, 0xC1, 0xF0,
  0xF8, 0x38, 0x1C, 0x04, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C,
  0x3E, 0x0F, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3C, 0xFB, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x1F, 0x07, 0xCF, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCE,
  0x00, 0xF7, 0x80, 0x39, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xC0, 0x1E, 0xF0, 0x07, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x07, 0x8F, 0xC7, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0xFD,
  0xE0, 0x79, 0xF0, 0x78, 0xF0, 0x30, 0x78, 0x10, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x81, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7E,
  0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x3E, 0x3E, 0x07,
  0xC7, 0x80, 0x79, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x3C, 0x03, 0xC7,
  0x80, 0xF8, 0xF0, 0x1E, 0x1F, 0x0F, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0xF1, 0xE0, 0xF9, 0xE0, 0x79, 0xF0, 0x3C, 0xF0, 0x1E,
  0xF0, 0x0F, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x1E, 0x03, 0xDF, 0xE0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x0F, 0x03, 0xC7, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0xF0, 0x1F, 0x3C, 0x07, 0x8F,
  0xC7, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFB, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x8F, 0xEF, 0xE3, 0xE0, 0x7D, 0xF0, 0x1F, 0x78, 0x03, 0xDE,
  0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xE7, 0xE3,
  0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x7B, 0xC0, 0x7D, 0xE0,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0xF8, 0x3E, 0x1E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1E, 0x1E,
  0x03, 0xC1, 0xE0, 0xF8, 0x3E, 0x3E, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xFC, 0x03, 0xFF, 0xC0, 0xF8, 0x7C, 0x3C, 0x07, 0x8F, 0x80, 0xF1, 0xE0,
  0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1F, 0x1F, 0x8F, 0xC3, 0xFF,
  0xF0, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x81, 0xFF,
  0xF0, 0xFF, 0xFE, 0x3E, 0x0F, 0x9E, 0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x1E,
  0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0xFB, 0xE0, 0x3C, 0xFC, 0x3F, 0x1F,
  0xFF, 0x83, 0xFD, 0xE0, 0x7E, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x00, 0x06, 0x0F, 0x87, 0xE7, 0xF1, 0xF0, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0xFE,
  0x7F, 0x3F, 0x0F, 0x00, 0x00, 0xC0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xE0,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0,
  0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x00,
  0xFC, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x01, 0x00,
  0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xE0, 0x18, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xC0, 0x00, 0xF0, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03,
  0xFE, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00, 0x3E,
  0x00, 0xFF, 0x83, 0xFF, 0x1F, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0xFE, 0x3F, 0xF0, 0xFF, 0x83,
  0xF8, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF8, 0x7C, 0x0F, 0x80, 0x78, 0x3C,
  0x01, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0xF0, 0x7C,
  0xE3, 0xC3, 0xFB, 0x8E, 0x1F, 0x7E, 0x38, 0x78, 0x78, 0xE1, 0xC1, 0xC3,
  0x8F, 0x07, 0x1E, 0x3C, 0x1C, 0x78, 0xF0, 0xF1, 0xC3, 0x83, 0xC7, 0x0E,
  0x0F, 0x1C, 0x38, 0x38, 0x70, 0xE1, 0xE3, 0xC3, 0xFF, 0x8F, 0x0F, 0xEE,
  0x3C, 0x1F, 0x38, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x77,
  0x00, 0x3D, 0xC0, 0x0F, 0x70, 0x07, 0x9C, 0x01, 0xE7, 0x00, 0x79, 0xE0,
  0x3C, 0x78, 0x0F, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x3C,
  0x1E, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x3C, 0x03,
  0xCF, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xF0,
  0x0F, 0xF0, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xF0, 0x3E,
  0x1E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xC0, 0x78,
  0x78, 0x1E, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0x0F, 0xE1,
  0xE0, 0x3C, 0x3C, 0x07, 0xC7, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x1F, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F,
  0x07, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0xF0,
  0x0F, 0x3E, 0x07, 0x8F, 0xC7, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xF0,
  0x7E, 0x3E, 0x07, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0,
  0x3C, 0x78, 0x0F, 0x0F, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00,
  0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0xC7, 0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x03,
  0xC7, 0x80, 0xF8, 0xF0, 0x3E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF,
  0xE1, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE,
  0x1F, 0xFF, 0x83, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0x07, 0xC7, 0x80, 0xF3,
  0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x3F, 0xE7, 0x8F, 0xF9, 0xE3, 0xFE, 0x78, 0x0F,
  0xBE, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3E, 0x07, 0x8F,
  0xC7, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0x00, 0xF0,
  0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1E,
  0x1E, 0x01, 0xE1, 0xE0, 0x3E, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03,
  0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xC0,
  0x78, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x7C, 0x07, 0x87, 0x80, 0x78, 0x78,
  0x0F, 0x87, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F,
  0x00, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0xF0, 0x7E, 0x3F, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x78, 0x78, 0x07, 0x83,
  0xC0, 0x7C, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0x78, 0x1E,
  0x03, 0xC1, 0xF0, 0x1E, 0x1F, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0x87, 0x80,
  0x3C, 0x3C, 0x01, 0xE1, 0xF0, 0x1F, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x81,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xF0, 0xF8, 0x0F, 0x87,
  0x80, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x01, 0xF1, 0xF8, 0x1F,
  0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0x71, 0xF8, 0x7F, 0x1D, 0x86,
  0xE1, 0xDC, 0xEE, 0x3D, 0xCE, 0xE3, 0xDD, 0xDE, 0x3D, 0xDD, 0xE3, 0xDF,
  0x9E, 0x39, 0xF9, 0xC3, 0x8F, 0x1C, 0x78, 0xF3, 0xC7, 0x80, 0x3C, 0x78,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x00, 0x38, 0xF0, 0x07, 0x8F,
  0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0,
  0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0xC0, 0xF0, 0xFC, 0x0E, 0x0F, 0xC1,
  0xE1, 0xFC, 0x1E, 0x1F, 0xC1, 0xE1, 0xFE, 0x1E, 0x1F, 0xE1, 0xE1, 0xCE,
  0x1C, 0x1C, 0xE3, 0xC3, 0xCE, 0x3C, 0x3C, 0xF3, 0xC3, 0xCF, 0x3C, 0x3C,
  0x73, 0xC3, 0xC7, 0x38, 0x38, 0x73, 0x87, 0x87, 0x38, 0x78, 0x7F, 0x87,
  0x83, 0xF8, 0x78, 0x3F, 0x87, 0x83, 0xF8, 0x70, 0x3F, 0x07, 0x03, 0xF0,
  0xF0, 0x3F, 0x0F, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x1F, 0x07, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C,
  0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x3E, 0x78, 0x0F, 0x3E, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x3C, 0xF0, 0x1F, 0x3E, 0x07, 0x8F, 0xC7, 0xE1, 0xFF, 0xF0, 0x3F,
  0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0x03, 0xF1, 0xF0, 0x1F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F,
  0x1E, 0x00, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xE1, 0xE0, 0x3E, 0x3F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x07, 0xCF, 0x80, 0xF3, 0xC0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xF7, 0x80, 0x79, 0xE0, 0x1E,
  0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0xF8, 0x0F, 0x3C,
  0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F, 0x3E, 0x07, 0x8F, 0xC7,
  0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0xFC, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x03, 0xE1, 0xF0, 0x1E,
  0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x03,
  0xE1, 0xE0, 0x7C, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF,
  0x80, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x7C, 0x3C, 0x07, 0x83, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x0F,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0,
  0xF8, 0x3E, 0x1E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1E, 0x3C,
  0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1F, 0x1F, 0x8F, 0xC3, 0xFF, 0xF0, 0x3F,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x8F, 0x01,
  0xE1, 0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x07,
  0xC7, 0x80, 0xF0, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE3, 0xC0, 0x3C,
  0x78, 0x07, 0x8F, 0x01, 0xF1, 0xF0, 0x3C, 0x3F, 0x1F, 0x83, 0xFF, 0xE0,
  0x3F, 0xF8, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7B,
  0xC0, 0x1E, 0xF0, 0x0F, 0xBC, 0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x78, 0x78,
  0x1E, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x1E,
  0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x78, 0x03, 0x9E, 0x00,
  0xE7, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x00, 0x78, 0x78, 0x7B, 0xC3, 0xC3, 0xDE, 0x1E, 0x1C,
  0xE1, 0xF0, 0xE7, 0x0F, 0x8F, 0x38, 0x7C, 0x79, 0xC3, 0xE3, 0x8E, 0x3F,
  0x1C, 0x71, 0xB9, 0xE3, 0x8D, 0x8E, 0x1C, 0xEC, 0x70, 0xE6, 0x63, 0x8F,
  0x33, 0x3C, 0x79, 0x99, 0xC3, 0xDC, 0xCE, 0x1E, 0xC6, 0x70, 0xF6, 0x37,
  0x87, 0xF1, 0xB8, 0x3B, 0x8D, 0xC1, 0xD8, 0x6E, 0x0E, 0xC3, 0xE0, 0x7E,
  0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC3, 0xE0,
  0x00, 0x0F, 0x00, 0x7C, 0x3E, 0x01, 0xE0, 0x78, 0x0F, 0x81, 0xF0, 0x7C,
  0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x80, 0x3E, 0x7C, 0x00, 0x79, 0xE0, 0x01,
  0xEF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xDE, 0x00,
  0x1F, 0x78, 0x00, 0x79, 0xF0, 0x03, 0xE3, 0xC0, 0x1F, 0x0F, 0x00, 0x78,
  0x3E, 0x03, 0xE0, 0x78, 0x1F, 0x01, 0xE0, 0x78, 0x07, 0xC3, 0xE0, 0x0F,
  0x00, 0xF8, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x03, 0xC7, 0xC0, 0x7C, 0x3C,
  0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x3E, 0x01,
  0xE3, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE0, 0x07, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC3, 0xFF, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xFF,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFF, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xB8, 0x07, 0xB8, 0x0F, 0x3C, 0x0F, 0x1C, 0x1E, 0x1C,
  0x1C, 0x1E, 0x3C, 0x1E, 0x78, 0x0E, 0x78, 0x0E, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xF0, 0xF1, 0xF0, 0x01,
  0x80, 0x01, 0xFC, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3E, 0x1F, 0x8F, 0x03,
  0xE7, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3,
  0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xF3, 0xE0, 0x78, 0xFC,
  0x7E, 0x1F, 0xFF, 0x87, 0xFD, 0xE0, 0xFE, 0x78, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE1, 0x80,
  0x79, 0xFC, 0x1E, 0xFF, 0x87, 0xFF, 0xE1, 0xF0, 0x7C, 0x78, 0x1F, 0x3E,
  0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01,
  0xE7, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x0F, 0x9F, 0x03, 0xC7, 0xE3, 0xF1,
  0xFF, 0xF8, 0xFF, 0xFC, 0x3C, 0xFE, 0x00, 0x00, 0x60, 0x03, 0xFF, 0x03,
  0xFF, 0xC3, 0xFF, 0xE3, 0xE0, 0xF9, 0xE0, 0x3D, 0xF0, 0x1E, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x7B, 0xC0, 0x3D, 0xF0, 0x3C, 0xFC, 0x7E, 0x3F, 0xFE, 0x0F, 0xFE, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x60, 0xF0, 0x3F, 0x9E, 0x0F, 0xFF, 0x83,
  0xFF, 0xF0, 0xF8, 0x7E, 0x1E, 0x07, 0xC7, 0xC0, 0x78, 0xF0, 0x0F, 0x1E,
  0x03, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x1F, 0x01, 0xE3, 0xC0, 0x3C, 0x78,
  0x07, 0x8F, 0x01, 0xF1, 0xF0, 0x3C, 0x3F, 0x1F, 0x83, 0xFF, 0xF0, 0x7F,
  0xDE, 0x07, 0xF3, 0xC0, 0x00, 0x60, 0x03, 0xFE, 0x03, 0xFF, 0xC3, 0xFF,
  0xE3, 0xE0, 0xF9, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBF,
  0xFF, 0x9F, 0xFF, 0xDE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x05,
  0xE0, 0x3C, 0xF8, 0x3E, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x80, 0x01, 0xFC, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3E, 0x1F, 0x8F, 0x03,
  0xE7, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3,
  0xE0, 0x3C, 0xF8, 0x0F, 0x3E, 0x07, 0xCF, 0x83, 0xF1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x0F, 0xF7, 0x81, 0xF1, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE1, 0x80, 0x79, 0xFC, 0x1E, 0xFF, 0x87, 0xFF, 0xE1, 0xF0, 0x7C, 0x78,
  0x1F, 0x3E, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x7C, 0xF0, 0x1E, 0x3C, 0x07,
  0x8F, 0x01, 0xE7, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x0F, 0x9E, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x02, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x1F, 0x1E, 0x03,
  0xE1, 0xE0, 0x7C, 0x1E, 0x0F, 0x81, 0xE0, 0xF0, 0x3E, 0x1E, 0x03, 0xC3,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3C,
  0x7C, 0x07, 0xC3, 0xC0, 0x78, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xF0, 0x78, 0x0F, 0x0F, 0x80, 0xF8, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0x20, 0x81, 0xEF, 0x3E, 0x1F, 0xFF, 0xF1, 0xF7, 0xCF, 0x1E, 0x38, 0xF1,
  0xC3, 0x8F, 0x1C, 0x38, 0xF3, 0xC7, 0x0F, 0x3C, 0x70, 0xE3, 0xC7, 0x0E,
  0x3C, 0x71, 0xE3, 0x87, 0x1E, 0x38, 0x71, 0xE7, 0x8F, 0x1E, 0x78, 0xE1,
  0xC7, 0x8E, 0x1C, 0x78, 0xE3, 0xC7, 0x0E, 0x3C, 0x70, 0xE3, 0xCF, 0x1E,
  0x3C, 0x00, 0x18, 0x07, 0x9F, 0xC1, 0xEF, 0xF8, 0x7F, 0xFE, 0x1F, 0x07,
  0xC7, 0x81, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x1E, 0x7C, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF9, 0xE0,
  0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x3C, 0x00, 0x60,
  0x03, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xE0, 0xF9, 0xE0, 0x7D, 0xE0,
  0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xDF, 0x01, 0xEF,
  0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x7D, 0xF0, 0x3C, 0xFC, 0x7E, 0x3F, 0xFE,
  0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x0C, 0x01, 0xE7, 0xF0, 0x3D, 0xFF,
  0x07, 0xFF, 0xE0, 0xF8, 0x3E, 0x1E, 0x07, 0xC7, 0xC0, 0x78, 0xF0, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE3, 0xE0, 0x3C,
  0x78, 0x07, 0x8F, 0x01, 0xF1, 0xF0, 0x3C, 0x3F, 0x1F, 0x87, 0xFF, 0xE1,
  0xFF, 0xF8, 0x3C, 0xFE, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x01, 0x80, 0x01, 0xFC, 0xF1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x3E, 0x1F, 0x8F, 0x03, 0xE7, 0x80, 0x79, 0xE0,
  0x1E, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F,
  0x3C, 0x03, 0xCF, 0x01, 0xF3, 0xE0, 0x78, 0xFC, 0x7E, 0x1F, 0xFF, 0x87,
  0xFD, 0xE0, 0xFE, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x08, 0x07, 0xBF, 0xC1, 0xFF,
  0xF8, 0xF7, 0xFE, 0x3F, 0x0F, 0xCF, 0x81, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F,
  0x3C, 0x07, 0xCF, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF,
  0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x79, 0xE0, 0x1E, 0x7C, 0x1F, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xE0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xC0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x3C, 0x03, 0xCF, 0x01, 0xF3, 0xC0,
  0x78, 0xF0, 0x1E, 0x7C, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3E,
  0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C,
  0x07, 0x8F, 0x81, 0xE3, 0xF1, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE,
  0x00, 0xF0, 0x07, 0xFC, 0x01, 0xE7, 0x80, 0xF9, 0xE0, 0x3C, 0x78, 0x1F,
  0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0xF0, 0x3C, 0x3C, 0x0F, 0x1E, 0x03,
  0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x78, 0x01, 0xDE, 0x00, 0x77,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xF0, 0xF0, 0xFF, 0x0F,
  0x0E, 0xF1, 0xF0, 0xEF, 0x1F, 0x1E, 0xF1, 0xF1, 0xCF, 0x3F, 0x1C, 0xF3,
  0x73, 0xCF, 0x37, 0x38, 0xF3, 0x73, 0x8E, 0x67, 0x78, 0xE6, 0x77, 0x0E,
  0x67, 0x70, 0xEE, 0x7F, 0x0E, 0xC7, 0xE0, 0xEC, 0x7E, 0x0F, 0xC7, 0xE0,
  0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x00, 0x1F, 0x01, 0xF8, 0x7C,
  0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x8F, 0x80, 0x3C, 0xF8, 0x01, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xCF, 0x00, 0x3C, 0x7C, 0x03,
  0xC1, 0xE0, 0x3E, 0x0F, 0x83, 0xE0, 0x3C, 0x3E, 0x01, 0xF0, 0x3C, 0x07,
  0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x7C, 0x07, 0x9E, 0x01, 0xE7,
  0x80, 0xF9, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xCF, 0x80, 0xF3, 0xE0,
  0x7C, 0xF8, 0x1F, 0x3F, 0x0F, 0x87, 0xFF, 0xE1, 0xFF, 0x78, 0x3F, 0x9E,
  0x01, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x07,
  0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xF1,
  0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF,
  0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x7E, 0x03,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x00, 0x07,
  0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x81, 0xCF, 0xF0, 0xF7, 0xFC, 0x3F, 0xC7, 0x8F, 0xF1,
  0xFF, 0xBC, 0x3F, 0xEE, 0x07, 0xF0, 0x00, 0x60,
};

const GFXglyph JetBrainsMono_SemiBoldItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 9, 26, 21, 6, -26 },
  { 31, 13, 11, 21, 6, -26 },
  { 49, 21, 26, 21, 0, -26 },
  { 118, 19, 35, 21, 1, -30 },
  { 202, 25, 26, 21, -2, -26 },
  { 284, 19, 26, 21, 1, -26 },
  { 346, 5, 11, 21, 10, -26 },
  { 353, 15, 34, 21, 5, -30 },
  { 417, 15, 34, 21, 2, -30 },
  { 481, 18, 18, 21, 2, -21 },
  { 522, 17, 17, 21, 2, -20 },
  { 559, 10, 11, 21, 3, -5 },
  { 573, 12, 3, 21, 5, -13 },
  { 578, 7, 6, 21, 6, -6 },
  { 584, 22, 33, 21, 0, -29 },
  { 675, 18, 26, 21, 2, -26 },
  { 734, 17, 26, 21, 1, -26 },
  { 790, 19, 26, 21, 1, -26 },
  { 852, 19, 26, 21, 1, -26 },
  { 914, 17, 26, 21, 2, -26 },
  { 970, 18, 26, 21, 2, -26 },
  { 1029, 18, 26, 21, 1, -26 },
  { 1088, 17, 26, 21, 4, -26 },
  { 1144, 19, 26, 21, 1, -26 },
  { 1206, 18, 26, 21, 3, -26 },
  { 1265, 9, 20, 21, 6, -20 },
  { 1288, 12, 26, 21, 3, -20 },
  { 1327, 17, 19, 21, 3, -21 },
  { 1368, 17, 13, 21, 2, -18 },
  { 1396, 18, 19, 21, 1, -21 },
  { 1439, 14, 26, 21, 5, -26 },
  { 1485, 22, 32, 21, 0, -26 },
  { 1573, 18, 26, 21, 0, -26 },
  { 1632, 19, 26, 21, 1, -26 },
  { 1694, 18, 26, 21, 2, -26 },
  { 1753, 19, 26, 21, 1, -26 },
  { 1815, 19, 26, 21, 2, -26 },
  { 1877, 20, 26, 21, 1, -26 },
  { 1942, 18, 26, 21, 2, -26 },
  { 2001, 20, 26, 21, 1, -26 },
  { 2066, 18, 26, 21, 2, -26 },
  { 2125, 20, 26, 21, 0, -26 },
  { 2190, 21, 26, 21, 1, -26 },
  { 2259, 16, 26, 21, 2, -26 },
  { 2311, 20, 26, 21, 1, -26 },
  { 2376, 20, 26, 21, 1, -26 },
  { 2441, 18, 26, 21, 2, -26 },
  { 2500, 20, 26, 21, 1, -26 },
  { 2565, 18, 32, 21, 2, -26 },
  { 2637, 20, 26, 21, 1, -26 },
  { 2702, 19, 26, 21, 1, -26 },
  { 2764, 18, 26, 21, 4, -26 },
  { 2823, 19, 26, 21, 2, -26 },
  { 2885, 18, 26, 21, 4, -26 },
  { 2944, 21, 26, 21, 2, -26 },
  { 3013, 22, 26, 21, 0, -26 },
  { 3085, 20, 26, 21, 3, -26 },
  { 3150, 19, 26, 21, 1, -26 },
  { 3212, 14, 33, 21, 5, -29 },
  { 3270, 12, 33, 21, 5, -29 },
  { 3320, 14, 33, 21, 3, -29 },
  { 3378, 16, 14, 21, 3, -26 },
  { 3406, 17, 4, 21, 0, 1 },
  { 3415, 7, 4, 21, 9, -27 },
  { 3419, 18, 20, 21, 2, -20 },
  { 3464, 18, 26, 21, 1, -26 },
  { 3523, 17, 20, 21, 2, -20 },
  { 3566, 19, 26, 21, 2, -26 },
  { 3628, 17, 20, 21, 2, -20 },
  { 3671, 24, 32, 21, -2, -26 },
  { 3767, 18, 26, 21, 2, -20 },
  { 3826, 18, 26, 21, 1, -26 },
  { 3885, 17, 27, 21, 1, -27 },
  { 3943, 19, 33, 21, 0, -27 },
  { 4022, 20, 26, 21, 1, -26 },
  { 4087, 16, 26, 21, 3, -26 },
  { 4139, 20, 20, 21, 0, -20 },
  { 4189, 18, 20, 21, 1, -20 },
  { 4234, 17, 20, 21, 2, -20 },
  { 4277, 19, 26, 21, 0, -20 },
  { 4339, 18, 26, 21, 2, -20 },
  { 4398, 18, 20, 21, 2, -20 },
  { 4443, 18, 20, 21, 1, -20 },
  { 4488, 17, 25, 21, 3, -25 },
  { 4542, 18, 19, 21, 2, -19 },
  { 4585, 18, 19, 21, 3, -19 },
  { 4628, 20, 19, 21, 2, -19 },
  { 4676, 21, 19, 21, 0, -19 },
  { 4726, 18, 25, 21, 2, -19 },
  { 4783, 18, 19, 21, 1, -19 },
  { 4826, 18, 33, 21, 3, -29 },
  { 4901, 10, 33, 21, 6, -29 },
  { 4943, 18, 33, 21, 1, -29 },
  { 5018, 18, 8, 21, 2, -16 },
};

const GFXfont JetBrainsMono_SemiBoldItalic35pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic35pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC35PT7B_H_
