#ifndef _JETBRAINSMONO_SEMIBOLDITALIC40PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1F, 0x8F, 0xE3, 0xF8,
  0x7C, 0x00, 0x7C, 0x3E, 0xF8, 0xF9, 0xF1, 0xF3, 0xC3, 0xEF, 0x87, 0xDF,
  0x0F, 0xBE, 0x1E, 0x7C, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x87,
  0x80, 0x00, 0x3C, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0x70,
  0x3C, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x78, 0x00, 0xE0, 0x78, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x01, 0xC0, 0xE0, 0x03, 0xC1,
  0xE0, 0x03, 0x81, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x03,
  0xC0, 0x07, 0x03, 0x80, 0x0F, 0x07, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3C, 0x0E, 0x00, 0x3C, 0x1E,
  0x00, 0x38, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0x70, 0x38,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7C, 0xCF, 0xC3, 0xE3,
  0x1F, 0x0F, 0x8C, 0x7C, 0x3C, 0x70, 0x00, 0xF1, 0xC0, 0x03, 0xE7, 0x00,
  0x0F, 0x98, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0C, 0xFC, 0x00, 0x31,
  0xF0, 0x00, 0xC7, 0xC0, 0x07, 0x1F, 0x1F, 0x1C, 0x7C, 0x7C, 0x71, 0xF1,
  0xF1, 0x8F, 0x87, 0xE6, 0x7E, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x78, 0x1F, 0xF0, 0x07, 0x01, 0xFF, 0xC0, 0x78, 0x0F, 0x0E, 0x07, 0x80,
  0x70, 0x70, 0x78, 0x07, 0x83, 0x87, 0x80, 0x3C, 0x3C, 0x38, 0x01, 0xE1,
  0xE3, 0x80, 0x0F, 0x0E, 0x38, 0x00, 0x78, 0xF3, 0xC0, 0x03, 0xFF, 0xBC,
  0x00, 0x0F, 0xFB, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x7E, 0x00, 0x01,
  0xEF, 0xF8, 0x00, 0x1E, 0xFF, 0xE0, 0x01, 0xE7, 0x8F, 0x00, 0x0E, 0x38,
  0x38, 0x00, 0xE3, 0xC1, 0xC0, 0x0E, 0x1E, 0x1E, 0x00, 0xF0, 0xE0, 0xF0,
  0x0F, 0x07, 0x07, 0x00, 0xF0, 0x3C, 0x78, 0x0F, 0x01, 0xFF, 0x80, 0x70,
  0x07, 0xFC, 0x0F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xF3, 0xF0, 0x1F, 0x07, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3E, 0xF8, 0x7D, 0xF3, 0xE3, 0xE7, 0x87, 0xCF, 0x1E,
  0x1F, 0x7C, 0x78, 0x3F, 0xE3, 0xE0, 0x7F, 0x0F, 0x81, 0xF8, 0x3E, 0x03,
  0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFE, 0xF8,
  0x7F, 0xF1, 0xE0, 0xFF, 0x87, 0xC0, 0x7D, 0xF7, 0xDF, 0x7B, 0xEF, 0xBE,
  0xFB, 0xCF, 0x3C, 0x00, 0x00, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00,
  0x01, 0x80, 0x02, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x03, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x18, 0x3C, 0x0D, 0xF1, 0xE3, 0xEF, 0xC6, 0x7F, 0xFF, 0xB7,
  0xFB, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x03,
  0xCE, 0x00, 0x3E, 0x78, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0x7C,
  0x1F, 0x03, 0xC0, 0x30, 0x0C, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC,
  0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80,
  0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3C, 0x7E, 0xFE, 0xFE, 0xFE,
  0xFE, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0x7F, 0x07,
  0xC0, 0xFC, 0x7C, 0x03, 0xE3, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x38, 0x78, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xC3, 0x8F, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0x78, 0xF8, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xFC,
  0x03, 0xFF, 0x80, 0xFD, 0xF0, 0x3F, 0x3E, 0x07, 0x87, 0xC0, 0xE0, 0xF0,
  0x10, 0x1E, 0x04, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFC, 0x00, 0x0C, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xC0, 0xF8, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0x3E,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8,
  0xFC, 0x0F, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x81, 0xE1, 0xF8,
  0x3E, 0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0x80, 0x3E, 0x78,
  0x03, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x9F, 0xC0, 0x3D, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0xFC, 0x1F, 0x87, 0xC0, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xFC, 0x0F, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFB, 0xF0, 0x1F, 0x7F, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xE0, 0x7E,
  0x7C, 0x03, 0xE7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x01,
  0xEF, 0x00, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xFC, 0x0F, 0xC7, 0xFF,
  0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0x80, 0x1F, 0x3C, 0x01,
  0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFF, 0x7F, 0x07, 0xC0, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1E,
  0x00, 0xF0, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xC0, 0xFC, 0xFC,
  0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0xFC,
  0x7E, 0x0F, 0x81, 0xF0, 0xF8, 0x07, 0xC7, 0x80, 0x3E, 0x7C, 0x01, 0xF3,
  0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x07, 0xC7, 0xE0, 0x7E, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFE, 0xFE, 0x1F, 0x81,
  0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x00, 0xF3, 0xC0, 0x07, 0x9E,
  0x00, 0x7C, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x01, 0xF1, 0xF8, 0x3F,
  0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0x7C, 0x01, 0xE7, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x87, 0xF1, 0xFC, 0x7F, 0x1F, 0x83, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x1F, 0x8F, 0xE3, 0xF8, 0xFE, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7C,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00,
  0x08, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0B, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x10,
  0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7E,
  0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80,
  0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF,
  0x87, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0xFF, 0xE0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x03, 0xE0,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x0F,
  0x0F, 0x00, 0x07, 0x87, 0x80, 0x43, 0xC3, 0xC1, 0xFD, 0xE3, 0xC1, 0xFF,
  0xF1, 0xE0, 0xF9, 0xF8, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x3C,
  0x1E, 0x1E, 0x3C, 0x0F, 0x1E, 0x1E, 0x07, 0x8F, 0x0F, 0x03, 0xC7, 0x87,
  0x81, 0xE3, 0xC3, 0xC1, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF0, 0x78, 0x70,
  0x7C, 0x7C, 0x78, 0x3F, 0xFE, 0x3C, 0x0F, 0xEF, 0x1E, 0x01, 0xC0, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xEF, 0x80, 0x0F,
  0x3C, 0x00, 0xF9, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0x78, 0x03, 0xE3, 0xC0,
  0x1E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0xC1,
  0xE0, 0x3C, 0x0F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF3, 0xE0, 0x07,
  0x9F, 0x00, 0x3D, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0x80, 0xFC, 0x3E,
  0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x78, 0x3C, 0x03,
  0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFC, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x0F, 0x0F, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F,
  0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xC0, 0xFC, 0x7C, 0x03, 0xE3,
  0xE0, 0x1F, 0x1E, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x0F, 0x9F, 0x00, 0x78, 0xF8, 0x07, 0xC3, 0xE0,
  0x7E, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F,
  0x81, 0xF8, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x00,
  0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x1F, 0x00, 0xF8,
  0x7C, 0x03, 0xE1, 0xE0, 0x0F, 0x87, 0x80, 0x3E, 0x3E, 0x00, 0xF0, 0xF8,
  0x03, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3C, 0x01, 0xF0, 0xF0, 0x07,
  0xC7, 0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0x7C, 0x1F, 0xC1, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x08, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xC0, 0xFC, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1E, 0x00, 0xF9,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x87, 0xFE, 0x7C, 0x3F, 0xF3, 0xE1, 0xFF, 0x1F,
  0x1F, 0xF8, 0xF8, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF3, 0xE0, 0x0F,
  0x9F, 0x00, 0x78, 0xF8, 0x07, 0xC3, 0xE0, 0x7E, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F,
  0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8,
  0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F,
  0x03, 0xC0, 0x1E, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x87, 0xC0, 0x1F,
  0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x7E, 0x07, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0x7C, 0x0F, 0x80, 0x7C,
  0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x83, 0xE0,
  0x0F, 0x03, 0xE0, 0x0F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x3C, 0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x78, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0xFE, 0x0F, 0xE3,
  0xDC, 0x3B, 0xC7, 0xB8, 0x77, 0x0F, 0x71, 0xDE, 0x1E, 0xE3, 0xBC, 0x3D,
  0xCF, 0x78, 0x7B, 0x9C, 0xF1, 0xF7, 0xF9, 0xE3, 0xC7, 0xE7, 0x87, 0x8F,
  0xCF, 0x0F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x00, 0xF8, 0xF8, 0x01,
  0xF1, 0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xC3,
  0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x3E,
  0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0xF0, 0x7F, 0x01, 0xE0, 0xFF, 0x03, 0xC1,
  0xFE, 0x07, 0x83, 0xFC, 0x1F, 0x07, 0xF8, 0x3E, 0x0F, 0x70, 0x78, 0x3E,
  0xF0, 0xF0, 0x79, 0xE1, 0xE0, 0xF3, 0xC3, 0xC1, 0xE7, 0x8F, 0x83, 0xC7,
  0x1F, 0x07, 0x8E, 0x3C, 0x1F, 0x1E, 0x78, 0x3E, 0x3C, 0xF0, 0x78, 0x79,
  0xE0, 0xF0, 0xF3, 0xC1, 0xE0, 0xE7, 0x83, 0xC1, 0xFF, 0x0F, 0x83, 0xFC,
  0x1F, 0x07, 0xF8, 0x3C, 0x0F, 0xF0, 0x78, 0x0F, 0xE0, 0xF0, 0x1F, 0xC1,
  0xE0, 0x3F, 0x83, 0xC0, 0x7E, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x1C, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xC0,
  0xFC, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1E, 0x00, 0xF9, 0xF0, 0x07, 0x8F,
  0x80, 0x3C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x07,
  0xC7, 0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8,
  0xF8, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0xF8, 0x0F, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x0F,
  0x87, 0xC0, 0x1F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0xF0,
  0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xC0, 0xFC, 0x7C, 0x03, 0xE3, 0xE0,
  0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x7C, 0x01, 0xE3,
  0xE0, 0x1F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01,
  0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x7C,
  0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x7C,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0x83,
  0xE0, 0x1F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x83, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0xF8, 0x03, 0xC0, 0xF8, 0x07, 0x81, 0xF0, 0x1F, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xE0, 0x0F, 0x83,
  0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x03, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x03, 0xE1, 0xF8, 0x1F, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x7C, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0x87, 0xC0, 0x1E, 0x1F, 0x00, 0xF8,
  0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF0, 0xF8,
  0x03, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF0, 0x07,
  0xC3, 0xC0, 0x1E, 0x1F, 0x00, 0x78, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87,
  0xC0, 0x3E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xE1, 0xE0, 0x0F, 0x0F, 0x80,
  0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x0F, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xDE,
  0x00, 0x7C, 0xF0, 0x03, 0xE7, 0xC0, 0x1E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F,
  0x8F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x1F, 0x03, 0xE0, 0x78,
  0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0x78, 0x07, 0x87, 0xC0,
  0x3C, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF0, 0x03, 0xEF,
  0x80, 0x1F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x3C,
  0x1E, 0x0F, 0x78, 0x3E, 0x0F, 0x78, 0x3E, 0x1E, 0x78, 0x3E, 0x1E, 0x78,
  0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x3C, 0x78, 0x6E, 0x3C, 0x78,
  0xEE, 0x3C, 0x78, 0xEE, 0x3C, 0x78, 0xCE, 0x78, 0x78, 0xCC, 0x78, 0x79,
  0xCC, 0x78, 0x79, 0xCC, 0x70, 0x79, 0x8C, 0xF0, 0x7B, 0x8C, 0xF0, 0x73,
  0x8C, 0xF0, 0x73, 0x8C, 0xE0, 0x73, 0x0D, 0xE0, 0x77, 0x1D, 0xE0, 0xF7,
  0x1D, 0xE0, 0xF6, 0x1D, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC,
  0x1F, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F,
  0xC0, 0x01, 0xE3, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xE7, 0x80, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x03, 0xE0, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x1E,
  0x0F, 0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xE0, 0x03, 0xCF, 0x80, 0x0F, 0x7C,
  0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00,
  0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F,
  0x80, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0xF7, 0x00, 0x1E, 0xE0, 0x07, 0x9E, 0x00, 0xF3,
  0xC0, 0x3C, 0x78, 0x0F, 0x87, 0x81, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x03,
  0xC3, 0xC0, 0x3C, 0xF8, 0x07, 0xBE, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFC, 0x7C, 0x3E, 0x1E, 0x1F, 0x03,
  0xF8, 0xF8, 0x3F, 0xE7, 0x83, 0xFF, 0xBC, 0x3F, 0xFF, 0xE1, 0xF0, 0x3F,
  0x1F, 0x01, 0xF8, 0xF8, 0x07, 0xC7, 0x80, 0x3C, 0x7C, 0x03, 0xE3, 0xE0,
  0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE3,
  0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xE0, 0x7E, 0x1F, 0xFF,
  0xF0, 0xFF, 0xEF, 0x03, 0xFE, 0x78, 0x0F, 0xE7, 0xC0, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF3, 0xF8, 0x0F, 0x3F, 0xE0, 0x7B, 0xFF, 0x87,
  0xFF, 0xFC, 0x3F, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x78, 0x03,
  0xC3, 0xC0, 0x1E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C,
  0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF1, 0xF0, 0x0F, 0x8F, 0xC0, 0x7C,
  0x7E, 0x07, 0xC3, 0xFF, 0xFE, 0x1E, 0xFF, 0xE0, 0xF7, 0xFE, 0x0F, 0x9F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x1F, 0x03, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x2F, 0x80, 0x3C, 0xF8, 0x07, 0xC7, 0xC0, 0xFC, 0x7F,
  0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0xFE, 0x3C, 0x07, 0xFC, 0xF0, 0x3F, 0xFB,
  0xC1, 0xFF, 0xFF, 0x07, 0xC0, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xC3,
  0xC0, 0x1E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x3E, 0x1E, 0x00, 0xF8, 0x78, 0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0x7C, 0x0F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0x78, 0x0F,
  0xF9, 0xE0, 0x1F, 0xCF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0xC1, 0xFC, 0x7E, 0x1F, 0x03, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xF3, 0xC0,
  0x1F, 0x7C, 0x01, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC7,
  0xC0, 0xF8, 0x7F, 0x3F, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0xF8, 0x3F, 0xF7, 0x83, 0xFF, 0xBC, 0x3F, 0xFF,
  0xE1, 0xF0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x07, 0xC7, 0x80, 0x3C, 0x7C,
  0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E,
  0x3C, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x7F, 0x3F, 0xC3, 0xFF,
  0xFE, 0x0F, 0xFD, 0xF0, 0x3F, 0xCF, 0x00, 0x70, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF3, 0xF8, 0x0F, 0x7F, 0xE0, 0x7B, 0xFF, 0x87, 0xFF, 0xFC,
  0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x8F, 0x80, 0x7C, 0x78, 0x03, 0xC3, 0xC0,
  0x1E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3,
  0xC0, 0x1E, 0x1E, 0x00, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x07, 0x8F, 0x80, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x3F, 0x1E, 0x01, 0xF8, 0x78, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x81, 0xF0,
  0x3E, 0x0F, 0xC0, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7C, 0x3E,
  0x01, 0xE0, 0xF8, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83,
  0xE0, 0x3E, 0x0F, 0x80, 0xFC, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x0F, 0x7C, 0x7C, 0x1F, 0xF9, 0xF8, 0x3B, 0xFF, 0xF8, 0xF8, 0xF9,
  0xF1, 0xE1, 0xE1, 0xE3, 0xC3, 0xC7, 0xC7, 0x87, 0x0F, 0x8F, 0x0E, 0x1E,
  0x1E, 0x1C, 0x3C, 0x7C, 0x78, 0x78, 0xF0, 0xF0, 0xF1, 0xE1, 0xE1, 0xE3,
  0xC3, 0x87, 0xC7, 0x87, 0x0F, 0x0F, 0x0E, 0x1E, 0x3E, 0x1C, 0x3C, 0x78,
  0x78, 0x78, 0xF0, 0xF0, 0xF1, 0xE1, 0xE3, 0xE3, 0xC3, 0x87, 0x87, 0x87,
  0x0F, 0x1F, 0x0E, 0x1E, 0x00, 0x0F, 0x9F, 0xC0, 0x7B, 0xFF, 0x03, 0xDF,
  0xFC, 0x3F, 0xFF, 0xE1, 0xF8, 0x1F, 0x0F, 0x80, 0xFC, 0x7C, 0x03, 0xE3,
  0xC0, 0x1E, 0x1E, 0x00, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x80, 0x7C, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0x80, 0x3C,
  0x7C, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x1F, 0x03, 0xE3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xC0, 0x1F, 0x7C,
  0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x03, 0xE7,
  0x80, 0x3E, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xC7, 0xC0, 0xF8,
  0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xCF,
  0xE0, 0x1E, 0x7F, 0xC0, 0x7B, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xC0, 0xF8,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x7C,
  0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x78, 0x03,
  0xE1, 0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0x83,
  0xFF, 0xFE, 0x0F, 0x7F, 0xF0, 0x3D, 0xFF, 0x81, 0xF3, 0xFC, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0xF8, 0x3F, 0xE7, 0x83,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xF0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x07,
  0x87, 0x80, 0x3C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8,
  0xF8, 0x07, 0xC7, 0xE0, 0x7E, 0x1F, 0xFF, 0xF0, 0xFF, 0xEF, 0x03, 0xFE,
  0x78, 0x0F, 0xE7, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x3F, 0xC0, 0xFB, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xF8, 0x1F,
  0x8F, 0x80, 0xFC, 0x78, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF1, 0xF0,
  0x08, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x7F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFC, 0x7F, 0x1E, 0x01, 0xF3, 0xE0, 0x1F,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xFE, 0x3F, 0x87, 0xFF, 0xF8, 0x7F,
  0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x1F, 0xF0, 0x1F, 0x00, 0xF8, 0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0x80, 0x3C, 0x3C,
  0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E,
  0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x7C, 0x07, 0xC3, 0xE0,
  0x7C, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0xF0, 0x01, 0xFF, 0x00, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xF8, 0x07,
  0xCF, 0x80, 0xF8, 0x78, 0x0F, 0x87, 0x80, 0xF0, 0x78, 0x1F, 0x07, 0xC1,
  0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x3C,
  0xF8, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xE0, 0x78, 0x3F, 0x83, 0xE0,
  0xEE, 0x0F, 0x87, 0xB8, 0x3E, 0x1E, 0xE1, 0xF8, 0x73, 0x87, 0xE3, 0xCE,
  0x1B, 0x8F, 0x38, 0xEE, 0x38, 0xE3, 0xB9, 0xE3, 0x8C, 0xE7, 0x8E, 0x73,
  0x9C, 0x39, 0xCE, 0x70, 0xE6, 0x3B, 0xC3, 0x98, 0xEF, 0x0E, 0xE3, 0xB8,
  0x3B, 0x0F, 0xE0, 0xEC, 0x3F, 0x83, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3E,
  0x0F, 0xC0, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x3F, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x03, 0xE1, 0xF8, 0x03, 0xE1, 0xF0, 0x01,
  0xF3, 0xE0, 0x01, 0xF7, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xEF, 0x80, 0x07, 0xCF, 0x80, 0x0F, 0xC7, 0xC0, 0x0F,
  0x87, 0xC0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0xFC,
  0x01, 0xF8, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F,
  0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x03, 0xC7, 0x80,
  0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F,
  0xF7, 0xC1, 0xFC, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFE,
  0x03, 0xCF, 0xF8, 0x1E, 0xFF, 0xE1, 0xF7, 0x8F, 0x8F, 0x3C, 0x7E, 0xFB,
  0xC1, 0xFF, 0xDE, 0x07, 0xFC, 0xF0, 0x1F, 0xC0,
};

const GFXglyph JetBrainsMono_SemiBoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 10, 29, 24, 7, -29 },
  { 38, 15, 12, 24, 7, -29 },
  { 61, 24, 29, 24, 1, -29 },
  { 148, 22, 41, 24, 1, -35 },
  { 261, 29, 29, 24, -2, -29 },
  { 367, 22, 30, 24, 1, -30 },
  { 450, 6, 12, 24, 11, -29 },
  { 459, 17, 39, 24, 6, -34 },
  { 542, 17, 39, 24, 2, -34 },
  { 625, 21, 20, 24, 2, -24 },
  { 678, 20, 19, 24, 2, -23 },
  { 726, 12, 12, 24, 3, -6 },
  { 744, 14, 4, 24, 5, -15 },
  { 751, 8, 7, 24, 7, -7 },
  { 758, 25, 37, 24, 0, -33 },
  { 874, 21, 30, 24, 2, -30 },
  { 953, 19, 29, 24, 2, -29 },
  { 1022, 21, 30, 24, 2, -30 },
  { 1101, 21, 29, 24, 2, -29 },
  { 1178, 20, 29, 24, 2, -29 },
  { 1251, 21, 29, 24, 2, -29 },
  { 1328, 20, 29, 24, 2, -29 },
  { 1401, 21, 29, 24, 4, -29 },
  { 1478, 21, 30, 24, 2, -30 },
  { 1557, 21, 30, 24, 3, -30 },
  { 1636, 10, 22, 24, 7, -22 },
  { 1664, 13, 28, 24, 4, -22 },
  { 1710, 20, 22, 24, 3, -24 },
  { 1765, 19, 14, 24, 3, -20 },
  { 1799, 20, 22, 24, 2, -24 },
  { 1854, 17, 29, 24, 5, -29 },
  { 1916, 25, 37, 24, 0, -30 },
  { 2032, 21, 29, 24, 0, -29 },
  { 2109, 22, 29, 24, 1, -29 },
  { 2189, 21, 30, 24, 2, -30 },
  { 2268, 22, 29, 24, 1, -29 },
  { 2348, 22, 29, 24, 2, -29 },
  { 2428, 22, 29, 24, 2, -29 },
  { 2508, 21, 30, 24, 2, -30 },
  { 2587, 23, 29, 24, 1, -29 },
  { 2671, 21, 29, 24, 2, -29 },
  { 2748, 23, 29, 24, 0, -29 },
  { 2832, 24, 29, 24, 1, -29 },
  { 2919, 18, 29, 24, 2, -29 },
  { 2985, 23, 29, 24, 1, -29 },
  { 3069, 23, 29, 24, 1, -29 },
  { 3153, 21, 30, 24, 2, -30 },
  { 3232, 23, 29, 24, 1, -29 },
  { 3316, 21, 37, 24, 2, -30 },
  { 3414, 23, 29, 24, 1, -29 },
  { 3498, 22, 30, 24, 1, -30 },
  { 3581, 21, 29, 24, 4, -29 },
  { 3658, 22, 29, 24, 2, -29 },
  { 3738, 21, 29, 24, 4, -29 },
  { 3815, 24, 29, 24, 2, -29 },
  { 3902, 26, 29, 24, -1, -29 },
  { 3997, 22, 29, 24, 4, -29 },
  { 4077, 22, 29, 24, 1, -29 },
  { 4157, 17, 37, 24, 5, -33 },
  { 4236, 13, 37, 24, 6, -33 },
  { 4297, 17, 37, 24, 3, -33 },
  { 4376, 19, 15, 24, 3, -29 },
  { 4412, 20, 4, 24, 0, 1 },
  { 4422, 8, 5, 24, 10, -31 },
  { 4427, 21, 22, 24, 2, -22 },
  { 4485, 21, 29, 24, 1, -29 },
  { 4562, 20, 22, 24, 2, -22 },
  { 4617, 22, 29, 24, 2, -29 },
  { 4697, 20, 22, 24, 2, -22 },
  { 4752, 27, 36, 24, -2, -29 },
  { 4874, 21, 29, 24, 2, -22 },
  { 4951, 21, 29, 24, 1, -29 },
  { 5028, 20, 31, 24, 1, -31 },
  { 5106, 22, 38, 24, 0, -31 },
  { 5211, 22, 29, 24, 2, -29 },
  { 5291, 17, 29, 24, 4, -29 },
  { 5353, 23, 22, 24, 0, -22 },
  { 5417, 21, 22, 24, 1, -22 },
  { 5475, 20, 22, 24, 2, -22 },
  { 5530, 22, 29, 24, 0, -22 },
  { 5610, 21, 29, 24, 2, -22 },
  { 5687, 21, 22, 24, 2, -22 },
  { 5745, 20, 22, 24, 2, -22 },
  { 5800, 20, 28, 24, 3, -28 },
  { 5870, 21, 22, 24, 2, -22 },
  { 5928, 20, 22, 24, 4, -22 },
  { 5983, 22, 22, 24, 3, -22 },
  { 6044, 24, 22, 24, 0, -22 },
  { 6110, 20, 29, 24, 2, -22 },
  { 6183, 21, 22, 24, 1, -22 },
  { 6241, 21, 37, 24, 3, -33 },
  { 6339, 11, 37, 24, 7, -33 },
  { 6390, 21, 37, 24, 1, -33 },
  { 6488, 21, 9, 24, 2, -19 },
};

const GFXfont JetBrainsMono_SemiBoldItalic40pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic40pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC40PT7B_H_
