#ifndef _JETBRAINSMONO_SEMIBOLDITALIC37PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0xE1, 0xF8, 0xFC, 0x7E, 0x3E, 0x00, 0x7C, 0x7D, 0xF1, 0xF7,
  0xC7, 0xDE, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0xF0, 0xF3,
  0xC3, 0xCF, 0x0F, 0x00, 0x00, 0x78, 0x38, 0x01, 0xC1, 0xE0, 0x0F, 0x07,
  0x00, 0x38, 0x1C, 0x00, 0xE0, 0xF0, 0x07, 0x83, 0x80, 0x1C, 0x0E, 0x07,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x38, 0x38, 0x01, 0xE0,
  0xE0, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0xF0, 0x70, 0x03, 0x81, 0xC0,
  0x0E, 0x0E, 0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x3C,
  0x1C, 0x00, 0xE0, 0x70, 0x03, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x70, 0x38,
  0x01, 0xC1, 0xC0, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7C, 0xCF, 0x83, 0xC6, 0x3C,
  0x3E, 0x31, 0xE1, 0xF3, 0x80, 0x0F, 0x9C, 0x00, 0x7C, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x33, 0xE0, 0x01, 0x8F, 0x80, 0x0C, 0x7C, 0x00, 0x63,
  0xE3, 0xC7, 0x1E, 0x1E, 0x38, 0xF0, 0xF9, 0x8F, 0x87, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF8, 0x01,
  0xE0, 0x7F, 0x80, 0x78, 0x1F, 0xF8, 0x1E, 0x03, 0x87, 0x03, 0x80, 0xF0,
  0xE0, 0xE0, 0x1C, 0x1C, 0x38, 0x03, 0x83, 0x8E, 0x00, 0x70, 0xF3, 0x80,
  0x0E, 0x1C, 0xF0, 0x01, 0xFF, 0xBC, 0x00, 0x1F, 0xE7, 0x00, 0x01, 0xF9,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE7, 0xE0, 0x00, 0x7B, 0xFE, 0x00, 0x0E, 0xFF, 0xC0, 0x03, 0x9C,
  0x38, 0x00, 0xE3, 0x87, 0x00, 0x38, 0xF0, 0xE0, 0x0E, 0x1C, 0x1C, 0x03,
  0xC3, 0x83, 0x80, 0xF0, 0x78, 0xF0, 0x1C, 0x0F, 0xFC, 0x07, 0x00, 0xFF,
  0x03, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7C, 0x7C, 0x07, 0x83, 0xE0, 0xF0, 0x3E, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x1F,
  0xC0, 0x03, 0xFE, 0x00, 0x7D, 0xF0, 0xF7, 0x8F, 0x1E, 0x78, 0xFB, 0xE7,
  0x87, 0xBC, 0xF8, 0x7F, 0x8F, 0x03, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xE0,
  0xF0, 0x3F, 0x0F, 0x8F, 0xF8, 0xFF, 0xFF, 0x87, 0xFE, 0x7C, 0x3F, 0xC3,
  0xE0, 0x7D, 0xF7, 0x9E, 0x79, 0xEF, 0xBE, 0xF3, 0xCF, 0x00, 0x00, 0x03,
  0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x20, 0x07, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x7F, 0x80, 0xFE, 0x01,
  0xF0, 0x03, 0x80, 0x04, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x04, 0x07, 0x02, 0x78, 0x71, 0xE7,
  0xC6, 0x7E, 0xFF, 0x6F, 0xF7, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x1E, 0x00,
  0x03, 0xF0, 0x00, 0x73, 0x80, 0x0F, 0x3C, 0x01, 0xE3, 0xE0, 0x3E, 0x3E,
  0x07, 0xC1, 0xF0, 0x38, 0x1C, 0x01, 0x00, 0x80, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0xE1, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F,
  0x81, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xE0, 0x3E, 0x7E, 0x7E, 0xFE, 0x7E, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xE7, 0xF1,
  0xF0, 0x3E, 0x3C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7,
  0x80, 0x3C, 0xF0, 0x0F, 0xBE, 0x71, 0xE7, 0x9F, 0x3C, 0xF3, 0xE7, 0x9E,
  0x7C, 0xF3, 0xC7, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x1E, 0x78,
  0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1F, 0x3E, 0x07, 0xC3, 0xF3, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0xFF, 0x80, 0xFF, 0xC1, 0xFB, 0xE0, 0xF9, 0xE0, 0x70, 0xF0, 0x30, 0x78,
  0x20, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x0F, 0x81, 0xF1, 0xF0, 0x1F, 0x1E, 0x00, 0xF1, 0xE0,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x11, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0x78, 0x7C, 0x0F, 0x87, 0xF3,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07,
  0xC3, 0xE1, 0xF0, 0x7C, 0x7C, 0x0F, 0x1F, 0x01, 0xE3, 0xC0, 0x3C, 0x78,
  0x07, 0x9F, 0x01, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF,
  0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF1,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC7, 0x80, 0xFB, 0xFC, 0x1E, 0xFF, 0xC3, 0xFF, 0xF8, 0x7C, 0x1F, 0x0F,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF9, 0xE0, 0x1F, 0x3E, 0x07, 0xC7, 0xF3, 0xF8, 0x7F,
  0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x78, 0x07, 0xBF, 0xC1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xC1, 0xF9, 0xF0, 0x1F, 0x7C, 0x03, 0xEF,
  0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xF7, 0x80, 0x3C, 0xF0, 0x0F, 0x9F,
  0x03, 0xE3, 0xF9, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0x80, 0x7D,
  0xF0, 0x0F, 0x3C, 0x03, 0xE7, 0x80, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7E, 0x7F, 0x0F, 0x81, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xF0,
  0x1F, 0x0F, 0x01, 0xE0, 0xF0, 0x3E, 0x0F, 0x87, 0xC0, 0x7F, 0xF8, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x01, 0xF8, 0xF8, 0x3E, 0x07, 0xC3,
  0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x7C,
  0x7C, 0x0F, 0x87, 0xF3, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xCF, 0xE3, 0xE0,
  0x7C, 0xF8, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xDF, 0x00,
  0x7B, 0xE0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0xF8, 0xFF, 0xFF, 0x0F, 0xFB,
  0xC0, 0xFE, 0xF0, 0x07, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x03, 0xE1, 0xFC, 0x7F, 0x1F,
  0x83, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x7E, 0x1F, 0x8F, 0xE1, 0xF8, 0x7C, 0x00, 0x00, 0xE0, 0x0F,
  0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFE,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xE0,
  0x00, 0x08, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x10, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00,
  0x0E, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3E, 0x03, 0xE0, 0x78,
  0x03, 0xC1, 0xE0, 0x03, 0x87, 0x80, 0x07, 0x0F, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x78, 0x1F, 0x38, 0xF0, 0x7F, 0x71, 0xE1, 0xFF, 0xE3, 0xC7, 0x83,
  0xC7, 0x0F, 0x07, 0x8E, 0x1E, 0x0E, 0x1C, 0x38, 0x1C, 0x78, 0x70, 0x78,
  0xF1, 0xE0, 0xF1, 0xE3, 0xC1, 0xE3, 0xC7, 0x83, 0xC7, 0x0F, 0x07, 0x0E,
  0x1E, 0x1E, 0x3C, 0x3F, 0xFC, 0x78, 0x3F, 0xB8, 0xF0, 0x3C, 0xF1, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xF3, 0x80, 0x3C,
  0x70, 0x07, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x0F, 0x87, 0x81, 0xE0,
  0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF,
  0xE3, 0xE0, 0x3E, 0x78, 0x07, 0xCF, 0x00, 0x7B, 0xE0, 0x0F, 0x78, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0x78, 0x3C, 0x03,
  0xC3, 0xE0, 0x1E, 0x1F, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0xF0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0x80, 0xF8,
  0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0xC7, 0xC0,
  0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0x3F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0xFE, 0xFE, 0x1F, 0x03, 0xE1, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xE0,
  0x1E, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0xF8,
  0xF8, 0x1F, 0x07, 0xF7, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0x03, 0xF0, 0xF0, 0x1F, 0x0F, 0x00, 0xF1, 0xF0, 0x0F, 0x1F, 0x00, 0xF1,
  0xE0, 0x1F, 0x1E, 0x01, 0xF1, 0xE0, 0x1E, 0x1E, 0x01, 0xE3, 0xE0, 0x1E,
  0x3E, 0x01, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x03,
  0xC7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0x78, 0x78, 0x1F, 0x87, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x41, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0,
  0xFE, 0xFE, 0x1F, 0x03, 0xE1, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xE0, 0x1E,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC7, 0xFC, 0x78, 0x7F, 0xC7, 0x87, 0xFC, 0x78, 0x7F, 0xC7, 0x80,
  0x7C, 0x78, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0xF8, 0xF8,
  0x1F, 0x07, 0xF7, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00,
  0x07, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0,
  0x0F, 0x07, 0x80, 0x78, 0x3C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0,
  0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x87, 0xC0, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F,
  0x00, 0xF0, 0x78, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xC1, 0xE0, 0x1E,
  0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C,
  0x03, 0xE1, 0xF0, 0x3E, 0x0F, 0xE7, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0x07, 0x80, 0x7C, 0x3E, 0x01, 0xE0, 0xF8, 0x0F, 0x83,
  0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x80, 0xF0, 0x7C, 0x07, 0xC1,
  0xF0, 0x1F, 0x0F, 0x80, 0x78, 0x7C, 0x01, 0xE1, 0xF0, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0x0F, 0x80, 0x3C,
  0x3E, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xF0, 0x0F, 0x07, 0xC0, 0x7C, 0x0F,
  0x01, 0xF0, 0x3E, 0x07, 0x80, 0xF8, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0xC1,
  0xE0, 0x1F, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xBF, 0xFF, 0xC0, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE0, 0xF8, 0x1F,
  0x87, 0x70, 0x7E, 0x1D, 0xC3, 0xB8, 0x77, 0x0F, 0xE1, 0xDC, 0x77, 0x87,
  0x71, 0xDC, 0x1D, 0xCE, 0x70, 0xF3, 0x3B, 0xC3, 0xCE, 0xEF, 0x0F, 0x3F,
  0x3C, 0x3C, 0xFC, 0xF0, 0xF3, 0xE3, 0x83, 0xCF, 0x9E, 0x1E, 0x00, 0x78,
  0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0xF8, 0x78,
  0x03, 0xC3, 0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03,
  0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x78, 0x7E, 0x03,
  0xC3, 0xF0, 0x1E, 0x1F, 0x81, 0xE0, 0xFE, 0x0F, 0x07, 0xF0, 0x78, 0x7B,
  0x83, 0xC3, 0xDC, 0x1E, 0x1E, 0xE0, 0xF0, 0xF7, 0x87, 0x87, 0xBC, 0x78,
  0x3C, 0xE3, 0xC1, 0xC7, 0x1E, 0x1E, 0x38, 0xF0, 0xF1, 0xE7, 0x87, 0x8F,
  0x3C, 0x3C, 0x7B, 0xC1, 0xE1, 0xDE, 0x0F, 0x0E, 0xF0, 0xF0, 0x7F, 0x87,
  0x83, 0xFC, 0x3C, 0x1F, 0xE1, 0xE0, 0x7E, 0x0F, 0x03, 0xF0, 0x78, 0x1F,
  0x87, 0x80, 0xFC, 0x3C, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x07, 0xF7, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0xCF, 0x80, 0x79, 0xF0,
  0x0F, 0x3C, 0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0xC0,
  0x3C, 0xF8, 0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0x8F, 0x00,
  0xF1, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x80, 0xF9, 0xF0, 0x1E, 0x3E, 0x07,
  0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xF0, 0x1F,
  0x87, 0x80, 0x7C, 0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF0,
  0x07, 0xC7, 0x80, 0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0xFE, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xF7, 0xF1, 0xF0, 0x3E, 0x3C, 0x03,
  0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x7C, 0xF0, 0x0F,
  0xBE, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3E,
  0x78, 0x07, 0xCF, 0x00, 0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x00, 0x79,
  0xF0, 0x1F, 0x3E, 0x07, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0x7C, 0x3C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x7C,
  0x3C, 0x07, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF,
  0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x3C, 0x07,
  0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xF0, 0x78, 0x0F,
  0x83, 0xC0, 0x3C, 0x3E, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x0F, 0xCF, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0x78, 0x7C, 0x03,
  0xC3, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC7, 0x80,
  0x3C, 0x3C, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0xF7, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0xF1, 0xF0, 0x1F, 0x1E, 0x01, 0xF1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0,
  0x1E, 0x3E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3E, 0x3C,
  0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7,
  0x80, 0x7C, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07, 0x8F, 0x80, 0x78,
  0xF8, 0x0F, 0x8F, 0x80, 0xF0, 0xF8, 0x1F, 0x07, 0xE7, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0x7C, 0x01, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x1E, 0x03, 0xE3, 0xC0,
  0x78, 0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xE0, 0x78, 0x3C, 0x1F, 0x07, 0x83,
  0xC0, 0xF8, 0x78, 0x1F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x9E,
  0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x3C, 0x3D, 0xE1, 0xF0, 0xF7, 0x87, 0xC3, 0xDE, 0x1F, 0x0E, 0x78, 0x7C,
  0x79, 0xE3, 0xE1, 0xE7, 0x8D, 0x87, 0x1E, 0x36, 0x1C, 0x71, 0xD8, 0xF1,
  0xC7, 0x63, 0xC7, 0x19, 0x8E, 0x1C, 0x66, 0x38, 0x73, 0x99, 0xE1, 0xCE,
  0x67, 0x87, 0x31, 0x9C, 0x3C, 0xC6, 0x70, 0xF7, 0x1B, 0xC3, 0xD8, 0xEE,
  0x0F, 0x63, 0xB8, 0x3F, 0x8E, 0xE0, 0xFE, 0x3F, 0x83, 0xF0, 0xFC, 0x0E,
  0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x83,
  0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x1E,
  0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0xF8, 0x00, 0xFB,
  0xE0, 0x00, 0xF7, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0x3C, 0x00, 0x3C, 0x7C, 0x00,
  0xF8, 0xF8, 0x03, 0xE0, 0xF0, 0x07, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7C,
  0x03, 0xC0, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0x80, 0xF0, 0x01, 0xFF, 0x00,
  0x3E, 0xF8, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0x87, 0xC0, 0xF0, 0x3C,
  0x1F, 0x03, 0xC1, 0xE0, 0x3E, 0x3E, 0x01, 0xE3, 0xC0, 0x1E, 0x78, 0x01,
  0xEF, 0x80, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x78,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1E,
  0x01, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3D, 0xC0, 0x3C, 0xE0, 0x1E, 0x78, 0x1E,
  0x3C, 0x0F, 0x0E, 0x0F, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE7, 0x80, 0x77,
  0xC0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7C, 0x3C, 0x1E, 0x1F, 0x01, 0xE0, 0x00, 0xFF, 0x7C, 0x3F, 0xEF, 0x8F,
  0xFF, 0xE3, 0xF0, 0xFC, 0x7C, 0x0F, 0x8F, 0x01, 0xF3, 0xE0, 0x3E, 0x78,
  0x07, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x79, 0xF0,
  0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x78, 0xF8, 0x1F, 0x1F, 0xCF, 0xE1, 0xFF,
  0xBC, 0x3F, 0xF7, 0x81, 0xF9, 0xF0, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC3, 0x80, 0xFB,
  0xFC, 0x1F, 0xFF, 0xC3, 0xDF, 0xFC, 0x7E, 0x1F, 0x8F, 0x81, 0xF1, 0xE0,
  0x1E, 0x7C, 0x03, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3C, 0x03, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x03,
  0xE3, 0xF9, 0xFC, 0x7F, 0xFF, 0x0F, 0x7F, 0xC3, 0xE7, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xF0, 0xFC, 0x7C,
  0x0F, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xE7, 0xC0,
  0x7C, 0xF8, 0x1F, 0x0F, 0xEF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE1, 0xE0, 0x7F, 0xBE, 0x0F, 0xFB, 0xE1,
  0xFF, 0xFC, 0x3F, 0x0F, 0xC3, 0xE0, 0x7C, 0x3C, 0x07, 0xC7, 0xC0, 0x7C,
  0x78, 0x07, 0xC7, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0x78, 0x07,
  0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0xE7,
  0xF0, 0x7F, 0xEF, 0x07, 0xFE, 0xF0, 0x1F, 0x9F, 0x00, 0x00, 0x78, 0x00,
  0xFF, 0x80, 0xFF, 0xF8, 0x7F, 0xFE, 0x1E, 0x07, 0xCF, 0x01, 0xF3, 0xC0,
  0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x02, 0xF8, 0x0F, 0x1F,
  0x0F, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF,
  0x7C, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xF0, 0xFC, 0x7C, 0x0F, 0x8F, 0x01,
  0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03,
  0xC7, 0x80, 0x79, 0xF0, 0x1F, 0x3E, 0x03, 0xE3, 0xE1, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFD, 0xE0, 0xFF, 0x3C, 0x07, 0x87, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0x80, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC3, 0x80, 0xFB, 0xFC, 0x1F, 0xFF,
  0xC3, 0xDF, 0xFC, 0x7E, 0x1F, 0x8F, 0x81, 0xF1, 0xE0, 0x3E, 0x7C, 0x07,
  0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F,
  0x1E, 0x01, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9E, 0x01, 0xE3, 0xC0, 0x3C,
  0x78, 0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x1F,
  0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x1F, 0x1F, 0x01, 0xF0, 0xF8,
  0x1F, 0x07, 0x81, 0xF0, 0x3C, 0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x0F, 0x80,
  0xF8, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0x1F,
  0x00, 0x78, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x0F,
  0x01, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x3C, 0x3E, 0x01, 0xF0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x30, 0x60, 0xF7,
  0xCF, 0x87, 0xFF, 0xFE, 0x3E, 0xFD, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xE1, 0xE3, 0x87, 0x0F, 0x3C, 0x38, 0x79, 0xE1, 0xC3, 0x8F, 0x0E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x0F, 0x1C, 0x38, 0x79, 0xE1, 0xC3, 0xCF,
  0x0E, 0x1C, 0x78, 0x71, 0xE3, 0xC7, 0x8F, 0x1E, 0x38, 0x78, 0xF1, 0xC3,
  0xCF, 0x0E, 0x1E, 0x00, 0x00, 0x0E, 0x03, 0xEF, 0xF0, 0x7F, 0xFF, 0x0F,
  0x7F, 0xF1, 0xF8, 0x7E, 0x3E, 0x07, 0xC7, 0x80, 0xF9, 0xF0, 0x1F, 0x3E,
  0x03, 0xE7, 0xC0, 0x7C, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF8,
  0x07, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0,
  0x1E, 0x3C, 0x03, 0xCF, 0x80, 0xF8, 0x00, 0x78, 0x00, 0xFF, 0x80, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0x0F, 0xCF, 0x81, 0xF3, 0xC0, 0x3D, 0xF0, 0x0F,
  0x78, 0x07, 0xDE, 0x01, 0xF7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0xBE,
  0x01, 0xEF, 0x80, 0xFB, 0xE0, 0x3C, 0xF8, 0x1F, 0x1F, 0x9F, 0x87, 0xFF,
  0xE0, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0x00, 0xFB, 0xFC, 0x0F,
  0xFF, 0xE0, 0xF7, 0xFF, 0x0F, 0xC3, 0xF0, 0xF8, 0x1F, 0x0F, 0x00, 0xF1,
  0xF0, 0x0F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E,
  0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07,
  0xC3, 0xF9, 0xFC, 0x3F, 0xFF, 0x83, 0xDF, 0xF0, 0x7C, 0xFE, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x7C, 0x3F, 0xEF, 0x8F,
  0xFF, 0xE3, 0xF0, 0xFC, 0x7C, 0x0F, 0x8F, 0x01, 0xF3, 0xE0, 0x3E, 0x78,
  0x07, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xCF, 0x80, 0x79, 0xF0,
  0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x78, 0xF8, 0x1F, 0x1F, 0xCF, 0xE1, 0xFF,
  0xBC, 0x3F, 0xF7, 0x83, 0xF9, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x0E, 0x03, 0xCF, 0xF0, 0x7B, 0xFF, 0x0F, 0xFF, 0xE1, 0xF8, 0x7E, 0x7C,
  0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x1F, 0x3C, 0x03, 0xE7, 0x80, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x3E, 0x07,
  0xCF, 0x00, 0xF3, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0xF0, 0x0F, 0xBF, 0x07, 0xCF, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C,
  0x78, 0x07, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x78, 0x07, 0xCF, 0x00, 0xF1,
  0xE0, 0x1E, 0x3C, 0x03, 0xCF, 0x80, 0x79, 0xF0, 0x1F, 0x3E, 0x03, 0xC7,
  0xC0, 0xF8, 0x7E, 0x7E, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0xF8, 0x03, 0xEF, 0x00, 0x79, 0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0x80, 0xF8,
  0xF0, 0x1E, 0x1F, 0x07, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x87, 0x80,
  0xF0, 0xF0, 0x1E, 0x3C, 0x03, 0xE7, 0x80, 0x3D, 0xE0, 0x07, 0xBC, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xF0, 0x70, 0x7F, 0x87, 0x83, 0xBC, 0x3C, 0x1D, 0xE1, 0xE1, 0xEF, 0x1F,
  0x0E, 0x78, 0xD8, 0x73, 0xC6, 0xC7, 0x9E, 0x76, 0x38, 0xF3, 0x31, 0xC7,
  0x99, 0x9E, 0x3D, 0xCC, 0xE1, 0xEE, 0x67, 0x0F, 0x63, 0x38, 0x7B, 0x1B,
  0xC3, 0xF8, 0xDC, 0x1F, 0x86, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF0, 0x3E,
  0x0F, 0x81, 0xF0, 0x7C, 0x00, 0x0F, 0x80, 0xFC, 0x1E, 0x07, 0xC0, 0x7C,
  0x1F, 0x00, 0xF0, 0xF8, 0x03, 0xE7, 0xC0, 0x07, 0xBE, 0x00, 0x1E, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0xF8, 0xF0, 0x03, 0xE3,
  0xE0, 0x1F, 0x07, 0x80, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x00, 0xF8,
  0x3E, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C,
  0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0x8F, 0x00, 0xF1,
  0xE0, 0x1E, 0x3C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3F, 0x1F, 0x8F, 0xC3,
  0xFF, 0xF8, 0x7F, 0xEF, 0x07, 0xF9, 0xE0, 0x08, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFE, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x01, 0xF0, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7C,
  0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E,
  0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x0F,
  0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x81, 0xE7,
  0xF8, 0x3D, 0xFF, 0x87, 0xBC, 0xF8, 0xFF, 0x0F, 0xBD, 0xE1, 0xFF, 0xBC,
  0x1F, 0xE7, 0x81, 0xF8,
};

const GFXglyph JetBrainsMono_SemiBoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 9, 27, 22, 7, -27 },
  { 32, 14, 11, 22, 6, -27 },
  { 52, 22, 27, 22, 1, -27 },
  { 127, 21, 37, 22, 1, -32 },
  { 225, 27, 27, 22, -2, -27 },
  { 317, 20, 27, 22, 1, -27 },
  { 385, 6, 11, 22, 10, -27 },
  { 394, 16, 36, 22, 5, -31 },
  { 466, 15, 36, 22, 2, -31 },
  { 534, 20, 20, 22, 2, -23 },
  { 584, 19, 18, 22, 2, -21 },
  { 627, 11, 12, 22, 3, -6 },
  { 644, 13, 4, 22, 5, -14 },
  { 651, 8, 6, 22, 6, -6 },
  { 657, 23, 35, 22, 0, -31 },
  { 758, 19, 27, 22, 2, -27 },
  { 823, 17, 27, 22, 2, -27 },
  { 881, 20, 27, 22, 1, -27 },
  { 949, 20, 27, 22, 1, -27 },
  { 1017, 19, 27, 22, 2, -27 },
  { 1082, 19, 27, 22, 2, -27 },
  { 1147, 19, 27, 22, 1, -27 },
  { 1212, 19, 27, 22, 4, -27 },
  { 1277, 20, 27, 22, 1, -27 },
  { 1345, 19, 27, 22, 3, -27 },
  { 1410, 10, 21, 22, 6, -21 },
  { 1437, 13, 27, 22, 3, -21 },
  { 1481, 18, 20, 22, 3, -22 },
  { 1526, 18, 13, 22, 2, -19 },
  { 1556, 18, 20, 22, 2, -22 },
  { 1601, 16, 27, 22, 5, -27 },
  { 1655, 23, 34, 22, 0, -27 },
  { 1753, 19, 27, 22, 0, -27 },
  { 1818, 21, 27, 22, 1, -27 },
  { 1889, 20, 27, 22, 2, -27 },
  { 1957, 20, 27, 22, 1, -27 },
  { 2025, 20, 27, 22, 2, -27 },
  { 2093, 21, 27, 22, 1, -27 },
  { 2164, 20, 27, 22, 2, -27 },
  { 2232, 21, 27, 22, 1, -27 },
  { 2303, 19, 27, 22, 2, -27 },
  { 2368, 21, 27, 22, 0, -27 },
  { 2439, 22, 27, 22, 1, -27 },
  { 2514, 17, 27, 22, 2, -27 },
  { 2572, 22, 27, 22, 1, -27 },
  { 2647, 21, 27, 22, 1, -27 },
  { 2718, 19, 27, 22, 2, -27 },
  { 2783, 21, 27, 22, 1, -27 },
  { 2854, 19, 34, 22, 2, -27 },
  { 2935, 21, 27, 22, 1, -27 },
  { 3006, 21, 27, 22, 1, -27 },
  { 3077, 19, 27, 22, 4, -27 },
  { 3142, 20, 27, 22, 2, -27 },
  { 3210, 19, 27, 22, 4, -27 },
  { 3275, 22, 27, 22, 2, -27 },
  { 3350, 23, 27, 22, 0, -27 },
  { 3428, 20, 27, 22, 4, -27 },
  { 3496, 21, 27, 22, 1, -27 },
  { 3567, 15, 35, 22, 5, -31 },
  { 3633, 12, 35, 22, 6, -31 },
  { 3686, 15, 35, 22, 3, -31 },
  { 3752, 17, 14, 22, 3, -27 },
  { 3782, 18, 4, 22, 0, 1 },
  { 3791, 8, 5, 22, 9, -29 },
  { 3796, 19, 21, 22, 2, -21 },
  { 3846, 19, 27, 22, 1, -27 },
  { 3911, 19, 21, 22, 2, -21 },
  { 3961, 20, 27, 22, 2, -27 },
  { 4029, 18, 21, 22, 2, -21 },
  { 4077, 25, 34, 22, -2, -27 },
  { 4184, 19, 28, 22, 2, -21 },
  { 4251, 19, 27, 22, 1, -27 },
  { 4316, 19, 29, 22, 1, -29 },
  { 4385, 20, 36, 22, 0, -29 },
  { 4475, 21, 27, 22, 1, -27 },
  { 4546, 17, 27, 22, 3, -27 },
  { 4604, 21, 21, 22, 0, -21 },
  { 4660, 19, 21, 22, 1, -21 },
  { 4710, 18, 21, 22, 2, -21 },
  { 4758, 20, 28, 22, 0, -21 },
  { 4828, 19, 28, 22, 2, -21 },
  { 4895, 19, 21, 22, 2, -21 },
  { 4945, 18, 21, 22, 2, -21 },
  { 4993, 18, 26, 22, 3, -26 },
  { 5052, 19, 20, 22, 2, -20 },
  { 5100, 19, 20, 22, 3, -20 },
  { 5148, 21, 20, 22, 2, -20 },
  { 5201, 22, 20, 22, 0, -20 },
  { 5256, 19, 27, 22, 2, -20 },
  { 5321, 19, 20, 22, 1, -20 },
  { 5369, 19, 35, 22, 3, -31 },
  { 5453, 9, 35, 22, 7, -31 },
  { 5493, 19, 35, 22, 1, -31 },
  { 5577, 19, 8, 22, 2, -17 },
};

const GFXfont JetBrainsMono_SemiBoldItalic37pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic37pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC37PT7B_H_
