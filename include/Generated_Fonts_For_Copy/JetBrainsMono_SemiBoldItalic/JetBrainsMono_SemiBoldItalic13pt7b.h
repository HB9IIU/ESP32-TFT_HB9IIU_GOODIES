#ifndef _JETBRAINSMONO_SEMIBOLDITALIC13PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x26, 0x64, 0x04, 0xE0, 0xDE, 0xF4, 0x1B, 0x12, 0x7F, 0x24,
  0x24, 0x24, 0xFE, 0x48, 0xD8, 0x0C, 0x0C, 0x3E, 0x2A, 0x68, 0x38, 0x1C,
  0x16, 0x56, 0x54, 0x7C, 0x10, 0x10, 0x18, 0x4B, 0x22, 0xD0, 0xA8, 0x34,
  0x02, 0x01, 0xF0, 0x54, 0x25, 0x31, 0xC0, 0x0C, 0x3E, 0x26, 0x20, 0x30,
  0x73, 0x5E, 0xCC, 0xCC, 0x76, 0xE8, 0x08, 0xC8, 0xC4, 0x23, 0x18, 0xC6,
  0x18, 0xE1, 0x00, 0x23, 0x86, 0x31, 0x8C, 0x63, 0x11, 0x99, 0x88, 0x00,
  0x10, 0x23, 0x5B, 0xC3, 0x0B, 0x22, 0x00, 0x10, 0xCF, 0xCC, 0x20, 0x80,
  0x36, 0x4C, 0xF0, 0xF8, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10,
  0x30, 0x20, 0x60, 0xC0, 0x18, 0xF9, 0x16, 0x2D, 0x56, 0xA3, 0x46, 0xC9,
  0xE0, 0x39, 0x69, 0x84, 0x10, 0x43, 0x0C, 0xFC, 0x0C, 0x7D, 0x88, 0x10,
  0x61, 0x86, 0x18, 0x63, 0xF8, 0x7C, 0x21, 0x0E, 0x0C, 0x38, 0xE2, 0xF0,
  0x0C, 0x63, 0x18, 0xCE, 0x3F, 0x82, 0x08, 0x7D, 0x04, 0x3F, 0xCC, 0x30,
  0xF2, 0xF0, 0x0C, 0x30, 0xC1, 0xE6, 0x68, 0xD1, 0xB2, 0x78, 0x7F, 0x88,
  0x30, 0x41, 0x82, 0x0C, 0x30, 0x40, 0x0C, 0x7C, 0x89, 0x13, 0xC7, 0x99,
  0xA3, 0x64, 0xF8, 0x18, 0xFB, 0x1E, 0x3C, 0x4F, 0x86, 0x08, 0x30, 0xC0,
  0x76, 0x00, 0x06, 0xE0, 0x39, 0x80, 0x00, 0x19, 0x88, 0xC0, 0x04, 0x77,
  0x30, 0xE0, 0xE0, 0xC0, 0x7F, 0xF0, 0x00, 0xFC, 0x83, 0x83, 0x83, 0x1F,
  0x88, 0x00, 0xF8, 0xC6, 0x37, 0x22, 0x18, 0xC0, 0x0C, 0x3F, 0x61, 0x41,
  0x4D, 0x53, 0xD2, 0xD2, 0x9E, 0x80, 0xC0, 0x70, 0x1C, 0x28, 0x51, 0xA2,
  0x4F, 0x9F, 0x23, 0xC6, 0x3E, 0x22, 0x22, 0x7E, 0x7C, 0x66, 0x46, 0x44,
  0xF8, 0x18, 0xF9, 0x16, 0x0C, 0x18, 0x20, 0x46, 0xC9, 0xE0, 0x3E, 0x22,
  0x62, 0x62, 0x62, 0x66, 0x46, 0x4C, 0xF8, 0x7E, 0x81, 0x07, 0xEF, 0xD8,
  0x30, 0x40, 0xF8, 0x7E, 0xFD, 0x02, 0x0C, 0x1F, 0xB0, 0x40, 0x81, 0x00,
  0x18, 0xF9, 0x16, 0x0C, 0x1B, 0xA3, 0x46, 0xC9, 0xE0, 0x33, 0x22, 0x22,
  0x7E, 0x7E, 0x66, 0x46, 0x44, 0xC4, 0x7E, 0x20, 0x41, 0x83, 0x06, 0x08,
  0x10, 0xF8, 0x0F, 0x02, 0x02, 0x06, 0x06, 0x06, 0xC4, 0xCC, 0x78, 0x33,
  0x26, 0x64, 0x7C, 0x78, 0x6C, 0x4C, 0x44, 0xC6, 0x61, 0x84, 0x10, 0x43,
  0x0C, 0x30, 0xFC, 0x33, 0x77, 0x76, 0x5A, 0x5A, 0x42, 0x46, 0xC6, 0xC6,
  0x33, 0x32, 0x72, 0x7A, 0x6A, 0x4E, 0x4E, 0x4C, 0xCC, 0x19, 0xF4, 0x71,
  0xC7, 0x38, 0xE3, 0xCB, 0xC0, 0x3E, 0x23, 0x63, 0x62, 0x7E, 0x60, 0x40,
  0x40, 0xC0, 0x18, 0xF9, 0x16, 0x2C, 0x58, 0xA3, 0x46, 0xC9, 0xE0, 0x40,
  0xC0, 0x3E, 0x23, 0x63, 0x66, 0x7C, 0x68, 0x4C, 0x44, 0xC6, 0x0C, 0x3E,
  0x22, 0x60, 0x30, 0x1C, 0x06, 0x46, 0x44, 0x7C, 0x7F, 0xFC, 0x40, 0x83,
  0x06, 0x0C, 0x10, 0x20, 0x40, 0x46, 0x8B, 0x16, 0x2C, 0xD1, 0xA3, 0x64,
  0xF0, 0xC6, 0x89, 0x32, 0x64, 0x8B, 0x1C, 0x38, 0x70, 0x9B, 0x92, 0xB6,
  0xB4, 0xB4, 0xD4, 0xDC, 0xD8, 0xD8, 0x63, 0x36, 0x1C, 0x18, 0x18, 0x38,
  0x2C, 0x64, 0xC6, 0xC6, 0x89, 0xB1, 0xC3, 0x06, 0x08, 0x10, 0x20, 0x3F,
  0x06, 0x0C, 0x08, 0x18, 0x30, 0x60, 0x40, 0xFC, 0x3B, 0xD8, 0xC4, 0x21,
  0x18, 0xC6, 0x21, 0xC0, 0xCC, 0xC4, 0x46, 0x62, 0x23, 0x33, 0x39, 0xC2,
  0x31, 0x8C, 0x42, 0x11, 0x8D, 0xE0, 0x18, 0xA6, 0x93, 0xC4, 0xFF, 0xF0,
  0xCC, 0x77, 0x3C, 0xE3, 0x8F, 0x6E, 0x80, 0x30, 0x41, 0xFB, 0x36, 0x6C,
  0xD1, 0xB2, 0xFC, 0x7F, 0x3C, 0x20, 0x87, 0x2F, 0x00, 0x06, 0x09, 0xD6,
  0x6C, 0xD1, 0xA3, 0x6C, 0xE8, 0x7F, 0x3C, 0xFF, 0x82, 0x3F, 0x00, 0x07,
  0x86, 0x03, 0x07, 0xE0, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x3C, 0x00,
  0x77, 0x3C, 0xE3, 0x8F, 0xE6, 0x82, 0xF0, 0x30, 0x41, 0xFB, 0x36, 0x6C,
  0xD1, 0xA2, 0xC4, 0x0C, 0x10, 0x11, 0xC0, 0x81, 0x06, 0x0C, 0x19, 0xFC,
  0x06, 0x08, 0x01, 0xE0, 0x40, 0x83, 0x06, 0x0C, 0x10, 0x67, 0x80, 0x30,
  0x20, 0x23, 0x66, 0x6C, 0x78, 0x4C, 0x4C, 0xC6, 0xF0, 0xC3, 0x08, 0x20,
  0x86, 0x18, 0x3C, 0x7E, 0x4A, 0x5A, 0x52, 0x52, 0xD6, 0xD6, 0x7E, 0xCD,
  0x9B, 0x34, 0x68, 0xB1, 0x00, 0x7F, 0x3C, 0xE3, 0x8F, 0x2F, 0x00, 0x7E,
  0xCD, 0x9B, 0x34, 0x6C, 0x9F, 0x60, 0xC0, 0x77, 0x3C, 0xE3, 0x8F, 0x6E,
  0x82, 0x18, 0x7C, 0x8B, 0x16, 0x0C, 0x10, 0x20, 0x00, 0x7F, 0x1C, 0x1E,
  0x0E, 0x3F, 0x80, 0x30, 0xCF, 0xC8, 0x20, 0x86, 0x18, 0x38, 0xC7, 0x1C,
  0xF3, 0x8F, 0x6F, 0x00, 0xC7, 0x99, 0x22, 0x45, 0x8A, 0x1C, 0x00, 0x93,
  0x6E, 0xD5, 0xAD, 0xDB, 0x36, 0x00, 0x67, 0x34, 0x1C, 0x18, 0x38, 0x6C,
  0xC6, 0xC7, 0x1C, 0xE3, 0x8F, 0xE0, 0x82, 0xF0, 0x3E, 0x0C, 0x30, 0xC3,
  0x0C, 0x3F, 0x00, 0x06, 0x1C, 0x60, 0xC1, 0x82, 0x3C, 0x08, 0x30, 0x60,
  0xC1, 0xC0, 0x33, 0x22, 0x26, 0x66, 0x44, 0x4C, 0x30, 0x70, 0x60, 0xC1,
  0x83, 0x03, 0x88, 0x30, 0x60, 0xC7, 0x00, 0xE6, 0xD9, 0x80,
};

const GFXglyph JetBrainsMono_SemiBoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 9, 8, 2, -9 },
  { 6, 5, 3, 8, 2, -9 },
  { 8, 8, 9, 8, 0, -9 },
  { 17, 8, 13, 8, 0, -11 },
  { 30, 10, 10, 8, -1, -10 },
  { 43, 8, 10, 8, 0, -10 },
  { 53, 2, 3, 8, 4, -9 },
  { 54, 5, 13, 8, 2, -11 },
  { 63, 5, 13, 8, 1, -11 },
  { 72, 7, 7, 8, 1, -8 },
  { 79, 6, 6, 8, 1, -7 },
  { 84, 4, 4, 8, 1, -2 },
  { 86, 4, 1, 8, 2, -5 },
  { 87, 3, 2, 8, 2, -2 },
  { 88, 8, 12, 8, 0, -11 },
  { 100, 7, 10, 8, 1, -10 },
  { 109, 6, 9, 8, 1, -9 },
  { 116, 7, 10, 8, 0, -10 },
  { 125, 6, 9, 8, 1, -9 },
  { 132, 6, 9, 8, 1, -9 },
  { 139, 6, 9, 8, 1, -9 },
  { 146, 7, 9, 8, 0, -9 },
  { 154, 7, 9, 8, 1, -9 },
  { 162, 7, 10, 8, 0, -10 },
  { 171, 7, 10, 8, 1, -10 },
  { 180, 4, 7, 8, 2, -7 },
  { 184, 5, 9, 8, 1, -7 },
  { 190, 6, 7, 8, 1, -8 },
  { 196, 6, 5, 8, 1, -7 },
  { 200, 6, 7, 8, 1, -8 },
  { 206, 5, 9, 8, 2, -9 },
  { 212, 8, 12, 8, 0, -10 },
  { 224, 7, 9, 8, 0, -9 },
  { 232, 8, 9, 8, 0, -9 },
  { 241, 7, 10, 8, 1, -10 },
  { 250, 8, 9, 8, 0, -9 },
  { 259, 7, 9, 8, 1, -9 },
  { 267, 7, 10, 8, 1, -10 },
  { 276, 7, 10, 8, 1, -10 },
  { 285, 8, 9, 8, 0, -9 },
  { 294, 7, 9, 8, 1, -9 },
  { 302, 8, 9, 8, 0, -9 },
  { 311, 8, 9, 8, 0, -9 },
  { 320, 6, 9, 8, 1, -9 },
  { 327, 8, 9, 8, 0, -9 },
  { 336, 8, 9, 8, 0, -9 },
  { 345, 6, 10, 8, 1, -10 },
  { 353, 8, 9, 8, 0, -9 },
  { 362, 7, 12, 8, 1, -10 },
  { 373, 8, 9, 8, 0, -9 },
  { 382, 8, 10, 8, 0, -10 },
  { 392, 7, 10, 8, 1, -10 },
  { 401, 7, 9, 8, 1, -9 },
  { 409, 7, 9, 8, 1, -9 },
  { 417, 8, 9, 8, 1, -9 },
  { 426, 8, 9, 8, 0, -9 },
  { 435, 7, 9, 8, 1, -9 },
  { 443, 8, 9, 8, 0, -9 },
  { 452, 5, 12, 8, 2, -11 },
  { 460, 4, 12, 8, 2, -11 },
  { 466, 5, 12, 8, 1, -11 },
  { 474, 6, 5, 8, 1, -9 },
  { 478, 6, 2, 8, 0, 0 },
  { 480, 3, 2, 8, 3, -10 },
  { 481, 6, 7, 8, 1, -7 },
  { 487, 7, 9, 8, 0, -9 },
  { 495, 6, 7, 8, 1, -7 },
  { 501, 7, 9, 8, 1, -9 },
  { 509, 6, 7, 8, 1, -7 },
  { 515, 9, 11, 8, -1, -9 },
  { 528, 6, 9, 8, 1, -7 },
  { 535, 7, 9, 8, 0, -9 },
  { 543, 7, 10, 8, 0, -10 },
  { 552, 7, 12, 8, 0, -10 },
  { 563, 8, 9, 8, 0, -9 },
  { 572, 6, 9, 8, 1, -9 },
  { 579, 8, 7, 8, 0, -7 },
  { 586, 7, 7, 8, 0, -7 },
  { 593, 6, 7, 8, 1, -7 },
  { 599, 7, 9, 8, 0, -7 },
  { 607, 6, 9, 8, 1, -7 },
  { 614, 7, 7, 8, 1, -7 },
  { 621, 6, 7, 8, 1, -7 },
  { 627, 6, 9, 8, 1, -9 },
  { 634, 6, 7, 8, 1, -7 },
  { 640, 7, 7, 8, 1, -7 },
  { 647, 7, 7, 8, 1, -7 },
  { 654, 8, 7, 8, 0, -7 },
  { 661, 6, 9, 8, 1, -7 },
  { 668, 7, 7, 8, 0, -7 },
  { 675, 7, 12, 8, 1, -11 },
  { 686, 4, 12, 8, 2, -11 },
  { 692, 7, 12, 8, 0, -11 },
  { 703, 6, 3, 8, 1, -6 },
};

const GFXfont JetBrainsMono_SemiBoldItalic13pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic13pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC13PT7B_H_
