#ifndef _JETBRAINSMONO_SEMIBOLDITALIC65PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0xC0, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x00, 0x3F,
  0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0x80, 0xFE, 0x7F,
  0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F,
  0x81, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F,
  0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0x9E, 0x7F, 0xE0, 0x1F, 0xE1, 0xE1, 0xFE, 0x01, 0xFE, 0x1E, 0x1F, 0xE0,
  0x3F, 0xC1, 0xE0, 0xFE, 0x03, 0xFC, 0x3E, 0x0F, 0xE0, 0x3F, 0x83, 0xC0,
  0xFE, 0x03, 0xF8, 0x3C, 0x00, 0x00, 0x7F, 0x83, 0xC0, 0x00, 0x07, 0xF8,
  0x3C, 0x00, 0x00, 0x7F, 0xC3, 0xC0, 0x00, 0x03, 0xFC, 0x3C, 0x00, 0x00,
  0x3F, 0xF7, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xF3, 0xFF, 0x00, 0x00, 0x1F, 0x1F, 0xF0, 0x00, 0x01,
  0xE0, 0xFF, 0x00, 0x00, 0x1E, 0x0F, 0xF0, 0x00, 0x01, 0xE0, 0x7F, 0x00,
  0x00, 0x1E, 0x07, 0xF0, 0x7F, 0x81, 0xE0, 0x7F, 0x07, 0xF8, 0x3E, 0x0F,
  0xF0, 0x7F, 0x83, 0xC0, 0xFF, 0x07, 0xF8, 0x3C, 0x1F, 0xE0, 0x7F, 0x83,
  0xC1, 0xFE, 0x07, 0xFC, 0x3C, 0x7F, 0xC0, 0x3F, 0xF3, 0xDF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x02, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0x3F, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x7E, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE1, 0xF8, 0x00, 0x01,
  0xF8, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x1F, 0x80, 0x00, 0x03,
  0xFF, 0xFE, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xF9, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xE3, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xE3, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0x9F, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xF8,
  0xFF, 0x7F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0x87,
  0xE0, 0x3E, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x08, 0x7F, 0xFF, 0xC0,
  0x3F, 0x87, 0xF8, 0xFE, 0x03, 0xF8, 0x3F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC,
  0x1F, 0xE1, 0xFC, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFE, 0x03, 0xFD, 0xFE,
  0x07, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F, 0x80, 0x7F, 0xFE, 0x03, 0xFC, 0x03,
  0xFF, 0xF0, 0x1F, 0xE0, 0x0F, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x07,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x03, 0xFE,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF, 0xFC, 0x7F, 0x80, 0x3F, 0xFF,
  0x81, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3F, 0xCF, 0xF3, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x3F,
  0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0x00, 0x1F, 0x00, 0x18, 0x7C, 0x03, 0xE0, 0x1F, 0x1F, 0xE0,
  0x7C, 0x0F, 0xE3, 0xFE, 0x0F, 0x07, 0xFC, 0xFF, 0xF1, 0xE3, 0xFF, 0xDF,
  0xFF, 0x39, 0xFF, 0xFF, 0xFF, 0xF7, 0x7F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0xFF, 0x8F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F,
  0xFB, 0xFF, 0xDF, 0xFE, 0x7F, 0xE3, 0xFF, 0x0F, 0xE0, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xE0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x1F, 0x03, 0xF8, 0x3F, 0x87, 0xF0, 0xFF,
  0x07, 0xF1, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0xE3, 0xF8, 0x3F, 0xC7, 0xFC,
  0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC0,
  0xF8, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xF7, 0xF0, 0x01, 0xFF, 0xDF, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x07, 0xF8,
  0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x78, 0x03,
  0xF8, 0x00, 0xE0, 0x0F, 0xF0, 0x01, 0x00, 0x1F, 0xE0, 0x04, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xF0,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0x3F, 0xC2, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x03, 0xF8, 0x1F, 0xF0, 0x01, 0xFC, 0x1F,
  0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x01, 0xFC,
  0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x1F,
  0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xE0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x03, 0xFD, 0xFF, 0xF0, 0x07, 0xFB, 0xFF, 0xF8, 0x0F, 0xF7,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8,
  0x07, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0,
  0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0x7F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x1F,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFE, 0x00,
  0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0xF8, 0x1F, 0xF8,
  0x07, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F,
  0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x1F, 0xF1,
  0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFD, 0xFE,
  0x00, 0x3F, 0xF9, 0xFE, 0x00, 0x03, 0xE1, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xFC, 0x03, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F,
  0xF8, 0x07, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF0, 0x7E, 0x0F,
  0xE0, 0x07, 0xFC, 0x7E, 0x0F, 0xE0, 0x1F, 0xFE, 0x7E, 0x0F, 0xC0, 0x3F,
  0xFF, 0x7E, 0x0F, 0xC0, 0x3F, 0xFF, 0x7C, 0x0F, 0xC0, 0x7F, 0x83, 0xFC,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0,
  0xFC, 0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x01,
  0xFC, 0x1F, 0x81, 0xFC, 0x01, 0xF8, 0x1F, 0x81, 0xFC, 0x01, 0xF8, 0x3F,
  0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x01, 0xF8,
  0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x03, 0xF8, 0x3F, 0x03, 0xF8, 0x03, 0xF0,
  0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x7F, 0x03, 0xF8, 0x03, 0xF0, 0x7F, 0x03,
  0xF8, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x0F,
  0xF0, 0x7E, 0x03, 0xFE, 0x3F, 0xE0, 0x7E, 0x01, 0xFF, 0xFB, 0xE0, 0x7E,
  0x01, 0xFF, 0xF3, 0xE0, 0xFE, 0x00, 0xFF, 0xE7, 0xE0, 0xFE, 0x00, 0x7F,
  0xC7, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0x00, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFE,
  0x3F, 0xC0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03,
  0xF9, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00,
  0xFF, 0xE0, 0x1F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x0F, 0xF8, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFE,
  0x03, 0xFF, 0xE0, 0x0F, 0xE0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03,
  0xFE, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFE,
  0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x7F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xFC, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xE1, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0x81, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F,
  0xFF, 0x87, 0xF8, 0x1F, 0xFF, 0xE1, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0x81,
  0xFF, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF, 0x87, 0xF0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F,
  0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF8,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x7D, 0xF0, 0x0F, 0xFF, 0x01, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xF7,
  0xC0, 0x7E, 0xF8, 0x07, 0xEF, 0x80, 0xFB, 0xF0, 0x0F, 0xDF, 0x03, 0xF7,
  0xE0, 0x1F, 0xBE, 0x07, 0xCF, 0xC0, 0x3F, 0x7E, 0x1F, 0x9F, 0x80, 0xFE,
  0x7C, 0x3E, 0x7F, 0x01, 0xFC, 0xF8, 0x7C, 0xFC, 0x03, 0xF1, 0xF1, 0xF1,
  0xF8, 0x07, 0xE3, 0xE3, 0xE3, 0xF0, 0x0F, 0xC7, 0xCF, 0xCF, 0xE0, 0x1F,
  0x8F, 0x9F, 0x1F, 0xC0, 0x7F, 0x1F, 0x7E, 0x3F, 0x80, 0xFE, 0x1F, 0xF8,
  0x7E, 0x01, 0xFC, 0x3F, 0xF1, 0xFC, 0x03, 0xF8, 0x7F, 0xC3, 0xF8, 0x07,
  0xF0, 0xFF, 0x87, 0xF0, 0x0F, 0xE1, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xFC,
  0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x03, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x03,
  0xFF, 0x80, 0x0F, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x03,
  0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0xFC, 0x01, 0xFC, 0x03, 0xF7,
  0xE0, 0x0F, 0xE0, 0x1F, 0xBF, 0x00, 0x7F, 0x00, 0xFD, 0xF8, 0x03, 0xF8,
  0x07, 0xEF, 0xC0, 0x1F, 0xC0, 0x3F, 0x7E, 0x00, 0xFE, 0x03, 0xF9, 0xF8,
  0x0F, 0xE0, 0x1F, 0xCF, 0xC0, 0x7F, 0x00, 0xFE, 0x7E, 0x03, 0xF8, 0x07,
  0xF3, 0xF0, 0x1F, 0xC0, 0x3F, 0x9F, 0x80, 0xFE, 0x01, 0xFC, 0xFE, 0x07,
  0xF0, 0x1F, 0xC3, 0xF0, 0x3F, 0x80, 0xFE, 0x1F, 0x83, 0xF8, 0x07, 0xF0,
  0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x87, 0xF0,
  0x0F, 0xE0, 0xFC, 0x3F, 0x80, 0x7E, 0x07, 0xE1, 0xFC, 0x07, 0xF0, 0x3F,
  0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0xFE, 0x01, 0xFC, 0x0F, 0xE7, 0xF0, 0x0F,
  0xE0, 0x3F, 0x3F, 0x80, 0x7F, 0x01, 0xF9, 0xFC, 0x03, 0xF8, 0x0F, 0xCF,
  0xE0, 0x3F, 0x80, 0x7E, 0x7E, 0x01, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xE0,
  0x1F, 0xDF, 0x80, 0x7F, 0x00, 0x7E, 0xFC, 0x03, 0xF8, 0x03, 0xFF, 0xE0,
  0x1F, 0xC0, 0x1F, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xE0, 0x07,
  0xFF, 0x80, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F,
  0xC0, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xE0, 0x01, 0xFF,
  0xC0, 0x7F, 0x00, 0x07, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF,
  0x83, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x80,
  0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0x80, 0x03, 0xFE, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFC, 0x00,
  0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x07, 0xFC, 0x07,
  0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xE0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F,
  0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x03, 0xFF, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x07, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x40, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xF9, 0xFC, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80,
  0x7F, 0x1F, 0x80, 0x7F, 0x80, 0xFE, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x1F,
  0x80, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0xFF, 0x00, 0xFC, 0x1F, 0x80, 0xFF,
  0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x01, 0xF8,
  0x3F, 0x81, 0xEF, 0x01, 0xF8, 0x3F, 0x81, 0xEF, 0x03, 0xF8, 0x3F, 0x81,
  0xEF, 0x03, 0xF8, 0x3F, 0x83, 0xEF, 0x03, 0xF0, 0x3F, 0x03, 0xCF, 0x03,
  0xF0, 0x3F, 0x03, 0xCF, 0x07, 0xF0, 0x3F, 0x03, 0xCF, 0x07, 0xF0, 0x3F,
  0x07, 0xCF, 0x07, 0xE0, 0x3F, 0x07, 0x8F, 0x07, 0xE0, 0x3F, 0x07, 0x8F,
  0x0F, 0xE0, 0x3F, 0x07, 0x8F, 0x0F, 0xC0, 0x3F, 0x0F, 0x9F, 0x0F, 0xC0,
  0x3F, 0x0F, 0x1F, 0x0F, 0xC0, 0x3F, 0x0F, 0x1F, 0x1F, 0xC0, 0x3F, 0x1F,
  0x1F, 0x1F, 0x80, 0x3F, 0x1E, 0x1E, 0x1F, 0x80, 0x3F, 0x1E, 0x1E, 0x1F,
  0x80, 0x7F, 0x1E, 0x1E, 0x3F, 0x80, 0x7F, 0x3E, 0x1E, 0x3F, 0x00, 0x7E,
  0x3C, 0x1E, 0x3F, 0x00, 0x7E, 0x3C, 0x1E, 0x3F, 0x00, 0x7E, 0x7C, 0x1E,
  0x7E, 0x00, 0x7E, 0x7C, 0x1E, 0x7E, 0x00, 0x7E, 0x78, 0x1E, 0x7E, 0x00,
  0x7E, 0x78, 0x1E, 0x7E, 0x00, 0x7E, 0xF8, 0x1E, 0xFC, 0x00, 0x7E, 0xF0,
  0x1E, 0xFC, 0x00, 0x7E, 0xF0, 0x1E, 0xFC, 0x00, 0x7E, 0xF0, 0x1E, 0xFC,
  0x00, 0x7F, 0xF0, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7D,
  0xE0, 0x3F, 0xF8, 0x00, 0x7D, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F,
  0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xC0, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFE, 0x1F, 0xC0,
  0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x3F, 0xC0, 0x0F, 0xFF, 0x8F, 0xE0, 0x0F, 0xFF, 0xF3, 0xF8, 0x07, 0xFF,
  0xFC, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xF0, 0xFF, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x03,
  0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xC1, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF8,
  0x1F, 0xF8, 0x0E, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xDF,
  0xE0, 0x3F, 0xFF, 0xF7, 0xF0, 0x07, 0xFF, 0xF9, 0xFC, 0x00, 0xFF, 0xFC,
  0x7F, 0x00, 0x0F, 0xFC, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0xFF, 0xC0, 0x03, 0xF8, 0x7F, 0xFC, 0x00, 0xFE, 0x7F, 0xFF, 0x80, 0x7F,
  0xBF, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xFD, 0xF1, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x1F, 0xE0,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x1F,
  0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x01, 0xFC, 0xFF, 0xFF, 0x80, 0x7F, 0x3F, 0xFF, 0xC0, 0x1F, 0xC7,
  0xFF, 0xE0, 0x0F, 0xF0, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0x1F, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x04, 0xFF,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFF, 0xE3, 0xF8,
  0x01, 0xFF, 0xFE, 0x7F, 0x00, 0x7F, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF8,
  0x1F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03,
  0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3B, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xDF, 0xE0, 0x1F,
  0xFF, 0xFB, 0xFC, 0x01, 0xFF, 0xFE, 0x7F, 0x00, 0x1F, 0xFF, 0x8F, 0xE0,
  0x00, 0xFF, 0xC1, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x83, 0xFE, 0x01, 0xFF,
  0x07, 0xF8, 0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0xFC,
  0xFF, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xEF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x27, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00,
  0xFF, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x3F, 0xFE, 0x3F, 0x80, 0x7F, 0xFF, 0x9F, 0xC0, 0x7F,
  0xFF, 0xCF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xF8, 0x7F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F,
  0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F,
  0x87, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x7F, 0x01, 0xFF, 0xFF,
  0xBF, 0x80, 0xFF, 0xFF, 0xBF, 0xC0, 0x3F, 0xFF, 0x9F, 0xE0, 0x07, 0xFF,
  0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xC0, 0x03, 0xF8, 0xFF, 0xFC, 0x00,
  0xFE, 0x7F, 0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFD, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xF1, 0xF8,
  0x1F, 0xC0, 0x3F, 0x3F, 0xE3, 0xFF, 0x01, 0xFB, 0xFF, 0x3F, 0xF8, 0x0F,
  0xDF, 0xFD, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x7F, 0xC7,
  0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x7E, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x01, 0xFC,
  0x1F, 0x80, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xC0, 0x7E, 0x0F, 0xE0, 0x7E,
  0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xFC, 0x1F,
  0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xC0, 0x7F, 0x0F, 0xE0, 0x3E, 0x03,
  0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xC0,
  0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x3E, 0x03, 0xF8,
  0x3F, 0x01, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC,
  0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x3F,
  0x81, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0x80, 0xFC, 0x1F, 0xC0, 0x7C, 0x07,
  0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x3F, 0x81,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xF0,
  0x00, 0xFE, 0x3F, 0xFF, 0x00, 0x3F, 0x9F, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF,
  0xF8, 0x07, 0xFB, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x78,
  0x3F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFE,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x1F,
  0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xC7, 0xFF, 0x07, 0xFC, 0x01, 0xFF,
  0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFC, 0xFF,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFE, 0x7F, 0x80,
  0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF8, 0x01, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xE1,
  0xFF, 0xF0, 0x00, 0xFE, 0x7F, 0xFF, 0x80, 0x1F, 0xEF, 0xFF, 0xF8, 0x01,
  0xFE, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFD, 0xF1, 0xFF,
  0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x80,
  0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x1F,
  0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xCF, 0xFF, 0xF8, 0x01, 0xFC, 0xFF,
  0xFF, 0x00, 0x1F, 0xC7, 0xFF, 0xE0, 0x03, 0xFC, 0x3F, 0xF8, 0x00, 0x3F,
  0xC0, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xFF,
  0x8F, 0xE0, 0x0F, 0xFF, 0xF3, 0xF8, 0x07, 0xFF, 0xFC, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF, 0xF8, 0x3F,
  0xF0, 0x0F, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03,
  0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFC, 0x1F, 0xE0,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0E, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xDF, 0xE0, 0x3F, 0xFF, 0xF7,
  0xF0, 0x07, 0xFF, 0xF9, 0xFC, 0x00, 0xFF, 0xFC, 0x7F, 0x00, 0x1F, 0xFC,
  0x3F, 0xC0, 0x00, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0xE0, 0x01, 0xFC, 0x7F,
  0xFE, 0x00, 0x7F, 0x3F, 0xFF, 0xC0, 0x1F, 0xDF, 0xFF, 0xF8, 0x0F, 0xF7,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x7F, 0xC7, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0,
  0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F,
  0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x03,
  0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x07, 0xF3, 0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFE, 0x01,
  0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0x80, 0x3F, 0xFE, 0x03, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0x80, 0x7E, 0xFC, 0x03, 0xF8, 0x07, 0xEF, 0xC0, 0x7F, 0x80,
  0x7E, 0xFC, 0x07, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F, 0x80, 0xFC, 0xFC, 0x0F,
  0xF8, 0x0F, 0xCF, 0xC0, 0xF7, 0x81, 0xF8, 0xFC, 0x0F, 0x78, 0x1F, 0x8F,
  0xC0, 0xF7, 0x81, 0xF8, 0xFC, 0x1E, 0x78, 0x3F, 0x0F, 0xC1, 0xE7, 0x83,
  0xF0, 0xFC, 0x1E, 0x78, 0x3F, 0x0F, 0xC3, 0xC7, 0x87, 0xE0, 0xFC, 0x3C,
  0x78, 0x7E, 0x0F, 0xC3, 0xC7, 0x87, 0xE0, 0xFC, 0x7C, 0x78, 0x7C, 0x0F,
  0xC7, 0x87, 0x8F, 0xC0, 0xFC, 0x78, 0x78, 0xFC, 0x0F, 0xCF, 0x87, 0x8F,
  0xC0, 0xFC, 0xF0, 0x79, 0xF8, 0x0F, 0xCF, 0x07, 0x9F, 0x80, 0xFD, 0xF0,
  0x79, 0xF8, 0x0F, 0xDE, 0x07, 0xBF, 0x00, 0xFD, 0xE0, 0x7B, 0xF0, 0x0F,
  0xDE, 0x07, 0xBF, 0x00, 0xFF, 0xC0, 0x7B, 0xE0, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00,
  0x7F, 0x8F, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x7F,
  0xCF, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F,
  0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F,
  0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x7F,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF,
  0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xF0, 0x7F, 0xFF, 0xF7, 0xF0, 0x7F,
  0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xEF, 0xF0, 0x1F, 0xFF, 0xCF, 0xF0, 0x0F,
  0xFF, 0x8F, 0xF0, 0x07, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0xFF, 0xFC, 0x01, 0xFC, 0x7F,
  0xFF, 0x80, 0x7F, 0x3F, 0xFF, 0xF0, 0x1F, 0xCF, 0xFF, 0xFC, 0x07, 0xF7,
  0xF8, 0x7F, 0x81, 0xF9, 0xFC, 0x0F, 0xF0, 0xFE, 0x7F, 0x03, 0xFF, 0xFF,
  0x9F, 0x80, 0x7F, 0xFF, 0xC7, 0xE0, 0x1F, 0xFF, 0xF1, 0xF8, 0x03, 0xFF,
  0xF8, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
};

const GFXglyph JetBrainsMono_SemiBoldItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 16, 47, 39, 12, -47 },
  { 95, 24, 19, 39, 11, -47 },
  { 152, 39, 47, 39, 1, -47 },
  { 382, 36, 66, 39, 2, -57 },
  { 679, 47, 48, 39, -3, -48 },
  { 961, 37, 49, 39, 1, -48 },
  { 1188, 10, 19, 39, 18, -47 },
  { 1212, 28, 63, 39, 9, -55 },
  { 1433, 28, 63, 39, 3, -55 },
  { 1654, 35, 34, 39, 3, -40 },
  { 1803, 32, 31, 39, 4, -37 },
  { 1927, 19, 20, 39, 5, -10 },
  { 1975, 22, 7, 39, 9, -25 },
  { 1995, 13, 12, 39, 11, -11 },
  { 2015, 41, 61, 39, 0, -54 },
  { 2328, 35, 49, 39, 3, -48 },
  { 2543, 31, 47, 39, 3, -47 },
  { 2726, 35, 48, 39, 2, -48 },
  { 2936, 34, 48, 39, 3, -47 },
  { 3140, 33, 47, 39, 3, -47 },
  { 3334, 34, 48, 39, 3, -47 },
  { 3538, 32, 48, 39, 3, -47 },
  { 3730, 33, 47, 39, 7, -47 },
  { 3924, 34, 49, 39, 3, -48 },
  { 4133, 33, 48, 39, 5, -48 },
  { 4331, 17, 37, 39, 11, -36 },
  { 4410, 22, 46, 39, 6, -36 },
  { 4537, 32, 35, 39, 5, -39 },
  { 4677, 32, 23, 39, 4, -33 },
  { 4769, 32, 35, 39, 3, -39 },
  { 4909, 28, 47, 39, 8, -47 },
  { 5074, 40, 60, 39, 0, -48 },
  { 5374, 34, 47, 39, 0, -47 },
  { 5574, 36, 47, 39, 2, -47 },
  { 5786, 34, 49, 39, 4, -48 },
  { 5995, 36, 47, 39, 2, -47 },
  { 6207, 36, 47, 39, 3, -47 },
  { 6419, 36, 48, 39, 3, -48 },
  { 6635, 34, 49, 39, 4, -48 },
  { 6844, 36, 47, 39, 2, -47 },
  { 7056, 35, 47, 39, 3, -47 },
  { 7262, 38, 48, 39, 0, -47 },
  { 7490, 39, 47, 39, 2, -47 },
  { 7720, 29, 47, 39, 4, -47 },
  { 7891, 39, 47, 39, 1, -47 },
  { 8121, 37, 47, 39, 2, -47 },
  { 8339, 33, 49, 39, 4, -48 },
  { 8542, 37, 47, 39, 2, -47 },
  { 8760, 35, 60, 39, 3, -48 },
  { 9023, 36, 47, 39, 2, -47 },
  { 9235, 36, 49, 39, 2, -48 },
  { 9456, 34, 48, 39, 7, -48 },
  { 9660, 36, 48, 39, 3, -47 },
  { 9876, 34, 47, 39, 7, -47 },
  { 10076, 40, 47, 39, 3, -47 },
  { 10311, 42, 47, 39, -1, -47 },
  { 10558, 36, 47, 39, 6, -47 },
  { 10770, 36, 47, 39, 2, -47 },
  { 10982, 28, 61, 39, 8, -54 },
  { 11196, 21, 61, 39, 10, -54 },
  { 11357, 27, 61, 39, 5, -54 },
  { 11563, 30, 25, 39, 5, -47 },
  { 11657, 32, 6, 39, 0, 2 },
  { 11681, 14, 9, 39, 16, -51 },
  { 11697, 34, 37, 39, 3, -36 },
  { 11855, 34, 48, 39, 2, -47 },
  { 12059, 32, 37, 39, 4, -36 },
  { 12207, 35, 48, 39, 3, -47 },
  { 12417, 31, 37, 39, 4, -36 },
  { 12561, 44, 59, 39, -3, -47 },
  { 12886, 33, 48, 39, 4, -36 },
  { 13084, 34, 47, 39, 2, -47 },
  { 13284, 32, 51, 39, 2, -51 },
  { 13488, 34, 63, 39, 1, -51 },
  { 13756, 36, 47, 39, 3, -47 },
  { 13968, 28, 47, 39, 6, -47 },
  { 14133, 37, 36, 39, 1, -36 },
  { 14300, 34, 36, 39, 2, -36 },
  { 14453, 31, 37, 39, 4, -36 },
  { 14597, 36, 48, 39, 0, -36 },
  { 14813, 34, 48, 39, 3, -36 },
  { 15017, 34, 36, 39, 4, -36 },
  { 15170, 33, 37, 39, 3, -36 },
  { 15323, 32, 46, 39, 5, -46 },
  { 15507, 34, 37, 39, 3, -36 },
  { 15665, 33, 36, 39, 6, -36 },
  { 15814, 36, 36, 39, 4, -36 },
  { 15976, 38, 36, 39, 0, -36 },
  { 16147, 32, 48, 39, 4, -36 },
  { 16339, 34, 36, 39, 2, -36 },
  { 16492, 33, 61, 39, 6, -54 },
  { 16744, 17, 61, 39, 12, -54 },
  { 16874, 34, 61, 39, 1, -54 },
  { 17134, 34, 14, 39, 3, -30 },
};

const GFXfont JetBrainsMono_SemiBoldItalic65pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic65pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic65pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC65PT7B_H_
