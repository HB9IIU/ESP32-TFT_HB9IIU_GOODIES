#ifndef _JETBRAINSMONO_SEMIBOLDITALIC61PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x3F, 0xC0, 0xFE, 0x7F, 0x83,
  0xFC, 0xFE, 0x07, 0xF9, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F,
  0x9F, 0xE0, 0x7F, 0x3F, 0xC1, 0xFE, 0x7F, 0x03, 0xFC, 0xFE, 0x07, 0xF1,
  0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xC0, 0x7E, 0x1F,
  0x80, 0xFC, 0x3F, 0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x00, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFB, 0xDF, 0xF0, 0x07, 0xF8, 0xF3, 0xFE, 0x03, 0xFC, 0x38,
  0x7F, 0x80, 0xFE, 0x1E, 0x0F, 0xE0, 0x3F, 0x87, 0x83, 0xF8, 0x1F, 0xC1,
  0xE0, 0xFE, 0x07, 0xF0, 0x78, 0x00, 0x01, 0xFC, 0x1E, 0x00, 0x00, 0x7F,
  0x07, 0x00, 0x00, 0x1F, 0xE3, 0xC0, 0x00, 0x07, 0xFC, 0xF0, 0x00, 0x01,
  0xFF, 0xBC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0x3F, 0xF0, 0x00, 0x03,
  0xC3, 0xFC, 0x00, 0x00, 0xF0, 0xFF, 0x00, 0x00, 0x3C, 0x1F, 0xC0, 0x00,
  0x0F, 0x07, 0xF0, 0x00, 0x03, 0xC1, 0xFC, 0x1F, 0xC0, 0xE0, 0x7F, 0x07,
  0xF0, 0x78, 0x1F, 0xC1, 0xFC, 0x1E, 0x0F, 0xE0, 0x7F, 0x07, 0x83, 0xF8,
  0x1F, 0xE1, 0xE1, 0xFE, 0x07, 0xFC, 0x79, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x3E,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x03,
  0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0x0F, 0xC0,
  0x00, 0x3E, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x3F, 0x00, 0x00,
  0x3F, 0x07, 0xE3, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x7C, 0x00, 0x00, 0x1F,
  0xFF, 0x8F, 0x80, 0x00, 0x00, 0xFF, 0xF1, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x3F, 0x00, 0x00, 0x00, 0x0E, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0xFF, 0x80, 0x00,
  0x03, 0xF3, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x3F, 0xBF, 0xC0, 0x00, 0x07,
  0xC7, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x87,
  0xC0, 0x7C, 0x00, 0x03, 0xF0, 0xFC, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80,
  0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0xFC,
  0x00, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x00,
  0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE7, 0xF0, 0x01, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0x1F, 0xE7, 0xF0, 0x3F, 0x8F, 0xF1, 0xFC, 0x0F, 0xE3,
  0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xF3, 0xF8, 0x3F, 0x81, 0xFC, 0xFE,
  0x0F, 0xC0, 0x7F, 0xFF, 0x07, 0xF0, 0x0F, 0xFF, 0x81, 0xFC, 0x03, 0xFF,
  0xE0, 0x7F, 0x00, 0x7F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xF0, 0x03,
  0xFC, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xF8, 0x07, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0x9F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xFE, 0x1F, 0xC0,
  0x7F, 0xFF, 0x07, 0xF0, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x3F, 0x9F, 0xCF, 0xEF, 0xF7, 0xFB, 0xF9, 0xFC, 0xFE, 0x7F, 0x7F,
  0xBF, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x18, 0x03, 0xF0, 0x07, 0x1F, 0x01, 0xF8, 0x1F, 0x8F, 0xE0,
  0x78, 0x3F, 0xCF, 0xFC, 0x3C, 0x7F, 0xE7, 0xFF, 0x1C, 0x7F, 0xF7, 0xFF,
  0xEE, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xE3, 0xFE, 0x3F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF,
  0x7F, 0xF7, 0xFE, 0x7F, 0xC3, 0xF8, 0x04, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x03, 0xFE,
  0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE,
  0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x8F, 0xF0, 0xFC,
  0x3F, 0x8F, 0xF1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFC, 0x3F, 0x87, 0xF1, 0xFC,
  0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x00, 0x81, 0xF8, 0x7F, 0x00, 0x01, 0xF8,
  0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0xFB, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xEF, 0xE0, 0x07, 0xFE, 0x7F, 0x00, 0x3F, 0xC3, 0xF8,
  0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0x80, 0xFE, 0x00, 0x78, 0x0F, 0xF0, 0x07,
  0x00, 0x7F, 0x00, 0x30, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x1F,
  0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0xE0, 0x03,
  0xF8, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE1, 0xFF, 0x00, 0x0F, 0xE7, 0xFF, 0xC0, 0x0F, 0xEF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF3, 0xFF,
  0x00, 0x1F, 0xEF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x1F, 0xF0, 0x03, 0xFC,
  0x3F, 0xC0, 0x07, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0,
  0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFE,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFC,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xFC, 0x03,
  0xFC, 0x01, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0x1F, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xFB,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xC0,
  0x03, 0xFC, 0x7F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF,
  0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x7F, 0x80, 0x1F, 0xFD, 0xFE, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x03, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFE,
  0x07, 0xFE, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0x80, 0x04, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x7E, 0x0F, 0xC0, 0x1F, 0xF9, 0xF8, 0x3F,
  0x00, 0xFF, 0xE7, 0xC0, 0xFC, 0x07, 0xFF, 0xDF, 0x03, 0xF0, 0x3F, 0xFF,
  0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xF0, 0x7E, 0x07, 0xF0, 0x1F, 0xC1, 0xF8,
  0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x07,
  0xE0, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0xFC, 0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0x3F,
  0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7E, 0x07,
  0xE0, 0x0F, 0xC1, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x7E, 0x01, 0xFC,
  0x1F, 0x81, 0xFC, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xFF, 0xFE, 0x07, 0xE0, 0x3F, 0xFE, 0xF8, 0x3F, 0x00, 0x7F, 0xF3, 0xE0,
  0xFC, 0x00, 0xFF, 0x9F, 0x83, 0xF0, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE,
  0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE,
  0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0,
  0x03, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x81,
  0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xFE, 0x07, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x87, 0xFE, 0x03, 0xFC, 0x01, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xF0, 0x07, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0x87, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0xFC, 0x3F, 0x81, 0xFF,
  0xFC, 0x3F, 0x81, 0xFF, 0xFC, 0x3F, 0x81, 0xFF, 0xFC, 0x3F, 0x81, 0xFF,
  0xFC, 0x3F, 0x83, 0xFF, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03,
  0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00,
  0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x03, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F,
  0x80, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x07,
  0xFE, 0x03, 0xEF, 0x00, 0x7F, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF,
  0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x1F, 0x7E, 0x07, 0xEF, 0x81, 0xF7, 0xE0,
  0x7E, 0xF8, 0x3E, 0x7E, 0x07, 0xE7, 0x83, 0xE7, 0xC0, 0x7E, 0x78, 0x3E,
  0xFC, 0x07, 0xE7, 0xC7, 0xCF, 0xC0, 0x7E, 0x7C, 0x7C, 0xFC, 0x07, 0xE7,
  0xCF, 0x8F, 0xC0, 0xFE, 0x7C, 0xF9, 0xFC, 0x0F, 0xC7, 0xDF, 0x1F, 0x80,
  0xFC, 0x3D, 0xF1, 0xF8, 0x0F, 0xC3, 0xDE, 0x1F, 0x80, 0xFC, 0x3F, 0xE1,
  0xF8, 0x0F, 0xC3, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xC3, 0xF8, 0x1F, 0xC3,
  0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x83, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xC0, 0x7F, 0xC0, 0x03, 0xF0, 0x1F, 0xF0, 0x01, 0xFC, 0x07, 0xFC,
  0x00, 0x7F, 0x03, 0xFF, 0x80, 0x1F, 0xC0, 0xFF, 0xE0, 0x07, 0xF0, 0x3F,
  0xF8, 0x01, 0xF8, 0x0F, 0xFE, 0x00, 0x7E, 0x03, 0xFF, 0x80, 0x3F, 0x80,
  0xFF, 0xF0, 0x0F, 0xE0, 0x7E, 0xFC, 0x03, 0xF8, 0x1F, 0xBF, 0x00, 0xFE,
  0x07, 0xEF, 0xC0, 0x3F, 0x01, 0xF9, 0xF0, 0x0F, 0xC0, 0x7E, 0x7C, 0x03,
  0xF0, 0x1F, 0x9F, 0x81, 0xFC, 0x07, 0xE7, 0xE0, 0x7F, 0x03, 0xF9, 0xF8,
  0x1F, 0xC0, 0xFE, 0x7E, 0x07, 0xE0, 0x3F, 0x8F, 0x81, 0xF8, 0x0F, 0xC3,
  0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x0F, 0xE0, 0x7F,
  0x0F, 0xC3, 0xF8, 0x1F, 0xC1, 0xF0, 0xFC, 0x07, 0xF0, 0x7E, 0x3F, 0x01,
  0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x81, 0xF9, 0xFC,
  0x0F, 0xE0, 0x3E, 0x7F, 0x03, 0xF8, 0x0F, 0xDF, 0xC0, 0xFE, 0x03, 0xF7,
  0xE0, 0x3F, 0x80, 0xFD, 0xF8, 0x0F, 0xC0, 0x3F, 0x7E, 0x03, 0xF0, 0x07,
  0xDF, 0x80, 0xFC, 0x01, 0xF7, 0xE0, 0x7F, 0x00, 0x7F, 0xF8, 0x1F, 0xC0,
  0x1F, 0xFC, 0x07, 0xF0, 0x07, 0xFF, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7E,
  0x00, 0x3F, 0xF0, 0x1F, 0x80, 0x0F, 0xFC, 0x0F, 0xE0, 0x03, 0xFF, 0x03,
  0xF8, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x07,
  0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x0F, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x01,
  0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01,
  0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x07, 0xFE,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xE0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFC,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0,
  0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x03, 0xFE,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0,
  0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFE,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03,
  0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x01, 0xF9, 0xFC, 0x07, 0xF0,
  0x1F, 0xCF, 0xC0, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xFC, 0x07, 0xE3, 0xF0,
  0x1F, 0xE0, 0x3F, 0x1F, 0x80, 0xFF, 0x03, 0xF8, 0xFC, 0x07, 0xF8, 0x1F,
  0x87, 0xE0, 0x3B, 0xC0, 0xFC, 0x3F, 0x03, 0xDE, 0x07, 0xE1, 0xF8, 0x1E,
  0xF0, 0x7E, 0x0F, 0xC0, 0xF7, 0x03, 0xF0, 0x7E, 0x0F, 0x78, 0x1F, 0x83,
  0xF0, 0x7B, 0xC0, 0xFC, 0x1F, 0x83, 0xDE, 0x0F, 0xC0, 0xFC, 0x1E, 0xF0,
  0x7E, 0x07, 0xE1, 0xE7, 0x83, 0xF0, 0x3F, 0x0F, 0x3C, 0x1F, 0x81, 0xF0,
  0x79, 0xE1, 0xF8, 0x0F, 0x87, 0xCF, 0x0F, 0xC0, 0xFC, 0x3C, 0x78, 0x7E,
  0x07, 0xE1, 0xE3, 0xC3, 0xE0, 0x3F, 0x0F, 0x1E, 0x3F, 0x01, 0xF8, 0xF0,
  0xF1, 0xF8, 0x0F, 0xC7, 0x87, 0x8F, 0xC0, 0x7E, 0x3C, 0x3C, 0x7C, 0x03,
  0xF1, 0xE1, 0xE7, 0xE0, 0x1F, 0x9E, 0x0F, 0x3F, 0x00, 0xFC, 0xF0, 0x79,
  0xF8, 0x07, 0xE7, 0x83, 0xCF, 0x80, 0x3F, 0x78, 0x1E, 0xFC, 0x01, 0xFB,
  0xC0, 0xE7, 0xE0, 0x0F, 0xDE, 0x0F, 0x3F, 0x00, 0x7C, 0xF0, 0x79, 0xF0,
  0x03, 0xEF, 0x03, 0xDF, 0x80, 0x1F, 0x78, 0x1E, 0xFC, 0x00, 0xFB, 0xC0,
  0xF7, 0xC0, 0x07, 0xDE, 0x07, 0xBE, 0x00, 0x7F, 0xE0, 0x3D, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00,
  0x0F, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F,
  0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7F,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x0F,
  0xC1, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7F,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0xFF, 0xF1, 0xFC, 0x03, 0xFF, 0xF3, 0xF8, 0x0F, 0xFF, 0xF7, 0xF0,
  0x3F, 0xFF, 0xEF, 0xE0, 0xFF, 0xFF, 0xDF, 0xC3, 0xFF, 0x03, 0xFF, 0x07,
  0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFD, 0xFC, 0x0F, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xEF, 0xE0,
  0x0F, 0xFF, 0x9F, 0xC0, 0x0F, 0xFC, 0x3F, 0x80, 0x01, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x07, 0xF0, 0xFF, 0xE0, 0x07, 0xF3, 0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xF8,
  0x07, 0xF7, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x07, 0xFE,
  0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF8,
  0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0xE0, 0x1F, 0xE0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0x7F, 0xFF, 0x80,
  0x7F, 0x7F, 0xFF, 0x00, 0xFE, 0x3F, 0xFE, 0x00, 0xFE, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F,
  0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x7F,
  0x83, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xFF,
  0x8F, 0xE0, 0x07, 0xFF, 0xE7, 0xF0, 0x07, 0xFF, 0xFB, 0xF8, 0x07, 0xFF,
  0xFD, 0xFC, 0x07, 0xFF, 0xFE, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFC,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFE,
  0x07, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xEF, 0xE0, 0x1F, 0xFF, 0xF7,
  0xF0, 0x07, 0xFF, 0xF7, 0xF0, 0x01, 0xFF, 0xF3, 0xF8, 0x00, 0x7F, 0xE1,
  0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x00, 0xFF,
  0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFE, 0x1F,
  0xE0, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0xF1,
  0xFC, 0x03, 0xFF, 0xF3, 0xF8, 0x0F, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xEF,
  0xE0, 0xFF, 0xFF, 0xDF, 0xC3, 0xFF, 0x03, 0xFF, 0x07, 0xF8, 0x03, 0xFE,
  0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF0,
  0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F,
  0x00, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x7F, 0x01, 0xFF, 0xFE, 0xFE, 0x01, 0xFF, 0xF9,
  0xFC, 0x01, 0xFF, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x07, 0xF0, 0xFF, 0xE0, 0x07, 0xF3, 0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xF8,
  0x07, 0xF7, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x07, 0xFE,
  0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFE,
  0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xFC,
  0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xE0,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x07, 0xE3, 0xE0,
  0x7E, 0x01, 0xF9, 0xFC, 0x3F, 0xC0, 0x7E, 0xFF, 0x9F, 0xF8, 0x3F, 0x7F,
  0xEF, 0xFE, 0x0F, 0xDF, 0xFB, 0xFF, 0xC3, 0xFC, 0x7F, 0x87, 0xF0, 0xFE,
  0x0F, 0xC1, 0xFC, 0x3F, 0x03, 0xF0, 0x7F, 0x0F, 0xC0, 0xF8, 0x1F, 0xC3,
  0xF0, 0x3E, 0x07, 0xE1, 0xFC, 0x0F, 0x81, 0xF8, 0x7F, 0x03, 0xE0, 0x7E,
  0x1F, 0x81, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x0F, 0xE1, 0xF8, 0x1F, 0x03,
  0xF8, 0x7E, 0x07, 0xC0, 0xFE, 0x3F, 0x81, 0xF0, 0x3F, 0x0F, 0xE0, 0x7C,
  0x0F, 0xC3, 0xF0, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC0, 0xFC, 0x3F, 0x03,
  0xE0, 0x7F, 0x0F, 0xC0, 0xF8, 0x1F, 0xC7, 0xF0, 0x3E, 0x07, 0xE1, 0xFC,
  0x0F, 0x81, 0xF8, 0x7F, 0x07, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x1F, 0x87,
  0xE0, 0x7C, 0x0F, 0xE1, 0xF8, 0x1F, 0x03, 0xF8, 0x7E, 0x07, 0xC0, 0xFC,
  0x3F, 0x81, 0xF0, 0x3F, 0x0F, 0xE0, 0x7C, 0x0F, 0xC3, 0xF0, 0x3F, 0x03,
  0xF0, 0xFC, 0x0F, 0x80, 0xFC, 0x3F, 0x03, 0xE0, 0x7F, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0xE0, 0x07, 0xF3, 0xFF, 0xF8, 0x07, 0xF7,
  0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFE,
  0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0,
  0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80,
  0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xC0, 0xFF, 0x83, 0xFC, 0x01, 0xFF, 0x0F, 0xE0, 0x03, 0xFC,
  0x7F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x3F,
  0x80, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x3F, 0x9F, 0xC0, 0x01, 0xFE, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xF1,
  0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x0F, 0xFE, 0x00, 0x1F,
  0xCF, 0xFF, 0xE0, 0x07, 0xF7, 0xFF, 0xF8, 0x01, 0xFD, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x3F,
  0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x7F, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xFC, 0x01, 0xFD, 0xFF,
  0xFE, 0x00, 0x7F, 0x7F, 0xFF, 0x00, 0x3F, 0xCF, 0xFF, 0x80, 0x0F, 0xE1,
  0xFF, 0x80, 0x03, 0xF8, 0x06, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0xF1, 0xFC, 0x03, 0xFF,
  0xF3, 0xF8, 0x0F, 0xFF, 0xE7, 0xF0, 0x3F, 0xFF, 0xEF, 0xE0, 0xFF, 0xFF,
  0xDF, 0xC3, 0xFF, 0x03, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x03,
  0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F,
  0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x83, 0xFE,
  0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFD, 0xFC, 0x0F, 0xFF,
  0xFB, 0xF8, 0x0F, 0xFF, 0xEF, 0xE0, 0x0F, 0xFF, 0x9F, 0xC0, 0x0F, 0xFC,
  0x3F, 0x80, 0x01, 0x80, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3F,
  0xC0, 0x07, 0xF1, 0xFF, 0xF0, 0x07, 0xF3, 0xFF, 0xF8, 0x07, 0xF7, 0xFF,
  0xFC, 0x07, 0xF7, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xEE, 0x03,
  0xFE, 0x0F, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80,
  0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xFB,
  0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0x1F,
  0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x03, 0xF8,
  0x03, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7F,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFC, 0x03, 0xEF, 0xC0, 0x7F, 0x01,
  0xFB, 0xF0, 0x1F, 0xC0, 0x7E, 0xFC, 0x07, 0xF0, 0x1F, 0x3F, 0x03, 0xFC,
  0x0F, 0xCF, 0xC0, 0xFF, 0x03, 0xF3, 0xF0, 0x3B, 0xC0, 0xFC, 0xFC, 0x1E,
  0xF0, 0x3E, 0x3F, 0x07, 0xBC, 0x1F, 0x8F, 0xC1, 0xEF, 0x07, 0xE3, 0xF0,
  0xF3, 0xC1, 0xF0, 0xFC, 0x3C, 0xF0, 0xFC, 0x3F, 0x0F, 0x3C, 0x3F, 0x0F,
  0xC3, 0x8F, 0x0F, 0x83, 0xF1, 0xE3, 0xC7, 0xE0, 0xFC, 0x78, 0xF1, 0xF8,
  0x3F, 0x1C, 0x3C, 0x7C, 0x0F, 0xCF, 0x0F, 0x1F, 0x03, 0xF3, 0xC3, 0xCF,
  0xC0, 0xF8, 0xF0, 0xF3, 0xE0, 0x3E, 0x78, 0x3C, 0xF8, 0x0F, 0x9E, 0x0F,
  0x7E, 0x03, 0xE7, 0x83, 0xDF, 0x00, 0xFB, 0xC0, 0xF7, 0xC0, 0x3E, 0xF0,
  0x3F, 0xF0, 0x0F, 0xBC, 0x0F, 0xFC, 0x03, 0xEE, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x1F,
  0xCF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xE0,
  0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03,
  0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC,
  0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFE, 0x1F,
  0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x7F, 0x01, 0xFF,
  0xFC, 0xFE, 0x01, 0xFF, 0xF1, 0xFC, 0x01, 0xFF, 0x87, 0xF0, 0x00, 0x10,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0x1F, 0xFF, 0x80,
  0x3F, 0x3F, 0xFF, 0xC0, 0x7F, 0x3F, 0xFF, 0xE0, 0x7E, 0x7F, 0x9F, 0xE0,
  0x7E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E, 0x07, 0xF9, 0xFE, 0x7E, 0x03, 0xFF,
  0xFC, 0xFE, 0x03, 0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0xF8, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xC0,
};

const GFXglyph JetBrainsMono_SemiBoldItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 16, 45, 37, 11, -45 },
  { 91, 23, 19, 37, 10, -45 },
  { 146, 36, 45, 37, 1, -45 },
  { 349, 34, 62, 37, 2, -53 },
  { 613, 44, 45, 37, -3, -45 },
  { 861, 34, 46, 37, 1, -45 },
  { 1057, 9, 19, 37, 17, -45 },
  { 1079, 26, 60, 37, 9, -52 },
  { 1274, 26, 60, 37, 3, -52 },
  { 1469, 33, 32, 37, 3, -37 },
  { 1601, 30, 29, 37, 4, -35 },
  { 1710, 17, 19, 37, 5, -9 },
  { 1751, 21, 6, 37, 8, -23 },
  { 1767, 12, 11, 37, 10, -10 },
  { 1784, 38, 58, 37, 0, -51 },
  { 2060, 32, 46, 37, 3, -45 },
  { 2244, 29, 45, 37, 3, -45 },
  { 2408, 33, 45, 37, 2, -45 },
  { 2594, 33, 46, 37, 2, -45 },
  { 2784, 31, 45, 37, 3, -45 },
  { 2959, 32, 46, 37, 3, -45 },
  { 3143, 31, 46, 37, 2, -45 },
  { 3322, 31, 45, 37, 6, -45 },
  { 3497, 33, 46, 37, 2, -45 },
  { 3687, 31, 45, 37, 5, -45 },
  { 3862, 16, 35, 37, 10, -34 },
  { 3932, 21, 44, 37, 5, -34 },
  { 4048, 30, 33, 37, 5, -37 },
  { 4172, 30, 22, 37, 4, -31 },
  { 4255, 30, 33, 37, 3, -37 },
  { 4379, 26, 45, 37, 8, -45 },
  { 4526, 38, 56, 37, 0, -45 },
  { 4792, 32, 45, 37, 0, -45 },
  { 4972, 34, 45, 37, 2, -45 },
  { 5164, 32, 46, 37, 3, -45 },
  { 5348, 33, 45, 37, 2, -45 },
  { 5534, 33, 45, 37, 3, -45 },
  { 5720, 35, 45, 37, 2, -45 },
  { 5917, 32, 46, 37, 3, -45 },
  { 6101, 34, 45, 37, 2, -45 },
  { 6293, 32, 45, 37, 3, -45 },
  { 6473, 35, 46, 37, 0, -45 },
  { 6675, 36, 45, 37, 2, -45 },
  { 6878, 27, 45, 37, 4, -45 },
  { 7030, 36, 45, 37, 1, -45 },
  { 7233, 34, 45, 37, 2, -45 },
  { 7425, 32, 46, 37, 3, -45 },
  { 7609, 35, 45, 37, 2, -45 },
  { 7806, 32, 56, 37, 3, -45 },
  { 8030, 34, 45, 37, 2, -45 },
  { 8222, 34, 46, 37, 2, -45 },
  { 8418, 32, 45, 37, 6, -45 },
  { 8598, 33, 46, 37, 3, -45 },
  { 8788, 32, 45, 37, 7, -45 },
  { 8968, 37, 45, 37, 3, -45 },
  { 9177, 39, 45, 37, -1, -45 },
  { 9397, 33, 45, 37, 6, -45 },
  { 9583, 33, 45, 37, 2, -45 },
  { 9769, 25, 58, 37, 8, -51 },
  { 9951, 20, 58, 37, 9, -51 },
  { 10096, 25, 58, 37, 5, -51 },
  { 10278, 28, 24, 37, 5, -45 },
  { 10362, 30, 6, 37, 0, 2 },
  { 10385, 13, 9, 37, 15, -48 },
  { 10400, 31, 35, 37, 3, -34 },
  { 10536, 32, 46, 37, 2, -45 },
  { 10720, 31, 35, 37, 3, -34 },
  { 10856, 33, 46, 37, 3, -45 },
  { 11046, 30, 35, 37, 3, -34 },
  { 11178, 41, 56, 37, -3, -45 },
  { 11465, 31, 45, 37, 3, -34 },
  { 11640, 32, 45, 37, 2, -45 },
  { 11820, 30, 48, 37, 2, -48 },
  { 12000, 32, 59, 37, 1, -48 },
  { 12236, 35, 45, 37, 2, -45 },
  { 12433, 27, 45, 37, 5, -45 },
  { 12585, 34, 34, 37, 1, -34 },
  { 12730, 32, 34, 37, 2, -34 },
  { 12866, 30, 35, 37, 3, -34 },
  { 12998, 34, 45, 37, 0, -34 },
  { 13190, 31, 45, 37, 3, -34 },
  { 13365, 32, 34, 37, 3, -34 },
  { 13501, 32, 35, 37, 2, -34 },
  { 13641, 31, 43, 37, 4, -43 },
  { 13808, 31, 35, 37, 3, -34 },
  { 13944, 31, 34, 37, 5, -34 },
  { 14076, 34, 34, 37, 4, -34 },
  { 14221, 36, 34, 37, 0, -34 },
  { 14374, 31, 45, 37, 3, -34 },
  { 14549, 32, 34, 37, 2, -34 },
  { 14685, 32, 58, 37, 5, -51 },
  { 14917, 16, 58, 37, 11, -51 },
  { 15033, 32, 58, 37, 1, -51 },
  { 15265, 32, 13, 37, 3, -28 },
};

const GFXfont JetBrainsMono_SemiBoldItalic61pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic61pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic61pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC61PT7B_H_
