#ifndef _JETBRAINSMONO_SEMIBOLDITALIC42PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x70, 0x1C, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xF8,
  0xFE, 0x3F, 0x0F, 0x80, 0x3E, 0x1F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C,
  0xF8, 0x7C, 0xF0, 0x78, 0xF0, 0x78, 0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x07,
  0x80, 0x0F, 0x03, 0x80, 0x07, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0,
  0xE0, 0x01, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x1C, 0x0F, 0x00, 0x1E,
  0x07, 0x80, 0x0F, 0x03, 0x80, 0x07, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03,
  0xC0, 0xE0, 0x01, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x8F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x3C, 0x0E, 0x00, 0x1C, 0x0F, 0x00,
  0x1E, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x07, 0x03, 0xC0, 0x07, 0x81, 0xE0,
  0x03, 0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x1F, 0xDB, 0xF8, 0x3E, 0x33, 0xF0, 0xF8, 0xE3, 0xE1, 0xF1, 0xC7, 0xC3,
  0xE3, 0x80, 0x07, 0xC7, 0x00, 0x0F, 0x8C, 0x00, 0x1F, 0x98, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x73, 0xF0, 0x00, 0xE3,
  0xE0, 0x01, 0xC7, 0xC0, 0x03, 0x0F, 0x8F, 0x86, 0x1F, 0x1F, 0x1C, 0x3E,
  0x3E, 0x38, 0xF8, 0x7F, 0x73, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x3C, 0x07, 0xFC, 0x01, 0xE0, 0x3F, 0xF0, 0x07, 0x01, 0xF3,
  0xE0, 0x38, 0x07, 0x87, 0x81, 0xE0, 0x1C, 0x1E, 0x0F, 0x00, 0x70, 0x78,
  0x78, 0x03, 0xC1, 0xE3, 0xC0, 0x0F, 0x07, 0x1E, 0x00, 0x3C, 0x3C, 0x70,
  0x00, 0xF0, 0xF3, 0x80, 0x03, 0xFF, 0x9E, 0x00, 0x07, 0xFC, 0xF0, 0x00,
  0x0F, 0xE7, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE7, 0xF8, 0x00, 0x0F,
  0x7F, 0xF0, 0x00, 0x79, 0xE3, 0xC0, 0x03, 0xCF, 0x0F, 0x00, 0x1E, 0x3C,
  0x1C, 0x00, 0x70, 0xE0, 0xF0, 0x03, 0xC3, 0x83, 0xC0, 0x1E, 0x0E, 0x0F,
  0x00, 0xF0, 0x78, 0x38, 0x07, 0x80, 0xF1, 0xE0, 0x3C, 0x03, 0xFF, 0x01,
  0xE0, 0x0F, 0xFC, 0x0F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3E, 0x1F, 0x80, 0xF8,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x3E, 0xF8, 0xF8, 0xF9,
  0xF1, 0xF1, 0xF3, 0xE1, 0xF7, 0xC7, 0x83, 0xFF, 0x0F, 0x03, 0xFC, 0x3E,
  0x07, 0xF8, 0x7C, 0x07, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x1F, 0x83, 0xF0,
  0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xDF, 0x0F, 0xFF, 0x3E, 0x07, 0xF8,
  0x3E, 0x00, 0x7D, 0xF7, 0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xCF, 0x3C, 0xF0,
  0x00, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x0C, 0x0F, 0x03, 0x3E, 0x1C, 0x3E, 0x7F,
  0x39, 0xFD, 0xFF, 0x67, 0xFD, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0xF7, 0x80, 0x03, 0xEF, 0x80, 0x0F, 0x9F,
  0x00, 0x3E, 0x1F, 0x00, 0xFC, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xC0, 0x78,
  0x01, 0x00, 0x40, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF,
  0x7E, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0xE1, 0xFC, 0x3E, 0x03, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00,
  0x7C, 0x78, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1E, 0x3E, 0x00, 0x78,
  0xF9, 0xE3, 0xE3, 0xC7, 0xCF, 0x8F, 0x3F, 0x3E, 0x7C, 0x7C, 0xF9, 0xF1,
  0xE3, 0xC7, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x78, 0x01, 0xF1, 0xE0, 0x07,
  0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xF0, 0x0F, 0x87,
  0xE0, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x07, 0xFF, 0x80, 0xFE, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF0, 0x1C, 0x1F,
  0x01, 0x81, 0xF0, 0x10, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE3, 0xF8, 0x3E, 0x03,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0xC0, 0xFC,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x78, 0x3E, 0x07, 0xC3, 0xF0, 0x3E, 0x3F, 0x01, 0xF3, 0xF0, 0x0F, 0x9F,
  0x00, 0x7C, 0xF8, 0x03, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xCF, 0xE0, 0x1F, 0x7F, 0xC0, 0x7B, 0xFF,
  0x81, 0xFF, 0xFF, 0x0F, 0xE0, 0xFC, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0xFC,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF9, 0xF0, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0x03, 0xF3, 0xF0, 0x0F, 0x9F,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7B, 0xE0, 0x07,
  0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x3F, 0x83, 0xF0, 0xFF,
  0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9,
  0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0xE1, 0xF8, 0x3E, 0x03, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00,
  0x78, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0xC7, 0xE0,
  0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x7F,
  0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0x80, 0xFC, 0x7C, 0x01, 0xF1, 0xE0, 0x07,
  0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xF0, 0x0F, 0x8F,
  0xE0, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF,
  0xFC, 0x1F, 0xC3, 0xF8, 0xFC, 0x07, 0xE3, 0xE0, 0x0F, 0x9F, 0x80, 0x3E,
  0x7C, 0x00, 0x79, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C,
  0x01, 0xF9, 0xF0, 0x07, 0xC7, 0xE0, 0x3F, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0x00, 0xF8, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F,
  0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0x83,
  0xF0, 0x00, 0x20, 0x07, 0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x7E, 0x03, 0xF8,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x18, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00,
  0x0F, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x07,
  0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03,
  0xF8, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x81,
  0xF0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x87, 0x80, 0x01, 0xE1, 0xE0, 0x08, 0x78, 0x78, 0x1F, 0xDE, 0x1E, 0x0F,
  0xF7, 0x8F, 0x87, 0xFF, 0xE3, 0xC1, 0xE0, 0xF8, 0xF0, 0xF8, 0x3C, 0x3C,
  0x3C, 0x0F, 0x0F, 0x0F, 0x03, 0xC3, 0xC3, 0xC0, 0xF1, 0xF0, 0xF0, 0x3C,
  0x78, 0x7C, 0x0F, 0x1E, 0x1E, 0x07, 0xC7, 0x87, 0x81, 0xE1, 0xE1, 0xE0,
  0x78, 0x78, 0x7C, 0x3E, 0x1E, 0x1F, 0x9F, 0x8F, 0x03, 0xFD, 0xE3, 0xC0,
  0xFE, 0x78, 0xF0, 0x06, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xDE, 0x00, 0x1F, 0x78,
  0x00, 0x7D, 0xF0, 0x01, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x01,
  0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xE0,
  0xF0, 0x1F, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xC0, 0x3E, 0x3E, 0x00, 0xF8, 0xF8,
  0x01, 0xE3, 0xE0, 0x07, 0x9F, 0x00, 0x1E, 0x7C, 0x00, 0x7B, 0xF0, 0x01,
  0xFF, 0x80, 0x07, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3C, 0x03, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0x80,
  0x3E, 0x3E, 0x03, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0xF0, 0x1F, 0xC3, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C,
  0x00, 0xF1, 0xF0, 0x03, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x78, 0x01,
  0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80,
  0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xE1, 0xFC, 0x3E, 0x03, 0xF1, 0xF8,
  0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xE0, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xF0,
  0x1F, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x01, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F,
  0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xE1, 0xFC, 0x3E, 0x03, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x87, 0xFE, 0x3E, 0x3F,
  0xF9, 0xF0, 0xFF, 0xE7, 0xC3, 0xFF, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1,
  0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xE1, 0xF0,
  0x0F, 0x87, 0xE0, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00,
  0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x87, 0xC0, 0x1F,
  0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7C, 0x03, 0xE0, 0xF0, 0x07, 0xC3, 0xE0,
  0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0x7C, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F,
  0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0xFC,
  0x0F, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0,
  0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x80,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x80,
  0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x78, 0x07, 0xC0,
  0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0,
  0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x1F, 0x87, 0xF0, 0x1F, 0x83, 0xF8,
  0x0F, 0xC1, 0xDC, 0x0F, 0xE0, 0xEE, 0x07, 0xF0, 0x77, 0x07, 0xF8, 0x3B,
  0x83, 0xBC, 0x3D, 0xC3, 0xDE, 0x1E, 0xF1, 0xDE, 0x0F, 0x79, 0xEF, 0x07,
  0x9C, 0xE7, 0x83, 0xCE, 0x73, 0xC1, 0xE7, 0x7B, 0xE1, 0xF3, 0xB9, 0xF0,
  0xF9, 0xFC, 0xF0, 0x7C, 0xFC, 0x78, 0x3E, 0x7E, 0x3C, 0x1E, 0x1E, 0x3E,
  0x0F, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0x83, 0xE0, 0x03,
  0xC1, 0xF0, 0x01, 0xE0, 0xF8, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00,
  0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x07, 0xC0,
  0x0F, 0x83, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07,
  0xF0, 0x1F, 0x07, 0xF0, 0x1E, 0x07, 0xF0, 0x1E, 0x0F, 0xF0, 0x1E, 0x0F,
  0xF0, 0x1E, 0x0F, 0x78, 0x3E, 0x0F, 0x78, 0x3E, 0x0F, 0x78, 0x3E, 0x0F,
  0x78, 0x3C, 0x1F, 0x78, 0x3C, 0x1F, 0x3C, 0x3C, 0x1F, 0x3C, 0x7C, 0x1E,
  0x3C, 0x7C, 0x1E, 0x3C, 0x7C, 0x1E, 0x3C, 0x78, 0x1E, 0x1E, 0x78, 0x3E,
  0x1E, 0x78, 0x3E, 0x1E, 0x78, 0x3E, 0x1E, 0xF8, 0x3C, 0x1E, 0xF8, 0x3C,
  0x1E, 0xF0, 0x3C, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C,
  0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x07, 0xF0, 0x78, 0x07, 0xE0, 0xF8,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xE1, 0xF8, 0x3E, 0x03, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E,
  0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00,
  0xF9, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1,
  0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0,
  0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xE0, 0x0F, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F, 0x81, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE1, 0xFC,
  0x3E, 0x03, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x78,
  0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1E, 0x3E, 0x00, 0xF8, 0xF8, 0x03,
  0xE3, 0xE0, 0x0F, 0x8F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xC7,
  0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80,
  0x1F, 0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0xFC,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC1, 0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3F, 0x1F, 0x00, 0x7E,
  0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x87,
  0xC0, 0x3F, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83,
  0xE0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x1F,
  0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0x7C,
  0x3C, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0xFE, 0x07, 0xC0, 0x7E, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x7F, 0x07,
  0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8,
  0x7C, 0x01, 0xE0, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0,
  0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0xF0, 0x78, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F,
  0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x78, 0x3E, 0x01, 0xF0,
  0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0,
  0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC1, 0xE0, 0x1F,
  0x07, 0x80, 0x78, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x07,
  0xC1, 0xF0, 0x1F, 0x07, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7,
  0xC0, 0x1F, 0x1F, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x00,
  0x0F, 0x3C, 0x00, 0x3D, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C,
  0x1F, 0x07, 0x9E, 0x0F, 0x83, 0xCF, 0x07, 0xC1, 0xE7, 0x83, 0xE1, 0xF3,
  0xC3, 0xF0, 0xF3, 0xE1, 0xF8, 0x79, 0xF0, 0xDC, 0x3C, 0xF8, 0xEE, 0x3E,
  0x78, 0x76, 0x1E, 0x3C, 0x3B, 0x0F, 0x1E, 0x19, 0x87, 0x8F, 0x1C, 0xC7,
  0x87, 0x8E, 0x63, 0xC3, 0xC7, 0x31, 0xE1, 0xE7, 0x38, 0xF0, 0xF3, 0x9C,
  0xF0, 0x79, 0xCE, 0x78, 0x3C, 0xC7, 0x3C, 0x1E, 0xE3, 0x9E, 0x0F, 0x71,
  0xDE, 0x07, 0xB8, 0xEF, 0x03, 0xD8, 0x77, 0x81, 0xDC, 0x3B, 0x80, 0xEE,
  0x1F, 0xC0, 0xF7, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x1F,
  0xC1, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x00, 0xF8,
  0x07, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE3, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC1, 0xF8,
  0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xF0,
  0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x87,
  0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x3E,
  0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF7,
  0xC0, 0x03, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x80, 0x3C, 0x78, 0x07,
  0xC7, 0x80, 0x78, 0x7C, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x1F, 0x03, 0xC3,
  0xE0, 0x3E, 0x3C, 0x01, 0xE7, 0xC0, 0x1E, 0xF8, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0xF8, 0x7C, 0x7C,
  0x3E, 0x1E, 0x1F, 0x00, 0x20, 0x00, 0x07, 0xF1, 0xF0, 0x7F, 0xE7, 0x83,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7E, 0x0F, 0xE3, 0xF0, 0x1F, 0x8F, 0x80,
  0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0x78,
  0x03, 0xE3, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x83, 0xF8, 0x7F, 0xFB,
  0xE1, 0xFF, 0xEF, 0x03, 0xFF, 0x7C, 0x07, 0xF9, 0xF0, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x40, 0x1F, 0x3F, 0xC0, 0xFB, 0xFF, 0x07,
  0xFF, 0xFC, 0x3D, 0xFF, 0xE3, 0xF8, 0x3F, 0x9F, 0x80, 0xFC, 0xF8, 0x03,
  0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8,
  0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7C,
  0x7C, 0x03, 0xE7, 0xE0, 0x3F, 0x3F, 0x83, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0x7D, 0xFF, 0x83, 0xC7, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xC0, 0xFC, 0xFC,
  0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x01, 0xF3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xFC, 0x1F, 0x87,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x10, 0x3E, 0x01, 0xFC, 0x7C,
  0x0F, 0xFC, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xF8, 0x3F, 0x87,
  0xE0, 0x3F, 0x0F, 0x80, 0x7E, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0xF8,
  0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF8, 0x0F,
  0xC1, 0xF8, 0x3F, 0x83, 0xFF, 0xDF, 0x07, 0xFF, 0xBC, 0x07, 0xFE, 0xF8,
  0x07, 0xF9, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFE, 0x7F, 0x0F, 0x80, 0xF8, 0x78, 0x03, 0xE7, 0xC0,
  0x1F, 0x3E, 0x00, 0xF9, 0xE0, 0x07, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x87, 0xFB, 0xFC, 0x1F,
  0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x07, 0xF1, 0xF0, 0x7F, 0xE7, 0x83, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7E, 0x0F, 0xE3, 0xF0, 0x1F, 0x8F, 0x80, 0x7E, 0x3E, 0x00,
  0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1,
  0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF8,
  0x1F, 0x87, 0xFF, 0xFE, 0x0F, 0xFE, 0xF8, 0x3F, 0xFB, 0xE0, 0x7F, 0x8F,
  0x00, 0x30, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x40, 0x1F, 0x3F, 0xC0, 0xFB, 0xFF, 0x07, 0xFF, 0xFC, 0x3D, 0xFF, 0xE3,
  0xF8, 0x3F, 0x9F, 0x80, 0xFC, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x01,
  0xF1, 0xF0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E,
  0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x78, 0x03, 0xE7, 0xC0, 0x1F,
  0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x7C, 0x03, 0xE3, 0xE0,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x7E, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF8,
  0x0F, 0x81, 0xE0, 0x3F, 0x07, 0xC0, 0xFC, 0x0F, 0x83, 0xF0, 0x1F, 0x07,
  0xC0, 0x3E, 0x1F, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0xC0, 0x3E, 0x0F, 0x80,
  0x7C, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3F, 0x07, 0xC0, 0x3E, 0x0F,
  0x80, 0x7E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x08, 0x08, 0x0F, 0x7E,
  0x7E, 0x0F, 0x7E, 0xFE, 0x0F, 0xFE, 0xFF, 0x0F, 0x9F, 0x1F, 0x1F, 0x0F,
  0x1F, 0x1F, 0x0E, 0x1F, 0x1E, 0x0E, 0x1F, 0x1E, 0x1E, 0x1F, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x1E, 0x1E, 0x3E, 0x1C, 0x1E, 0x3E, 0x1C,
  0x3E, 0x3C, 0x3C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x3C,
  0x3C, 0x7C, 0x38, 0x3C, 0x7C, 0x38, 0x7C, 0x78, 0x78, 0x7C, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0xF8, 0x78, 0x78, 0x00, 0x02, 0x00, 0xF9, 0xFE,
  0x07, 0xDF, 0xF8, 0x3F, 0xFF, 0xE1, 0xEF, 0xFF, 0x1F, 0xC1, 0xFC, 0xFC,
  0x07, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0x7C,
  0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80,
  0x7C, 0x7C, 0x03, 0xE3, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF,
  0x80, 0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0x00, 0x08,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F,
  0xC1, 0xF8, 0xFC, 0x07, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07,
  0xDF, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0,
  0x07, 0xCF, 0x80, 0x3E, 0x78, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8,
  0xFC, 0x1F, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x80, 0x0F, 0x9F, 0xE0, 0x1F, 0x7F, 0xE0, 0x3F, 0xFF,
  0xE0, 0x7B, 0xFF, 0xC1, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x1F,
  0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0xF8, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xFC, 0x1F, 0x83, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xBF, 0xF0, 0x1E, 0x3F, 0x80, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x07, 0xF1, 0xF0, 0x7F, 0xE7, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7E,
  0x0F, 0xE3, 0xF0, 0x1F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xF8, 0x07,
  0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0xC0,
  0x7E, 0x1F, 0x83, 0xF8, 0x7F, 0xFB, 0xE1, 0xFF, 0xEF, 0x03, 0xFF, 0x7C,
  0x07, 0xF9, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0x00, 0x3E, 0x7F, 0x80, 0xF3, 0xFF, 0x07, 0xDF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x7F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x1F, 0x1F,
  0x00, 0x7C, 0x78, 0x03, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFE,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x80, 0x7C, 0xF8,
  0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x3E, 0x00, 0xF9, 0xF8, 0x0F, 0xCF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xE0, 0x40, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xF0, 0x0F, 0x8F,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C,
  0x03, 0xE1, 0xF0, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xBE, 0x00, 0x7D, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x3C, 0x03, 0xE1, 0xF0,
  0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x78, 0x0F, 0x07, 0xC0,
  0x78, 0x3E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xCF,
  0x80, 0x1E, 0xF8, 0x00, 0xF7, 0xC0, 0x07, 0xBC, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x78, 0x1F, 0xE0,
  0xF0, 0x3F, 0xC1, 0xE0, 0xF7, 0x87, 0xC1, 0xEF, 0x0F, 0x83, 0xDE, 0x1B,
  0x0F, 0x3C, 0x76, 0x1E, 0x78, 0xEC, 0x3C, 0xF1, 0x98, 0xF1, 0xE7, 0x31,
  0xE3, 0xCE, 0x63, 0xC7, 0x98, 0xC7, 0x0F, 0x71, 0x9E, 0x1E, 0xE3, 0x3C,
  0x3D, 0x86, 0x70, 0x77, 0x0D, 0xE0, 0xEE, 0x1B, 0xC1, 0xDC, 0x37, 0x03,
  0xB0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF0, 0x1F, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x1F, 0x01, 0xF8, 0x1F,
  0x80, 0x7C, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xEF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x07, 0xE1, 0xF0, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x0F, 0xC3,
  0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x8F,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80,
  0x7C, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0x7E,
  0x0F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xBE, 0x0F, 0xFC, 0xF0, 0x0F, 0xE7,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8,
  0x00, 0x03, 0xC0, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x3F, 0x80, 0xF3, 0xFF, 0x03, 0xCF, 0xFE, 0x1F, 0x7C,
  0xF8, 0x7D, 0xE1, 0xF1, 0xE7, 0x87, 0xFF, 0xBE, 0x0F, 0xFC, 0xF0, 0x1F,
  0xE0, 0x00, 0x3E, 0x00,
};

const GFXglyph JetBrainsMono_SemiBoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 10, 31, 25, 8, -31 },
  { 40, 16, 13, 25, 7, -31 },
  { 66, 25, 31, 25, 1, -31 },
  { 163, 23, 43, 25, 1, -37 },
  { 287, 30, 31, 25, -2, -31 },
  { 404, 23, 31, 25, 1, -31 },
  { 494, 6, 13, 25, 12, -31 },
  { 504, 18, 40, 25, 6, -35 },
  { 594, 18, 40, 25, 2, -35 },
  { 684, 23, 22, 25, 2, -26 },
  { 748, 20, 20, 25, 3, -24 },
  { 798, 11, 13, 25, 4, -6 },
  { 816, 14, 4, 25, 6, -16 },
  { 823, 8, 7, 25, 7, -7 },
  { 830, 26, 40, 25, 0, -35 },
  { 960, 22, 31, 25, 2, -31 },
  { 1046, 20, 31, 25, 2, -31 },
  { 1124, 22, 31, 25, 2, -31 },
  { 1210, 22, 31, 25, 2, -31 },
  { 1296, 21, 31, 25, 2, -31 },
  { 1378, 22, 31, 25, 2, -31 },
  { 1464, 21, 31, 25, 2, -31 },
  { 1546, 22, 31, 25, 4, -31 },
  { 1632, 22, 31, 25, 2, -31 },
  { 1718, 22, 31, 25, 3, -31 },
  { 1804, 11, 24, 25, 7, -24 },
  { 1837, 14, 31, 25, 4, -24 },
  { 1892, 21, 23, 25, 3, -25 },
  { 1953, 20, 14, 25, 3, -21 },
  { 1988, 21, 23, 25, 2, -25 },
  { 2049, 18, 31, 25, 5, -31 },
  { 2119, 26, 39, 25, 0, -31 },
  { 2246, 22, 31, 25, 0, -31 },
  { 2332, 22, 31, 25, 2, -31 },
  { 2418, 22, 31, 25, 2, -31 },
  { 2504, 23, 31, 25, 1, -31 },
  { 2594, 23, 31, 25, 2, -31 },
  { 2684, 23, 31, 25, 2, -31 },
  { 2774, 22, 31, 25, 2, -31 },
  { 2860, 23, 31, 25, 2, -31 },
  { 2950, 22, 31, 25, 2, -31 },
  { 3036, 24, 31, 25, 0, -31 },
  { 3129, 24, 31, 25, 2, -31 },
  { 3222, 18, 31, 25, 3, -31 },
  { 3292, 25, 31, 25, 1, -31 },
  { 3389, 24, 31, 25, 1, -31 },
  { 3482, 22, 31, 25, 2, -31 },
  { 3568, 23, 31, 25, 2, -31 },
  { 3658, 22, 39, 25, 2, -31 },
  { 3766, 23, 31, 25, 2, -31 },
  { 3856, 24, 31, 25, 1, -31 },
  { 3949, 22, 31, 25, 4, -31 },
  { 4035, 23, 31, 25, 2, -31 },
  { 4125, 22, 31, 25, 5, -31 },
  { 4211, 25, 31, 25, 2, -31 },
  { 4308, 27, 31, 25, -1, -31 },
  { 4413, 23, 31, 25, 4, -31 },
  { 4503, 22, 31, 25, 2, -31 },
  { 4589, 18, 40, 25, 5, -35 },
  { 4679, 14, 40, 25, 6, -35 },
  { 4749, 18, 40, 25, 3, -35 },
  { 4839, 20, 17, 25, 3, -31 },
  { 4882, 21, 4, 25, 0, 1 },
  { 4893, 8, 6, 25, 11, -33 },
  { 4899, 22, 24, 25, 2, -24 },
  { 4965, 21, 31, 25, 2, -31 },
  { 5047, 21, 24, 25, 2, -24 },
  { 5110, 23, 31, 25, 2, -31 },
  { 5200, 21, 24, 25, 2, -24 },
  { 5263, 28, 39, 25, -2, -31 },
  { 5400, 22, 32, 25, 2, -24 },
  { 5488, 21, 31, 25, 2, -31 },
  { 5570, 21, 33, 25, 1, -33 },
  { 5657, 23, 41, 25, 0, -33 },
  { 5775, 23, 31, 25, 2, -31 },
  { 5865, 18, 31, 25, 4, -31 },
  { 5935, 24, 24, 25, 0, -24 },
  { 6007, 21, 24, 25, 2, -24 },
  { 6070, 21, 24, 25, 2, -24 },
  { 6133, 23, 32, 25, 0, -24 },
  { 6225, 22, 32, 25, 2, -24 },
  { 6313, 22, 24, 25, 2, -24 },
  { 6379, 21, 24, 25, 2, -24 },
  { 6442, 21, 29, 25, 3, -29 },
  { 6519, 22, 23, 25, 2, -23 },
  { 6583, 21, 23, 25, 4, -23 },
  { 6644, 23, 23, 25, 3, -23 },
  { 6711, 25, 23, 25, 0, -23 },
  { 6783, 22, 31, 25, 2, -23 },
  { 6869, 21, 23, 25, 2, -23 },
  { 6930, 21, 40, 25, 4, -35 },
  { 7035, 11, 40, 25, 8, -35 },
  { 7090, 22, 40, 25, 1, -35 },
  { 7200, 22, 10, 25, 2, -20 },
};

const GFXfont JetBrainsMono_SemiBoldItalic42pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic42pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC42PT7B_H_
