#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/JetBrainsMono_SemiBoldItalic
// Headers: 67

#include "JetBrainsMono_SemiBoldItalic6pt7b.h"
#include "JetBrainsMono_SemiBoldItalic7pt7b.h"
#include "JetBrainsMono_SemiBoldItalic8pt7b.h"
#include "JetBrainsMono_SemiBoldItalic9pt7b.h"
#include "JetBrainsMono_SemiBoldItalic10pt7b.h"
#include "JetBrainsMono_SemiBoldItalic11pt7b.h"
#include "JetBrainsMono_SemiBoldItalic12pt7b.h"
#include "JetBrainsMono_SemiBoldItalic13pt7b.h"
#include "JetBrainsMono_SemiBoldItalic14pt7b.h"
#include "JetBrainsMono_SemiBoldItalic15pt7b.h"
#include "JetBrainsMono_SemiBoldItalic16pt7b.h"
#include "JetBrainsMono_SemiBoldItalic17pt7b.h"
#include "JetBrainsMono_SemiBoldItalic18pt7b.h"
#include "JetBrainsMono_SemiBoldItalic19pt7b.h"
#include "JetBrainsMono_SemiBoldItalic20pt7b.h"
#include "JetBrainsMono_SemiBoldItalic21pt7b.h"
#include "JetBrainsMono_SemiBoldItalic22pt7b.h"
#include "JetBrainsMono_SemiBoldItalic23pt7b.h"
#include "JetBrainsMono_SemiBoldItalic24pt7b.h"
#include "JetBrainsMono_SemiBoldItalic25pt7b.h"
#include "JetBrainsMono_SemiBoldItalic26pt7b.h"
#include "JetBrainsMono_SemiBoldItalic27pt7b.h"
#include "JetBrainsMono_SemiBoldItalic28pt7b.h"
#include "JetBrainsMono_SemiBoldItalic29pt7b.h"
#include "JetBrainsMono_SemiBoldItalic30pt7b.h"
#include "JetBrainsMono_SemiBoldItalic31pt7b.h"
#include "JetBrainsMono_SemiBoldItalic32pt7b.h"
#include "JetBrainsMono_SemiBoldItalic33pt7b.h"
#include "JetBrainsMono_SemiBoldItalic34pt7b.h"
#include "JetBrainsMono_SemiBoldItalic35pt7b.h"
#include "JetBrainsMono_SemiBoldItalic36pt7b.h"
#include "JetBrainsMono_SemiBoldItalic37pt7b.h"
#include "JetBrainsMono_SemiBoldItalic38pt7b.h"
#include "JetBrainsMono_SemiBoldItalic39pt7b.h"
#include "JetBrainsMono_SemiBoldItalic40pt7b.h"
#include "JetBrainsMono_SemiBoldItalic41pt7b.h"
#include "JetBrainsMono_SemiBoldItalic42pt7b.h"
#include "JetBrainsMono_SemiBoldItalic43pt7b.h"
#include "JetBrainsMono_SemiBoldItalic44pt7b.h"
#include "JetBrainsMono_SemiBoldItalic45pt7b.h"
#include "JetBrainsMono_SemiBoldItalic46pt7b.h"
#include "JetBrainsMono_SemiBoldItalic47pt7b.h"
#include "JetBrainsMono_SemiBoldItalic48pt7b.h"
#include "JetBrainsMono_SemiBoldItalic49pt7b.h"
#include "JetBrainsMono_SemiBoldItalic50pt7b.h"
#include "JetBrainsMono_SemiBoldItalic51pt7b.h"
#include "JetBrainsMono_SemiBoldItalic52pt7b.h"
#include "JetBrainsMono_SemiBoldItalic53pt7b.h"
#include "JetBrainsMono_SemiBoldItalic54pt7b.h"
#include "JetBrainsMono_SemiBoldItalic55pt7b.h"
#include "JetBrainsMono_SemiBoldItalic56pt7b.h"
#include "JetBrainsMono_SemiBoldItalic57pt7b.h"
#include "JetBrainsMono_SemiBoldItalic58pt7b.h"
#include "JetBrainsMono_SemiBoldItalic59pt7b.h"
#include "JetBrainsMono_SemiBoldItalic60pt7b.h"
#include "JetBrainsMono_SemiBoldItalic61pt7b.h"
#include "JetBrainsMono_SemiBoldItalic62pt7b.h"
#include "JetBrainsMono_SemiBoldItalic63pt7b.h"
#include "JetBrainsMono_SemiBoldItalic64pt7b.h"
#include "JetBrainsMono_SemiBoldItalic65pt7b.h"
#include "JetBrainsMono_SemiBoldItalic66pt7b.h"
#include "JetBrainsMono_SemiBoldItalic67pt7b.h"
#include "JetBrainsMono_SemiBoldItalic68pt7b.h"
#include "JetBrainsMono_SemiBoldItalic69pt7b.h"
#include "JetBrainsMono_SemiBoldItalic70pt7b.h"
#include "JetBrainsMono_SemiBoldItalic71pt7b.h"
#include "JetBrainsMono_SemiBoldItalic72pt7b.h"
