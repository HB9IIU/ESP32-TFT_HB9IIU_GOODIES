#ifndef _JETBRAINSMONO_SEMIBOLDITALIC20PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCC, 0x63, 0x39, 0xCC, 0x63, 0x00, 0x00, 0x73, 0x80, 0x67,
  0x67, 0x66, 0x66, 0x66, 0xC6, 0x02, 0x30, 0x63, 0x06, 0x60, 0x46, 0x3F,
  0xF3, 0xFF, 0x08, 0xC1, 0x8C, 0x19, 0x81, 0x18, 0xFF, 0xE3, 0x30, 0x23,
  0x06, 0x20, 0x66, 0x00, 0x03, 0x00, 0x40, 0x1C, 0x0F, 0xE3, 0xBC, 0x6D,
  0x9D, 0x03, 0xA0, 0x3C, 0x07, 0xE0, 0x3E, 0x06, 0xE0, 0x9D, 0x93, 0x3A,
  0xE7, 0xF8, 0x7E, 0x03, 0x00, 0x60, 0x08, 0x00, 0x0E, 0x04, 0x7C, 0x23,
  0x31, 0x8C, 0xCC, 0x33, 0x60, 0xFB, 0x01, 0xD8, 0x00, 0x40, 0x02, 0x60,
  0x1F, 0xC0, 0xD9, 0x86, 0x44, 0x33, 0x11, 0x86, 0xCC, 0x1E, 0x00, 0x07,
  0x80, 0xFC, 0x1C, 0xE1, 0x8E, 0x18, 0x01, 0x80, 0x1C, 0x03, 0xC1, 0x76,
  0x66, 0x7C, 0x63, 0xC6, 0x38, 0x63, 0x87, 0xFC, 0x7C, 0xE0, 0x76, 0x66,
  0x6E, 0x01, 0x83, 0x83, 0xC3, 0x83, 0x81, 0x81, 0xC0, 0xC0, 0x60, 0x30,
  0x18, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x1E, 0x07, 0x00, 0x80,
  0x10, 0x1C, 0x1E, 0x07, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07,
  0x06, 0x06, 0x0E, 0x1C, 0x38, 0xF0, 0xE0, 0x80, 0x06, 0x00, 0xC1, 0x18,
  0xF2, 0x7F, 0xFE, 0x18, 0x07, 0x81, 0xB8, 0x73, 0x8C, 0x60, 0x06, 0x03,
  0x80, 0xE1, 0xFF, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x1C, 0x00, 0x39, 0x9C,
  0xCE, 0x60, 0xFF, 0xF8, 0x77, 0x70, 0x00, 0x30, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x00, 0x07,
  0x03, 0xF8, 0xE7, 0x38, 0x66, 0x0C, 0xC1, 0x99, 0x33, 0x76, 0x6C, 0xDC,
  0x3B, 0x06, 0x60, 0xCE, 0x38, 0xFE, 0x1F, 0x80, 0x07, 0x07, 0x8F, 0xC6,
  0xE6, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC7, 0xFF,
  0xFE, 0x0F, 0x07, 0xF3, 0x9D, 0xC3, 0x60, 0xC0, 0x30, 0x18, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x3F, 0xEF, 0xF8, 0x3F, 0xCF, 0xF0, 0x0C,
  0x0E, 0x07, 0x03, 0x00, 0xF0, 0x3E, 0x01, 0x80, 0x60, 0x1B, 0x06, 0xE3,
  0xBF, 0xC7, 0xE0, 0x01, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x07, 0x03, 0x81,
  0xC7, 0x61, 0xB8, 0x6F, 0xFB, 0xFE, 0x03, 0x80, 0xE0, 0x30, 0x3F, 0xCF,
  0xF3, 0xFC, 0xC0, 0x30, 0x1D, 0x87, 0xF9, 0xCE, 0x01, 0xC0, 0x70, 0x18,
  0x06, 0xE3, 0x9F, 0xC7, 0xE0, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x0E,
  0x03, 0x71, 0xFE, 0x61, 0xF8, 0x7C, 0x1F, 0x06, 0xE3, 0x9F, 0xC7, 0xE0,
  0x7F, 0xDF, 0xFF, 0xFF, 0x86, 0xC3, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03,
  0x01, 0x80, 0xE0, 0x30, 0x1C, 0x0E, 0x00, 0x0F, 0x07, 0xF3, 0x9C, 0xC3,
  0x70, 0xCC, 0x73, 0xB8, 0x78, 0x3F, 0x98, 0x6E, 0x1B, 0x06, 0xE3, 0xBF,
  0xC7, 0xE0, 0x0E, 0x0F, 0xE7, 0x3B, 0x87, 0xC1, 0xF0, 0x6C, 0x1B, 0xDE,
  0x7F, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0C, 0x07, 0x00, 0x38, 0xE3, 0x80,
  0x00, 0x00, 0x00, 0x71, 0xC7, 0x00, 0x1C, 0x38, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x71, 0xC3, 0x06, 0x18, 0x00, 0x00, 0x81, 0xC3, 0xE7, 0x8F,
  0x04, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0x80, 0x40, 0x7F, 0xDF, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x60, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x70, 0x78, 0x78, 0xF8, 0x38, 0x08, 0x00, 0x78, 0x7E, 0x7F, 0x07, 0x07,
  0x07, 0x0E, 0x7C, 0x78, 0x60, 0x60, 0x00, 0x00, 0xE0, 0xE0, 0x03, 0xC0,
  0xFE, 0x18, 0x73, 0x03, 0x30, 0x36, 0x1B, 0x67, 0xF6, 0x63, 0x66, 0x36,
  0x66, 0x6C, 0x6C, 0xC6, 0xCF, 0xEC, 0x76, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0xE0, 0x0C, 0x00, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x0D, 0x83, 0x61, 0xDC,
  0x67, 0x18, 0xCF, 0xF3, 0xFD, 0xC3, 0x60, 0xD8, 0x3E, 0x0C, 0x3F, 0x07,
  0xF8, 0xC7, 0x18, 0x67, 0x0C, 0xE1, 0x9F, 0xE3, 0xF8, 0x63, 0x8C, 0x3B,
  0x87, 0x70, 0xCC, 0x39, 0xFE, 0x3F, 0x80, 0x07, 0x03, 0xF8, 0xE7, 0x18,
  0x67, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0xCE,
  0x38, 0xFE, 0x0F, 0x80, 0x3E, 0x07, 0xF0, 0xFF, 0x18, 0x67, 0x0C, 0xE1,
  0x98, 0x33, 0x06, 0x61, 0xCC, 0x3B, 0x86, 0x70, 0xCC, 0x39, 0xFE, 0x3F,
  0x00, 0x3F, 0xE7, 0xFC, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1F, 0xE3, 0xFC,
  0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7,
  0xFC, 0xFF, 0x98, 0x07, 0x00, 0xE0, 0x18, 0x13, 0xFC, 0x7F, 0x8C, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x00, 0x07, 0x03, 0xF8, 0xE7, 0x18,
  0x67, 0x00, 0xC0, 0x18, 0x03, 0x3E, 0x67, 0xCC, 0x3B, 0x86, 0x70, 0xCE,
  0x38, 0xFE, 0x0F, 0x80, 0x30, 0xE6, 0x1C, 0xC3, 0x18, 0x67, 0x0C, 0xE1,
  0x9F, 0xF3, 0xFE, 0x7F, 0xCC, 0x33, 0x86, 0x70, 0xCC, 0x19, 0x87, 0x30,
  0xE0, 0x3F, 0xE7, 0xF8, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC1, 0xFF, 0x3F, 0xC0, 0x03, 0xF0,
  0x3E, 0x07, 0xE0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xCE, 0x1C, 0xE1, 0x87, 0xF8, 0x3E, 0x00, 0x30, 0x73, 0x0E,
  0x30, 0xC3, 0x1C, 0x73, 0x87, 0x30, 0x7F, 0x07, 0xE0, 0x7E, 0x06, 0x70,
  0xE3, 0x0E, 0x30, 0xC3, 0x8C, 0x38, 0xC1, 0x80, 0x18, 0x1C, 0x0E, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x07, 0xFF,
  0xFE, 0x18, 0x73, 0xC7, 0x3C, 0xF3, 0xCF, 0x3D, 0xB3, 0x5E, 0x35, 0x63,
  0x76, 0x76, 0x66, 0x06, 0x60, 0xE6, 0x0C, 0x60, 0xC6, 0x0C, 0xE0, 0xC0,
  0x38, 0x67, 0x0C, 0xE3, 0xB4, 0x66, 0xCC, 0xD9, 0x9B, 0x33, 0x66, 0x6D,
  0xCC, 0xF3, 0x1E, 0x63, 0xCC, 0x79, 0x8F, 0x30, 0xE0, 0x07, 0x03, 0xF8,
  0xE7, 0x18, 0x67, 0x0C, 0xC1, 0x98, 0x33, 0x0E, 0x61, 0xCC, 0x33, 0x86,
  0x70, 0xCE, 0x38, 0xFE, 0x1F, 0x80, 0x3F, 0x07, 0xF8, 0xFF, 0x98, 0x77,
  0x06, 0xE1, 0xD8, 0x33, 0xFE, 0x7F, 0x8C, 0x03, 0x80, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x00, 0x07, 0x03, 0xF8, 0xE7, 0x38, 0x67, 0x0C, 0xC1, 0x98,
  0x33, 0x06, 0x61, 0xDC, 0x3B, 0x86, 0x60, 0xCE, 0x38, 0xFE, 0x1F, 0x80,
  0x70, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0x3F, 0x07, 0xF8, 0xC7, 0x18, 0x77,
  0x0E, 0xE1, 0x98, 0x73, 0xFC, 0x7F, 0x0C, 0xC3, 0x9C, 0x71, 0x8C, 0x31,
  0x87, 0x30, 0x60, 0x07, 0x03, 0xF8, 0xE7, 0x18, 0x67, 0x00, 0xE0, 0x0F,
  0x01, 0xF8, 0x0F, 0x80, 0x30, 0x07, 0x60, 0xCE, 0x39, 0xFE, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0x30, 0x66, 0x1C, 0xC3, 0xB8,
  0x67, 0x0C, 0xC1, 0x98, 0x33, 0x0E, 0x61, 0xCC, 0x33, 0x86, 0x70, 0xCE,
  0x38, 0xFE, 0x1F, 0x80, 0xE0, 0xFC, 0x1B, 0x87, 0x30, 0xC6, 0x18, 0xC7,
  0x18, 0xC3, 0x38, 0x66, 0x0C, 0xC1, 0xB0, 0x36, 0x06, 0xC0, 0xF0, 0x0E,
  0x00, 0x67, 0x36, 0x63, 0x66, 0x36, 0x66, 0x6E, 0x64, 0xA6, 0xCA, 0x4D,
  0xAC, 0xD2, 0xCD, 0x2C, 0xD2, 0x8F, 0x38, 0xE3, 0x8E, 0x38, 0xE7, 0x00,
  0x38, 0x38, 0xC3, 0x87, 0x18, 0x39, 0x80, 0xDC, 0x07, 0xC0, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x06, 0xE0, 0x73, 0x07, 0x1C, 0x30, 0xE3, 0x83,
  0x80, 0xC0, 0xFC, 0x19, 0x87, 0x30, 0xC7, 0x30, 0x6E, 0x0D, 0x81, 0xE0,
  0x3C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x00, 0x3F, 0xE7,
  0xF8, 0xFF, 0x00, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00,
  0xC0, 0x38, 0x0E, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0x3F, 0x3F, 0x30, 0x30,
  0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0xC0,
  0xF8, 0xF8, 0xC1, 0xC3, 0x83, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x60, 0xE1,
  0xC1, 0x83, 0x06, 0x0E, 0x0C, 0x18, 0x38, 0x1F, 0x3F, 0x3F, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x18,
  0xF8, 0xF8, 0x0E, 0x07, 0x07, 0x87, 0x43, 0x33, 0x19, 0x8D, 0x83, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE6, 0x30, 0x1E, 0xCF, 0xF7, 0x1D, 0x87, 0x61, 0xD8,
  0x6E, 0x1B, 0x86, 0xE3, 0xBF, 0xE7, 0xB8, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x77, 0x9F, 0xF7, 0x1D, 0x87, 0x61, 0xD8, 0x6E, 0x1B, 0x86, 0xE3, 0xBF,
  0xCD, 0xE0, 0x1F, 0x8F, 0xF7, 0x1D, 0x83, 0x60, 0x38, 0x0E, 0x03, 0x86,
  0xE3, 0x9F, 0xC3, 0xE0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x61, 0xEC, 0x7F,
  0x9C, 0x73, 0x0E, 0x61, 0xCC, 0x33, 0x86, 0x70, 0xCE, 0x39, 0xFF, 0x1E,
  0xE0, 0x1F, 0x0F, 0xE7, 0x1D, 0x83, 0x61, 0xFF, 0xEE, 0x03, 0x00, 0xE3,
  0x9F, 0xC3, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x38, 0x00, 0xC0, 0x03, 0x00,
  0x7F, 0xC1, 0xFF, 0x09, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x03, 0xE0, 0x0E, 0x00,
  0x00, 0x1E, 0xCF, 0xF7, 0x1D, 0x87, 0x61, 0xD8, 0x6E, 0x1B, 0x8E, 0x7F,
  0x9F, 0xE0, 0x38, 0x0C, 0x07, 0x1F, 0x87, 0x80, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x77, 0x9F, 0xF7, 0x1D, 0x87, 0x61, 0xD8, 0x6E, 0x1B, 0x86, 0xC1,
  0xB0, 0xEC, 0x38, 0x03, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x0F, 0x83, 0xE0,
  0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFE, 0x00,
  0xC0, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x0E, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x0F, 0xC3,
  0xF8, 0x78, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x0E, 0xE3, 0x98,
  0xE3, 0x18, 0x7E, 0x0F, 0xC3, 0x98, 0x73, 0x8E, 0x31, 0x87, 0x30, 0x60,
  0xFC, 0x7E, 0x3E, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0xFC, 0x7C, 0x3E, 0xE3, 0xF6, 0x32, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x64, 0xCE, 0x4C, 0xCC, 0xC0, 0x77, 0x9F,
  0xF7, 0x1D, 0x87, 0x61, 0xD8, 0x6E, 0x1B, 0x86, 0xC1, 0xB0, 0xEC, 0x38,
  0x1F, 0x0F, 0xE7, 0x1D, 0x87, 0x61, 0xF8, 0x6E, 0x1B, 0x86, 0xE3, 0x9F,
  0xC7, 0xE0, 0x3B, 0xC7, 0xFC, 0xE3, 0x98, 0x73, 0x0E, 0x61, 0x9C, 0x33,
  0x86, 0x71, 0xCF, 0xF1, 0xBC, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x00, 0x1E,
  0xCF, 0xF7, 0x1D, 0x87, 0x61, 0xF8, 0x6E, 0x1B, 0x86, 0xE3, 0xBF, 0xE7,
  0xB8, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x37, 0x87, 0xF9, 0xC3, 0x38, 0x66,
  0x0C, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x1F, 0x8F,
  0xF7, 0x0D, 0x80, 0x7C, 0x0F, 0xE0, 0x38, 0x06, 0xC1, 0xBF, 0xE7, 0xF0,
  0x0E, 0x03, 0x00, 0xC1, 0xFF, 0xFF, 0xC7, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x1F, 0x87, 0xE0, 0x70, 0xDC, 0x36, 0x0D, 0x87, 0x61,
  0xD8, 0x6E, 0x1B, 0x86, 0xE3, 0x9F, 0xC3, 0xE0, 0xC1, 0xF0, 0x6C, 0x3B,
  0x8C, 0x67, 0x19, 0x86, 0x61, 0xB0, 0x6C, 0x1E, 0x03, 0x80, 0xC6, 0x79,
  0xCF, 0x29, 0xE5, 0x6D, 0xAD, 0xA5, 0xB4, 0xA6, 0xBC, 0xE7, 0x9C, 0xE3,
  0x9C, 0x00, 0x38, 0x71, 0x8E, 0x1D, 0xC0, 0xF8, 0x0F, 0x00, 0xE0, 0x0F,
  0x01, 0xB0, 0x39, 0x87, 0x1C, 0xE1, 0xC0, 0x70, 0xD8, 0x36, 0x1D, 0x87,
  0x61, 0xD8, 0x6E, 0x1B, 0x8E, 0x7D, 0x9F, 0xE0, 0x38, 0x0C, 0x07, 0x1F,
  0x87, 0x80, 0x3F, 0xDF, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x3F, 0xEF, 0xF8, 0x00, 0xC0, 0xF0, 0x7C, 0x18, 0x06, 0x01, 0x80,
  0xE0, 0x38, 0x0C, 0x3E, 0x0F, 0x80, 0x70, 0x0C, 0x07, 0x01, 0x80, 0x60,
  0x18, 0x07, 0xC0, 0xE0, 0x19, 0xCE, 0x63, 0x18, 0xCE, 0x73, 0x18, 0xC6,
  0x33, 0x9C, 0xC6, 0x30, 0x1C, 0x03, 0xC0, 0x7C, 0x03, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x7C, 0x1F, 0x87, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0xFF, 0x3C, 0xFF, 0x1E,
};

const GFXglyph JetBrainsMono_SemiBoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 15, 12, 4, -15 },
  { 11, 8, 6, 12, 3, -15 },
  { 17, 12, 15, 12, 0, -15 },
  { 40, 11, 20, 12, 1, -17 },
  { 68, 14, 15, 12, -1, -15 },
  { 95, 12, 15, 12, 0, -15 },
  { 118, 4, 6, 12, 5, -15 },
  { 121, 9, 20, 12, 3, -17 },
  { 144, 8, 20, 12, 1, -17 },
  { 164, 11, 10, 12, 1, -12 },
  { 178, 10, 9, 12, 1, -11 },
  { 190, 5, 6, 12, 2, -3 },
  { 194, 7, 2, 12, 3, -8 },
  { 196, 4, 3, 12, 3, -3 },
  { 198, 12, 19, 12, 0, -17 },
  { 227, 11, 15, 12, 1, -15 },
  { 248, 9, 15, 12, 1, -15 },
  { 265, 10, 15, 12, 1, -15 },
  { 284, 10, 15, 12, 1, -15 },
  { 303, 10, 15, 12, 1, -15 },
  { 322, 10, 15, 12, 1, -15 },
  { 341, 10, 15, 12, 1, -15 },
  { 360, 10, 15, 12, 2, -15 },
  { 379, 10, 15, 12, 1, -15 },
  { 398, 10, 15, 12, 2, -15 },
  { 417, 6, 11, 12, 3, -11 },
  { 426, 7, 14, 12, 2, -11 },
  { 439, 9, 11, 12, 2, -12 },
  { 452, 10, 7, 12, 1, -10 },
  { 461, 10, 11, 12, 1, -12 },
  { 475, 8, 15, 12, 3, -15 },
  { 490, 12, 19, 12, 0, -15 },
  { 519, 10, 15, 12, 0, -15 },
  { 538, 11, 15, 12, 1, -15 },
  { 559, 11, 15, 12, 1, -15 },
  { 580, 11, 15, 12, 1, -15 },
  { 601, 11, 15, 12, 1, -15 },
  { 622, 11, 15, 12, 1, -15 },
  { 643, 11, 15, 12, 1, -15 },
  { 664, 11, 15, 12, 1, -15 },
  { 685, 11, 15, 12, 1, -15 },
  { 706, 12, 15, 12, 0, -15 },
  { 729, 12, 15, 12, 1, -15 },
  { 752, 9, 15, 12, 1, -15 },
  { 769, 12, 15, 12, 0, -15 },
  { 792, 11, 15, 12, 1, -15 },
  { 813, 11, 15, 12, 1, -15 },
  { 834, 11, 15, 12, 1, -15 },
  { 855, 11, 19, 12, 1, -15 },
  { 882, 11, 15, 12, 1, -15 },
  { 903, 11, 15, 12, 1, -15 },
  { 924, 10, 15, 12, 2, -15 },
  { 943, 11, 15, 12, 1, -15 },
  { 964, 11, 15, 12, 2, -15 },
  { 985, 12, 15, 12, 1, -15 },
  { 1008, 13, 15, 12, 0, -15 },
  { 1033, 11, 15, 12, 2, -15 },
  { 1054, 11, 15, 12, 1, -15 },
  { 1075, 8, 19, 12, 3, -17 },
  { 1094, 7, 19, 12, 3, -17 },
  { 1111, 8, 19, 12, 2, -17 },
  { 1130, 9, 8, 12, 2, -15 },
  { 1139, 10, 3, 12, 0, 0 },
  { 1143, 4, 3, 12, 5, -16 },
  { 1145, 10, 11, 12, 1, -11 },
  { 1159, 10, 15, 12, 1, -15 },
  { 1178, 10, 11, 12, 1, -11 },
  { 1192, 11, 15, 12, 1, -15 },
  { 1213, 10, 11, 12, 1, -11 },
  { 1227, 14, 19, 12, -1, -15 },
  { 1261, 10, 15, 12, 1, -11 },
  { 1280, 10, 15, 12, 1, -15 },
  { 1299, 10, 16, 12, 1, -16 },
  { 1319, 11, 20, 12, 0, -16 },
  { 1347, 11, 15, 12, 1, -15 },
  { 1368, 9, 15, 12, 2, -15 },
  { 1385, 12, 11, 12, 0, -11 },
  { 1402, 10, 11, 12, 1, -11 },
  { 1416, 10, 11, 12, 1, -11 },
  { 1430, 11, 15, 12, 0, -11 },
  { 1451, 10, 15, 12, 1, -11 },
  { 1470, 11, 11, 12, 1, -11 },
  { 1486, 10, 11, 12, 1, -11 },
  { 1500, 10, 14, 12, 1, -14 },
  { 1518, 10, 11, 12, 1, -11 },
  { 1532, 10, 11, 12, 2, -11 },
  { 1546, 11, 11, 12, 1, -11 },
  { 1562, 12, 11, 12, 0, -11 },
  { 1579, 10, 15, 12, 1, -11 },
  { 1598, 10, 11, 12, 1, -11 },
  { 1612, 10, 19, 12, 2, -17 },
  { 1636, 5, 19, 12, 4, -17 },
  { 1648, 11, 19, 12, 0, -17 },
  { 1675, 10, 4, 12, 1, -9 },
};

const GFXfont JetBrainsMono_SemiBoldItalic20pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic20pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC20PT7B_H_
