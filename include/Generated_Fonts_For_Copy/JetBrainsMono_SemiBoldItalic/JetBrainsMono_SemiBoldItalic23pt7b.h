#ifndef _JETBRAINSMONO_SEMIBOLDITALIC23PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC6, 0x38, 0xE3, 0x8E, 0x30, 0xC3, 0x0C, 0x00, 0x07,
  0x3C, 0xF0, 0x63, 0xE7, 0xE7, 0xE7, 0xE7, 0xC6, 0xC6, 0x03, 0x0C, 0x0C,
  0x60, 0x31, 0x81, 0x86, 0x06, 0x30, 0xFF, 0xF0, 0xC3, 0x03, 0x18, 0x0C,
  0x60, 0x61, 0x81, 0x8C, 0x1F, 0xFC, 0xFF, 0xF0, 0xC6, 0x03, 0x18, 0x18,
  0x60, 0x63, 0x00, 0x01, 0x80, 0x18, 0x01, 0x00, 0x7C, 0x1F, 0xE1, 0xFF,
  0x3B, 0x73, 0x37, 0x32, 0x03, 0xA0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x6E,
  0x06, 0xE0, 0x4E, 0xE4, 0xEF, 0x5C, 0x7F, 0xC3, 0xF0, 0x0C, 0x00, 0x80,
  0x08, 0x00, 0x0F, 0x03, 0x1F, 0x86, 0x19, 0x8C, 0x31, 0x8C, 0x31, 0x98,
  0x31, 0xB0, 0x3F, 0x60, 0x0E, 0xC0, 0x01, 0x80, 0x03, 0x30, 0x03, 0x7C,
  0x06, 0xCC, 0x0C, 0xCC, 0x19, 0x8C, 0x31, 0x8C, 0x61, 0xF8, 0xC0, 0xF0,
  0x03, 0xE0, 0x7F, 0x83, 0x9C, 0x38, 0x61, 0xC0, 0x0E, 0x00, 0x30, 0x03,
  0xC0, 0x3E, 0x03, 0xB9, 0xDC, 0xFC, 0xC7, 0xC6, 0x1E, 0x30, 0xE1, 0xCF,
  0x8F, 0xEC, 0x3E, 0x70, 0x77, 0x66, 0xEE, 0xE0, 0x00, 0xC0, 0xF0, 0x78,
  0x38, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0xC0, 0x78, 0x0E, 0x00, 0x80,
  0x0C, 0x07, 0x80, 0xF0, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x03, 0x83, 0xC1,
  0xE0, 0xF0, 0x20, 0x00, 0x03, 0x00, 0x30, 0x03, 0x06, 0x31, 0x72, 0xFF,
  0xFF, 0x06, 0x00, 0xF0, 0x1B, 0x83, 0x98, 0x71, 0xC2, 0x08, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x7F, 0xF7, 0xFF, 0xFF, 0xE0, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x1C, 0xE3, 0x9C, 0x73, 0x8C, 0x00, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x00, 0x07, 0xC1, 0xFE, 0x3C, 0xF3, 0x87, 0x30,
  0x37, 0x07, 0x70, 0x77, 0x67, 0x77, 0x66, 0x66, 0x60, 0x6E, 0x0E, 0xE0,
  0xEE, 0x0E, 0xF1, 0xC7, 0xF8, 0x3F, 0x00, 0x03, 0xC1, 0xF8, 0x7E, 0x1C,
  0xC3, 0x38, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0x87, 0xFF, 0xFF, 0xE0, 0x07, 0xC1, 0xFE, 0x3C, 0xF3,
  0x87, 0x70, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF,
  0x3F, 0xF0, 0x0E, 0x01, 0x80, 0x70, 0x07, 0x00, 0xFC, 0x0F, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0xE0, 0xEE, 0x0C, 0xE1, 0xC7, 0xF8, 0x3F, 0x00, 0x00,
  0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC6, 0x38,
  0xE7, 0x0E, 0x60, 0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1F, 0xF1, 0xFF, 0x3F, 0xF3, 0x80, 0x38, 0x03, 0x80, 0x37, 0xC3,
  0xFE, 0x78, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xEE, 0x0E, 0xF1, 0xC7,
  0xF8, 0x3F, 0x00, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x1C, 0x03, 0xFC, 0x7F, 0xE7, 0x0E, 0xE0, 0x6E, 0x06, 0xE0, 0xEE, 0x0E,
  0xF1, 0xC7, 0xF8, 0x3F, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xF6, 0x06, 0xE0,
  0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x00, 0x07, 0xC1, 0xFE, 0x1C, 0xF3,
  0x87, 0x30, 0x73, 0x87, 0x38, 0xE1, 0xFC, 0x0F, 0x83, 0xFC, 0x70, 0xE6,
  0x0E, 0xE0, 0xEE, 0x0E, 0xF1, 0xC7, 0xFC, 0x3F, 0x00, 0x0F, 0x83, 0xFC,
  0x79, 0xE7, 0x0E, 0xE0, 0x6E, 0x06, 0xE0, 0xEE, 0x0E, 0xFF, 0xC7, 0xFC,
  0x1B, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x18,
  0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x8F, 0x3C, 0xF0, 0x0E, 0x0F, 0x1F,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x1C, 0x38, 0x38, 0x70, 0x70,
  0x60, 0xE0, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xC7, 0xE1, 0xF0, 0x30, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xC0, 0x04, 0x3F, 0xF3, 0xFF, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x20, 0x07, 0x00, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x18, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0x70,
  0x08, 0x00, 0x7E, 0x1F, 0xC7, 0xF8, 0x0E, 0x01, 0x80, 0x60, 0x38, 0x1E,
  0x3F, 0x0F, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x03, 0xC0, 0xE0, 0x00,
  0x03, 0xF0, 0x3F, 0xE1, 0xC1, 0xC6, 0x07, 0x30, 0x0C, 0xC0, 0x37, 0x1E,
  0xDC, 0xEF, 0x63, 0x19, 0x9C, 0x66, 0x71, 0x99, 0x86, 0x66, 0x1B, 0x98,
  0xEC, 0x7D, 0x30, 0xEC, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1F, 0xC0, 0x1F,
  0x00, 0x01, 0xC0, 0x3C, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0xE0,
  0xC6, 0x1C, 0x61, 0xC6, 0x18, 0x63, 0xFE, 0x3F, 0xE7, 0x07, 0x70, 0x76,
  0x07, 0xE0, 0x70, 0x3F, 0xC3, 0xFE, 0x39, 0xF3, 0x87, 0x30, 0x73, 0x07,
  0x30, 0xE7, 0xFC, 0x7F, 0xC7, 0x1E, 0x60, 0xE6, 0x06, 0x60, 0x6E, 0x0E,
  0xE1, 0xCF, 0xFC, 0xFF, 0x00, 0x07, 0xC1, 0xFE, 0x1C, 0xF3, 0x87, 0x30,
  0x73, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0xEE, 0x0E, 0x71, 0xC7, 0xF8, 0x3F, 0x00, 0x3F, 0x83, 0xFE, 0x3F, 0xF3,
  0x87, 0x30, 0x73, 0x07, 0x70, 0x77, 0x07, 0x70, 0x77, 0x06, 0x70, 0x66,
  0x0E, 0x60, 0xEE, 0x0C, 0xE7, 0xCF, 0xF8, 0xFE, 0x00, 0x1F, 0xF8, 0xFF,
  0xCF, 0xFC, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x07, 0xFC, 0x7F, 0xE3,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1F, 0xF8, 0xFF,
  0xC0, 0x1F, 0xF9, 0xFF, 0xCF, 0xFE, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x0F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0xC1, 0xFE, 0x1C, 0xF3, 0x87, 0x30,
  0x73, 0x00, 0x70, 0x07, 0x00, 0x73, 0xF7, 0x3E, 0x63, 0xE6, 0x0E, 0xE0,
  0xEE, 0x0E, 0x71, 0xC7, 0xF8, 0x3F, 0x00, 0x38, 0x39, 0xC1, 0x8E, 0x0C,
  0x70, 0xE3, 0x87, 0x18, 0x38, 0xC1, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF, 0x1C,
  0x38, 0xC1, 0xC6, 0x0E, 0x70, 0x63, 0x83, 0x1C, 0x38, 0xE1, 0xC0, 0x1F,
  0xF1, 0xFF, 0x3F, 0xF0, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0F, 0xFC, 0xFF,
  0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xCE, 0x06, 0x70, 0x71,
  0xC7, 0x8F, 0xF8, 0x3F, 0x00, 0x38, 0x39, 0xC1, 0xCE, 0x1C, 0x71, 0xC3,
  0x0E, 0x18, 0xE1, 0xC6, 0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x1C, 0xE0, 0xC7,
  0x06, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x1C, 0xE0, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFF, 0xFF, 0xC0, 0x1C, 0x1C, 0x70,
  0xF1, 0xE3, 0xC7, 0x9F, 0x3E, 0x78, 0xDB, 0x63, 0x6D, 0x8D, 0xA6, 0x33,
  0xB8, 0xCC, 0xE7, 0x03, 0x1C, 0x0C, 0x70, 0x31, 0x81, 0xC6, 0x07, 0x18,
  0x1C, 0xE0, 0x60, 0x3C, 0x39, 0xE1, 0x8F, 0x0C, 0x78, 0x63, 0xE3, 0x1B,
  0x39, 0xD9, 0xCE, 0xCE, 0x76, 0x63, 0x33, 0x18, 0xD8, 0xC6, 0xCE, 0x3E,
  0x71, 0xF3, 0x8F, 0x18, 0x78, 0xC1, 0xC0, 0x07, 0xC1, 0xFE, 0x1C, 0xF3,
  0x87, 0x30, 0x73, 0x07, 0x70, 0x77, 0x07, 0x70, 0x67, 0x06, 0x60, 0xE6,
  0x0E, 0xE0, 0xEE, 0x0C, 0x71, 0xC7, 0xF8, 0x3F, 0x00, 0x3F, 0xC1, 0xFF,
  0x8F, 0xFC, 0x70, 0x73, 0x03, 0x98, 0x1D, 0xC0, 0xCE, 0x0E, 0x7F, 0xE3,
  0xFE, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x00, 0x07, 0xC1, 0xFE, 0x3C, 0xF3, 0x87, 0x30, 0x77, 0x07, 0x70, 0x77,
  0x07, 0x70, 0x66, 0x06, 0x60, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xF1, 0xC7,
  0xF8, 0x3F, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x3F, 0xC1, 0xFF,
  0x0F, 0xFC, 0x70, 0xE3, 0x03, 0x18, 0x19, 0xC1, 0xCE, 0x1C, 0x7F, 0xE3,
  0xFC, 0x1C, 0xE0, 0xC7, 0x06, 0x38, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE0,
  0xE0, 0x07, 0xC1, 0xFE, 0x3C, 0xF3, 0x87, 0x30, 0x73, 0x00, 0x38, 0x03,
  0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xEE, 0x0E, 0xF1, 0xC7,
  0xFC, 0x3F, 0x00, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x00, 0x38, 0x39, 0xC1, 0x8E, 0x0C, 0x70, 0xE3,
  0x07, 0x18, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x63, 0x83, 0x18, 0x38, 0xC1,
  0xCE, 0x0E, 0x70, 0x61, 0xC7, 0x0F, 0xF0, 0x3F, 0x00, 0xC0, 0x7C, 0x0E,
  0xC0, 0xEE, 0x0C, 0xE1, 0xCE, 0x18, 0xE3, 0x8E, 0x38, 0xE3, 0x0E, 0x70,
  0x66, 0x06, 0xE0, 0x6C, 0x06, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x00, 0x63,
  0x8D, 0x8E, 0x76, 0x39, 0x99, 0xE6, 0x67, 0x99, 0x96, 0xE6, 0x53, 0x1B,
  0x4C, 0x6D, 0x31, 0xA5, 0xC7, 0x96, 0x3E, 0x58, 0xF1, 0x63, 0x47, 0x0F,
  0x1C, 0x3C, 0x70, 0xE3, 0xC0, 0x1C, 0x1C, 0x70, 0x70, 0xC3, 0x83, 0x9C,
  0x0E, 0x60, 0x1B, 0x80, 0x7C, 0x01, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0xFC,
  0x03, 0x70, 0x1C, 0xC0, 0xE3, 0x87, 0x0E, 0x1C, 0x1C, 0xE0, 0x70, 0xE0,
  0x3B, 0x03, 0x9C, 0x18, 0xE1, 0xC3, 0x1C, 0x1C, 0xE0, 0xEE, 0x07, 0x60,
  0x1F, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x00, 0x1F, 0xF3, 0xFF, 0x3F, 0xF0, 0x0E, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00,
  0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xC7, 0xE1, 0xC0, 0x60, 0x18, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x60, 0x18, 0x0E, 0x03, 0xF8, 0xFC, 0x3F, 0x00, 0xE0, 0x60, 0x70,
  0x70, 0x70, 0x30, 0x38, 0x38, 0x38, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x0C,
  0x0E, 0x0E, 0x0E, 0x06, 0x06, 0x07, 0x07, 0x1F, 0x8F, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x9F, 0x8F, 0xC7, 0xE0, 0x07, 0x01, 0xC0, 0xF8,
  0x76, 0x19, 0x8E, 0x67, 0x1D, 0x83, 0xE0, 0xC0, 0xFF, 0xFF, 0xFC, 0xE3,
  0x9E, 0x0F, 0x71, 0xFF, 0x3D, 0xF7, 0x0E, 0x70, 0x67, 0x0E, 0x60, 0xE6,
  0x0E, 0xE0, 0xEE, 0x0E, 0xF1, 0xC7, 0xEC, 0x3D, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x33, 0xC3, 0x7E, 0x7D, 0xE7, 0x06, 0x70, 0x67, 0x06,
  0x70, 0xE6, 0x0E, 0x60, 0xEE, 0x0E, 0xF1, 0xCF, 0xF8, 0xEF, 0x00, 0x07,
  0x81, 0xFE, 0x3D, 0xE7, 0x07, 0x70, 0x77, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x0E, 0x71, 0xC7, 0xF8, 0x3F, 0x00, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0xF7, 0x0F, 0xF8, 0xF7, 0xCE, 0x1C, 0x70, 0x63, 0x87, 0x18,
  0x38, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0xC7, 0x0F, 0xD8, 0x3D, 0xC0, 0x07,
  0x81, 0xFE, 0x38, 0xE7, 0x06, 0x70, 0x66, 0x06, 0x7F, 0xE6, 0x00, 0xE0,
  0x0E, 0x02, 0x61, 0xC7, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x07,
  0xF8, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x0F,
  0x71, 0xFF, 0x3D, 0xF7, 0x0E, 0x70, 0x67, 0x0E, 0x60, 0xE6, 0x0E, 0x60,
  0xE7, 0x1C, 0x7E, 0xC3, 0xEC, 0x01, 0xC0, 0x1C, 0x03, 0xC7, 0xF8, 0x7F,
  0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x33, 0xC3, 0x7E, 0x7D, 0xE7,
  0x0E, 0x70, 0x67, 0x06, 0x70, 0xE6, 0x0E, 0x60, 0xEE, 0x0E, 0xE0, 0xCE,
  0x0C, 0xE1, 0xC0, 0x01, 0x80, 0x78, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0x0F,
  0xE1, 0xF8, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80,
  0x30, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x07, 0x00, 0x70, 0x00, 0x00, 0x00,
  0xFE, 0x1F, 0xE1, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x78, 0x7F, 0x0F,
  0xE0, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0x98, 0x38, 0xC3,
  0x8E, 0x38, 0x73, 0xC3, 0xFC, 0x1F, 0xC0, 0xFE, 0x06, 0x38, 0x71, 0xC3,
  0x87, 0x1C, 0x38, 0xE0, 0xE0, 0xFE, 0x3F, 0x8F, 0xE0, 0x30, 0x0C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0,
  0x7F, 0x0F, 0xC0, 0x37, 0x31, 0xBB, 0xCE, 0xE6, 0x66, 0x33, 0x33, 0xB9,
  0x9D, 0xCC, 0xEE, 0x66, 0x63, 0x33, 0x31, 0x99, 0x8D, 0xCC, 0xEE, 0x67,
  0x00, 0x33, 0xC3, 0x7E, 0x7D, 0xE7, 0x0E, 0x70, 0x67, 0x06, 0x70, 0xE6,
  0x0E, 0x60, 0xEE, 0x0E, 0xE0, 0xCE, 0x0C, 0xE1, 0xC0, 0x07, 0x81, 0xFE,
  0x3D, 0xE7, 0x06, 0x70, 0x67, 0x06, 0x60, 0xE6, 0x0E, 0xE0, 0xEE, 0x0C,
  0x71, 0xC7, 0xF8, 0x3F, 0x00, 0x19, 0xE0, 0xDF, 0x8F, 0xBC, 0x70, 0x63,
  0x83, 0x1C, 0x18, 0xE1, 0xC6, 0x0E, 0x30, 0x73, 0x83, 0x9E, 0x38, 0xFF,
  0x87, 0x78, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x0F, 0x71, 0xFF,
  0x3D, 0xF7, 0x0E, 0x70, 0x67, 0x0E, 0x60, 0xE6, 0x0E, 0xE0, 0xEE, 0x0C,
  0xF1, 0xC7, 0xEC, 0x3D, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x3B,
  0xC3, 0xFE, 0x34, 0xF3, 0x87, 0x30, 0x77, 0x07, 0x70, 0x07, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0xC1, 0xFE, 0x38, 0xE7,
  0x07, 0x70, 0x07, 0xC0, 0x3F, 0xC0, 0x7E, 0x00, 0xE0, 0x0E, 0xE1, 0xCF,
  0xFC, 0x7F, 0x80, 0x0E, 0x01, 0x80, 0x30, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xE0,
  0xFC, 0x30, 0x73, 0x07, 0x70, 0x77, 0x06, 0x70, 0x67, 0x0E, 0x70, 0xE6,
  0x0E, 0x60, 0xEE, 0x0C, 0x71, 0xC7, 0xF8, 0x3F, 0x00, 0xE0, 0x7E, 0x0E,
  0xE0, 0xE6, 0x1C, 0x61, 0xC6, 0x18, 0x73, 0x87, 0x30, 0x77, 0x03, 0x60,
  0x3E, 0x03, 0xC0, 0x3C, 0x00, 0x63, 0x1B, 0x38, 0xD9, 0x4E, 0xCA, 0x66,
  0xD3, 0x36, 0x99, 0xAD, 0x8D, 0x6C, 0xFB, 0x67, 0x9E, 0x34, 0xF1, 0xE7,
  0x8E, 0x38, 0x00, 0x38, 0x3C, 0x70, 0xE1, 0xC7, 0x03, 0xB8, 0x0F, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0xC0, 0x77, 0x03, 0x8E, 0x1C, 0x38,
  0xE0, 0x70, 0x30, 0x73, 0x07, 0x70, 0x77, 0x06, 0x70, 0x67, 0x0E, 0x60,
  0xE6, 0x0E, 0x60, 0xE7, 0x1C, 0x7E, 0xC3, 0xDC, 0x01, 0xC0, 0x1C, 0x03,
  0x87, 0xF8, 0x7F, 0x00, 0x3F, 0xF3, 0xFE, 0x3F, 0xE0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0,
  0x00, 0xF0, 0x1F, 0x03, 0xC0, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x07, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x1C, 0x00, 0xF8, 0x0F, 0x80, 0x38, 0x1C, 0x71, 0xC7,
  0x1C, 0x61, 0x8E, 0x38, 0xE3, 0x8C, 0x31, 0xC7, 0x1C, 0x71, 0x86, 0x38,
  0xE3, 0x80, 0x0F, 0x00, 0xF8, 0x17, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x3F, 0x01, 0xF0, 0x3F, 0x07, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x07, 0xC0, 0x78, 0x0E, 0x00, 0x18,
  0x07, 0xE3, 0x6E, 0x3E, 0x7F, 0xE3, 0xE0, 0x08,
};

const GFXglyph JetBrainsMono_SemiBoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 17, 14, 4, -17 },
  { 14, 8, 7, 14, 4, -17 },
  { 21, 14, 17, 14, 0, -17 },
  { 51, 12, 23, 14, 1, -20 },
  { 86, 16, 17, 14, -1, -17 },
  { 120, 13, 17, 14, 0, -17 },
  { 148, 4, 7, 14, 6, -17 },
  { 152, 10, 22, 14, 3, -19 },
  { 180, 10, 22, 14, 1, -19 },
  { 208, 12, 12, 14, 1, -14 },
  { 226, 12, 11, 14, 1, -13 },
  { 243, 6, 7, 14, 2, -3 },
  { 249, 8, 3, 14, 3, -9 },
  { 252, 4, 4, 14, 4, -4 },
  { 254, 14, 22, 14, 0, -19 },
  { 293, 12, 17, 14, 1, -17 },
  { 319, 11, 17, 14, 1, -17 },
  { 343, 12, 17, 14, 1, -17 },
  { 369, 12, 17, 14, 1, -17 },
  { 395, 12, 17, 14, 1, -17 },
  { 421, 12, 17, 14, 1, -17 },
  { 447, 12, 17, 14, 1, -17 },
  { 473, 12, 17, 14, 2, -17 },
  { 499, 12, 17, 14, 1, -17 },
  { 525, 12, 17, 14, 2, -17 },
  { 551, 6, 13, 14, 4, -13 },
  { 561, 8, 17, 14, 2, -13 },
  { 578, 11, 13, 14, 2, -14 },
  { 596, 12, 8, 14, 1, -12 },
  { 608, 11, 13, 14, 1, -14 },
  { 626, 10, 17, 14, 3, -17 },
  { 648, 14, 21, 14, 0, -17 },
  { 685, 12, 17, 14, 0, -17 },
  { 711, 12, 17, 14, 1, -17 },
  { 737, 12, 17, 14, 1, -17 },
  { 763, 12, 17, 14, 1, -17 },
  { 789, 13, 17, 14, 1, -17 },
  { 817, 13, 17, 14, 1, -17 },
  { 845, 12, 17, 14, 1, -17 },
  { 871, 13, 17, 14, 1, -17 },
  { 899, 12, 17, 14, 1, -17 },
  { 925, 13, 17, 14, 0, -17 },
  { 953, 13, 17, 14, 1, -17 },
  { 981, 11, 17, 14, 1, -17 },
  { 1005, 14, 17, 14, 0, -17 },
  { 1035, 13, 17, 14, 1, -17 },
  { 1063, 12, 17, 14, 1, -17 },
  { 1089, 13, 17, 14, 1, -17 },
  { 1117, 12, 21, 14, 1, -17 },
  { 1149, 13, 17, 14, 1, -17 },
  { 1177, 12, 17, 14, 1, -17 },
  { 1203, 12, 17, 14, 2, -17 },
  { 1229, 13, 17, 14, 1, -17 },
  { 1257, 12, 17, 14, 3, -17 },
  { 1283, 14, 17, 14, 1, -17 },
  { 1313, 14, 17, 14, 0, -17 },
  { 1343, 13, 17, 14, 2, -17 },
  { 1371, 12, 17, 14, 1, -17 },
  { 1397, 10, 22, 14, 3, -19 },
  { 1425, 8, 22, 14, 3, -19 },
  { 1447, 9, 22, 14, 2, -19 },
  { 1472, 10, 9, 14, 2, -17 },
  { 1484, 11, 2, 14, 0, 1 },
  { 1487, 5, 3, 14, 6, -18 },
  { 1489, 12, 13, 14, 1, -13 },
  { 1509, 12, 17, 14, 1, -17 },
  { 1535, 12, 13, 14, 1, -13 },
  { 1555, 13, 17, 14, 1, -17 },
  { 1583, 12, 13, 14, 1, -13 },
  { 1603, 15, 21, 14, -1, -17 },
  { 1643, 12, 17, 14, 1, -13 },
  { 1669, 12, 17, 14, 1, -17 },
  { 1695, 11, 18, 14, 1, -18 },
  { 1720, 12, 22, 14, 0, -18 },
  { 1753, 13, 17, 14, 1, -17 },
  { 1781, 10, 17, 14, 2, -17 },
  { 1803, 13, 13, 14, 0, -13 },
  { 1825, 12, 13, 14, 1, -13 },
  { 1845, 12, 13, 14, 1, -13 },
  { 1865, 13, 17, 14, 0, -13 },
  { 1893, 12, 17, 14, 1, -13 },
  { 1919, 12, 13, 14, 1, -13 },
  { 1939, 12, 13, 14, 1, -13 },
  { 1959, 11, 16, 14, 2, -16 },
  { 1981, 12, 13, 14, 1, -13 },
  { 2001, 12, 13, 14, 2, -13 },
  { 2021, 13, 13, 14, 1, -13 },
  { 2043, 14, 13, 14, 0, -13 },
  { 2066, 12, 17, 14, 1, -13 },
  { 2092, 12, 13, 14, 1, -13 },
  { 2112, 12, 22, 14, 2, -19 },
  { 2145, 6, 22, 14, 4, -19 },
  { 2162, 12, 22, 14, 0, -19 },
  { 2195, 12, 6, 14, 1, -11 },
};

const GFXfont JetBrainsMono_SemiBoldItalic23pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic23pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC23PT7B_H_
