#ifndef _JETBRAINSMONO_SEMIBOLDITALIC12PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0xB4, 0x80, 0xC0, 0xDD, 0x99, 0x12, 0x25, 0xF9, 0x22, 0x45,
  0x3F, 0x24, 0xD0, 0x08, 0x38, 0xFB, 0x77, 0x07, 0x87, 0x0A, 0x5C, 0xF0,
  0x41, 0x00, 0x18, 0x94, 0x8A, 0x87, 0x80, 0x80, 0xF8, 0x64, 0x52, 0xCE,
  0x00, 0x1C, 0x48, 0x81, 0x07, 0x0A, 0xF3, 0x66, 0x74, 0x5F, 0x19, 0x98,
  0x8C, 0x62, 0x10, 0xC6, 0x18, 0x20, 0x61, 0x84, 0x31, 0x08, 0x42, 0x33,
  0x31, 0x00, 0x32, 0x9D, 0xCC, 0x52, 0x60, 0x30, 0xCF, 0xFE, 0x20, 0x80,
  0x6D, 0x40, 0xFF, 0xF0, 0x02, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x18, 0x20,
  0x83, 0x00, 0x39, 0x3C, 0x73, 0xBE, 0x28, 0xA6, 0xF0, 0x1C, 0xE4, 0x82,
  0x08, 0x61, 0x84, 0xFC, 0x1C, 0x6D, 0x98, 0x20, 0xC3, 0x0C, 0x30, 0xFC,
  0x3E, 0x0C, 0x20, 0xC1, 0xC0, 0x81, 0x26, 0x78, 0x0C, 0x63, 0x18, 0xCA,
  0x2F, 0x86, 0x18, 0x7D, 0xF4, 0x3E, 0xD8, 0x20, 0xA6, 0xF0, 0x0C, 0x30,
  0x41, 0x07, 0xC8, 0x91, 0x26, 0x78, 0x7F, 0xFC, 0xC2, 0x10, 0xC2, 0x18,
  0xC0, 0x1C, 0x4D, 0x99, 0x21, 0x8D, 0x91, 0x26, 0x78, 0x39, 0x3C, 0x63,
  0xD9, 0xE1, 0x08, 0x40, 0x6C, 0x01, 0xB0, 0x33, 0x00, 0x06, 0x64, 0xC0,
  0x0C, 0xEE, 0x30, 0x70, 0x60, 0xFC, 0x00, 0x3E, 0xC3, 0x86, 0x37, 0x40,
  0xE7, 0x86, 0x27, 0x60, 0x00, 0xC0, 0x1C, 0x45, 0x0A, 0x75, 0x3A, 0x64,
  0xCF, 0x81, 0x81, 0xC0, 0x18, 0x61, 0xCF, 0x2D, 0x97, 0xD1, 0xC4, 0x3C,
  0x4D, 0x9B, 0x27, 0x88, 0x91, 0x26, 0xF8, 0x39, 0xBC, 0xF0, 0x82, 0x08,
  0x26, 0xF0, 0x3C, 0x7D, 0x9B, 0x36, 0x68, 0x91, 0x26, 0xF8, 0x7D, 0x04,
  0x30, 0xFA, 0x08, 0x20, 0xF8, 0x3E, 0x7C, 0x83, 0x07, 0xC8, 0x10, 0x20,
  0xC0, 0x39, 0xBC, 0xF0, 0x9E, 0xE8, 0xA6, 0xF0, 0x22, 0x4D, 0x9B, 0x37,
  0xC8, 0x91, 0x22, 0xCC, 0x7C, 0x43, 0x0C, 0x20, 0x82, 0x08, 0xF8, 0x1E,
  0x3C, 0x18, 0x20, 0x40, 0xB1, 0x66, 0x78, 0x23, 0x26, 0x64, 0x68, 0x78,
  0x48, 0x48, 0x4C, 0xC4, 0x62, 0x10, 0x8C, 0x63, 0x10, 0xF8, 0x26, 0xCD,
  0x5A, 0xD5, 0xE8, 0x91, 0x62, 0xC4, 0x32, 0x65, 0xCB, 0xB5, 0x4B, 0x93,
  0x26, 0xCC, 0x39, 0xBC, 0xF3, 0x8A, 0x28, 0xA6, 0xF0, 0x3C, 0x7D, 0x8B,
  0x17, 0xCF, 0x10, 0x20, 0xC0, 0x39, 0xBC, 0xF3, 0x8E, 0x28, 0xA6, 0xF0,
  0xC1, 0x80, 0x3C, 0x4D, 0x8B, 0x37, 0xC9, 0x12, 0x26, 0xCC, 0x1C, 0x6D,
  0x9B, 0x03, 0x81, 0x81, 0x26, 0x78, 0xFF, 0xF3, 0x0C, 0x20, 0x82, 0x08,
  0x60, 0x45, 0x1C, 0xF3, 0xCA, 0x28, 0xA6, 0xF0, 0xC7, 0x89, 0x32, 0x45,
  0x8A, 0x14, 0x38, 0x60, 0x93, 0x6E, 0xD5, 0xAB, 0x5B, 0x36, 0x6C, 0x98,
  0x63, 0x26, 0x3C, 0x18, 0x18, 0x38, 0x28, 0x4C, 0xC4, 0xC6, 0x99, 0x23,
  0xC7, 0x04, 0x08, 0x10, 0x60, 0x3E, 0x7C, 0x30, 0x41, 0x86, 0x08, 0x20,
  0xFC, 0x7B, 0x10, 0x84, 0x63, 0x18, 0x84, 0x38, 0x8C, 0xC4, 0x44, 0x66,
  0x22, 0x30, 0x38, 0xC6, 0x21, 0x08, 0x46, 0x31, 0x38, 0x11, 0x9A, 0x9C,
  0x80, 0xFF, 0xF0, 0xE0, 0x3D, 0xFC, 0xA2, 0x8A, 0x6F, 0x80, 0x20, 0x41,
  0xB3, 0xE6, 0x48, 0x91, 0x26, 0xF8, 0x31, 0xEC, 0xE0, 0x82, 0x6F, 0x00,
  0x04, 0x13, 0xDF, 0xCA, 0x28, 0xA6, 0xF8, 0x31, 0x28, 0xBE, 0x82, 0x6F,
  0x00, 0x07, 0x86, 0x02, 0x07, 0xE0, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08,
  0x3C, 0x00, 0x3D, 0xFC, 0xA2, 0x8B, 0xE5, 0x86, 0xF0, 0x20, 0x41, 0xB3,
  0xE6, 0x48, 0x91, 0x22, 0xCC, 0x0C, 0x03, 0x8E, 0x18, 0x61, 0x04, 0xFC,
  0x04, 0x00, 0xF1, 0xE0, 0xC1, 0x02, 0x04, 0x08, 0x33, 0xC0, 0x20, 0x41,
  0x8B, 0x26, 0xCF, 0x12, 0x26, 0xCC, 0xF7, 0x08, 0x42, 0x31, 0x8C, 0x38,
  0x54, 0xF5, 0x5A, 0xB5, 0x5A, 0xA5, 0x00, 0x6C, 0xF9, 0x92, 0x24, 0x48,
  0xB3, 0x00, 0x31, 0xEC, 0xA2, 0x8A, 0x6F, 0x00, 0x6C, 0xF9, 0x92, 0x24,
  0x49, 0xBE, 0x60, 0xC0, 0x3F, 0xFC, 0xA2, 0x8A, 0x6F, 0x86, 0x10, 0x59,
  0xBC, 0xF0, 0x82, 0x08, 0x00, 0x1C, 0xCD, 0x81, 0xC0, 0x48, 0x9E, 0x00,
  0x33, 0xFF, 0xC8, 0x61, 0x86, 0x1E, 0xCF, 0x3C, 0xA2, 0x8A, 0x6F, 0x00,
  0x87, 0x3C, 0x96, 0x51, 0xC6, 0x00, 0x96, 0xDB, 0x76, 0xDB, 0x69, 0x80,
  0x66, 0x48, 0xE0, 0xC3, 0x8D, 0x33, 0x00, 0xCF, 0x38, 0xA2, 0x8B, 0xE5,
  0x86, 0xF0, 0x3E, 0xF8, 0x30, 0xC3, 0x0C, 0x3F, 0x00, 0x0C, 0x61, 0x04,
  0x13, 0x83, 0x0C, 0x20, 0x83, 0x80, 0x24, 0xB6, 0x92, 0x5B, 0x00, 0x30,
  0x61, 0x84, 0x10, 0x71, 0x0C, 0x30, 0x8E, 0x00, 0x43, 0x9B, 0x80,
};

const GFXglyph JetBrainsMono_SemiBoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 9, 7, 2, -9 },
  { 5, 4, 4, 7, 2, -9 },
  { 7, 7, 9, 7, 0, -9 },
  { 15, 7, 12, 7, 0, -10 },
  { 26, 9, 9, 7, -1, -9 },
  { 37, 7, 9, 7, 0, -9 },
  { 45, 2, 4, 7, 3, -9 },
  { 46, 5, 12, 7, 2, -10 },
  { 54, 5, 12, 7, 1, -10 },
  { 62, 6, 6, 7, 1, -7 },
  { 67, 6, 6, 7, 1, -7 },
  { 72, 3, 4, 7, 1, -2 },
  { 74, 4, 2, 7, 2, -5 },
  { 75, 2, 2, 7, 2, -2 },
  { 76, 7, 11, 7, 0, -10 },
  { 86, 6, 9, 7, 1, -9 },
  { 93, 6, 9, 7, 0, -9 },
  { 100, 7, 9, 7, 0, -9 },
  { 108, 7, 9, 7, 0, -9 },
  { 116, 6, 9, 7, 1, -9 },
  { 123, 6, 9, 7, 1, -9 },
  { 130, 7, 9, 7, 0, -9 },
  { 138, 6, 9, 7, 1, -9 },
  { 145, 7, 9, 7, 0, -9 },
  { 153, 6, 9, 7, 1, -9 },
  { 160, 3, 7, 7, 2, -7 },
  { 163, 4, 9, 7, 1, -7 },
  { 168, 6, 6, 7, 1, -7 },
  { 173, 6, 4, 7, 1, -6 },
  { 176, 5, 6, 7, 1, -7 },
  { 180, 5, 9, 7, 2, -9 },
  { 186, 7, 11, 7, 0, -9 },
  { 196, 6, 9, 7, 0, -9 },
  { 203, 7, 9, 7, 0, -9 },
  { 211, 6, 9, 7, 1, -9 },
  { 218, 7, 9, 7, 0, -9 },
  { 226, 6, 9, 7, 1, -9 },
  { 233, 7, 9, 7, 0, -9 },
  { 241, 6, 9, 7, 1, -9 },
  { 248, 7, 9, 7, 0, -9 },
  { 256, 6, 9, 7, 1, -9 },
  { 263, 7, 9, 7, 0, -9 },
  { 271, 8, 9, 7, 0, -9 },
  { 280, 5, 9, 7, 1, -9 },
  { 286, 7, 9, 7, 0, -9 },
  { 294, 7, 9, 7, 0, -9 },
  { 302, 6, 9, 7, 1, -9 },
  { 309, 7, 9, 7, 0, -9 },
  { 317, 6, 11, 7, 1, -9 },
  { 326, 7, 9, 7, 0, -9 },
  { 334, 7, 9, 7, 0, -9 },
  { 342, 6, 9, 7, 1, -9 },
  { 349, 6, 9, 7, 1, -9 },
  { 356, 7, 9, 7, 1, -9 },
  { 364, 7, 9, 7, 1, -9 },
  { 372, 8, 9, 7, 0, -9 },
  { 381, 7, 9, 7, 1, -9 },
  { 389, 7, 9, 7, 0, -9 },
  { 397, 5, 11, 7, 2, -10 },
  { 404, 4, 11, 7, 2, -10 },
  { 410, 5, 11, 7, 1, -10 },
  { 417, 5, 5, 7, 1, -9 },
  { 421, 6, 2, 7, 0, 0 },
  { 423, 3, 1, 7, 3, -9 },
  { 424, 6, 7, 7, 1, -7 },
  { 430, 7, 9, 7, 0, -9 },
  { 438, 6, 7, 7, 1, -7 },
  { 444, 6, 9, 7, 1, -9 },
  { 451, 6, 7, 7, 1, -7 },
  { 457, 9, 11, 7, -1, -9 },
  { 470, 6, 9, 7, 1, -7 },
  { 477, 7, 9, 7, 0, -9 },
  { 485, 6, 9, 7, 0, -9 },
  { 492, 7, 11, 7, 0, -9 },
  { 502, 7, 9, 7, 0, -9 },
  { 510, 5, 9, 7, 1, -9 },
  { 516, 7, 7, 7, 0, -7 },
  { 523, 7, 7, 7, 0, -7 },
  { 530, 6, 7, 7, 1, -7 },
  { 536, 7, 9, 7, 0, -7 },
  { 544, 6, 9, 7, 1, -7 },
  { 551, 6, 7, 7, 1, -7 },
  { 557, 7, 7, 7, 0, -7 },
  { 564, 6, 8, 7, 1, -8 },
  { 570, 6, 7, 7, 1, -7 },
  { 576, 6, 7, 7, 1, -7 },
  { 582, 6, 7, 7, 1, -7 },
  { 588, 7, 7, 7, 0, -7 },
  { 595, 6, 9, 7, 1, -7 },
  { 602, 7, 7, 7, 0, -7 },
  { 609, 6, 11, 7, 1, -10 },
  { 618, 3, 11, 7, 2, -10 },
  { 623, 6, 11, 7, 0, -10 },
  { 632, 6, 3, 7, 1, -6 },
};

const GFXfont JetBrainsMono_SemiBoldItalic12pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic12pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC12PT7B_H_
