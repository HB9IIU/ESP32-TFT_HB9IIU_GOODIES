#ifndef _JETBRAINSMONO_SEMIBOLDITALIC29PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x18, 0x38, 0x38, 0x00, 0x00, 0x00, 0x30, 0x78, 0xF8, 0x70, 0x71, 0xEE,
  0x3B, 0xC7, 0x78, 0xEF, 0x3D, 0xC7, 0xB8, 0xE7, 0x1C, 0xE3, 0x80, 0x00,
  0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x30, 0x06, 0x1C, 0x03, 0x87, 0x07, 0xFF,
  0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x07, 0x0C, 0x01, 0x87, 0x00, 0xE1, 0xC0,
  0x38, 0x60, 0x0C, 0x38, 0x1F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF8, 0x38,
  0x70, 0x0E, 0x18, 0x03, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x03, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFE, 0x1E, 0xCF, 0x1C, 0xCF, 0x3C, 0xC0, 0x3C, 0xC0, 0x3C, 0xC0, 0x1F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xBC, 0x01,
  0x1C, 0xF3, 0x1C, 0xF3, 0x3C, 0xF3, 0x3C, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F,
  0xC0, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0xC0, 0x70,
  0xFE, 0x0E, 0x1C, 0x60, 0xC1, 0x86, 0x18, 0x18, 0x63, 0x01, 0x8E, 0x70,
  0x38, 0xEE, 0x01, 0xFD, 0xC0, 0x1F, 0xB8, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x20, 0x01, 0xDF, 0x80, 0x3B, 0xFC, 0x07, 0x71, 0xC0, 0xE7,
  0x1C, 0x0C, 0x71, 0x81, 0x86, 0x18, 0x30, 0x73, 0x87, 0x07, 0xF0, 0xE0,
  0x3E, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x01, 0xE7, 0x81, 0xE1, 0xC0, 0xE0,
  0xE0, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x0F, 0xC0, 0x0F,
  0xE0, 0x27, 0x38, 0xE7, 0x9E, 0xE3, 0x87, 0xF1, 0xC3, 0xF0, 0xE0, 0xF0,
  0x70, 0x78, 0x38, 0x7C, 0x1F, 0xFF, 0x0F, 0xFB, 0x83, 0xF8, 0xE0, 0x77,
  0x7F, 0xFE, 0xEE, 0xE0, 0x00, 0x08, 0x01, 0xC0, 0x3C, 0x03, 0xE0, 0x7C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xE0,
  0x0E, 0x00, 0x10, 0x00, 0x08, 0x00, 0x38, 0x01, 0xE0, 0x1F, 0x80, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x1E, 0x00,
  0xE0, 0x08, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x21, 0xC2, 0x79, 0x8F, 0xFD, 0xBF, 0x3F, 0xFE, 0x01, 0x80, 0x03, 0xC0,
  0x0E, 0xE0, 0x1E, 0xF0, 0x3C, 0x70, 0x78, 0x78, 0x30, 0x30, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x8F, 0x87,
  0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x39, 0xEF, 0xBE, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xFE, 0x0F, 0xBE, 0x1E,
  0x0E, 0x3C, 0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x8E, 0x3B,
  0xCE, 0x7B, 0xDE, 0x71, 0xDE, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70,
  0x1C, 0x70, 0x3C, 0x78, 0x78, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xC0, 0x01,
  0xF8, 0x0F, 0xC0, 0xFF, 0x07, 0xDC, 0x1C, 0xF0, 0x63, 0xC2, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x3C, 0x0E, 0x38, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x03, 0xF0,
  0x03, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0,
  0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x38, 0xF0, 0x73, 0xC0, 0xE7, 0x03,
  0xCE, 0x07, 0x9F, 0xFF, 0x3F, 0xFC, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1D, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC,
  0x3C, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x70, 0x3C, 0x70, 0x78, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x1F, 0xF0, 0x7F, 0xF8, 0xFF, 0xF3, 0xC1, 0xE7, 0x01, 0xEE, 0x03,
  0xFC, 0x07, 0x78, 0x0E, 0xF0, 0x3C, 0xF0, 0xF1, 0xFF, 0xE1, 0xFF, 0x81,
  0xFC, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF7, 0x80, 0xEF, 0x03, 0x9C,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xFE, 0x0F, 0xBE,
  0x1E, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x1E, 0x1C, 0x1C, 0x1F, 0x78,
  0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xF8, 0x3C, 0x3C, 0x78, 0x3C, 0x70, 0x1C,
  0x70, 0x1C, 0xF0, 0x3C, 0x70, 0x78, 0x7F, 0xF8, 0x7F, 0xF0, 0x1F, 0xC0,
  0x07, 0xF0, 0x3F, 0xF8, 0xFD, 0xF1, 0xE0, 0xF7, 0x81, 0xEE, 0x03, 0xDC,
  0x07, 0xB8, 0x0F, 0x70, 0x1C, 0xF0, 0x79, 0xFF, 0xE1, 0xFF, 0xC1, 0xEF,
  0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x9F, 0x3E, 0x7C, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x21, 0xE0, 0xF0, 0xF0, 0x78,
  0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x78, 0x03, 0xF0,
  0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x70, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x04, 0x00, 0x7F,
  0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x00, 0x18, 0x00, 0x78, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x06, 0x00, 0x7C,
  0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x0E, 0x00, 0x30, 0x00, 0x00,
  0x3F, 0x87, 0xFC, 0x7F, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x01, 0xE3, 0xFC, 0x3F, 0x83, 0xF0, 0x38, 0x03, 0x80, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xFE, 0x01, 0xFF,
  0xC0, 0xF0, 0x78, 0x78, 0x0E, 0x1C, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C,
  0xE1, 0xF6, 0x38, 0xFD, 0x8C, 0x78, 0xE7, 0x1C, 0x39, 0xC7, 0x0E, 0x71,
  0xC3, 0x9C, 0x60, 0xC7, 0x38, 0x71, 0x8E, 0x1C, 0xE3, 0x87, 0x38, 0x7F,
  0xCE, 0x1F, 0x73, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x73, 0x80, 0xE7, 0x03, 0xCE, 0x07, 0x1C,
  0x0E, 0x38, 0x3C, 0x70, 0x70, 0xE1, 0xE1, 0xC3, 0xFF, 0x87, 0xFF, 0x1F,
  0xFE, 0x38, 0x1E, 0xF0, 0x3D, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xE0, 0x1F,
  0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x1C, 0x0F, 0x1C, 0x0F, 0x1C, 0x0E, 0x3C,
  0x0E, 0x3C, 0x1E, 0x38, 0x7C, 0x3F, 0xF0, 0x3F, 0xF8, 0x38, 0x7C, 0x78,
  0x1C, 0x78, 0x1C, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x7C, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x07, 0xF8, 0x1F, 0xF8, 0x7F, 0xF1, 0xE0,
  0xF3, 0x81, 0xEF, 0x03, 0xDE, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x1C, 0xE0,
  0x79, 0xE1, 0xE3, 0xFF, 0xC3, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFE, 0x1C, 0x1E, 0x1C, 0x0E, 0x3C, 0x0F, 0x3C, 0x0E, 0x3C,
  0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x38, 0x1E, 0x78, 0x1C, 0x78,
  0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x3C, 0x70, 0x78, 0xFF, 0xF0, 0xFF,
  0xE0, 0xFF, 0x80, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xF8, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0x1F, 0xFF, 0x8F,
  0xFF, 0x87, 0xFF, 0xC3, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xF8, 0x7F, 0xF1,
  0xE0, 0xF3, 0x81, 0xEF, 0x03, 0xDE, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC7, 0xF7, 0x9F, 0xEF, 0x3F, 0xDE, 0x07, 0x38, 0x0E, 0x70, 0x1C,
  0xE0, 0x79, 0xE1, 0xE3, 0xFF, 0xC3, 0xFF, 0x03, 0xF8, 0x00, 0x1E, 0x07,
  0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x0E,
  0x3C, 0x0E, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x78, 0x1C,
  0x78, 0x1C, 0x70, 0x3C, 0x70, 0x3C, 0x70, 0x3C, 0x70, 0x38, 0xF0, 0x38,
  0xF0, 0x38, 0xF0, 0x78, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0xE0, 0x38, 0x70, 0x3C, 0x3C, 0x1E,
  0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x1E, 0x07, 0x8F, 0x07, 0x87,
  0x03, 0xC3, 0x83, 0xC1, 0xC1, 0xC1, 0xE1, 0xE0, 0xF1, 0xE0, 0x78, 0xE0,
  0x38, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0x8E, 0x03, 0xC7,
  0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x78, 0x38, 0x3C, 0x3C, 0x0E, 0x1E,
  0x07, 0x8F, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0x07, 0xC3, 0xC1, 0xE1, 0xF0, 0xF8, 0x7C, 0x36,
  0x1F, 0x9F, 0x87, 0xE6, 0xE1, 0xD9, 0xB8, 0x76, 0xCE, 0x39, 0xB7, 0x0E,
  0x7D, 0xC3, 0x9E, 0x70, 0xE7, 0x9C, 0x38, 0x07, 0x0E, 0x03, 0xC3, 0x80,
  0xE1, 0xE0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x78,
  0xF0, 0x1C, 0x00, 0x1F, 0x07, 0x1F, 0x07, 0x1F, 0x07, 0x1F, 0x07, 0x1B,
  0x0F, 0x3B, 0x8E, 0x3B, 0x8E, 0x3B, 0x8E, 0x3B, 0x8E, 0x39, 0x8E, 0x39,
  0xDE, 0x79, 0xDC, 0x71, 0xDC, 0x71, 0xDC, 0x70, 0xDC, 0x70, 0xDC, 0x70,
  0xFC, 0xF0, 0xF8, 0xE0, 0xF8, 0xE0, 0xF8, 0xE0, 0x78, 0x07, 0xF8, 0x3F,
  0xF8, 0x7F, 0xF1, 0xE0, 0xE3, 0x81, 0xCF, 0x03, 0x9E, 0x07, 0x38, 0x0E,
  0x70, 0x1C, 0xE0, 0x79, 0xC0, 0xF7, 0x81, 0xCF, 0x03, 0x9E, 0x07, 0x38,
  0x0E, 0x70, 0x3C, 0xE0, 0x79, 0xE1, 0xE3, 0xFF, 0x83, 0xFF, 0x03, 0xF8,
  0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0x81, 0xE1, 0xC0, 0x71,
  0xE0, 0x38, 0xF0, 0x1C, 0x78, 0x1E, 0x38, 0x0F, 0x1C, 0x1F, 0x0F, 0xFF,
  0x07, 0xFF, 0x07, 0xFE, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF8,
  0x0F, 0xFE, 0x0F, 0xFE, 0x1E, 0x0E, 0x3C, 0x0F, 0x3C, 0x0E, 0x38, 0x0E,
  0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1C,
  0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x3C, 0x78, 0x78, 0x7F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x1F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x1C, 0x0F, 0x1C, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E, 0x38, 0x1E, 0x3F, 0xFC, 0x3F, 0xF8,
  0x3F, 0xF0, 0x78, 0xE0, 0x78, 0xE0, 0x70, 0xF0, 0x70, 0xF0, 0x70, 0x70,
  0x70, 0x78, 0xF0, 0x78, 0xF0, 0x38, 0xE0, 0x3C, 0x03, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFE, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0xF0, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C, 0x7F, 0xF8, 0x7F, 0xF0,
  0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x0F,
  0x1C, 0x0F, 0x1C, 0x0F, 0x3C, 0x0E, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x1E,
  0x38, 0x1E, 0x38, 0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x78, 0x1C, 0x70, 0x1C,
  0x70, 0x3C, 0x70, 0x38, 0x78, 0x78, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xC0,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x73, 0x81, 0xE7, 0x03, 0x8E, 0x07, 0x1C,
  0x1E, 0x38, 0x38, 0x70, 0xF0, 0xE1, 0xC1, 0xC3, 0x83, 0xCF, 0x07, 0x9C,
  0x07, 0x38, 0x0E, 0xE0, 0x1D, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x38, 0xE1, 0xCC, 0x38, 0x77, 0x0E, 0x39, 0xC7,
  0x8E, 0x71, 0xE3, 0x9C, 0x78, 0xC7, 0x36, 0x71, 0xCD, 0x9C, 0x73, 0x67,
  0x1C, 0xD9, 0x87, 0x66, 0xE1, 0xD9, 0xB8, 0x76, 0x6E, 0x1F, 0x1B, 0x07,
  0xC7, 0xC1, 0xB1, 0xF0, 0x6C, 0x78, 0x1E, 0x16, 0x07, 0x87, 0x81, 0xE3,
  0xE0, 0xF0, 0xF0, 0x00, 0x1E, 0x03, 0xC3, 0xC1, 0xE0, 0xF0, 0x70, 0x1C,
  0x3C, 0x07, 0x9E, 0x01, 0xE7, 0x00, 0x3B, 0xC0, 0x0F, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xDC, 0x00,
  0xF7, 0x80, 0x78, 0xE0, 0x1C, 0x3C, 0x0F, 0x0F, 0x07, 0x81, 0xC1, 0xC0,
  0x78, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0xF0, 0x1E, 0x70, 0x1C, 0x70, 0x38,
  0x78, 0x78, 0x38, 0x70, 0x38, 0xF0, 0x3D, 0xE0, 0x3D, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0xF0, 0x1C, 0x07,
  0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x70,
  0x1E, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01,
  0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x7F, 0x8F, 0xF0, 0xFF, 0x00,
  0x01, 0xE0, 0x0F, 0x80, 0x36, 0x01, 0xD8, 0x0E, 0x70, 0x39, 0xC1, 0xC7,
  0x07, 0x0E, 0x38, 0x39, 0xE0, 0xEF, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF1, 0xE3, 0x8F, 0x07, 0xCE, 0x1F, 0xDC, 0x7F, 0xB9, 0xE0,
  0xF3, 0x81, 0xE7, 0x03, 0x9E, 0x07, 0x3C, 0x0E, 0x78, 0x1C, 0xE0, 0x79,
  0xC0, 0xF3, 0x81, 0xE7, 0x87, 0x8F, 0xFF, 0x1F, 0xEE, 0x1F, 0xBC, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xBF, 0x0F, 0xFF,
  0x1D, 0xFE, 0x3C, 0x1E, 0x78, 0x3C, 0xE0, 0x79, 0xC0, 0xE7, 0x81, 0xCF,
  0x03, 0x9C, 0x07, 0x38, 0x1E, 0x70, 0x3C, 0xF0, 0xF3, 0xFF, 0xE7, 0xFF,
  0x8E, 0x7E, 0x00, 0x07, 0xE0, 0x7F, 0xE3, 0xFF, 0x9E, 0x0F, 0x70, 0x3D,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x1E,
  0xF0, 0xF3, 0xFF, 0xC7, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x07, 0xCE, 0x0F, 0xEE, 0x1F, 0xEE, 0x3C,
  0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x78, 0x1C, 0x78, 0x1C, 0x78, 0x1C, 0x70,
  0x3C, 0x70, 0x3C, 0x70, 0x3C, 0x78, 0x78, 0x7F, 0xF8, 0x7F, 0xB8, 0x3F,
  0x78, 0x07, 0xE0, 0x7F, 0xE3, 0xEF, 0x9E, 0x0E, 0x70, 0x3D, 0xC0, 0xFF,
  0x03, 0xBF, 0xFE, 0xFF, 0xFB, 0x80, 0x0E, 0x00, 0x38, 0x02, 0xE0, 0x73,
  0xEF, 0xC7, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0xFF,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x9C,
  0x7F, 0x73, 0xFD, 0xDE, 0x0F, 0x70, 0x3D, 0xC0, 0xEF, 0x03, 0xBC, 0x0E,
  0xF0, 0x3B, 0x81, 0xEF, 0x07, 0xBC, 0x3E, 0xFF, 0xF1, 0xFD, 0xC3, 0xE7,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0x87, 0xFE, 0x1F, 0xF0, 0xFF, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xBF, 0x0F, 0xFF,
  0x1F, 0xFE, 0x3C, 0x1E, 0x78, 0x3C, 0xE0, 0x79, 0xC0, 0xE7, 0x81, 0xCF,
  0x03, 0x9C, 0x0F, 0x38, 0x1E, 0x70, 0x3C, 0xE0, 0x73, 0xC0, 0xE7, 0x81,
  0xCF, 0x07, 0x80, 0x00, 0x70, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x7F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x0F, 0x3C, 0x1E, 0x3C, 0x1C, 0x3C, 0x3C, 0x38, 0x78,
  0x38, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x79, 0xE0, 0x70, 0xE0,
  0x70, 0xF0, 0x70, 0x70, 0x70, 0x78, 0xF0, 0x38, 0xF0, 0x3C, 0xFF, 0x0F,
  0xF0, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3F, 0xF1, 0xFF, 0x0F, 0xF0, 0x1D, 0xCF, 0x0D, 0xFF, 0x8F, 0x3D,
  0xE7, 0x1C, 0xF3, 0x8C, 0x71, 0xC6, 0x38, 0xE3, 0x1C, 0x71, 0x8E, 0x79,
  0xC7, 0x38, 0xE3, 0x9C, 0x73, 0x8E, 0x31, 0xC7, 0x18, 0xE3, 0x8C, 0x71,
  0xCE, 0x39, 0xC7, 0x1C, 0x3D, 0xF8, 0x7F, 0xF8, 0xFF, 0xF1, 0xE0, 0xF3,
  0xC1, 0xE7, 0x03, 0xCE, 0x07, 0x3C, 0x0E, 0x78, 0x1C, 0xE0, 0x79, 0xC0,
  0xF3, 0x81, 0xE7, 0x03, 0x9E, 0x07, 0x3C, 0x0E, 0x78, 0x3C, 0x0F, 0xE0,
  0x7F, 0xE3, 0xFF, 0x9E, 0x0E, 0x70, 0x3D, 0xC0, 0xFF, 0x03, 0xBC, 0x0E,
  0xF0, 0x3B, 0x80, 0xEE, 0x07, 0xB8, 0x1E, 0xF0, 0xF3, 0xFF, 0x87, 0xFE,
  0x0F, 0xE0, 0x1E, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1E, 0x0F, 0x1E, 0x0F,
  0x1C, 0x0F, 0x1C, 0x0E, 0x3C, 0x0E, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x1E,
  0x38, 0x1E, 0x3C, 0x3C, 0x7F, 0xFC, 0x7F, 0xF8, 0x7B, 0xF0, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xCE, 0x1F, 0xDC,
  0x7F, 0xB9, 0xE1, 0xF3, 0x81, 0xE7, 0x03, 0x9E, 0x07, 0x3C, 0x0E, 0x78,
  0x1C, 0xE0, 0x79, 0xC0, 0xF3, 0x81, 0xE7, 0x87, 0x8F, 0xFF, 0x1F, 0xEE,
  0x1F, 0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x39, 0xF8, 0x77, 0xF8, 0xFF, 0xF1, 0xE1, 0xE7, 0x81, 0xCF, 0x03, 0x9C,
  0x07, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0xF8, 0x3F, 0xF8, 0x7F, 0xF9,
  0xE0, 0xF3, 0x80, 0x07, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xEF, 0x03, 0xCF, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0x80, 0x3C, 0x0E, 0x78, 0x1C, 0xF0, 0x39, 0xC0, 0xF3, 0x81, 0xE7,
  0x03, 0xDE, 0x07, 0x3C, 0x0E, 0x78, 0x1C, 0xE0, 0x79, 0xC0, 0xF3, 0x81,
  0xC7, 0x87, 0x8F, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0xE0, 0x1F, 0x80, 0xFE,
  0x03, 0xB8, 0x1E, 0xF0, 0x73, 0xC3, 0xC7, 0x0E, 0x1C, 0x78, 0x71, 0xC1,
  0xCF, 0x07, 0xB8, 0x1E, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x8E, 0xE7, 0x8E, 0xE7, 0x8E, 0xE7, 0x8C,
  0xED, 0x9C, 0xED, 0x9C, 0xED, 0x98, 0xE9, 0xB8, 0xF9, 0xB8, 0xD9, 0xB0,
  0xD1, 0xF0, 0xF1, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0, 0x1E, 0x07, 0x87, 0x07,
  0x83, 0xC7, 0x80, 0xE7, 0x80, 0x7B, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xF8, 0x03, 0xDC, 0x01, 0xCF, 0x01, 0xE7, 0x81,
  0xE1, 0xE1, 0xE0, 0xF1, 0xE0, 0x3C, 0x78, 0x1D, 0xE0, 0x77, 0x03, 0xDC,
  0x0F, 0x70, 0x3D, 0xC0, 0xEF, 0x03, 0xBC, 0x0E, 0xF0, 0x3B, 0x81, 0xEF,
  0x07, 0xBC, 0x3C, 0xFF, 0xF1, 0xFD, 0xC3, 0xC7, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x87, 0xFE, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xFC, 0xFF,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F,
  0xFC, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x7F, 0x80, 0x7E, 0x00, 0x7F, 0x80, 0x87, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E,
  0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38,
  0x38, 0x38, 0x78, 0x78, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0x0F, 0x00,
  0x1F, 0x80, 0x7F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3F, 0xE0, 0x1F,
  0x80, 0xFF, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x04, 0x00, 0x3F, 0x07, 0x7F, 0x8E, 0x73, 0xCE, 0x71, 0xFE, 0x71,
  0xFC, 0xE0, 0xF8,
};

const GFXglyph JetBrainsMono_SemiBoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 8, 21, 17, 5, -21 },
  { 22, 11, 9, 17, 5, -21 },
  { 35, 18, 21, 17, 0, -21 },
  { 83, 16, 29, 17, 1, -25 },
  { 141, 20, 21, 17, -1, -21 },
  { 194, 17, 21, 17, 0, -21 },
  { 239, 4, 9, 17, 8, -21 },
  { 244, 13, 29, 17, 4, -25 },
  { 292, 13, 29, 17, 1, -25 },
  { 340, 16, 15, 17, 1, -18 },
  { 370, 14, 13, 17, 2, -16 },
  { 393, 9, 9, 17, 2, -4 },
  { 404, 10, 3, 17, 4, -11 },
  { 408, 6, 5, 17, 5, -5 },
  { 412, 18, 27, 17, 0, -24 },
  { 473, 16, 21, 17, 1, -21 },
  { 515, 14, 21, 17, 1, -21 },
  { 552, 16, 21, 17, 1, -21 },
  { 594, 16, 21, 17, 1, -21 },
  { 636, 15, 21, 17, 1, -21 },
  { 676, 16, 21, 17, 1, -21 },
  { 718, 15, 21, 17, 1, -21 },
  { 758, 15, 21, 17, 3, -21 },
  { 798, 16, 21, 17, 1, -21 },
  { 840, 15, 21, 17, 2, -21 },
  { 880, 7, 16, 17, 5, -16 },
  { 894, 9, 21, 17, 3, -16 },
  { 918, 15, 15, 17, 2, -17 },
  { 947, 14, 11, 17, 2, -15 },
  { 967, 15, 15, 17, 1, -17 },
  { 996, 12, 21, 17, 4, -21 },
  { 1028, 18, 26, 17, 0, -21 },
  { 1087, 15, 21, 17, 0, -21 },
  { 1127, 16, 21, 17, 1, -21 },
  { 1169, 15, 21, 17, 2, -21 },
  { 1209, 16, 21, 17, 1, -21 },
  { 1251, 16, 21, 17, 1, -21 },
  { 1293, 17, 21, 17, 1, -21 },
  { 1338, 15, 21, 17, 2, -21 },
  { 1378, 16, 21, 17, 1, -21 },
  { 1420, 16, 21, 17, 1, -21 },
  { 1462, 17, 21, 17, 0, -21 },
  { 1507, 17, 21, 17, 1, -21 },
  { 1552, 13, 21, 17, 2, -21 },
  { 1587, 18, 21, 17, 0, -21 },
  { 1635, 16, 21, 17, 1, -21 },
  { 1677, 15, 21, 17, 2, -21 },
  { 1717, 17, 21, 17, 1, -21 },
  { 1762, 16, 26, 17, 1, -21 },
  { 1814, 16, 21, 17, 1, -21 },
  { 1856, 16, 21, 17, 1, -21 },
  { 1898, 15, 21, 17, 3, -21 },
  { 1938, 16, 21, 17, 1, -21 },
  { 1980, 15, 21, 17, 3, -21 },
  { 2020, 18, 21, 17, 1, -21 },
  { 2068, 18, 21, 17, 0, -21 },
  { 2116, 16, 21, 17, 3, -21 },
  { 2158, 16, 21, 17, 1, -21 },
  { 2200, 12, 27, 17, 4, -24 },
  { 2241, 10, 27, 17, 4, -24 },
  { 2275, 12, 27, 17, 2, -24 },
  { 2316, 14, 11, 17, 2, -21 },
  { 2336, 14, 3, 17, 0, 1 },
  { 2342, 6, 4, 17, 7, -23 },
  { 2345, 15, 16, 17, 1, -16 },
  { 2375, 15, 21, 17, 1, -21 },
  { 2415, 14, 16, 17, 2, -16 },
  { 2443, 16, 21, 17, 1, -21 },
  { 2485, 14, 16, 17, 2, -16 },
  { 2513, 20, 26, 17, -2, -21 },
  { 2578, 14, 21, 17, 2, -16 },
  { 2615, 15, 21, 17, 1, -21 },
  { 2655, 14, 23, 17, 1, -23 },
  { 2696, 16, 28, 17, 0, -23 },
  { 2752, 16, 21, 17, 1, -21 },
  { 2794, 12, 21, 17, 3, -21 },
  { 2826, 17, 16, 17, 0, -16 },
  { 2860, 15, 16, 17, 1, -16 },
  { 2890, 14, 16, 17, 2, -16 },
  { 2918, 16, 21, 17, 0, -16 },
  { 2960, 15, 21, 17, 1, -16 },
  { 3000, 15, 16, 17, 2, -16 },
  { 3030, 15, 16, 17, 1, -16 },
  { 3060, 15, 20, 17, 2, -20 },
  { 3098, 15, 16, 17, 1, -16 },
  { 3128, 14, 16, 17, 3, -16 },
  { 3156, 16, 16, 17, 2, -16 },
  { 3188, 17, 16, 17, 0, -16 },
  { 3222, 14, 21, 17, 2, -16 },
  { 3259, 15, 16, 17, 1, -16 },
  { 3289, 16, 27, 17, 2, -24 },
  { 3343, 8, 27, 17, 5, -24 },
  { 3370, 15, 27, 17, 1, -24 },
  { 3421, 16, 7, 17, 1, -14 },
};

const GFXfont JetBrainsMono_SemiBoldItalic29pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic29pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC29PT7B_H_
