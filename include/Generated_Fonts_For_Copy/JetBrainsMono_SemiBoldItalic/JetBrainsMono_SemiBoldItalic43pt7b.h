#ifndef _JETBRAINSMONO_SEMIBOLDITALIC43PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x00, 0x3E, 0x1F, 0x7E, 0x1F,
  0x7C, 0x1F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3E,
  0x78, 0x3E, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF0, 0x3C, 0x00, 0x1E,
  0x07, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x07,
  0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0x78, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x3C, 0x0F, 0x00,
  0x1C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x03, 0xC0,
  0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xC0, 0xF0, 0x01, 0xE0, 0x78,
  0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F,
  0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x03,
  0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xE7, 0x3E, 0x07, 0xC6, 0x3F, 0x0F,
  0x86, 0x1F, 0x0F, 0x8E, 0x1F, 0x0F, 0x8E, 0x00, 0x0F, 0x8E, 0x00, 0x0F,
  0xCE, 0x00, 0x0F, 0xEE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1B, 0xF8, 0x00, 0x18, 0xFC, 0x00, 0x38, 0xFC, 0x00, 0x38, 0x7C, 0x00,
  0x38, 0x7C, 0x7C, 0x38, 0xF8, 0x7C, 0x30, 0xF8, 0x7E, 0x31, 0xF8, 0x7F,
  0x73, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x02,
  0x01, 0xFE, 0x00, 0x78, 0x07, 0xFE, 0x01, 0xE0, 0x1F, 0xFC, 0x03, 0x80,
  0x78, 0x78, 0x0F, 0x00, 0xF0, 0x70, 0x3C, 0x01, 0xC1, 0xE0, 0xF0, 0x03,
  0x83, 0xC3, 0xC0, 0x0F, 0x07, 0x8F, 0x00, 0x1E, 0x0F, 0x3C, 0x00, 0x3C,
  0x3C, 0x70, 0x00, 0x7E, 0xF9, 0xE0, 0x00, 0x7F, 0xE7, 0x80, 0x00, 0x7F,
  0x9E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0xFC, 0x00, 0x00, 0xF3,
  0xFE, 0x00, 0x03, 0xCF, 0xFC, 0x00, 0x0F, 0x3C, 0x7C, 0x00, 0x3C, 0x70,
  0x78, 0x00, 0xF1, 0xE0, 0xF0, 0x01, 0xC3, 0xC1, 0xE0, 0x07, 0x87, 0x83,
  0x80, 0x1E, 0x0F, 0x07, 0x00, 0x78, 0x1C, 0x1E, 0x01, 0xE0, 0x3C, 0x7C,
  0x07, 0x80, 0x7F, 0xF0, 0x1E, 0x00, 0x7F, 0xC0, 0x78, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xFB, 0xF8, 0x03, 0xE0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x01, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C,
  0x7C, 0x3E, 0xF8, 0x7C, 0x1F, 0xF0, 0x78, 0x1F, 0xF0, 0xF8, 0x0F, 0xE0,
  0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0xE0, 0xFC, 0x1F, 0xE0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFD, 0xF0, 0x3F, 0xF8, 0xF8, 0x1F, 0xE0, 0xFC,
  0x7D, 0xF7, 0xDF, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0x3C, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x1F,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x04,
  0x07, 0x80, 0x4E, 0x0F, 0x07, 0x3F, 0x1E, 0x3F, 0x7F, 0x39, 0xFF, 0xFF,
  0xBF, 0xFC, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0xF7, 0x80, 0x03, 0xE7, 0x80, 0x0F, 0x8F, 0x80, 0x3F, 0x1F,
  0x00, 0xFC, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xC0, 0x78, 0x01, 0x00, 0x60,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC,
  0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0x80,
  0xF8, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x3F,
  0x3F, 0x9F, 0xEF, 0xE7, 0xF3, 0xF9, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xF8, 0x1F, 0x83, 0xE0, 0x1F, 0x0F, 0x80,
  0x1F, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xF1, 0xF0, 0x03,
  0xE3, 0xE0, 0x07, 0xC7, 0xC2, 0x0F, 0x8F, 0x9F, 0x1F, 0x1F, 0x3E, 0x3C,
  0x3C, 0x7C, 0x78, 0xF8, 0xF9, 0xF1, 0xF0, 0xE3, 0xE3, 0xE0, 0x07, 0xC7,
  0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0xF8, 0xF8,
  0x01, 0xF1, 0xF0, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xF0, 0x7F, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x80, 0xFC,
  0xF8, 0x0F, 0x8F, 0x81, 0xE0, 0xF8, 0x1C, 0x0F, 0x81, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x1F,
  0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xF0, 0x1F, 0x8F,
  0xE0, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x3F, 0x01,
  0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x1C, 0x00,
  0xF9, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F,
  0x80, 0xFC, 0x3E, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xC1, 0xF8, 0x3F, 0x83, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF9, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x3E, 0xF8, 0x01, 0xF7, 0xE0, 0x1F, 0x9F, 0x83, 0xF8, 0xFF, 0xFF, 0x83,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7C, 0x00, 0xFD, 0xF0, 0x03,
  0xE7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC1, 0xF8, 0x1F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xFC, 0x07, 0xC0, 0xFC, 0x1F, 0x00,
  0xFC, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x7F, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xE0, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03,
  0xE3, 0xF0, 0x0F, 0xC7, 0xF0, 0x7F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0x81, 0xF9, 0xF8, 0x07,
  0xEF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xF0, 0x0F, 0xDF, 0xC1, 0xFC,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xBF, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC1, 0xFC, 0x3F, 0x8F, 0xF1,
  0xFE, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF0, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC,
  0x07, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x10, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F,
  0xF0, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xF8,
  0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x0F,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x0F, 0xCF,
  0x1E, 0x07, 0xFB, 0xC7, 0x83, 0xFE, 0xE3, 0xE1, 0xF0, 0xF8, 0xF0, 0x78,
  0x1E, 0x3C, 0x1E, 0x07, 0x8F, 0x0F, 0x81, 0xE3, 0xC3, 0xC0, 0xF8, 0xF0,
  0xF0, 0x3E, 0x7C, 0x3C, 0x0F, 0x1F, 0x0F, 0x03, 0xC7, 0x83, 0xC0, 0xF1,
  0xE1, 0xF0, 0x3C, 0x78, 0x7C, 0x1F, 0x1E, 0x1F, 0x07, 0xC7, 0x83, 0xFF,
  0xE3, 0xE0, 0xFF, 0xB8, 0xF0, 0x1F, 0xDE, 0x3C, 0x01, 0x80, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xEF, 0x00, 0x1F, 0x3C, 0x00, 0x7C, 0xF0, 0x01, 0xE3, 0xC0, 0x0F,
  0x8F, 0x00, 0x3E, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xC3, 0xE0, 0x1E, 0x0F,
  0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xC0,
  0x1F, 0x3F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x1F,
  0x7C, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xF8, 0x0F, 0xC1,
  0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x0F, 0xC1, 0xE0, 0x7F, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7C, 0x07,
  0xE0, 0xF0, 0x07, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xE3,
  0xE0, 0x3F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xF8, 0x1F, 0x83, 0xE0, 0x1F, 0x8F,
  0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xF0, 0x7F, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07,
  0xC0, 0xFE, 0x07, 0xC0, 0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E,
  0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xF8, 0x1F, 0x83, 0xE0, 0x1F, 0x8F, 0xC0,
  0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0xFE,
  0x3E, 0x1F, 0xF8, 0x7C, 0x3F, 0xF1, 0xF8, 0xFF, 0xE3, 0xE1, 0xFF, 0xC7,
  0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x83, 0xF0, 0x7F, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xC0,
  0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03,
  0xE1, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7C,
  0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF8, 0x07,
  0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C,
  0x3E, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x83, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01,
  0xF0, 0x7C, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xC0, 0x1F, 0x87, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0,
  0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0,
  0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF8,
  0x03, 0xF1, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x0F, 0x81,
  0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3F, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xF0, 0x3E, 0x00, 0xF8, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC0,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF0, 0x07, 0xE0, 0x1F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1,
  0xFC, 0x0F, 0xF0, 0xFE, 0x07, 0x78, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xBC,
  0x3D, 0xE3, 0xDE, 0x1E, 0x71, 0xEF, 0x0F, 0x38, 0xE7, 0x87, 0x9C, 0xF7,
  0xC3, 0xCE, 0x73, 0xC1, 0xE7, 0xF9, 0xE1, 0xF3, 0xF8, 0xF0, 0xF9, 0xFC,
  0xF8, 0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x3E, 0x1F, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0,
  0x01, 0xF0, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3,
  0xE0, 0x03, 0xC0, 0x07, 0xF0, 0x0F, 0x83, 0xF8, 0x07, 0x81, 0xFC, 0x03,
  0xC0, 0xFE, 0x03, 0xE0, 0x7F, 0x01, 0xF0, 0x7F, 0xC0, 0xF8, 0x3F, 0xE0,
  0x7C, 0x1E, 0xF0, 0x3C, 0x0F, 0x78, 0x1E, 0x07, 0xBC, 0x1F, 0x03, 0xCF,
  0x0F, 0x81, 0xE7, 0x87, 0xC1, 0xF3, 0xC3, 0xE0, 0xF9, 0xE1, 0xE0, 0x7C,
  0xF0, 0xF0, 0x3C, 0x3C, 0xF8, 0x1E, 0x1E, 0x7C, 0x0F, 0x0F, 0x3E, 0x0F,
  0x87, 0x9F, 0x07, 0xC3, 0xCF, 0x03, 0xE1, 0xF7, 0x81, 0xF0, 0x7B, 0xC0,
  0xF0, 0x3D, 0xE0, 0x78, 0x1E, 0xF0, 0x7C, 0x0F, 0xF8, 0x3E, 0x07, 0xF8,
  0x1F, 0x01, 0xFC, 0x0F, 0x80, 0xFE, 0x07, 0x80, 0x7F, 0x03, 0xC0, 0x3F,
  0x83, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xF8, 0x1F, 0x83, 0xE0, 0x1F,
  0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF8, 0x03, 0xE3, 0xE0,
  0x07, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xF0, 0x7F,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x0F, 0x80, 0xFE, 0x0F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x1F,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x3F, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1,
  0xF8, 0x1F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0,
  0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x01,
  0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F,
  0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF8, 0x07, 0xE1,
  0xF0, 0x0F, 0x83, 0xF0, 0x7F, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xF8, 0x0F, 0xE1, 0xF0, 0x0F, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x7F, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xF8, 0x7C, 0x03, 0xE0,
  0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3F,
  0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x03, 0xF0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x7E, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01,
  0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F,
  0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E,
  0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x1E, 0x00, 0xF8, 0x7C,
  0x03, 0xE1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x03, 0xC3, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x7C, 0x00, 0xFB,
  0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3C, 0x1F, 0x03, 0xCF, 0x07, 0xC1, 0xF3, 0xC1, 0xF0,
  0x78, 0xF0, 0x7C, 0x1E, 0x3C, 0x3F, 0x07, 0x8F, 0x0F, 0xC3, 0xE7, 0xC3,
  0xF0, 0xF1, 0xF0, 0xDC, 0x3C, 0x7C, 0x77, 0x0F, 0x1F, 0x1D, 0xC7, 0x87,
  0x87, 0x71, 0xE1, 0xE3, 0x9C, 0x78, 0x78, 0xE7, 0x1E, 0x1E, 0x39, 0xCF,
  0x07, 0x8C, 0x73, 0xC1, 0xE7, 0x1C, 0xF0, 0x79, 0xC6, 0x3C, 0x1E, 0x71,
  0x9E, 0x07, 0xB8, 0x67, 0x81, 0xEE, 0x19, 0xE0, 0x7B, 0x8E, 0x78, 0x1E,
  0xE3, 0xBC, 0x07, 0xF0, 0xEF, 0x01, 0xFC, 0x3B, 0xC0, 0x77, 0x0E, 0xE0,
  0x3D, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F,
  0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x1F, 0x00, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xF8, 0x00, 0xF8,
  0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x7C, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x9F,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xE0, 0xF8, 0x00,
  0xFC, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F,
  0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x3E, 0x01, 0xF8,
  0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0xC0,
  0x1F, 0x0F, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x9F, 0x00, 0x0F, 0x9F, 0x00,
  0x0F, 0xBE, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x81,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1F, 0x78, 0x03, 0xE7, 0x80,
  0x3C, 0x7C, 0x07, 0xC3, 0xC0, 0x78, 0x3C, 0x0F, 0x83, 0xE1, 0xF0, 0x3E,
  0x1E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x00, 0xFC, 0x7C, 0x0F, 0xF9,
  0xF0, 0x7F, 0xF7, 0xC3, 0xFF, 0xDF, 0x1F, 0xE7, 0x7C, 0x7E, 0x07, 0xE3,
  0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0,
  0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x7E, 0x1F,
  0x83, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xEF, 0x83, 0xFF, 0x3E, 0x07, 0xF8,
  0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC3, 0xF0, 0x1F,
  0x3F, 0xE0, 0x7D, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xF8, 0xFE, 0x3F, 0x81,
  0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xF3, 0xF0, 0x0F,
  0x8F, 0xE0, 0xFE, 0x3F, 0xFF, 0xF0, 0xFB, 0xFF, 0x83, 0xEF, 0xFC, 0x0F,
  0x9F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0x03,
  0xFF, 0xFE, 0x1F, 0xE3, 0xF8, 0x7E, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x83, 0xF8, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x7E, 0x3E, 0x03, 0xFE, 0x7C, 0x0F,
  0xFE, 0xF8, 0x3F, 0xFD, 0xF0, 0xFF, 0x3B, 0xE1, 0xF8, 0x1F, 0x87, 0xE0,
  0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01,
  0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x0F, 0xC1,
  0xF8, 0x3F, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xBE, 0x07, 0xFE, 0x7C, 0x07,
  0xF8, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xF8, 0x1F, 0x8F, 0x80, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F,
  0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x9F, 0x00, 0xF8, 0xFC, 0x0F, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x7C, 0x0F, 0xF9, 0xF0, 0x7F, 0xF7,
  0xC3, 0xFF, 0xDF, 0x1F, 0xE7, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x0F, 0x8F,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00,
  0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0xFC,
  0x7C, 0x03, 0xF1, 0xF8, 0x1F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFB, 0xE0, 0x7F, 0xCF, 0x80, 0x10, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC7, 0xF0, 0x1F, 0x3F, 0xE0, 0x7D, 0xFF, 0xC1,
  0xFF, 0xFF, 0x87, 0xF8, 0xFE, 0x3F, 0x81, 0xF8, 0xFC, 0x03, 0xE3, 0xE0,
  0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F,
  0x9F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F,
  0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00,
  0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x7E,
  0x1F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x1F, 0x03, 0xF0,
  0x3E, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7C, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x7C, 0x0F, 0x80,
  0x7C, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xE0,
  0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0x87, 0xFF,
  0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0x3E, 0x3E, 0x07,
  0xBF, 0x3F, 0x83, 0xDF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xF0, 0xF0, 0xF8,
  0xF8, 0x78, 0x78, 0x7C, 0x3C, 0x3C, 0x3E, 0x1C, 0x1E, 0x1E, 0x0E, 0x0F,
  0x0F, 0x0F, 0x0F, 0x87, 0x87, 0x87, 0xC7, 0xC3, 0xC3, 0xE3, 0xE1, 0xE1,
  0xE1, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x78, 0x7C, 0x3C, 0x3C,
  0x3E, 0x3E, 0x1E, 0x1F, 0x1F, 0x0F, 0x0F, 0x0F, 0x87, 0x87, 0x87, 0xC3,
  0x83, 0xC3, 0xC1, 0xC3, 0xE1, 0xE1, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0x1F,
  0x1F, 0xC0, 0x7C, 0xFF, 0x81, 0xF7, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xE3,
  0xF8, 0xFE, 0x07, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x7C, 0x01, 0xF1, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x01, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE1, 0xFE, 0x7F, 0x8F, 0xC0, 0xFC, 0xFC, 0x03, 0xE7,
  0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x01,
  0xF7, 0xC0, 0x1F, 0xBE, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C,
  0x01, 0xF3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xFC, 0x1F, 0xC7, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xC3, 0xF0, 0x07,
  0xCF, 0xF8, 0x07, 0xDF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xF8, 0xFE, 0x0F,
  0xE0, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0xFF, 0xF0, 0x3E,
  0xFF, 0xE0, 0x3E, 0xFF, 0xC0, 0x3E, 0x7F, 0x80, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x7C, 0x0F,
  0xF9, 0xF0, 0x7F, 0xF7, 0xC3, 0xFF, 0xDF, 0x1F, 0xE7, 0x7C, 0x7E, 0x07,
  0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE7,
  0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0,
  0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x03, 0xF3, 0xF0, 0x0F, 0x87, 0xC0, 0x7E,
  0x1F, 0x83, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xEF, 0x83, 0xFF, 0x3E, 0x07,
  0xF8, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x0F, 0x8F, 0xE0, 0x1F, 0x7F, 0xE0, 0x3F, 0xFF, 0xE0, 0x7B, 0xFF, 0xE1,
  0xFE, 0x1F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0x81, 0xF8, 0x7C,
  0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xCF, 0x80,
  0x1F, 0x3F, 0x00, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0,
  0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E,
  0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x7E, 0x7C,
  0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01,
  0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x0F,
  0x87, 0xC0, 0x3E, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x3E, 0x03,
  0xC0, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xE3,
  0xE0, 0x0F, 0x9F, 0x00, 0x1E, 0x7C, 0x00, 0x79, 0xE0, 0x01, 0xEF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0xF0, 0x3C, 0x0F, 0xF0, 0x7C, 0x1E, 0xF0, 0x7C, 0x1E, 0xF0,
  0x7C, 0x1E, 0xF0, 0xFC, 0x3C, 0xF0, 0xFC, 0x3C, 0xF0, 0xDC, 0x3C, 0xF1,
  0xDC, 0x78, 0xF1, 0xDC, 0x78, 0xF1, 0x9C, 0x78, 0xF3, 0x9C, 0xF0, 0xF3,
  0x9C, 0xF0, 0xF3, 0x9C, 0xF0, 0xF7, 0x1C, 0xE0, 0xF7, 0x1D, 0xE0, 0xF7,
  0x1D, 0xE0, 0xF6, 0x1D, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFC,
  0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0xF8,
  0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF8, 0x0F, 0xC0,
  0x7C, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xE7, 0xC0,
  0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x03, 0xF3, 0xF0, 0x03, 0xF0,
  0xF8, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x01, 0xF8, 0x0F, 0xC1, 0xF8,
  0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x9F,
  0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00,
  0xFC, 0x7E, 0x03, 0xF1, 0xFC, 0x3F, 0x87, 0xFF, 0xFE, 0x0F, 0xFE, 0xF8,
  0x1F, 0xF3, 0xE0, 0x3F, 0x8F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0xE0, 0x7C, 0xFF, 0xE0, 0xF3, 0xFF, 0xC1, 0xE7, 0xCF, 0xC3,
  0xCF, 0x0F, 0xCF, 0x9E, 0x0F, 0xFE, 0x7C, 0x1F, 0xF8, 0xF8, 0x1F, 0xE0,
  0x00, 0x0F, 0x00,
};

const GFXglyph JetBrainsMono_SemiBoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 11, 31, 26, 8, -31 },
  { 44, 16, 13, 26, 7, -31 },
  { 70, 25, 31, 26, 1, -31 },
  { 167, 24, 43, 26, 1, -37 },
  { 296, 31, 32, 26, -2, -32 },
  { 420, 24, 32, 26, 1, -32 },
  { 516, 6, 13, 26, 12, -31 },
  { 526, 19, 41, 26, 6, -36 },
  { 624, 18, 41, 26, 2, -36 },
  { 717, 23, 22, 26, 2, -26 },
  { 781, 21, 20, 26, 3, -24 },
  { 834, 12, 14, 26, 4, -7 },
  { 855, 15, 4, 26, 6, -16 },
  { 863, 9, 7, 26, 7, -7 },
  { 871, 27, 41, 26, 0, -36 },
  { 1010, 23, 32, 26, 2, -32 },
  { 1102, 20, 31, 26, 2, -31 },
  { 1180, 23, 32, 26, 2, -32 },
  { 1272, 22, 31, 26, 2, -31 },
  { 1358, 22, 31, 26, 2, -31 },
  { 1444, 23, 31, 26, 2, -31 },
  { 1534, 21, 31, 26, 2, -31 },
  { 1616, 22, 31, 26, 4, -31 },
  { 1702, 23, 32, 26, 2, -32 },
  { 1794, 21, 32, 26, 4, -32 },
  { 1878, 11, 24, 26, 7, -24 },
  { 1911, 14, 31, 26, 4, -24 },
  { 1966, 22, 24, 26, 3, -26 },
  { 2032, 21, 15, 26, 3, -22 },
  { 2072, 21, 24, 26, 2, -26 },
  { 2135, 18, 31, 26, 6, -31 },
  { 2205, 26, 40, 26, 0, -32 },
  { 2335, 22, 31, 26, 0, -31 },
  { 2421, 23, 31, 26, 2, -31 },
  { 2511, 23, 32, 26, 2, -32 },
  { 2603, 24, 31, 26, 1, -31 },
  { 2696, 24, 31, 26, 2, -31 },
  { 2789, 24, 31, 26, 2, -31 },
  { 2882, 23, 32, 26, 2, -32 },
  { 2974, 23, 31, 26, 2, -31 },
  { 3064, 23, 31, 26, 2, -31 },
  { 3154, 25, 31, 26, 0, -31 },
  { 3251, 25, 31, 26, 2, -31 },
  { 3348, 19, 31, 26, 3, -31 },
  { 3422, 25, 31, 26, 1, -31 },
  { 3519, 25, 31, 26, 1, -31 },
  { 3616, 23, 32, 26, 2, -32 },
  { 3708, 24, 31, 26, 2, -31 },
  { 3801, 23, 40, 26, 2, -32 },
  { 3916, 23, 31, 26, 2, -31 },
  { 4006, 24, 32, 26, 1, -32 },
  { 4102, 23, 31, 26, 4, -31 },
  { 4192, 24, 31, 26, 2, -31 },
  { 4285, 22, 31, 26, 5, -31 },
  { 4371, 26, 31, 26, 2, -31 },
  { 4472, 28, 31, 26, -1, -31 },
  { 4581, 24, 31, 26, 4, -31 },
  { 4674, 23, 31, 26, 2, -31 },
  { 4764, 18, 41, 26, 6, -36 },
  { 4857, 14, 41, 26, 6, -36 },
  { 4929, 18, 41, 26, 3, -36 },
  { 5022, 20, 16, 26, 3, -31 },
  { 5062, 21, 5, 26, 0, 1 },
  { 5076, 9, 6, 26, 11, -34 },
  { 5083, 22, 24, 26, 2, -24 },
  { 5149, 22, 31, 26, 2, -31 },
  { 5235, 22, 24, 26, 2, -24 },
  { 5301, 23, 31, 26, 2, -31 },
  { 5391, 21, 24, 26, 2, -24 },
  { 5454, 29, 39, 26, -2, -31 },
  { 5596, 22, 32, 26, 2, -24 },
  { 5684, 22, 31, 26, 2, -31 },
  { 5770, 22, 34, 26, 1, -34 },
  { 5864, 23, 42, 26, 0, -34 },
  { 5985, 24, 31, 26, 2, -31 },
  { 6078, 19, 31, 26, 4, -31 },
  { 6152, 25, 24, 26, 0, -24 },
  { 6227, 22, 24, 26, 2, -24 },
  { 6293, 21, 24, 26, 2, -24 },
  { 6356, 24, 32, 26, 0, -24 },
  { 6452, 22, 32, 26, 2, -24 },
  { 6540, 23, 24, 26, 2, -24 },
  { 6609, 22, 24, 26, 2, -24 },
  { 6675, 22, 30, 26, 3, -30 },
  { 6758, 22, 24, 26, 2, -24 },
  { 6824, 22, 24, 26, 4, -24 },
  { 6890, 24, 24, 26, 3, -24 },
  { 6962, 25, 24, 26, 0, -24 },
  { 7037, 22, 32, 26, 2, -24 },
  { 7125, 22, 24, 26, 2, -24 },
  { 7191, 22, 41, 26, 4, -36 },
  { 7304, 11, 41, 26, 8, -36 },
  { 7361, 22, 41, 26, 1, -36 },
  { 7474, 23, 10, 26, 2, -20 },
};

const GFXfont JetBrainsMono_SemiBoldItalic43pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic43pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC43PT7B_H_
