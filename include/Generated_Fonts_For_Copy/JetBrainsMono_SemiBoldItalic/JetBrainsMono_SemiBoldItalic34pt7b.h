#ifndef _JETBRAINSMONO_SEMIBOLDITALIC34PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x10, 0x00, 0x00, 0x00,
  0x03, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x78, 0xF7, 0x8F, 0x78, 0xFF, 0x0F,
  0xF0, 0xFF, 0x1E, 0xF1, 0xEF, 0x1E, 0xE1, 0xEE, 0x1E, 0x00, 0x70, 0x70,
  0x03, 0x83, 0x80, 0x1C, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70,
  0xE0, 0x07, 0x07, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x1C, 0x1C, 0x00,
  0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x38,
  0x01, 0xC1, 0xC0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x38,
  0x38, 0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x00,
  0x70, 0x70, 0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xC1, 0xE6, 0x78, 0x78, 0xCF, 0x0F, 0x19, 0xE1, 0xE7, 0x00, 0x3C, 0xC0,
  0x07, 0xD8, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x0C, 0xF8, 0x01, 0x8F, 0x00, 0x31, 0xE3, 0xC6, 0x3C,
  0x78, 0xC7, 0x8F, 0x39, 0xE1, 0xF6, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0,
  0x3F, 0xE0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x07, 0xF0, 0x0E, 0x0F, 0xF8, 0x1C,
  0x1C, 0x38, 0x38, 0x1C, 0x38, 0x70, 0x1C, 0x38, 0xE0, 0x1C, 0x39, 0xC0,
  0x1C, 0x33, 0xC0, 0x1C, 0x73, 0x80, 0x1F, 0xE7, 0x00, 0x0F, 0xCE, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x77, 0xE0,
  0x00, 0xEF, 0xF0, 0x01, 0xDE, 0x70, 0x03, 0x9C, 0x38, 0x07, 0x1C, 0x38,
  0x0E, 0x18, 0x70, 0x1C, 0x38, 0x70, 0x1C, 0x38, 0x70, 0x38, 0x3C, 0xF0,
  0x70, 0x1F, 0xE0, 0xE0, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0xFC, 0x07, 0xC7, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xFC,
  0x02, 0xFF, 0xC7, 0x9E, 0x78, 0xF3, 0x87, 0xBC, 0xF0, 0xFF, 0x1E, 0x0F,
  0xC3, 0xC1, 0xF8, 0x78, 0x1E, 0x0F, 0x07, 0xC1, 0xE1, 0xFC, 0x3F, 0xFF,
  0xC3, 0xFF, 0x78, 0x3F, 0x87, 0x80, 0x7D, 0xE7, 0x9E, 0x79, 0xE7, 0x3C,
  0xF3, 0xC0, 0x00, 0x02, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF0,
  0x03, 0xE0, 0x01, 0x80, 0x04, 0x00, 0x1C, 0x00, 0x7C, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x03, 0xF8, 0x0F, 0xC0, 0x3C, 0x00,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x18, 0x38, 0x6F, 0x8C, 0x7F, 0xFB, 0x7F, 0xFF, 0xFF, 0x83, 0xFE,
  0x00, 0x3C, 0x00, 0x1D, 0x80, 0x0E, 0x70, 0x07, 0x9E, 0x03, 0xC7, 0xC1,
  0xF0, 0xF0, 0x78, 0x38, 0x04, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x87, 0xC7, 0xC3, 0xC3, 0xE1, 0xE1,
  0xF0, 0xF0, 0x78, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x39,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7E,
  0x3E, 0x1E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x38, 0xE0, 0x1E, 0x38, 0x07,
  0x9E, 0x01, 0xE7, 0x8C, 0x79, 0xE7, 0x9E, 0x7B, 0xE7, 0x1E, 0x79, 0xC7,
  0x0C, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xE3, 0xC0,
  0x78, 0xF0, 0x1E, 0x3E, 0x1F, 0x07, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFB, 0xC0,
  0xF9, 0xE0, 0x70, 0xF0, 0x30, 0x78, 0x10, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x03, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0,
  0x7F, 0xF8, 0x3F, 0x3F, 0x1F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x80,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF,
  0xFC, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE7, 0x80, 0xF1, 0xE0,
  0x3C, 0x78, 0x1F, 0x1F, 0x0F, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC1, 0xE3, 0xC0, 0xF3, 0xE0, 0x79, 0xE0, 0x3D, 0xE0, 0x3C, 0xFF,
  0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE3, 0xFF, 0xF1, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xE1, 0xF3, 0xC0,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x9E,
  0x03, 0xCF, 0x03, 0xE7, 0xC3, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF7, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0x83, 0xE7, 0xC0, 0x79, 0xE0,
  0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3E, 0x78, 0x0F,
  0x1F, 0x0F, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0x78, 0x07, 0x9E, 0x03, 0xC7,
  0x80, 0xF2, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xE0,
  0x7F, 0xFC, 0x3F, 0x1F, 0x0F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78,
  0x0F, 0x1E, 0x07, 0x83, 0xC3, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0, 0x03, 0xFC,
  0x03, 0xFF, 0x81, 0xF1, 0xF0, 0xF0, 0x3C, 0x78, 0x07, 0x9E, 0x01, 0xE7,
  0x80, 0x79, 0xE0, 0x3C, 0x78, 0x0F, 0x1F, 0x0F, 0xC7, 0xFF, 0xE0, 0xFF,
  0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xE3,
  0xE7, 0xC0, 0xF3, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x07, 0xBC, 0x03, 0xDF, 0x03, 0xE7, 0xFF, 0xE3, 0xFF, 0xF0, 0xFE, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x0F,
  0x8F, 0xC7, 0xE1, 0xE0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x00, 0x01, 0xE0, 0x3E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1E,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x0F,
  0x00, 0x3F, 0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x04, 0x3F, 0xFF, 0x9F, 0xFF,
  0xCF, 0xFF, 0xC8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0x18, 0x00,
  0x0F, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x00, 0x1F, 0x80, 0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0xFF, 0xC1,
  0xFF, 0x03, 0xF8, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0xF0,
  0x07, 0x0F, 0x00, 0x3C, 0x70, 0x01, 0xE3, 0x80, 0x0F, 0x3C, 0x04, 0x71,
  0xE1, 0xFB, 0x8E, 0x1F, 0xFC, 0x70, 0xF1, 0xE3, 0x8F, 0x0F, 0x1C, 0x78,
  0x79, 0xE3, 0x83, 0xCF, 0x1C, 0x1C, 0x70, 0xE0, 0xE3, 0x87, 0x07, 0x1C,
  0x78, 0x78, 0xE3, 0xC3, 0xCF, 0x0F, 0x3E, 0x78, 0x7F, 0xE3, 0xC1, 0xF7,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xCF, 0x00, 0xF1, 0xC0, 0x3C, 0x70, 0x1E,
  0x1C, 0x07, 0x87, 0x01, 0xC1, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0xFF,
  0x87, 0xFF, 0xE3, 0xFF, 0xF8, 0xF0, 0x1E, 0x3C, 0x07, 0x9E, 0x01, 0xE7,
  0x80, 0x7B, 0xE0, 0x0E, 0xF0, 0x03, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0,
  0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x03, 0xE1, 0xE0, 0x3C, 0x38, 0x07, 0x8F,
  0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0xF8, 0x7E, 0x7E, 0x1E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x3F, 0x1F, 0x07, 0xFF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xFF, 0xE1, 0xE0, 0x7C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E,
  0x03, 0xC3, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78,
  0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x8F, 0x00, 0xF1, 0xE0,
  0x3C, 0x3C, 0x07, 0x87, 0x81, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0xC0, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F,
  0xFF, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x87,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8,
  0x3F, 0xFF, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7E,
  0x7E, 0x1E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0xFF, 0x9E, 0x3F, 0xC7,
  0x8F, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x78, 0xF0, 0x1E, 0x3F, 0x1F, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0,
  0x00, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0,
  0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0,
  0x78, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0x01,
  0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x8F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07,
  0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x1E,
  0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x78, 0x07, 0x87, 0x80, 0xF0,
  0x78, 0x0F, 0x07, 0xC3, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x1E,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x01, 0xE1, 0xF0, 0x1E, 0x1E, 0x01,
  0xE3, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x3C, 0x78, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0, 0x78, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0x01, 0xF1, 0xF0, 0x3F, 0x1F, 0x83, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xEE, 0x3F, 0x8E, 0xE3, 0xD8, 0xDE, 0x3D,
  0x9D, 0xC3, 0x9D, 0x9C, 0x39, 0xF9, 0xC3, 0x9F, 0xBC, 0x39, 0xF3, 0xC7,
  0x9F, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x38, 0x78, 0x07, 0x87, 0x80, 0x78,
  0x70, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x70, 0xF0, 0x0F,
  0x0F, 0x00, 0xF0, 0xE0, 0x0F, 0x00, 0x0F, 0x80, 0xE1, 0xF0, 0x3C, 0x3E,
  0x07, 0x87, 0xE0, 0xF1, 0xFC, 0x1E, 0x3F, 0x83, 0x87, 0x70, 0x70, 0xEE,
  0x1E, 0x1D, 0xE3, 0xC3, 0xBC, 0x78, 0xF3, 0x8F, 0x1E, 0x71, 0xC3, 0xCE,
  0x38, 0x79, 0xCF, 0x0E, 0x3D, 0xE1, 0xC3, 0xBC, 0x78, 0x77, 0x8F, 0x0E,
  0xE1, 0xE1, 0xDC, 0x3C, 0x3F, 0x87, 0x03, 0xF0, 0xE0, 0x7E, 0x1C, 0x0F,
  0xC7, 0x81, 0xF8, 0xF0, 0x3E, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x7E, 0x7E, 0x1E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x3C, 0x07, 0x8F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3C, 0x78, 0x0F, 0x1E,
  0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x01,
  0xE3, 0xC0, 0x78, 0xF0, 0x3E, 0x3E, 0x1F, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0x1F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x1E, 0x03, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E,
  0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0xFC, 0x3F, 0xFF, 0x83,
  0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x7E, 0x7E, 0x1E, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x38, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x0F, 0x1E,
  0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00,
  0xE3, 0xC0, 0x78, 0xF0, 0x3E, 0x3E, 0x1F, 0x07, 0xFF, 0xC1, 0xFF, 0xC0,
  0x1F, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07,
  0xFF, 0xE1, 0xE0, 0x3E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E,
  0x03, 0xE3, 0xC0, 0x78, 0x70, 0x1F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFE, 0x01, 0xE3, 0xC0, 0x3C, 0x7C, 0x0F, 0x07, 0x81, 0xE0,
  0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0xC7, 0x80,
  0x78, 0xF0, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07,
  0xE7, 0xE0, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF1, 0xE0,
  0x1E, 0x7C, 0x03, 0xC7, 0x80, 0xF0, 0xF8, 0x7E, 0x1F, 0xFF, 0x81, 0xFF,
  0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3C, 0x03,
  0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE7,
  0x80, 0x79, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3E,
  0x3E, 0x1F, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xF0, 0x07,
  0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x8F,
  0x01, 0xE3, 0xC0, 0x78, 0x70, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x81, 0xE1,
  0xE0, 0x78, 0x70, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE7, 0x80, 0x79, 0xE0,
  0x1E, 0x70, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x70, 0x70, 0x77, 0x0F, 0x0F,
  0x70, 0xF0, 0xF7, 0x0F, 0x0E, 0x70, 0xF0, 0xE7, 0x1F, 0x1E, 0x71, 0xB1,
  0xE7, 0x1B, 0x1C, 0x71, 0xB1, 0xC7, 0x3B, 0x3C, 0xF3, 0x33, 0x8F, 0x33,
  0x38, 0xF7, 0x33, 0x8F, 0x63, 0x78, 0xF6, 0x37, 0x0E, 0x63, 0x70, 0xEE,
  0x77, 0x0E, 0xC7, 0xF0, 0xEC, 0x7E, 0x0E, 0xC7, 0xE0, 0xFC, 0x6E, 0x0F,
  0x86, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF0, 0x7C, 0x00, 0x0F, 0x00,
  0x78, 0x7C, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x3C, 0x3C, 0x01,
  0xE3, 0xE0, 0x0F, 0x1E, 0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xDE, 0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x80,
  0x3E, 0x1E, 0x01, 0xE0, 0xF0, 0x1E, 0x07, 0xC1, 0xF0, 0x1E, 0x0F, 0x00,
  0xF0, 0xF0, 0x07, 0xC0, 0xF0, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x1F, 0x3C,
  0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x80, 0xF1, 0xE0, 0x1E,
  0x3C, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF0, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xE0, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F,
  0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x7B, 0x80, 0xE7, 0x03, 0xCE, 0x0F, 0x1E, 0x1C,
  0x1C, 0x78, 0x38, 0xE0, 0x7B, 0xC0, 0xFF, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xE1, 0xE1, 0xE3, 0xE0, 0x03, 0xE7, 0x87,
  0xFB, 0xC7, 0xFD, 0xE7, 0xE7, 0xF3, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x3C,
  0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xCF, 0x01,
  0xE7, 0x80, 0xF3, 0xC0, 0xF9, 0xF0, 0xFC, 0xFF, 0xDE, 0x3F, 0xEE, 0x0F,
  0xCF, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE3, 0xE0, 0x7B, 0xFC, 0x1F, 0xFF, 0x87, 0xF7,
  0xE1, 0xE0, 0x78, 0xF8, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78,
  0xF0, 0x1E, 0x3C, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF1, 0xE0, 0x3C, 0x7C,
  0x1F, 0x1F, 0x8F, 0x87, 0xFF, 0xE3, 0xDF, 0xF0, 0xF3, 0xF0, 0x00, 0x03,
  0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xF7, 0xE3, 0xC0, 0xF3, 0xE0, 0x7D,
  0xE0, 0x1E, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x17, 0x80, 0xF3, 0xC0, 0x79, 0xF8, 0xF8, 0x7F, 0xFC, 0x1F,
  0xFC, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3E, 0x78, 0x3F, 0xDE, 0x1F, 0xF7,
  0x8F, 0xCF, 0xE3, 0xC0, 0xF9, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0,
  0x78, 0xF0, 0x3E, 0x3E, 0x1F, 0x8F, 0xFD, 0xE1, 0xFF, 0x70, 0x3F, 0x3C,
  0x00, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x87, 0xC3, 0xE3, 0xC0, 0xF3,
  0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x7F, 0xFF, 0x3F, 0xFF, 0xBF, 0xFF,
  0xDE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x79, 0xF0, 0x78, 0x7F,
  0xFC, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xE7, 0x87, 0xFB, 0xC7, 0xFD, 0xE7, 0xE7, 0xF3, 0xC0, 0xF3, 0xC0,
  0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0xBC, 0x03, 0xDE,
  0x03, 0xCF, 0x01, 0xE7, 0xC1, 0xF1, 0xFF, 0xF8, 0xFF, 0xBC, 0x3F, 0xDE,
  0x07, 0x9E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x07, 0xC1, 0xFF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE7, 0xE0, 0x7B, 0xFC,
  0x1F, 0xFF, 0x87, 0xE7, 0xE1, 0xE0, 0x78, 0xF8, 0x1E, 0x3C, 0x07, 0x8F,
  0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x9E, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x3C,
  0xF0, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x01, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x78, 0xF0, 0x1F, 0x1E,
  0x07, 0xC3, 0xC1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0xC3, 0xE0, 0x78,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0x8F, 0x01, 0xE1,
  0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0,
  0xF8, 0xF0, 0x0F, 0x80, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xC3, 0xFF, 0x87,
  0xFF, 0x03, 0xFE, 0x1E, 0xF3, 0xC1, 0xDF, 0x7E, 0x1D, 0xFF, 0xE1, 0xE7,
  0x8E, 0x1C, 0x30, 0xE3, 0xC7, 0x0E, 0x3C, 0x71, 0xE3, 0xC7, 0x1E, 0x3C,
  0x71, 0xE3, 0x87, 0x1E, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x78, 0xE1, 0xC7,
  0x8E, 0x3C, 0x78, 0xE3, 0xC7, 0x0E, 0x3C, 0x70, 0xE3, 0x87, 0x1C, 0x38,
  0xF1, 0xC3, 0x80, 0x1E, 0x7E, 0x07, 0xBF, 0xC1, 0xFF, 0xF8, 0x7E, 0x7E,
  0x1E, 0x07, 0x8F, 0x81, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F,
  0x01, 0xE3, 0xC0, 0x79, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80,
  0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE0, 0x03, 0xF8,
  0x07, 0xFF, 0x07, 0xFF, 0x87, 0xF7, 0xE3, 0xC0, 0xF3, 0xC0, 0x79, 0xE0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF,
  0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF9, 0xF0, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8,
  0x07, 0xF8, 0x00, 0x0F, 0x1F, 0x01, 0xEF, 0xF0, 0x3F, 0xFF, 0x07, 0xF7,
  0xE1, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03,
  0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x78, 0x78, 0x0F,
  0x0F, 0x83, 0xE1, 0xF8, 0xF8, 0x3F, 0xFF, 0x0F, 0x7F, 0xC1, 0xE7, 0xF0,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xE7, 0x87, 0xFB, 0xC7, 0xFD, 0xE7, 0xE7, 0xF3,
  0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07,
  0xBC, 0x03, 0xDE, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF9, 0xF0,
  0xFC, 0xFF, 0xDE, 0x3F, 0xFE, 0x0F, 0xCF, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x7E, 0x07,
  0x3F, 0xC3, 0xDF, 0xF8, 0xFE, 0x7E, 0x3E, 0x07, 0x8F, 0x01, 0xE3, 0xC0,
  0x78, 0xF0, 0x1E, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C,
  0x3E, 0x1E, 0x07, 0xCF, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x7C, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0,
  0x07, 0xF8, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF7, 0x80,
  0x7B, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0xBC,
  0x03, 0xDE, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xE0, 0xF9, 0xF8, 0xF8,
  0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x03, 0xCE, 0x01, 0xE7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0x78,
  0x78, 0x78, 0x1C, 0x3C, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCE, 0x01, 0xEF,
  0x00, 0xF7, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0xF0, 0xE0, 0xFE, 0x1C, 0x3F, 0x87, 0x87, 0x70, 0xF0, 0xEE, 0x1E, 0x1D,
  0xC6, 0xC7, 0x38, 0xD8, 0xE7, 0x1B, 0x1C, 0xE7, 0x67, 0x1C, 0xCC, 0xE3,
  0x99, 0x9C, 0x77, 0x37, 0x8E, 0xC6, 0xE1, 0xD8, 0xDC, 0x3B, 0x1B, 0x87,
  0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xE0, 0x00, 0x1F, 0x01,
  0xF0, 0xF0, 0x3E, 0x0F, 0x83, 0xC0, 0x78, 0x78, 0x07, 0xCF, 0x80, 0x3D,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFB, 0xE0, 0x0F, 0x1E, 0x01,
  0xE1, 0xF0, 0x3E, 0x0F, 0x07, 0xC0, 0xF8, 0xF8, 0x07, 0x80, 0x3C, 0x07,
  0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF7, 0x80, 0xF3, 0xC0, 0x79, 0xE0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0xBC, 0x07, 0x9E, 0x03, 0xCF,
  0x01, 0xE7, 0xC1, 0xF1, 0xFF, 0xF8, 0xFF, 0xBC, 0x3F, 0x9E, 0x02, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x07, 0xC1, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x00,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0x07,
  0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x1F, 0xC1, 0xDF,
  0xF0, 0xFF, 0x78, 0x7F, 0x1F, 0x7F, 0x0F, 0xFB, 0x83, 0xF8, 0x00, 0x78,
};

const GFXglyph JetBrainsMono_SemiBoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 9, 25, 20, 6, -25 },
  { 30, 12, 10, 20, 6, -25 },
  { 45, 21, 25, 20, 0, -25 },
  { 111, 19, 35, 20, 1, -30 },
  { 195, 24, 25, 20, -1, -25 },
  { 270, 19, 25, 20, 1, -25 },
  { 330, 6, 10, 20, 9, -25 },
  { 338, 15, 33, 20, 5, -29 },
  { 400, 14, 33, 20, 2, -29 },
  { 458, 18, 18, 20, 2, -21 },
  { 499, 17, 16, 20, 2, -19 },
  { 533, 9, 10, 20, 3, -5 },
  { 545, 11, 4, 20, 5, -13 },
  { 551, 6, 6, 20, 6, -6 },
  { 556, 21, 32, 20, 0, -28 },
  { 640, 18, 25, 20, 2, -25 },
  { 697, 17, 25, 20, 1, -25 },
  { 751, 18, 25, 20, 1, -25 },
  { 808, 18, 25, 20, 1, -25 },
  { 865, 17, 25, 20, 2, -25 },
  { 919, 17, 25, 20, 2, -25 },
  { 973, 18, 25, 20, 1, -25 },
  { 1030, 18, 25, 20, 3, -25 },
  { 1087, 18, 25, 20, 1, -25 },
  { 1144, 17, 25, 20, 3, -25 },
  { 1198, 9, 19, 20, 6, -19 },
  { 1220, 12, 24, 20, 3, -19 },
  { 1256, 16, 18, 20, 3, -20 },
  { 1292, 17, 12, 20, 2, -17 },
  { 1318, 17, 18, 20, 1, -20 },
  { 1357, 15, 25, 20, 4, -25 },
  { 1404, 21, 31, 20, 0, -25 },
  { 1486, 18, 25, 20, 0, -25 },
  { 1543, 19, 25, 20, 1, -25 },
  { 1603, 18, 25, 20, 2, -25 },
  { 1660, 19, 25, 20, 1, -25 },
  { 1720, 18, 25, 20, 2, -25 },
  { 1777, 20, 25, 20, 1, -25 },
  { 1840, 18, 25, 20, 2, -25 },
  { 1897, 19, 25, 20, 1, -25 },
  { 1957, 18, 25, 20, 2, -25 },
  { 2014, 20, 25, 20, 0, -25 },
  { 2077, 20, 25, 20, 1, -25 },
  { 2140, 15, 25, 20, 2, -25 },
  { 2187, 20, 25, 20, 1, -25 },
  { 2250, 19, 25, 20, 1, -25 },
  { 2310, 18, 25, 20, 2, -25 },
  { 2367, 20, 25, 20, 1, -25 },
  { 2430, 18, 31, 20, 2, -25 },
  { 2500, 19, 25, 20, 1, -25 },
  { 2560, 19, 25, 20, 1, -25 },
  { 2620, 18, 25, 20, 3, -25 },
  { 2677, 18, 25, 20, 2, -25 },
  { 2734, 18, 25, 20, 4, -25 },
  { 2791, 20, 25, 20, 2, -25 },
  { 2854, 21, 25, 20, 0, -25 },
  { 2920, 19, 25, 20, 3, -25 },
  { 2980, 19, 25, 20, 1, -25 },
  { 3040, 15, 32, 20, 4, -28 },
  { 3100, 11, 32, 20, 5, -28 },
  { 3144, 14, 32, 20, 3, -28 },
  { 3200, 15, 13, 20, 3, -25 },
  { 3225, 17, 3, 20, 0, 1 },
  { 3232, 7, 5, 20, 9, -27 },
  { 3237, 17, 19, 20, 2, -19 },
  { 3278, 18, 25, 20, 1, -25 },
  { 3335, 17, 19, 20, 2, -19 },
  { 3376, 18, 25, 20, 2, -25 },
  { 3433, 17, 19, 20, 2, -19 },
  { 3474, 23, 31, 20, -2, -25 },
  { 3564, 17, 25, 20, 2, -19 },
  { 3618, 18, 25, 20, 1, -25 },
  { 3675, 17, 27, 20, 1, -27 },
  { 3733, 18, 33, 20, 0, -27 },
  { 3808, 19, 25, 20, 1, -25 },
  { 3868, 15, 25, 20, 3, -25 },
  { 3915, 20, 19, 20, 0, -19 },
  { 3963, 18, 19, 20, 1, -19 },
  { 4006, 17, 19, 20, 2, -19 },
  { 4047, 19, 25, 20, 0, -19 },
  { 4107, 17, 25, 20, 2, -19 },
  { 4161, 18, 19, 20, 2, -19 },
  { 4204, 18, 19, 20, 1, -19 },
  { 4247, 17, 24, 20, 2, -24 },
  { 4298, 17, 19, 20, 2, -19 },
  { 4339, 17, 19, 20, 3, -19 },
  { 4380, 19, 19, 20, 2, -19 },
  { 4426, 20, 19, 20, 0, -19 },
  { 4474, 17, 25, 20, 2, -19 },
  { 4528, 18, 19, 20, 1, -19 },
  { 4571, 18, 32, 20, 3, -28 },
  { 4643, 9, 32, 20, 6, -28 },
  { 4679, 17, 32, 20, 1, -28 },
  { 4747, 17, 8, 20, 2, -16 },
};

const GFXfont JetBrainsMono_SemiBoldItalic34pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic34pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC34PT7B_H_
