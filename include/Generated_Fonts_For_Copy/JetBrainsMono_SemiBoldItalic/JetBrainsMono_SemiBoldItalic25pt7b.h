#ifndef _JETBRAINSMONO_SEMIBOLDITALIC25PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0xC0,
  0x00, 0x00, 0x3C, 0x78, 0xE0, 0x73, 0xDC, 0xE7, 0x39, 0x8E, 0xE3, 0xB8,
  0xCE, 0x30, 0x01, 0x8E, 0x07, 0x18, 0x0C, 0x30, 0x18, 0xE1, 0xFF, 0xE7,
  0xFF, 0xC1, 0x8E, 0x07, 0x18, 0x0C, 0x30, 0x18, 0xE0, 0x71, 0x83, 0xFF,
  0xCF, 0xFF, 0x87, 0x18, 0x0C, 0x30, 0x18, 0xE0, 0x71, 0x80, 0xC3, 0x00,
  0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x07, 0xF0, 0x7F, 0xE1, 0xDB,
  0x8E, 0x6E, 0x39, 0x00, 0xE4, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x3F, 0x00, 0x9C, 0x02, 0x73, 0x99, 0xCE, 0x67, 0x3F, 0xF8, 0x7F,
  0xC0, 0xFE, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x0F, 0x81,
  0xC7, 0xF0, 0xC1, 0x8C, 0x60, 0xE3, 0x38, 0x39, 0xDC, 0x0E, 0x66, 0x01,
  0xFB, 0x00, 0x7D, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3B, 0xE0, 0x1D,
  0xF8, 0x06, 0xC6, 0x03, 0x31, 0x81, 0x8C, 0x60, 0xC3, 0x18, 0x60, 0xFC,
  0x38, 0x1E, 0x00, 0x00, 0x80, 0x07, 0xE0, 0x3F, 0xE0, 0x71, 0xC0, 0xC3,
  0x83, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x7E, 0x00, 0xFC, 0x7B,
  0x9C, 0xC7, 0x1F, 0x8E, 0x3E, 0x1C, 0x38, 0x30, 0x70, 0x73, 0xF0, 0xFF,
  0xE0, 0xFC, 0xE0, 0x7E, 0xEE, 0xEE, 0xC0, 0x00, 0xC0, 0xF0, 0x7C, 0x3C,
  0x1E, 0x0F, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x81, 0xE0,
  0x18, 0x0C, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0x70, 0x1C, 0x07, 0x81, 0xE0, 0xF8, 0x1C, 0x06, 0x00, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x18, 0xC2, 0x7B, 0x7B, 0xFB, 0xF1, 0xFE, 0x01, 0xC0,
  0x0D, 0x80, 0x67, 0x03, 0x9E, 0x1C, 0x38, 0x20, 0x80, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xF0, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0x1E, 0x38, 0xF1, 0xC3, 0x8E, 0x1C, 0x70,
  0x7F, 0xBF, 0xFF, 0xE0, 0x7B, 0xFE, 0xE0, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x3F, 0x87, 0xFE,
  0x38, 0x73, 0x83, 0x9C, 0x1C, 0xC0, 0xEE, 0x07, 0x73, 0x3B, 0xB9, 0xDD,
  0xCC, 0xE0, 0x66, 0x07, 0x30, 0x3B, 0x81, 0xDE, 0x1C, 0x79, 0xE3, 0xFE,
  0x0F, 0xE0, 0x03, 0xE0, 0xFC, 0x1F, 0xC3, 0xDC, 0x31, 0xC2, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x80, 0x3F, 0x87, 0xFE, 0x78, 0xF3,
  0x83, 0x9C, 0x1D, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xF7, 0xFF, 0x3F, 0xF8,
  0x1F, 0xF8, 0xFF, 0xC0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x00,
  0xFC, 0x07, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x70, 0x3B, 0x83,
  0x9E, 0x3C, 0x7F, 0xC1, 0xFC, 0x00, 0x00, 0x78, 0x07, 0x00, 0x78, 0x07,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x8E, 0x38, 0x73, 0xC3, 0x9C, 0x1C,
  0xC0, 0xEF, 0xFF, 0x7F, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x1F, 0xF8, 0xFF, 0xC7, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xEF, 0x07,
  0xFE, 0x3F, 0xF3, 0xC3, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3B, 0x83,
  0x8F, 0x3C, 0x7F, 0xC1, 0xFC, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x7C, 0x3F, 0xF3, 0xC3, 0x9C, 0x1D,
  0xC0, 0x6E, 0x07, 0x70, 0x3B, 0x83, 0xCE, 0x3C, 0x7F, 0xC1, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7E, 0x0E, 0xE0, 0xE0, 0x1C, 0x01, 0xC0, 0x38,
  0x07, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x80,
  0x70, 0x0E, 0x00, 0x00, 0x80, 0x3F, 0x87, 0xFE, 0x38, 0x73, 0x83, 0x9C,
  0x1C, 0xE0, 0xE7, 0x8E, 0x1F, 0xE0, 0x7C, 0x07, 0xF8, 0x71, 0xE7, 0x07,
  0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xF1, 0xE3, 0xFE, 0x0F, 0xE0, 0x01, 0x00,
  0x7F, 0x0F, 0xFC, 0xF0, 0xE7, 0x07, 0x30, 0x1F, 0x80, 0xDC, 0x0E, 0xE0,
  0x73, 0xCF, 0x1F, 0xF8, 0x7B, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xE0, 0x1E, 0x00, 0x1C, 0x7C, 0xF1, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC3, 0xCF, 0x8E, 0x00, 0x07, 0x07, 0xC3, 0xC1, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0,
  0x70, 0x70, 0x00, 0x00, 0x10, 0x07, 0x01, 0xF0, 0xFC, 0x3F, 0x0F, 0xC0,
  0xE0, 0x0F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xC0, 0x02,
  0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xEF, 0xFE,
  0xFF, 0xE0, 0x20, 0x03, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x70, 0x0F, 0x03, 0xE1, 0xF8, 0x7E, 0x0F, 0x80, 0xC0, 0x08, 0x00, 0x3F,
  0x87, 0xF9, 0x1F, 0x00, 0xF0, 0x0E, 0x03, 0x80, 0x70, 0x1E, 0x3F, 0x87,
  0xE0, 0xE0, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x0E, 0x00,
  0x00, 0x40, 0x07, 0xF0, 0x3F, 0xF0, 0xE0, 0x71, 0x80, 0x67, 0x00, 0xCC,
  0x01, 0x98, 0x7B, 0x71, 0xFE, 0xE7, 0x1D, 0xCC, 0x33, 0x18, 0x66, 0x30,
  0xCC, 0x61, 0x99, 0xC7, 0x73, 0x9E, 0xE3, 0xFD, 0xC1, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0x80, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0xE0, 0x77, 0x03, 0xB8, 0x19, 0xC1, 0xCE, 0x0E, 0x70,
  0xE3, 0x87, 0x1C, 0x3F, 0xE3, 0xFF, 0x1C, 0x1D, 0xC0, 0xEE, 0x07, 0xF0,
  0x3F, 0x01, 0xC0, 0x1F, 0xF0, 0x7F, 0xE3, 0x87, 0x8E, 0x0E, 0x38, 0x38,
  0xE0, 0xE3, 0x87, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0xC7, 0x07, 0x1C, 0x1C,
  0x70, 0x71, 0x81, 0xCE, 0x07, 0x38, 0xF8, 0xFF, 0xC3, 0xFE, 0x00, 0x00,
  0x80, 0x1F, 0xC1, 0xFF, 0x87, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x07, 0x3C, 0x3C, 0x79, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xE1, 0xFF,
  0x8E, 0x3E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE6, 0x07, 0x70, 0x3B,
  0x81, 0xDC, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x3B, 0x83, 0x9F, 0xFC, 0xFF,
  0xC7, 0xF8, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x87, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0x80, 0x1F,
  0xFC, 0x7F, 0xF3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x7F, 0xF1, 0xFF, 0xC7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x80, 0x1F, 0xC1, 0xFF,
  0x87, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC7,
  0xE7, 0x3F, 0x9C, 0xFC, 0x70, 0x71, 0xC1, 0xC6, 0x07, 0x3C, 0x3C, 0x79,
  0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x1C, 0x1C, 0x60, 0x73, 0x83, 0x8E, 0x0E,
  0x38, 0x38, 0xE0, 0xE3, 0x83, 0x8F, 0xFE, 0x7F, 0xF1, 0xFF, 0xC7, 0x07,
  0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xCE, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x83,
  0x80, 0x1F, 0xF8, 0xFF, 0xC0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x0F, 0xFC, 0xFF, 0xE7, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x10, 0x73, 0x81, 0xC7, 0x07, 0x1E, 0x78, 0x7F,
  0xC0, 0xFE, 0x00, 0x1C, 0x1E, 0x30, 0x78, 0xE0, 0xE1, 0xC3, 0x83, 0x87,
  0x07, 0x1C, 0x0E, 0x70, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xC7, 0x03,
  0x8E, 0x07, 0x1C, 0x0E, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xF1, 0xC0,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0xD8, 0xF1, 0xF1, 0xE3, 0xE7,
  0x6D, 0x8E, 0xDB, 0x1D, 0xEE, 0x3B, 0xDC, 0x67, 0x38, 0xC0, 0x73, 0x80,
  0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x60, 0x39, 0xC0, 0x60,
  0x1C, 0x1C, 0xF8, 0x73, 0xE1, 0x8F, 0x86, 0x36, 0x38, 0xD8, 0xE3, 0x73,
  0x9D, 0xCE, 0x73, 0x31, 0xCC, 0xC7, 0x33, 0x1C, 0xFC, 0x63, 0xF1, 0x87,
  0xCE, 0x1F, 0x38, 0x78, 0xE1, 0xE3, 0x87, 0x80, 0x00, 0x80, 0x3F, 0x87,
  0xFE, 0x38, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x70, 0x3B, 0x81,
  0xDC, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x3B, 0x81, 0xCE, 0x1C, 0x79, 0xE3,
  0xFE, 0x0F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE3, 0x87, 0xCE, 0x07, 0x38, 0x1C,
  0xE0, 0x73, 0x81, 0xCE, 0x0E, 0x7F, 0xF1, 0xFF, 0x87, 0xFC, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00,
  0x80, 0x3F, 0x87, 0xFE, 0x38, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xEE, 0x07,
  0x70, 0x3B, 0x81, 0xDC, 0x0C, 0xE0, 0xE7, 0x07, 0x30, 0x3B, 0x81, 0xDE,
  0x1C, 0x79, 0xE3, 0xFE, 0x0F, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x1F, 0xF0, 0x7F, 0xE3, 0x87, 0x8E, 0x0F, 0x38, 0x1C, 0xE0,
  0xE3, 0x83, 0x8C, 0x1E, 0x7F, 0xF1, 0xFF, 0x87, 0xF8, 0x1C, 0x70, 0x71,
  0xC1, 0xC7, 0x0E, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0xC0, 0x00, 0x80,
  0x1F, 0xC1, 0xFF, 0x87, 0x0E, 0x38, 0x38, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xCE, 0x07,
  0x38, 0x1C, 0xF9, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x83,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x1C, 0x1C, 0xE0, 0x73, 0x81, 0x8E, 0x0E, 0x38, 0x38, 0xE0,
  0xE3, 0x83, 0x9C, 0x0E, 0x70, 0x31, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x70,
  0x71, 0x81, 0xC7, 0x0E, 0x1E, 0x78, 0x7F, 0xC0, 0xFE, 0x00, 0xE0, 0x3F,
  0x03, 0xB8, 0x1D, 0xC1, 0xCE, 0x0E, 0x70, 0x63, 0x87, 0x0C, 0x38, 0x63,
  0x83, 0x1C, 0x1C, 0xC0, 0xEE, 0x07, 0x70, 0x3F, 0x01, 0xF8, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x00, 0x71, 0xC6, 0xE7, 0x9D, 0xCF, 0x3B, 0x9C, 0x66,
  0x28, 0xCC, 0xD3, 0x99, 0xA7, 0x32, 0x4C, 0x64, 0x98, 0xD9, 0x71, 0xB6,
  0xC3, 0x4D, 0x87, 0x9B, 0x0F, 0x3E, 0x3E, 0x78, 0x78, 0xF0, 0xF1, 0xE1,
  0xE3, 0xC0, 0x1C, 0x0F, 0x0E, 0x1E, 0x0E, 0x1C, 0x0E, 0x38, 0x07, 0x70,
  0x07, 0x70, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x38, 0x70, 0x78, 0x70, 0x70, 0x78,
  0xE0, 0x38, 0xF0, 0x1D, 0xC0, 0xE7, 0x07, 0x0E, 0x1C, 0x38, 0xE0, 0xE3,
  0x81, 0x9C, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1F, 0xFC,
  0x7F, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00,
  0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0xE1, 0xFC, 0x3F, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFC,
  0x3F, 0x87, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x0E,
  0x0E, 0x07, 0x07, 0x0F, 0xC7, 0xF1, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x18,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x38, 0x0E, 0x3F, 0x8F, 0xE3, 0xF8, 0x07, 0x80, 0xF0,
  0x3F, 0x06, 0xE1, 0xCC, 0x71, 0x8E, 0x3B, 0x87, 0x60, 0x7C, 0x0C, 0xFF,
  0xFF, 0xFF, 0xE3, 0x8E, 0x70, 0x0F, 0xB8, 0xFD, 0xCF, 0xFE, 0x70, 0xF7,
  0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x77, 0x03, 0xBC, 0x38, 0xF3,
  0xC7, 0xFE, 0x1F, 0x70, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x9E,
  0x1F, 0xF8, 0xFF, 0xC7, 0x0E, 0x70, 0x3B, 0x83, 0x9C, 0x1C, 0xE0, 0xE7,
  0x07, 0x38, 0x3B, 0xC3, 0x9F, 0x3C, 0xFF, 0xC7, 0x7C, 0x00, 0x07, 0xC0,
  0xFF, 0x8F, 0xFC, 0x70, 0xF7, 0x03, 0xB8, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x03, 0xBC, 0x3C, 0xF3, 0xC7, 0xFC, 0x1F, 0xC0, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x0F, 0xB8, 0x7E, 0xE3, 0xFF, 0x8E, 0x1E, 0x70,
  0x71, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0x81, 0xCF, 0x0E, 0x1E,
  0x78, 0x7F, 0xE0, 0xFB, 0x80, 0x07, 0xC0, 0xFF, 0x8F, 0x3C, 0x70, 0xE7,
  0x03, 0x38, 0x19, 0xFF, 0xCF, 0xFE, 0x60, 0x03, 0x00, 0x38, 0x1C, 0xE1,
  0xC7, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x3C, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0xB8, 0xFF, 0xCF, 0xFE, 0x70, 0xF7,
  0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x87, 0x9E, 0x78, 0xFF,
  0xC3, 0xEE, 0x00, 0x70, 0x03, 0x80, 0x38, 0x7F, 0xC3, 0xFC, 0x1F, 0x00,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xBE, 0x1F, 0xF8, 0xFF, 0xC7,
  0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x3B, 0x81,
  0xDC, 0x1C, 0xE0, 0xE7, 0x07, 0x00, 0x00, 0x80, 0x1E, 0x01, 0xE0, 0x1C,
  0x00, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x3F, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x10, 0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x07, 0xF8, 0x3F, 0xC0, 0xF0, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x3C, 0xE0, 0xE3, 0x87, 0x0E, 0x38, 0x71, 0xE1,
  0xCF, 0x07, 0xF8, 0x1F, 0xE0, 0x73, 0x81, 0xC7, 0x06, 0x1C, 0x38, 0x38,
  0xE0, 0xE3, 0x83, 0xC0, 0xFF, 0x1F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xFF, 0x1F, 0xE1, 0xFC, 0x3B, 0xB8, 0xFE, 0xF3, 0x9D, 0xCE, 0x63,
  0x31, 0x9C, 0xC6, 0x77, 0x39, 0xDC, 0xE7, 0x73, 0x19, 0xCC, 0x66, 0x33,
  0x98, 0xCE, 0x63, 0x3B, 0x9C, 0xE0, 0x3B, 0xE1, 0xFF, 0x8F, 0xFC, 0x70,
  0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0xB8, 0x1D,
  0xC1, 0xCE, 0x0E, 0x70, 0x70, 0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x70, 0xE7,
  0x03, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x77, 0x03, 0x9C, 0x38, 0xF3,
  0xC7, 0xFC, 0x1F, 0xC0, 0x1C, 0xF0, 0x7F, 0xE1, 0xFF, 0x87, 0x0E, 0x38,
  0x1C, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE7, 0x87, 0x1F,
  0x3C, 0x7F, 0xE1, 0xDF, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x0F, 0xB8, 0xFD, 0xCF, 0xFE, 0x70, 0xF7, 0x07, 0x38, 0x39,
  0xC1, 0xCE, 0x0E, 0x70, 0x77, 0x03, 0xBC, 0x38, 0xF3, 0xC7, 0xFE, 0x1F,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x39, 0xE1, 0xDF,
  0x8F, 0xFE, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0x0F, 0xE0, 0xFF, 0x8F,
  0x3C, 0x70, 0x77, 0x00, 0x1C, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xF0, 0x03,
  0xB8, 0x1D, 0xE1, 0xC7, 0xFE, 0x1F, 0xC0, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0xFC, 0x1F, 0xC0, 0xFC, 0x38, 0x39,
  0xC1, 0xCE, 0x0E, 0xE0, 0x77, 0x03, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70,
  0x73, 0x83, 0x9C, 0x38, 0xF3, 0xC7, 0xFC, 0x1F, 0xC0, 0xE0, 0x3F, 0x03,
  0x98, 0x1C, 0xE1, 0xC7, 0x0E, 0x38, 0xE1, 0xC7, 0x0E, 0x30, 0x33, 0x81,
  0xD8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xC7, 0x1E, 0x38, 0xF1,
  0xCF, 0x9E, 0x6C, 0xF3, 0x65, 0x9B, 0x6D, 0xDB, 0x6C, 0xD3, 0x67, 0x9F,
  0x3C, 0xF1, 0xC7, 0x8E, 0x3C, 0x71, 0xC0, 0x3C, 0x1E, 0x38, 0x78, 0x38,
  0xE0, 0x73, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1D, 0xC0, 0x73, 0x81, 0xC7, 0x87, 0x87, 0x1E, 0x0F, 0x00, 0x38, 0x39,
  0xC1, 0xCE, 0x0E, 0xE0, 0x77, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70,
  0x73, 0x87, 0x9F, 0xD8, 0xFF, 0xC3, 0xEE, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x7F, 0xC3, 0xFC, 0x1F, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFC, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xFF,
  0xCF, 0xFE, 0x7F, 0xF0, 0x00, 0x38, 0x07, 0xC0, 0x7E, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC1, 0xFC, 0x0F,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0xE0, 0x1F, 0x00, 0x78, 0x1C, 0x71, 0xC7, 0x18, 0xE3,
  0x8E, 0x38, 0xE3, 0x9C, 0x71, 0xC7, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x8E,
  0x30, 0x0F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x40, 0x7E, 0x01, 0xF8,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x01, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0x08, 0x01, 0xF0, 0xDF, 0xC6,
  0xCF, 0x7E, 0x3F, 0x70, 0xF0,
};

const GFXglyph JetBrainsMono_SemiBoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 7, 18, 15, 4, -18 },
  { 17, 10, 7, 15, 4, -18 },
  { 26, 15, 18, 15, 0, -18 },
  { 60, 14, 26, 15, 1, -22 },
  { 106, 18, 18, 15, -1, -18 },
  { 147, 15, 19, 15, 0, -19 },
  { 183, 4, 7, 15, 7, -18 },
  { 187, 10, 24, 15, 4, -21 },
  { 217, 11, 24, 15, 1, -21 },
  { 250, 14, 13, 15, 1, -15 },
  { 273, 13, 12, 15, 1, -14 },
  { 293, 7, 8, 15, 2, -4 },
  { 300, 9, 3, 15, 3, -10 },
  { 304, 5, 4, 15, 4, -4 },
  { 307, 16, 24, 15, 0, -21 },
  { 355, 13, 19, 15, 1, -19 },
  { 386, 12, 18, 15, 1, -18 },
  { 413, 13, 19, 15, 1, -19 },
  { 444, 13, 18, 15, 1, -18 },
  { 474, 13, 18, 15, 1, -18 },
  { 504, 13, 18, 15, 1, -18 },
  { 534, 13, 18, 15, 1, -18 },
  { 564, 12, 18, 15, 3, -18 },
  { 591, 13, 19, 15, 1, -19 },
  { 622, 13, 19, 15, 2, -19 },
  { 653, 7, 14, 15, 4, -14 },
  { 666, 9, 18, 15, 2, -14 },
  { 687, 12, 14, 15, 2, -15 },
  { 708, 12, 9, 15, 2, -13 },
  { 722, 12, 14, 15, 1, -15 },
  { 743, 11, 18, 15, 3, -18 },
  { 768, 15, 24, 15, 0, -19 },
  { 813, 13, 18, 15, 0, -18 },
  { 843, 14, 18, 15, 1, -18 },
  { 875, 14, 19, 15, 1, -19 },
  { 909, 13, 18, 15, 1, -18 },
  { 939, 14, 18, 15, 1, -18 },
  { 971, 14, 18, 15, 1, -18 },
  { 1003, 14, 19, 15, 1, -19 },
  { 1037, 14, 18, 15, 1, -18 },
  { 1069, 13, 18, 15, 1, -18 },
  { 1099, 14, 18, 15, 0, -18 },
  { 1131, 15, 18, 15, 1, -18 },
  { 1165, 11, 18, 15, 2, -18 },
  { 1190, 15, 18, 15, 0, -18 },
  { 1224, 14, 18, 15, 1, -18 },
  { 1256, 13, 19, 15, 1, -19 },
  { 1287, 14, 18, 15, 1, -18 },
  { 1319, 13, 24, 15, 1, -19 },
  { 1358, 14, 18, 15, 1, -18 },
  { 1390, 14, 19, 15, 1, -19 },
  { 1424, 13, 18, 15, 3, -18 },
  { 1454, 14, 18, 15, 1, -18 },
  { 1486, 13, 18, 15, 3, -18 },
  { 1516, 15, 18, 15, 1, -18 },
  { 1550, 16, 18, 15, 0, -18 },
  { 1586, 14, 18, 15, 2, -18 },
  { 1618, 14, 18, 15, 1, -18 },
  { 1650, 11, 24, 15, 3, -21 },
  { 1683, 8, 24, 15, 4, -21 },
  { 1707, 10, 24, 15, 2, -21 },
  { 1737, 11, 10, 15, 2, -18 },
  { 1751, 12, 2, 15, 0, 1 },
  { 1754, 5, 4, 15, 6, -20 },
  { 1757, 13, 14, 15, 1, -14 },
  { 1780, 13, 18, 15, 1, -18 },
  { 1810, 13, 14, 15, 1, -14 },
  { 1833, 14, 18, 15, 1, -18 },
  { 1865, 13, 14, 15, 1, -14 },
  { 1888, 17, 23, 15, -1, -18 },
  { 1937, 13, 19, 15, 1, -14 },
  { 1968, 13, 18, 15, 1, -18 },
  { 1998, 12, 20, 15, 1, -20 },
  { 2028, 14, 25, 15, 0, -20 },
  { 2072, 14, 18, 15, 1, -18 },
  { 2104, 11, 18, 15, 2, -18 },
  { 2129, 14, 14, 15, 0, -14 },
  { 2154, 13, 14, 15, 1, -14 },
  { 2177, 13, 14, 15, 1, -14 },
  { 2200, 14, 19, 15, 0, -14 },
  { 2234, 13, 19, 15, 1, -14 },
  { 2265, 13, 14, 15, 1, -14 },
  { 2288, 13, 14, 15, 1, -14 },
  { 2311, 12, 18, 15, 2, -18 },
  { 2338, 13, 14, 15, 1, -14 },
  { 2361, 13, 14, 15, 2, -14 },
  { 2384, 13, 14, 15, 2, -14 },
  { 2407, 15, 14, 15, 0, -14 },
  { 2434, 13, 19, 15, 1, -14 },
  { 2465, 13, 14, 15, 1, -14 },
  { 2488, 13, 24, 15, 2, -21 },
  { 2527, 6, 24, 15, 5, -21 },
  { 2545, 14, 24, 15, 0, -21 },
  { 2587, 13, 6, 15, 1, -12 },
};

const GFXfont JetBrainsMono_SemiBoldItalic25pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic25pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC25PT7B_H_
