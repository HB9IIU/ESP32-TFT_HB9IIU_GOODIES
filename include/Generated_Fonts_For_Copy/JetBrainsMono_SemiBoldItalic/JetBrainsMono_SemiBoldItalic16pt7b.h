#ifndef _JETBRAINSMONO_SEMIBOLDITALIC16PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x36, 0x66, 0x66, 0x00, 0xEC, 0xCF, 0x2D, 0xB6, 0x98, 0x0C,
  0xC2, 0x20, 0x98, 0xFF, 0x7F, 0xC4, 0xC3, 0x20, 0x88, 0xFF, 0x99, 0x04,
  0x41, 0x30, 0x04, 0x04, 0x1E, 0x3F, 0x6B, 0x68, 0x68, 0x7C, 0x3E, 0x16,
  0x12, 0xD6, 0xFE, 0x7C, 0x10, 0x20, 0x1C, 0x33, 0x66, 0x26, 0xC2, 0x48,
  0x3D, 0x01, 0xA0, 0x04, 0x00, 0xFC, 0x1A, 0x43, 0x64, 0x26, 0xCC, 0x38,
  0x0E, 0x0F, 0x8C, 0x46, 0x03, 0x01, 0xC1, 0xE6, 0xDA, 0x47, 0x63, 0x3B,
  0xCF, 0x60, 0x6D, 0xEC, 0x02, 0x0C, 0x70, 0xC3, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0E, 0x0E, 0x0C, 0x20, 0x60, 0x60, 0x60, 0xC0, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0xC1, 0x86, 0x38, 0x40, 0x0C, 0x08, 0x89, 0xEF,
  0x7E, 0x38, 0x6C, 0xC6, 0x44, 0x08, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x10,
  0x30, 0x39, 0x98, 0xCC, 0x00, 0xFF, 0xE0, 0x5F, 0x00, 0x00, 0xC0, 0x60,
  0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x0C, 0x00, 0x1E, 0x3F, 0x63, 0x63, 0x43, 0xDB, 0xDB, 0xC2,
  0xC2, 0xC6, 0xEE, 0x78, 0x0C, 0x79, 0xF2, 0x60, 0xC1, 0x82, 0x0C, 0x18,
  0x33, 0xFF, 0xF0, 0x1E, 0x3F, 0x63, 0x63, 0x03, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xFE, 0xFE, 0x3F, 0x7F, 0x06, 0x0C, 0x18, 0x1E, 0x06, 0x06, 0x06,
  0xC6, 0xEE, 0x78, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x63, 0x66, 0xC6, 0xFE,
  0xFE, 0x06, 0x06, 0x3F, 0x7F, 0x60, 0x60, 0x6C, 0x7E, 0x66, 0x02, 0x06,
  0xC6, 0xEE, 0x7C, 0x06, 0x0C, 0x18, 0x38, 0x30, 0x7E, 0xE6, 0xC3, 0xC3,
  0xC6, 0xEE, 0x7C, 0xFF, 0xFF, 0xC6, 0xC6, 0x0C, 0x0C, 0x18, 0x30, 0x30,
  0x60, 0x60, 0xC0, 0x1E, 0x3F, 0x63, 0x63, 0x66, 0x3C, 0x3C, 0xC6, 0xC6,
  0xC6, 0xEE, 0x7C, 0x1E, 0x3F, 0x63, 0x43, 0xC3, 0x63, 0x7E, 0x16, 0x0C,
  0x18, 0x30, 0x70, 0x77, 0x60, 0x00, 0x0E, 0xC0, 0x1C, 0x71, 0x80, 0x00,
  0x00, 0x8C, 0x31, 0x86, 0x30, 0x01, 0x03, 0x1E, 0x78, 0xE0, 0xE0, 0x38,
  0x0E, 0x02, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x40, 0x60, 0x38, 0x0E,
  0x03, 0x0E, 0x38, 0xE0, 0x80, 0x78, 0xF8, 0x38, 0x30, 0xCF, 0x9E, 0x30,
  0x60, 0x03, 0x87, 0x00, 0x0F, 0x07, 0xE3, 0x0D, 0x83, 0x66, 0xD3, 0x64,
  0x89, 0x22, 0xC9, 0xB6, 0x6C, 0xFB, 0x00, 0xC0, 0x1E, 0x03, 0x80, 0x06,
  0x0E, 0x0E, 0x1A, 0x1B, 0x13, 0x33, 0x33, 0x7F, 0x63, 0x43, 0xC3, 0x7C,
  0x7F, 0x63, 0x63, 0x63, 0x7E, 0xFE, 0xC2, 0xC3, 0xC6, 0xFE, 0xFC, 0x1E,
  0x3F, 0x63, 0x63, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC6, 0xEE, 0x7C, 0x7C,
  0x7F, 0x63, 0x63, 0x63, 0x43, 0xC3, 0xC2, 0xC6, 0xC6, 0xFC, 0xF8, 0x3F,
  0xBF, 0x98, 0x0C, 0x06, 0x03, 0xF1, 0xF9, 0x80, 0xC0, 0x60, 0x3F, 0x9F,
  0xC0, 0x7F, 0xBF, 0x98, 0x0C, 0x06, 0x03, 0xF1, 0xF9, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x00, 0x1E, 0x3F, 0x63, 0x63, 0x60, 0x40, 0xCF, 0xC3, 0xC6,
  0xC6, 0xEE, 0x7C, 0x61, 0x63, 0x63, 0x63, 0x63, 0x7F, 0xFE, 0xC6, 0xC6,
  0xC6, 0xC6, 0xC6, 0x3F, 0x7F, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x10, 0xFE, 0xFC, 0x07, 0x87, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x0C, 0x06,
  0x03, 0x61, 0x9B, 0x8F, 0x80, 0x61, 0xB1, 0x98, 0xCC, 0xC6, 0xC3, 0xE3,
  0xF1, 0x98, 0xCC, 0x63, 0x31, 0x98, 0xC0, 0x30, 0x61, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x41, 0x83, 0xFF, 0xF0, 0x31, 0xCE, 0x73, 0xB8, 0xAA, 0x6A,
  0x9B, 0x66, 0xD9, 0x86, 0x61, 0x10, 0x44, 0x33, 0x0C, 0x71, 0xB8, 0x9C,
  0xCA, 0x65, 0x32, 0xDB, 0x6D, 0x94, 0xCA, 0x65, 0x23, 0x91, 0xC0, 0x1E,
  0x3F, 0x63, 0x63, 0x63, 0x43, 0xC3, 0xC2, 0xC6, 0xC6, 0xEE, 0x78, 0x7E,
  0x3F, 0x98, 0xEC, 0x36, 0x32, 0x1B, 0xF9, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x00, 0x1E, 0x3F, 0x63, 0x63, 0x43, 0xC3, 0xC3, 0xC2, 0xC6, 0xC6, 0xEE,
  0x78, 0x18, 0x0C, 0x0C, 0x7C, 0x7F, 0x63, 0x63, 0x63, 0x47, 0xFE, 0xCC,
  0xCC, 0xCC, 0xC6, 0xC6, 0x1E, 0x3F, 0x63, 0x60, 0x60, 0x78, 0x3E, 0x06,
  0x02, 0xC6, 0xEE, 0x7C, 0xFF, 0xFF, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x20, 0x60, 0x60, 0x61, 0xB1, 0x98, 0xCC, 0x66, 0x32, 0x1B, 0x0D,
  0x84, 0xC6, 0x63, 0x3B, 0x8F, 0x00, 0xC3, 0xC3, 0xC6, 0xC6, 0xC4, 0xCC,
  0xCC, 0xD8, 0x58, 0x50, 0x70, 0x70, 0xCC, 0xE6, 0x73, 0x7A, 0xBD, 0x56,
  0xAB, 0xBD, 0xD6, 0xAA, 0x55, 0x33, 0x99, 0x80, 0x30, 0xCC, 0x61, 0xB8,
  0x6C, 0x1E, 0x03, 0x00, 0xC0, 0x78, 0x36, 0x0D, 0x86, 0x33, 0x0C, 0xC3,
  0xC3, 0xC6, 0x4C, 0x6C, 0x78, 0x70, 0x30, 0x30, 0x20, 0x60, 0x60, 0x3F,
  0x7F, 0x03, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC0, 0xFE, 0xFE, 0x3E,
  0x60, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x0C, 0x1F, 0x3C,
  0x00, 0xC1, 0x86, 0x18, 0x60, 0xC3, 0x0C, 0x30, 0x41, 0x86, 0x18, 0x60,
  0xC0, 0x3E, 0x0C, 0x18, 0x20, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x60, 0xC1,
  0x9F, 0x3E, 0x00, 0x0C, 0x1C, 0x14, 0x36, 0x26, 0x62, 0xC3, 0xFF, 0xFF,
  0xCD, 0x80, 0x3B, 0x7F, 0x63, 0xC2, 0xC6, 0xC6, 0xC6, 0xEE, 0x76, 0x60,
  0x60, 0x60, 0x6E, 0x7E, 0x63, 0xC3, 0xC2, 0xC6, 0xC6, 0xEE, 0xFC, 0x3E,
  0x7E, 0x63, 0xC0, 0xC0, 0xC0, 0xC6, 0xEE, 0x7C, 0x01, 0x03, 0x03, 0x3B,
  0x7F, 0x63, 0xC2, 0xC6, 0xC6, 0xC6, 0xEE, 0x76, 0x3C, 0x7E, 0x43, 0xC3,
  0xFE, 0xC0, 0xC0, 0xCE, 0x7C, 0x01, 0xE0, 0x7C, 0x18, 0x03, 0x03, 0xFC,
  0x7F, 0x81, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x81, 0xF0,
  0x3C, 0x00, 0x3B, 0x7F, 0x63, 0xC2, 0xC6, 0xC6, 0xC6, 0xFE, 0x06, 0x06,
  0x7C, 0xF8, 0x60, 0x60, 0x60, 0x6E, 0x7E, 0x63, 0xC3, 0xC6, 0xC6, 0xC6,
  0xC6, 0xC6, 0x04, 0x18, 0x30, 0x07, 0xCF, 0x82, 0x0C, 0x18, 0x30, 0x67,
  0xFF, 0xE0, 0x01, 0x01, 0xC0, 0xC0, 0x03, 0xF1, 0xF8, 0x0C, 0x04, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x63, 0xF1, 0xE0, 0x60, 0x30, 0x18, 0x0C,
  0x76, 0x73, 0x33, 0x31, 0xF0, 0xCC, 0x66, 0x31, 0x98, 0xC0, 0x79, 0xF0,
  0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x60, 0xF8, 0xF0, 0x2F, 0xBE, 0xDB,
  0x6D, 0xB6, 0x9A, 0x4D, 0x25, 0x92, 0xDB, 0x00, 0x6E, 0x7E, 0x63, 0xC3,
  0xC6, 0xC6, 0xC6, 0xC6, 0xC6, 0x3C, 0x7E, 0x63, 0xC3, 0xC2, 0xC6, 0xC6,
  0xEE, 0x78, 0x37, 0x1F, 0x8C, 0x6C, 0x36, 0x13, 0x19, 0x8C, 0xEE, 0x7E,
  0x60, 0x30, 0x18, 0x00, 0x3B, 0x7F, 0x63, 0xC2, 0xC6, 0xC6, 0xC6, 0xEE,
  0x76, 0x06, 0x04, 0x0C, 0x6E, 0x7F, 0x63, 0x63, 0x40, 0xC0, 0xC0, 0xC0,
  0xC0, 0x3E, 0x7F, 0x40, 0x60, 0x7E, 0x06, 0x06, 0xCE, 0xFC, 0x18, 0x18,
  0xFF, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3E, 0x3E, 0x63, 0x63, 0x43,
  0xC3, 0xC6, 0xC6, 0xC6, 0xEC, 0x78, 0xC3, 0xA1, 0x98, 0x8C, 0xC6, 0x43,
  0x61, 0xB0, 0x70, 0x38, 0x00, 0xC9, 0xEC, 0xB6, 0x5B, 0x6E, 0xB5, 0x52,
  0xB9, 0x9C, 0xCC, 0x00, 0x31, 0x99, 0x87, 0xC3, 0xC0, 0xC0, 0xE0, 0xD8,
  0xCC, 0xE3, 0x00, 0x63, 0x63, 0x43, 0xC2, 0xC6, 0xC6, 0xCE, 0x7E, 0x06,
  0x04, 0xFC, 0xF8, 0x7F, 0x7F, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFE, 0xFE,
  0x07, 0x83, 0x03, 0x01, 0x80, 0xC0, 0x61, 0xE1, 0xF0, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xF0, 0x30, 0x33, 0x33, 0x26, 0x66, 0x66, 0x4C, 0xCC,
  0xC0, 0x1C, 0x16, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3E, 0x1E, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x83, 0x83, 0x80, 0x73, 0xDB, 0x8E,
};

const GFXglyph JetBrainsMono_SemiBoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 6, 5, 10, 3, -12 },
  { 11, 10, 12, 10, 0, -12 },
  { 26, 8, 16, 10, 1, -14 },
  { 42, 12, 12, 10, -1, -12 },
  { 60, 9, 12, 10, 0, -12 },
  { 74, 3, 5, 10, 4, -12 },
  { 76, 7, 16, 10, 2, -14 },
  { 90, 7, 16, 10, 1, -14 },
  { 104, 8, 9, 10, 1, -10 },
  { 113, 8, 8, 10, 1, -9 },
  { 121, 5, 5, 10, 1, -2 },
  { 125, 6, 2, 10, 2, -6 },
  { 127, 3, 3, 10, 3, -3 },
  { 129, 10, 15, 10, 0, -13 },
  { 148, 8, 12, 10, 1, -12 },
  { 160, 7, 12, 10, 1, -12 },
  { 171, 8, 12, 10, 1, -12 },
  { 183, 8, 12, 10, 1, -12 },
  { 195, 8, 12, 10, 1, -12 },
  { 207, 8, 12, 10, 1, -12 },
  { 219, 8, 12, 10, 1, -12 },
  { 231, 8, 12, 10, 2, -12 },
  { 243, 8, 12, 10, 1, -12 },
  { 255, 8, 12, 10, 1, -12 },
  { 267, 4, 9, 10, 3, -9 },
  { 272, 6, 12, 10, 1, -9 },
  { 281, 8, 9, 10, 1, -10 },
  { 290, 8, 6, 10, 1, -8 },
  { 296, 8, 9, 10, 1, -10 },
  { 305, 7, 12, 10, 2, -12 },
  { 316, 10, 15, 10, 0, -12 },
  { 335, 8, 12, 10, 0, -12 },
  { 347, 8, 12, 10, 1, -12 },
  { 359, 8, 12, 10, 1, -12 },
  { 371, 8, 12, 10, 1, -12 },
  { 383, 9, 12, 10, 1, -12 },
  { 397, 9, 12, 10, 1, -12 },
  { 411, 8, 12, 10, 1, -12 },
  { 423, 8, 12, 10, 1, -12 },
  { 435, 8, 12, 10, 1, -12 },
  { 447, 9, 12, 10, 0, -12 },
  { 461, 9, 12, 10, 1, -12 },
  { 475, 7, 12, 10, 1, -12 },
  { 486, 10, 12, 10, 0, -12 },
  { 501, 9, 12, 10, 1, -12 },
  { 515, 8, 12, 10, 1, -12 },
  { 527, 9, 12, 10, 1, -12 },
  { 541, 8, 15, 10, 1, -12 },
  { 556, 8, 12, 10, 1, -12 },
  { 568, 8, 12, 10, 1, -12 },
  { 580, 8, 12, 10, 2, -12 },
  { 592, 9, 12, 10, 1, -12 },
  { 606, 8, 12, 10, 2, -12 },
  { 618, 9, 12, 10, 1, -12 },
  { 632, 10, 12, 10, 0, -12 },
  { 647, 8, 12, 10, 2, -12 },
  { 659, 8, 12, 10, 1, -12 },
  { 671, 7, 15, 10, 2, -13 },
  { 685, 6, 15, 10, 2, -13 },
  { 697, 7, 15, 10, 1, -13 },
  { 711, 8, 7, 10, 1, -12 },
  { 718, 8, 2, 10, 0, 0 },
  { 720, 3, 3, 10, 4, -13 },
  { 722, 8, 9, 10, 1, -9 },
  { 731, 8, 12, 10, 1, -12 },
  { 743, 8, 9, 10, 1, -9 },
  { 752, 8, 12, 10, 1, -12 },
  { 764, 8, 9, 10, 1, -9 },
  { 773, 11, 15, 10, -1, -12 },
  { 794, 8, 12, 10, 1, -9 },
  { 806, 8, 12, 10, 1, -12 },
  { 818, 7, 13, 10, 1, -13 },
  { 830, 9, 16, 10, 0, -13 },
  { 848, 9, 12, 10, 1, -12 },
  { 862, 7, 12, 10, 1, -12 },
  { 873, 9, 9, 10, 0, -9 },
  { 884, 8, 9, 10, 1, -9 },
  { 893, 8, 9, 10, 1, -9 },
  { 902, 9, 12, 10, 0, -9 },
  { 916, 8, 12, 10, 1, -9 },
  { 928, 8, 9, 10, 1, -9 },
  { 937, 8, 9, 10, 1, -9 },
  { 946, 8, 11, 10, 1, -11 },
  { 957, 8, 9, 10, 1, -9 },
  { 966, 9, 9, 10, 1, -9 },
  { 977, 9, 9, 10, 1, -9 },
  { 988, 9, 9, 10, 0, -9 },
  { 999, 8, 12, 10, 1, -9 },
  { 1011, 8, 9, 10, 1, -9 },
  { 1020, 9, 15, 10, 1, -13 },
  { 1037, 4, 15, 10, 3, -13 },
  { 1045, 9, 15, 10, 0, -13 },
  { 1062, 8, 3, 10, 1, -7 },
};

const GFXfont JetBrainsMono_SemiBoldItalic16pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic16pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC16PT7B_H_
