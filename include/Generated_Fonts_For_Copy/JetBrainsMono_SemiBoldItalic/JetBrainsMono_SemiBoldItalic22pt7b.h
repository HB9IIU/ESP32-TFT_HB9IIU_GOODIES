#ifndef _JETBRAINSMONO_SEMIBOLDITALIC22PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x63, 0x8E, 0x38, 0xE3, 0x0C, 0x30, 0xC6, 0x00, 0x01, 0x8F,
  0x38, 0xE7, 0xE7, 0xE6, 0xC6, 0xC6, 0xC6, 0xCE, 0x03, 0x18, 0x0C, 0x60,
  0x63, 0x01, 0x8C, 0x3F, 0xFC, 0xFF, 0xE0, 0xC6, 0x03, 0x18, 0x18, 0xC0,
  0x63, 0x07, 0xFF, 0x3F, 0xFC, 0x31, 0x80, 0x86, 0x06, 0x30, 0x18, 0xC0,
  0x01, 0x00, 0x10, 0x01, 0x00, 0xFC, 0x1F, 0xE3, 0xA7, 0x32, 0x73, 0x20,
  0x32, 0x03, 0xE0, 0x3F, 0x80, 0xFC, 0x05, 0xC0, 0x4E, 0x04, 0xEE, 0x4C,
  0xED, 0xC7, 0xF8, 0x3F, 0x00, 0x80, 0x08, 0x01, 0x80, 0x0F, 0x07, 0x1F,
  0x8C, 0x31, 0x8C, 0x31, 0x98, 0x31, 0x30, 0x3B, 0x60, 0x1E, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x03, 0x78, 0x06, 0xDC, 0x0D, 0x8C, 0x19, 0x8C, 0x31,
  0x98, 0x61, 0xF8, 0xC0, 0xF0, 0x07, 0xC0, 0x7F, 0x07, 0x1C, 0x30, 0xE1,
  0x80, 0x0E, 0x00, 0x30, 0x07, 0xC0, 0x76, 0x3B, 0xBB, 0x98, 0xF8, 0xC7,
  0x86, 0x1C, 0x31, 0xE1, 0xFF, 0x87, 0xCE, 0x6F, 0xFF, 0xB0, 0x00, 0x40,
  0x60, 0x78, 0x3C, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xF8, 0x1C,
  0x01, 0x00, 0x10, 0x0E, 0x07, 0x80, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x01,
  0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x07, 0x0F, 0x1F,
  0x0E, 0x04, 0x00, 0x07, 0x00, 0x70, 0x46, 0x17, 0x67, 0xFF, 0xF3, 0xF8,
  0x0E, 0x01, 0xB0, 0x3B, 0x87, 0x1C, 0x21, 0x00, 0x07, 0x00, 0xE0, 0x18,
  0x03, 0x07, 0xFF, 0xFF, 0xC3, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x3C, 0xE3,
  0x1C, 0x63, 0x8C, 0x00, 0xFF, 0xFE, 0x6F, 0xFE, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x0F, 0xC1, 0xFE, 0x38, 0x63,
  0x07, 0x70, 0x67, 0x06, 0x74, 0x66, 0xE6, 0x66, 0xE6, 0x0E, 0xE0, 0xEE,
  0x0C, 0xE0, 0xCE, 0x1C, 0x7F, 0x83, 0xF0, 0x07, 0x83, 0xE3, 0xF8, 0xCE,
  0x23, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01,
  0x8F, 0xFF, 0xFF, 0x0F, 0xC1, 0xFE, 0x38, 0xE3, 0x06, 0x70, 0x60, 0x0E,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x00,
  0xFF, 0xCF, 0xFC, 0x1F, 0xF3, 0xFE, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0,
  0x0F, 0x80, 0xFC, 0x01, 0xC0, 0x0E, 0x00, 0xC0, 0x0C, 0xE1, 0xCE, 0x1C,
  0x7F, 0x83, 0xF0, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07,
  0x01, 0xC7, 0x70, 0xCC, 0x1B, 0xFF, 0x7F, 0xEF, 0xFC, 0x03, 0x80, 0x70,
  0x0C, 0x1F, 0xF3, 0xFE, 0x38, 0x03, 0x80, 0x30, 0x03, 0x30, 0x3F, 0xC7,
  0xFC, 0x70, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0xE1, 0xCE, 0x1C, 0x7F, 0x83,
  0xF0, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0F, 0xE3, 0xFE,
  0x71, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0D, 0xC3, 0x9F, 0xE1, 0xF8, 0x7F,
  0xF7, 0xFE, 0x60, 0xEE, 0x0C, 0xE1, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x07, 0x00, 0x0F,
  0xC1, 0xFE, 0x38, 0xE3, 0x06, 0x30, 0x63, 0x8E, 0x3D, 0xC1, 0xF0, 0x3F,
  0x87, 0x1C, 0x60, 0xCE, 0x0C, 0xE0, 0xCE, 0x1C, 0x7F, 0x83, 0xF0, 0x1F,
  0x87, 0xF9, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x37, 0x9E, 0x7F, 0x87,
  0x70, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x3B, 0xDE, 0x00,
  0x00, 0x00, 0x07, 0xBD, 0xC0, 0x0E, 0x3C, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0xE1, 0xC7, 0x0C, 0x38, 0x60, 0x00, 0x60, 0x38, 0x3F, 0x1F,
  0x0F, 0x81, 0xC0, 0x38, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0E, 0x00, 0x40,
  0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x9F, 0xF7, 0xFE, 0x20,
  0x07, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xC0, 0x78, 0x7C, 0x3E, 0x1F,
  0x03, 0x80, 0x40, 0x00, 0x7E, 0x3F, 0x81, 0xE0, 0x70, 0x38, 0x1C, 0x1C,
  0x7E, 0x3C, 0x38, 0x1C, 0x00, 0x00, 0x03, 0x03, 0xC1, 0xC0, 0x07, 0xF0,
  0x3F, 0xE1, 0x81, 0x8E, 0x06, 0x30, 0x18, 0xC7, 0x66, 0x3F, 0x98, 0xCE,
  0x66, 0x19, 0x98, 0xE6, 0x63, 0x19, 0x8C, 0xE6, 0x33, 0x1F, 0xCC, 0x3B,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0x60, 0x6C, 0x1D, 0x83, 0x30, 0xE7, 0x1C, 0xE3, 0x1C, 0xFF,
  0x9F, 0xF7, 0x06, 0xE0, 0xD8, 0x1F, 0x03, 0x3F, 0xC3, 0xFE, 0x30, 0xE3,
  0x07, 0x30, 0x67, 0x0E, 0x71, 0xC7, 0xF0, 0x7F, 0xC6, 0x0E, 0x60, 0xE6,
  0x0E, 0xE0, 0xCE, 0x1C, 0xFF, 0x8F, 0xF0, 0x0F, 0xC1, 0xFE, 0x38, 0x73,
  0x07, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0xCF, 0x1C, 0x7F, 0x83, 0xF0, 0x3F, 0xC3, 0xFE, 0x30, 0xE3,
  0x07, 0x30, 0x77, 0x06, 0x70, 0x67, 0x0E, 0x70, 0xE6, 0x0E, 0x60, 0xEE,
  0x0C, 0xE1, 0xCE, 0x3C, 0xFF, 0x8F, 0xE0, 0x1F, 0xF3, 0xFF, 0x38, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x30, 0x07, 0xFC, 0x7F, 0xC7, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xFF, 0xCF, 0xFC, 0x3F, 0xF3, 0xFF, 0x38, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0xFE, 0x7F, 0xC6, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0xC1, 0xFE, 0x38, 0x73,
  0x07, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x67, 0xE6, 0x7E, 0x60, 0xEE,
  0x0C, 0xE0, 0xCF, 0x1C, 0x7F, 0x83, 0xF0, 0x38, 0x73, 0x87, 0x38, 0x73,
  0x06, 0x30, 0x67, 0x06, 0x7F, 0xE7, 0xFE, 0x7F, 0xE6, 0x0C, 0x60, 0xC6,
  0x0C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCC, 0x1C, 0x1F, 0xF3, 0xFE, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC4, 0xFF, 0x8F, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x38, 0xC1, 0xCE, 0x0E, 0x38, 0xE1, 0xFE, 0x07, 0xE0, 0x38, 0x39, 0xC3,
  0x8E, 0x38, 0x61, 0xC3, 0x1C, 0x39, 0xC1, 0xCE, 0x0F, 0xE0, 0x7F, 0x03,
  0x18, 0x18, 0xE0, 0xC7, 0x0E, 0x18, 0x70, 0xE3, 0x87, 0x18, 0x1C, 0x18,
  0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07,
  0x01, 0xC0, 0x60, 0x18, 0x07, 0xFF, 0xFF, 0x1C, 0x38, 0xE1, 0xC5, 0x1E,
  0x6C, 0xB3, 0x6D, 0x9B, 0x7C, 0xDE, 0xC6, 0xF6, 0x37, 0x33, 0x81, 0x9C,
  0x1C, 0xE0, 0xE6, 0x06, 0x30, 0x31, 0x81, 0x9C, 0x1C, 0x3C, 0x33, 0xC7,
  0x3C, 0x73, 0xC7, 0x3C, 0x67, 0xC6, 0x76, 0x66, 0x66, 0x66, 0xE6, 0x6E,
  0x66, 0xCE, 0x3C, 0xE3, 0xCC, 0x3C, 0xC3, 0xCC, 0x3C, 0x0F, 0xC1, 0xFE,
  0x38, 0xE3, 0x06, 0x30, 0x67, 0x06, 0x70, 0x67, 0x0E, 0x60, 0xE6, 0x0E,
  0x60, 0xCE, 0x0C, 0xE1, 0xCE, 0x1C, 0x7F, 0x83, 0xF0, 0x3F, 0xC3, 0xFE,
  0x38, 0x73, 0x07, 0x30, 0x37, 0x07, 0x70, 0x77, 0xFE, 0x7F, 0xC7, 0xF0,
  0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x0F, 0xC1, 0xFE,
  0x38, 0xE3, 0x07, 0x70, 0x67, 0x06, 0x70, 0x66, 0x0E, 0x60, 0xE6, 0x0E,
  0xE0, 0xEE, 0x0C, 0xE1, 0xCE, 0x1C, 0x7F, 0x83, 0xF0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x3F, 0xC3, 0xFE, 0x30, 0xF3, 0x07, 0x30, 0x77, 0x07,
  0x70, 0xE7, 0xFE, 0x7F, 0x87, 0xF0, 0x63, 0x06, 0x38, 0xE3, 0x8E, 0x18,
  0xE1, 0xCC, 0x1C, 0x0F, 0xC1, 0xFE, 0x38, 0x73, 0x07, 0x30, 0x03, 0x00,
  0x3C, 0x03, 0xF8, 0x0F, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0xE0, 0xCE, 0x1C,
  0x7F, 0x83, 0xF0, 0x7F, 0xFF, 0xFE, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x38, 0x73, 0x87, 0x30, 0x73, 0x07, 0x30, 0x67, 0x06,
  0x70, 0xE7, 0x0E, 0x60, 0xE6, 0x0E, 0x60, 0xCE, 0x0C, 0xE1, 0xCE, 0x1C,
  0x7F, 0x83, 0xF0, 0xE0, 0x76, 0x06, 0x60, 0xE6, 0x0C, 0x61, 0xC6, 0x1C,
  0x71, 0x87, 0x38, 0x73, 0x07, 0x30, 0x77, 0x03, 0x60, 0x3E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x63, 0x1B, 0x18, 0xD9, 0xC6, 0xCA, 0x66, 0x53, 0x36,
  0x99, 0xB4, 0xCD, 0x2C, 0x69, 0x67, 0xDB, 0x36, 0xD9, 0xA7, 0x8D, 0x3C,
  0x79, 0xE3, 0x8E, 0x1C, 0x70, 0x1C, 0x1C, 0x70, 0xE0, 0xC7, 0x03, 0x98,
  0x0E, 0xE0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xD8,
  0x07, 0x70, 0x38, 0xC1, 0xC3, 0x87, 0x0E, 0x38, 0x1C, 0xE0, 0x76, 0x06,
  0x70, 0xE7, 0x1C, 0x31, 0x83, 0x38, 0x3B, 0x03, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x3F, 0xF3, 0xFF,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xFF, 0xCF, 0xFC, 0x1F, 0x8F, 0xC6,
  0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03,
  0x01, 0x80, 0xC0, 0xE0, 0x70, 0x3F, 0x1F, 0x80, 0xE0, 0xC1, 0x83, 0x87,
  0x06, 0x0C, 0x1C, 0x38, 0x70, 0x60, 0xC1, 0xC3, 0x83, 0x06, 0x0E, 0x1C,
  0x38, 0x30, 0x1F, 0x8F, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x3F, 0x1F,
  0x80, 0x07, 0x03, 0xC1, 0xF0, 0x6C, 0x39, 0x8C, 0x66, 0x1B, 0x87, 0xC0,
  0xC0, 0xFF, 0xFF, 0xFC, 0xE6, 0x70, 0x1F, 0x67, 0xED, 0xC3, 0xB8, 0x76,
  0x0E, 0xC1, 0xD8, 0x37, 0x06, 0xE1, 0xDC, 0x39, 0xFF, 0x3E, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x18, 0x03, 0x7C, 0xFF, 0xDE, 0x3B, 0x87, 0x70, 0xEC,
  0x1D, 0x83, 0x30, 0x6E, 0x1D, 0xE3, 0xBF, 0xE6, 0xF8, 0x1F, 0xC7, 0xFC,
  0xC3, 0xB8, 0x76, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0xDC, 0x39, 0xFE,
  0x1F, 0x80, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x1F, 0x63, 0xF6, 0x70,
  0xE7, 0x0E, 0x60, 0xE6, 0x0E, 0x60, 0xCE, 0x0C, 0xE1, 0xCE, 0x1C, 0x7F,
  0xC7, 0xDC, 0x1F, 0x87, 0xF8, 0xC3, 0xB8, 0x76, 0x0E, 0xFF, 0xDF, 0xF7,
  0x00, 0xE0, 0x1C, 0x39, 0xFE, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xFC, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x03, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x67, 0xED,
  0xC3, 0xB8, 0x76, 0x0E, 0xC1, 0xD8, 0x37, 0x06, 0x71, 0xCF, 0xF8, 0xF7,
  0x00, 0xE0, 0x18, 0x07, 0x1F, 0xC3, 0xF0, 0x38, 0x07, 0x00, 0xE0, 0x18,
  0x03, 0x7C, 0xFF, 0xDE, 0x3B, 0x87, 0x70, 0xEC, 0x1D, 0x83, 0x30, 0x6E,
  0x1D, 0xC3, 0xB8, 0x76, 0x0E, 0x03, 0x80, 0x70, 0x0C, 0x00, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0x8F, 0xFE, 0xFF, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x60, 0x00, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x0F, 0x0F, 0xE0, 0xFC,
  0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x73, 0x0E, 0x71, 0xC7,
  0x38, 0x73, 0x87, 0xF0, 0x7F, 0x06, 0x70, 0xE3, 0x8E, 0x38, 0xE1, 0xCE,
  0x1C, 0xFE, 0x3F, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFC, 0x7E, 0x37, 0x71, 0xFF,
  0xCC, 0xCE, 0x66, 0x67, 0x33, 0x39, 0x99, 0x88, 0xCC, 0xCE, 0x66, 0x73,
  0x33, 0x39, 0x99, 0xCC, 0xC0, 0x37, 0xCF, 0xFD, 0xE3, 0xB8, 0x77, 0x0E,
  0xC1, 0xD8, 0x33, 0x06, 0xE1, 0xDC, 0x3B, 0x87, 0x60, 0xE0, 0x1F, 0x87,
  0xF8, 0xC3, 0xB8, 0x76, 0x0E, 0xC1, 0xD8, 0x37, 0x06, 0xE1, 0xDC, 0x39,
  0xFE, 0x1F, 0x80, 0x1B, 0xE3, 0xFF, 0x3C, 0x73, 0x87, 0x38, 0x73, 0x07,
  0x30, 0x67, 0x06, 0x70, 0xE7, 0x8E, 0x7F, 0xC6, 0xF8, 0x60, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0x1F, 0x67, 0xED, 0xC3, 0xB8, 0x76, 0x0E, 0xC1, 0x98,
  0x37, 0x06, 0xE1, 0xDC, 0x79, 0xFF, 0x3E, 0xE0, 0x18, 0x03, 0x00, 0xE0,
  0x1C, 0x3F, 0xC3, 0x7E, 0x38, 0xE3, 0x06, 0x70, 0x67, 0x00, 0x70, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0x1F, 0xC7, 0xFD, 0xC3, 0xB8,
  0x07, 0x00, 0x7F, 0x03, 0xF0, 0x0E, 0x00, 0xDC, 0x3B, 0xFE, 0x3F, 0x80,
  0x0C, 0x01, 0x80, 0x70, 0x7F, 0xFF, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x18, 0x03, 0x80, 0x7F, 0x07, 0xC0, 0x30, 0x6E, 0x0D,
  0xC3, 0xB8, 0x77, 0x0E, 0xC1, 0xD8, 0x37, 0x06, 0xE1, 0xDE, 0x39, 0xFE,
  0x1F, 0x80, 0xE0, 0xFC, 0x1B, 0x87, 0x30, 0xC6, 0x38, 0xC6, 0x1D, 0xC3,
  0xB0, 0x76, 0x07, 0xC0, 0xF0, 0x1E, 0x00, 0xE7, 0x3F, 0x39, 0xB9, 0xCD,
  0x9E, 0xCC, 0xB6, 0x65, 0xB3, 0x6D, 0x9A, 0x78, 0xD3, 0xC7, 0x9E, 0x3C,
  0xE1, 0xC7, 0x00, 0x38, 0x38, 0xE3, 0x87, 0x38, 0x1F, 0x80, 0x78, 0x03,
  0x80, 0x3C, 0x01, 0xF0, 0x1D, 0xC1, 0xCE, 0x1C, 0x39, 0xC1, 0xC0, 0x30,
  0x6E, 0x0D, 0xC3, 0xB8, 0x76, 0x0E, 0xC1, 0x98, 0x37, 0x0E, 0x71, 0xCF,
  0xF8, 0xF7, 0x00, 0xE0, 0x18, 0x07, 0x1F, 0xC3, 0xF0, 0x3F, 0xE7, 0xFC,
  0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0xFF,
  0x7F, 0xE0, 0x01, 0xE0, 0x7C, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x0E, 0x1F, 0x83, 0xF0, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x80, 0x7C, 0x07, 0x80, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x8E,
  0x30, 0xC3, 0x1C, 0x71, 0xC6, 0x18, 0x63, 0x8E, 0x38, 0x0F, 0x01, 0xF0,
  0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x3F,
  0x03, 0xF0, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x7C, 0x0F, 0x80, 0x3C, 0x77, 0xE6, 0xE6, 0x6C, 0x7E, 0x03, 0x80,
};

const GFXglyph JetBrainsMono_SemiBoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 6, 16, 13, 4, -16 },
  { 13, 8, 7, 13, 4, -16 },
  { 20, 14, 16, 13, 0, -16 },
  { 48, 12, 22, 13, 1, -19 },
  { 81, 16, 16, 13, -1, -16 },
  { 113, 13, 16, 13, 0, -16 },
  { 139, 3, 7, 13, 6, -16 },
  { 142, 10, 22, 13, 3, -19 },
  { 170, 9, 22, 13, 1, -19 },
  { 195, 12, 11, 13, 1, -13 },
  { 212, 11, 10, 13, 1, -12 },
  { 226, 6, 7, 13, 2, -3 },
  { 232, 8, 2, 13, 3, -8 },
  { 234, 4, 4, 13, 4, -4 },
  { 236, 14, 20, 13, 0, -18 },
  { 271, 12, 16, 13, 1, -16 },
  { 295, 10, 16, 13, 1, -16 },
  { 315, 12, 16, 13, 1, -16 },
  { 339, 12, 16, 13, 1, -16 },
  { 363, 11, 16, 13, 1, -16 },
  { 385, 12, 16, 13, 1, -16 },
  { 409, 11, 16, 13, 1, -16 },
  { 431, 12, 16, 13, 2, -16 },
  { 455, 12, 16, 13, 1, -16 },
  { 479, 11, 16, 13, 2, -16 },
  { 501, 5, 12, 13, 4, -12 },
  { 509, 7, 16, 13, 2, -12 },
  { 523, 11, 12, 13, 2, -13 },
  { 540, 11, 8, 13, 1, -11 },
  { 551, 11, 12, 13, 1, -13 },
  { 568, 9, 16, 13, 3, -16 },
  { 586, 14, 20, 13, 0, -16 },
  { 621, 11, 16, 13, 0, -16 },
  { 643, 12, 16, 13, 1, -16 },
  { 667, 12, 16, 13, 1, -16 },
  { 691, 12, 16, 13, 1, -16 },
  { 715, 12, 16, 13, 1, -16 },
  { 739, 12, 16, 13, 1, -16 },
  { 763, 12, 16, 13, 1, -16 },
  { 787, 12, 16, 13, 1, -16 },
  { 811, 12, 16, 13, 1, -16 },
  { 835, 13, 16, 13, 0, -16 },
  { 861, 13, 16, 13, 1, -16 },
  { 887, 10, 16, 13, 1, -16 },
  { 907, 13, 16, 13, 0, -16 },
  { 933, 12, 16, 13, 1, -16 },
  { 957, 12, 16, 13, 1, -16 },
  { 981, 12, 16, 13, 1, -16 },
  { 1005, 12, 20, 13, 1, -16 },
  { 1035, 12, 16, 13, 1, -16 },
  { 1059, 12, 16, 13, 1, -16 },
  { 1083, 12, 16, 13, 2, -16 },
  { 1107, 12, 16, 13, 1, -16 },
  { 1131, 12, 16, 13, 2, -16 },
  { 1155, 13, 16, 13, 1, -16 },
  { 1181, 14, 16, 13, 0, -16 },
  { 1209, 12, 16, 13, 2, -16 },
  { 1233, 12, 16, 13, 1, -16 },
  { 1257, 9, 20, 13, 3, -18 },
  { 1280, 7, 20, 13, 3, -18 },
  { 1298, 9, 20, 13, 2, -18 },
  { 1321, 10, 9, 13, 2, -16 },
  { 1333, 11, 2, 13, 0, 1 },
  { 1336, 4, 3, 13, 6, -17 },
  { 1338, 11, 12, 13, 1, -12 },
  { 1355, 11, 16, 13, 1, -16 },
  { 1377, 11, 12, 13, 1, -12 },
  { 1394, 12, 16, 13, 1, -16 },
  { 1418, 11, 12, 13, 1, -12 },
  { 1435, 15, 20, 13, -1, -16 },
  { 1473, 11, 16, 13, 1, -12 },
  { 1495, 11, 16, 13, 1, -16 },
  { 1517, 11, 17, 13, 1, -17 },
  { 1541, 12, 21, 13, 0, -17 },
  { 1573, 12, 16, 13, 1, -16 },
  { 1597, 10, 16, 13, 2, -16 },
  { 1617, 13, 12, 13, 0, -12 },
  { 1637, 11, 12, 13, 1, -12 },
  { 1654, 11, 12, 13, 1, -12 },
  { 1671, 12, 16, 13, 0, -12 },
  { 1695, 11, 16, 13, 1, -12 },
  { 1717, 12, 12, 13, 1, -12 },
  { 1735, 11, 12, 13, 1, -12 },
  { 1752, 11, 15, 13, 2, -15 },
  { 1773, 11, 12, 13, 1, -12 },
  { 1790, 11, 12, 13, 2, -12 },
  { 1807, 13, 12, 13, 1, -12 },
  { 1827, 13, 12, 13, 0, -12 },
  { 1847, 11, 16, 13, 1, -12 },
  { 1869, 11, 12, 13, 1, -12 },
  { 1886, 11, 20, 13, 2, -18 },
  { 1914, 6, 20, 13, 4, -18 },
  { 1929, 12, 20, 13, 0, -18 },
  { 1959, 12, 5, 13, 1, -10 },
};

const GFXfont JetBrainsMono_SemiBoldItalic22pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic22pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC22PT7B_H_
