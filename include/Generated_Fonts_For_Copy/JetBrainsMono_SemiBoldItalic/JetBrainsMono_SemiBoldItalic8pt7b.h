#ifndef _JETBRAINSMONO_SEMIBOLDITALIC8PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x21, 0x80, 0x76, 0x80, 0x29, 0xD4, 0xAF, 0x50, 0x11, 0x9A,
  0xC3, 0x59, 0xC8, 0x6D, 0x94, 0x66, 0xD8, 0x32, 0x91, 0x7B, 0x78, 0xE0,
  0x16, 0x44, 0x88, 0xC6, 0x42, 0x11, 0x22, 0x2C, 0x27, 0xC8, 0xA0, 0x22,
  0xF2, 0xE0, 0xE0, 0xC0, 0x08, 0x84, 0x42, 0x21, 0x10, 0x32, 0x54, 0xE9,
  0x38, 0x35, 0x22, 0x2F, 0x32, 0x44, 0x44, 0x78, 0x78, 0x8C, 0x29, 0x38,
  0x12, 0x45, 0xF1, 0x7A, 0x1C, 0x29, 0x38, 0x12, 0x75, 0x97, 0xF9, 0x24,
  0x48, 0x32, 0x54, 0xE9, 0x38, 0x69, 0xAE, 0x48, 0x43, 0x43, 0x80, 0x16,
  0x86, 0x20, 0x70, 0xF0, 0x43, 0x16, 0x80, 0xE4, 0xA9, 0x00, 0x32, 0x6F,
  0x5A, 0xDB, 0x80, 0x33, 0x55, 0x79, 0x72, 0x5C, 0xA9, 0x78, 0x32, 0x50,
  0x89, 0x38, 0x72, 0x54, 0xA9, 0x70, 0x7A, 0x1C, 0x84, 0x78, 0x7A, 0x10,
  0xE4, 0x40, 0x32, 0x50, 0xE9, 0x38, 0x4A, 0x5C, 0xA9, 0x48, 0x79, 0x08,
  0x42, 0x78, 0x38, 0x84, 0x29, 0x70, 0x4A, 0x94, 0xC9, 0x48, 0x44, 0x44,
  0x4F, 0x4A, 0xDB, 0x29, 0x48, 0x4B, 0x5C, 0xEB, 0x48, 0x32, 0x54, 0xA9,
  0x38, 0x72, 0x52, 0xE8, 0x40, 0x32, 0x54, 0xA9, 0x38, 0xC0, 0x72, 0x54,
  0xC9, 0x48, 0x32, 0x50, 0x69, 0x38, 0xF4, 0x44, 0x44, 0x4A, 0x54, 0xA9,
  0x38, 0x99, 0xAA, 0xCC, 0x6B, 0x6B, 0xED, 0x68, 0x4A, 0x88, 0x45, 0x48,
  0x9A, 0xA4, 0x44, 0x78, 0x88, 0x44, 0x78, 0x69, 0x25, 0x26, 0x91, 0x24,
  0x89, 0x64, 0x94, 0x96, 0x6E, 0x80, 0xF0, 0xC0, 0x7A, 0xA4, 0xE0, 0x46,
  0x55, 0x9F, 0x74, 0x97, 0x09, 0x54, 0xA9, 0x38, 0x77, 0x87, 0x19, 0x1E,
  0x42, 0x23, 0x00, 0x7A, 0x94, 0xE7, 0x00, 0x46, 0x55, 0x99, 0x30, 0x62,
  0x2F, 0x10, 0x71, 0x12, 0xE0, 0x42, 0x54, 0xC6, 0x48, 0xC9, 0x28, 0xC0,
  0x7D, 0xAD, 0x60, 0x75, 0x99, 0x75, 0x97, 0x75, 0x9F, 0x80, 0x7A, 0xA4,
  0xE1, 0x00, 0x7A, 0x11, 0x00, 0x76, 0x1F, 0x45, 0xE4, 0x86, 0x5A, 0xA4,
  0xE0, 0xBA, 0xCC, 0xDE, 0xAA, 0x59, 0x19, 0x20, 0x55, 0x57, 0x70, 0x72,
  0x4F, 0x12, 0x24, 0xC4, 0x46, 0x29, 0x24, 0x94, 0x62, 0x22, 0x34, 0x4C,
  0x6D, 0x80,
};

const GFXglyph JetBrainsMono_SemiBoldItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 6, 5, 1, -6 },
  { 4, 3, 3, 5, 1, -6 },
  { 6, 5, 6, 5, 0, -6 },
  { 10, 5, 8, 5, 0, -7 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 5, 6, 5, 0, -6 },
  { 23, 1, 3, 5, 2, -6 },
  { 24, 4, 8, 5, 1, -7 },
  { 28, 4, 8, 5, 0, -7 },
  { 32, 5, 4, 5, 0, -5 },
  { 35, 4, 4, 5, 0, -5 },
  { 37, 2, 2, 5, 1, -1 },
  { 38, 3, 1, 5, 1, -3 },
  { 39, 2, 1, 5, 1, -1 },
  { 40, 5, 8, 5, 0, -7 },
  { 45, 5, 6, 5, 0, -6 },
  { 49, 4, 6, 5, 0, -6 },
  { 52, 5, 6, 5, 0, -6 },
  { 56, 5, 6, 5, 0, -6 },
  { 60, 4, 6, 5, 0, -6 },
  { 63, 5, 6, 5, 0, -6 },
  { 67, 4, 6, 5, 0, -6 },
  { 70, 4, 6, 5, 1, -6 },
  { 73, 5, 6, 5, 0, -6 },
  { 77, 4, 6, 5, 1, -6 },
  { 80, 2, 4, 5, 1, -4 },
  { 81, 2, 5, 5, 1, -4 },
  { 83, 4, 5, 5, 1, -5 },
  { 86, 4, 3, 5, 0, -4 },
  { 88, 4, 5, 5, 0, -5 },
  { 91, 3, 6, 5, 1, -6 },
  { 94, 5, 7, 5, 0, -6 },
  { 99, 4, 6, 5, 0, -6 },
  { 102, 5, 6, 5, 0, -6 },
  { 106, 5, 6, 5, 0, -6 },
  { 110, 5, 6, 5, 0, -6 },
  { 114, 5, 6, 5, 0, -6 },
  { 118, 5, 6, 5, 0, -6 },
  { 122, 5, 6, 5, 0, -6 },
  { 126, 5, 6, 5, 0, -6 },
  { 130, 5, 6, 5, 0, -6 },
  { 134, 5, 6, 5, 0, -6 },
  { 138, 5, 6, 5, 0, -6 },
  { 142, 4, 6, 5, 0, -6 },
  { 145, 5, 6, 5, 0, -6 },
  { 149, 5, 6, 5, 0, -6 },
  { 153, 5, 6, 5, 0, -6 },
  { 157, 5, 6, 5, 0, -6 },
  { 161, 5, 7, 5, 0, -6 },
  { 166, 5, 6, 5, 0, -6 },
  { 170, 5, 6, 5, 0, -6 },
  { 174, 4, 6, 5, 1, -6 },
  { 177, 5, 6, 5, 0, -6 },
  { 181, 4, 6, 5, 1, -6 },
  { 184, 5, 6, 5, 0, -6 },
  { 188, 5, 6, 5, 0, -6 },
  { 192, 4, 6, 5, 1, -6 },
  { 195, 5, 6, 5, 0, -6 },
  { 199, 3, 8, 5, 1, -7 },
  { 202, 3, 8, 5, 1, -7 },
  { 205, 3, 8, 5, 1, -7 },
  { 208, 3, 3, 5, 1, -6 },
  { 210, 4, 1, 5, 0, 0 },
  { 211, 2, 1, 5, 2, -6 },
  { 212, 5, 4, 5, 0, -4 },
  { 215, 4, 6, 5, 0, -6 },
  { 218, 4, 4, 5, 0, -4 },
  { 220, 5, 6, 5, 0, -6 },
  { 224, 4, 4, 5, 0, -4 },
  { 226, 5, 7, 5, 0, -6 },
  { 231, 5, 5, 5, 0, -4 },
  { 235, 4, 6, 5, 0, -6 },
  { 238, 4, 6, 5, 0, -6 },
  { 241, 4, 7, 5, 0, -6 },
  { 245, 5, 6, 5, 0, -6 },
  { 249, 3, 6, 5, 1, -6 },
  { 252, 5, 4, 5, 0, -4 },
  { 255, 4, 4, 5, 0, -4 },
  { 257, 4, 4, 5, 0, -4 },
  { 259, 4, 5, 5, 0, -4 },
  { 262, 5, 5, 5, 0, -4 },
  { 266, 5, 4, 5, 0, -4 },
  { 269, 4, 4, 5, 0, -4 },
  { 271, 4, 6, 5, 1, -6 },
  { 274, 5, 4, 5, 0, -4 },
  { 277, 4, 4, 5, 1, -4 },
  { 279, 4, 4, 5, 1, -4 },
  { 281, 5, 4, 5, 0, -4 },
  { 284, 4, 5, 5, 0, -4 },
  { 287, 4, 4, 5, 0, -4 },
  { 289, 4, 8, 5, 1, -7 },
  { 293, 3, 8, 5, 1, -7 },
  { 296, 4, 8, 5, 0, -7 },
  { 300, 5, 2, 5, 0, -4 },
};

const GFXfont JetBrainsMono_SemiBoldItalic8pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic8pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC8PT7B_H_
