#ifndef _JETBRAINSMONO_SEMIBOLDITALIC11PT7B_H_
#define _JETBRAINSMONO_SEMIBOLDITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-SemiBoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_SemiBoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0x24, 0x06, 0xDB, 0xA0, 0x16, 0x29, 0xF9, 0x42, 0x9F, 0x94,
  0x48, 0x08, 0x23, 0xDD, 0x70, 0xC1, 0xC5, 0x5D, 0xE2, 0x08, 0x72, 0xA9,
  0x63, 0x81, 0xC6, 0x95, 0x4E, 0x38, 0x92, 0x18, 0x57, 0x6D, 0x9F, 0xE8,
  0x36, 0x4C, 0x88, 0x88, 0xC6, 0x63, 0x11, 0x13, 0x32, 0x6C, 0x21, 0x3E,
  0x45, 0x48, 0x21, 0x3E, 0x46, 0x00, 0x6B, 0x40, 0xF0, 0xF0, 0x06, 0x08,
  0x20, 0x41, 0x02, 0x08, 0x30, 0x41, 0x80, 0x7E, 0x63, 0x5A, 0xC6, 0x5E,
  0x19, 0xA5, 0x86, 0x10, 0x41, 0x3F, 0x3D, 0x90, 0x43, 0x18, 0xC6, 0x3F,
  0x3C, 0x31, 0x0E, 0x0C, 0x34, 0x9E, 0x19, 0x88, 0x99, 0xFC, 0x42, 0x7A,
  0x31, 0xF0, 0x8E, 0x5E, 0x08, 0x43, 0x1E, 0x4D, 0x14, 0xDE, 0xFF, 0x21,
  0x84, 0x30, 0x86, 0x30, 0x3D, 0x96, 0x4E, 0x69, 0x34, 0xDE, 0x7E, 0x63,
  0x17, 0x98, 0x98, 0x68, 0x0D, 0x80, 0x32, 0x00, 0x64, 0x48, 0x08, 0xD9,
  0x06, 0x0C, 0xFF, 0xC1, 0xF0, 0x41, 0xC1, 0x83, 0x3B, 0x00, 0x70, 0xC2,
  0xE6, 0x20, 0x18, 0x3C, 0x8D, 0x0A, 0xED, 0x56, 0xAF, 0x40, 0xC0, 0xE0,
  0x18, 0x62, 0x8A, 0x69, 0xE4, 0xE3, 0x3D, 0x96, 0x5E, 0x4D, 0x14, 0xFE,
  0x7E, 0x71, 0x08, 0x42, 0x7E, 0x3D, 0x96, 0x51, 0x45, 0x34, 0xBC, 0x7D,
  0x0C, 0x3E, 0x82, 0x08, 0x3C, 0x3E, 0xC1, 0x83, 0xE7, 0xC8, 0x10, 0x60,
  0x7E, 0x71, 0x0B, 0xCE, 0x5E, 0x26, 0xC9, 0x93, 0xE4, 0x49, 0x92, 0x64,
  0x79, 0x08, 0x42, 0x11, 0x9E, 0x1C, 0x10, 0x41, 0x0C, 0x2C, 0x9C, 0x26,
  0xC9, 0xA3, 0xC5, 0x89, 0x12, 0x66, 0x42, 0x11, 0x8C, 0x42, 0x1F, 0x66,
  0xD9, 0xB2, 0xA5, 0x48, 0xB3, 0x46, 0x26, 0xE9, 0x52, 0xA5, 0x4A, 0x97,
  0x64, 0x7E, 0x73, 0x18, 0xCE, 0x5E, 0x3C, 0xCD, 0x9A, 0x27, 0x88, 0x10,
  0x60, 0x7E, 0x63, 0x18, 0xCE, 0x5E, 0x20, 0x80, 0x3C, 0xC9, 0x92, 0x67,
  0x8B, 0x12, 0x66, 0x3D, 0x96, 0x0C, 0x1C, 0x1C, 0xDE, 0xFC, 0x82, 0x08,
  0x20, 0x86, 0x18, 0x4F, 0x2C, 0xA2, 0x8A, 0x69, 0x3C, 0xCF, 0x2C, 0x96,
  0x51, 0xC6, 0x18, 0xB6, 0xDB, 0xF6, 0xDB, 0x69, 0x24, 0x66, 0x58, 0xE0,
  0x83, 0x07, 0x12, 0x66, 0xCD, 0x25, 0x94, 0x60, 0x86, 0x18, 0x3C, 0x10,
  0x84, 0x30, 0x84, 0x3E, 0x39, 0x08, 0xC6, 0x21, 0x08, 0x47, 0x80, 0x93,
  0x64, 0x93, 0x24, 0x71, 0x11, 0x33, 0x22, 0x2E, 0x31, 0x95, 0x90, 0xF8,
  0x90, 0x7C, 0x67, 0x39, 0x78, 0x21, 0x87, 0xD9, 0x45, 0x34, 0xBE, 0x7C,
  0x61, 0x09, 0xF8, 0x0C, 0x27, 0xA2, 0x9A, 0x69, 0x3C, 0x7C, 0x7F, 0x09,
  0xF8, 0x0F, 0x08, 0x08, 0x3E, 0x18, 0x10, 0x10, 0x10, 0x10, 0xE0, 0x7E,
  0x63, 0x3F, 0x28, 0x5C, 0x21, 0x87, 0xD9, 0x45, 0x34, 0xF2, 0x08, 0x60,
  0x1E, 0x10, 0x41, 0x04, 0xFC, 0x04, 0x30, 0x0E, 0x08, 0x20, 0x86, 0x18,
  0x4E, 0x00, 0x20, 0xC1, 0x9A, 0x47, 0x8B, 0x12, 0x66, 0xE1, 0x08, 0xC6,
  0x21, 0x0F, 0x7D, 0x55, 0x55, 0xD6, 0xB0, 0x7D, 0x94, 0x53, 0x4F, 0x20,
  0x7C, 0x63, 0x39, 0x78, 0x7D, 0x94, 0x53, 0x4B, 0xEC, 0x20, 0x7C, 0x67,
  0x39, 0x78, 0x42, 0xFE, 0x63, 0x08, 0x40, 0x3D, 0x07, 0x03, 0x4D, 0xE0,
  0x21, 0x3E, 0xC6, 0x21, 0x0E, 0xCC, 0x63, 0x39, 0x78, 0x8E, 0x2D, 0x14,
  0x61, 0x80, 0xA6, 0xAE, 0xBA, 0xD2, 0x40, 0x64, 0xA3, 0x0C, 0x6B, 0x30,
  0xCC, 0x67, 0x3F, 0x28, 0x5C, 0x7C, 0x31, 0x08, 0x43, 0xE0, 0x1C, 0x41,
  0x04, 0xE3, 0x82, 0x08, 0x20, 0xC0, 0x2D, 0x24, 0x96, 0xD0, 0x30, 0x41,
  0x04, 0x1C, 0x72, 0x08, 0x23, 0x80, 0xED, 0xC0,
};

const GFXglyph JetBrainsMono_SemiBoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 8, 7, 2, -8 },
  { 4, 4, 3, 7, 2, -8 },
  { 6, 7, 8, 7, 0, -8 },
  { 13, 6, 12, 7, 0, -10 },
  { 22, 7, 8, 7, 0, -8 },
  { 29, 6, 8, 7, 0, -8 },
  { 35, 2, 3, 7, 3, -8 },
  { 36, 4, 10, 7, 2, -9 },
  { 41, 4, 10, 7, 1, -9 },
  { 46, 5, 6, 7, 1, -7 },
  { 50, 5, 5, 7, 1, -6 },
  { 54, 3, 4, 7, 1, -2 },
  { 56, 4, 1, 7, 1, -4 },
  { 57, 2, 2, 7, 2, -2 },
  { 58, 7, 10, 7, 0, -9 },
  { 67, 5, 8, 7, 1, -8 },
  { 72, 6, 8, 7, 0, -8 },
  { 78, 6, 8, 7, 0, -8 },
  { 84, 6, 8, 7, 0, -8 },
  { 90, 5, 8, 7, 1, -8 },
  { 95, 5, 8, 7, 1, -8 },
  { 100, 6, 8, 7, 0, -8 },
  { 106, 6, 8, 7, 1, -8 },
  { 112, 6, 8, 7, 0, -8 },
  { 118, 5, 8, 7, 1, -8 },
  { 123, 3, 6, 7, 2, -6 },
  { 126, 4, 8, 7, 1, -6 },
  { 130, 5, 6, 7, 1, -7 },
  { 134, 5, 4, 7, 1, -6 },
  { 137, 6, 6, 7, 0, -7 },
  { 142, 5, 8, 7, 1, -8 },
  { 147, 7, 10, 7, 0, -8 },
  { 156, 6, 8, 7, 0, -8 },
  { 162, 6, 8, 7, 0, -8 },
  { 168, 5, 8, 7, 1, -8 },
  { 173, 6, 8, 7, 0, -8 },
  { 179, 6, 8, 7, 1, -8 },
  { 185, 7, 8, 7, 0, -8 },
  { 192, 5, 8, 7, 1, -8 },
  { 197, 7, 8, 7, 0, -8 },
  { 204, 5, 8, 7, 1, -8 },
  { 209, 6, 8, 7, 0, -8 },
  { 215, 7, 8, 7, 0, -8 },
  { 222, 5, 8, 7, 1, -8 },
  { 227, 7, 8, 7, 0, -8 },
  { 234, 7, 8, 7, 0, -8 },
  { 241, 5, 8, 7, 1, -8 },
  { 246, 7, 8, 7, 0, -8 },
  { 253, 5, 10, 7, 1, -8 },
  { 260, 7, 8, 7, 0, -8 },
  { 267, 6, 8, 7, 0, -8 },
  { 273, 6, 8, 7, 1, -8 },
  { 279, 6, 8, 7, 1, -8 },
  { 285, 6, 8, 7, 1, -8 },
  { 291, 6, 8, 7, 1, -8 },
  { 297, 7, 8, 7, 0, -8 },
  { 304, 6, 8, 7, 1, -8 },
  { 310, 6, 8, 7, 0, -8 },
  { 316, 5, 10, 7, 1, -9 },
  { 323, 3, 10, 7, 2, -9 },
  { 327, 4, 10, 7, 1, -9 },
  { 332, 5, 4, 7, 1, -8 },
  { 335, 5, 1, 7, 0, 0 },
  { 336, 2, 2, 7, 3, -9 },
  { 337, 5, 6, 7, 1, -6 },
  { 341, 6, 8, 7, 0, -8 },
  { 347, 5, 6, 7, 1, -6 },
  { 351, 6, 8, 7, 1, -8 },
  { 357, 5, 6, 7, 1, -6 },
  { 361, 8, 10, 7, -1, -8 },
  { 371, 5, 8, 7, 1, -6 },
  { 376, 6, 8, 7, 0, -8 },
  { 382, 6, 9, 7, 0, -9 },
  { 389, 6, 11, 7, 0, -9 },
  { 398, 7, 8, 7, 0, -8 },
  { 405, 5, 8, 7, 1, -8 },
  { 410, 6, 6, 7, 0, -6 },
  { 415, 6, 6, 7, 0, -6 },
  { 420, 5, 6, 7, 1, -6 },
  { 424, 6, 8, 7, 0, -6 },
  { 430, 5, 8, 7, 1, -6 },
  { 435, 5, 6, 7, 1, -6 },
  { 439, 6, 6, 7, 0, -6 },
  { 444, 5, 8, 7, 1, -8 },
  { 449, 5, 6, 7, 1, -6 },
  { 453, 6, 6, 7, 1, -6 },
  { 458, 6, 6, 7, 1, -6 },
  { 463, 6, 6, 7, 0, -6 },
  { 468, 5, 8, 7, 1, -6 },
  { 473, 6, 6, 7, 0, -6 },
  { 478, 6, 10, 7, 1, -9 },
  { 486, 3, 10, 7, 2, -9 },
  { 490, 6, 10, 7, 0, -9 },
  { 498, 5, 2, 7, 1, -5 },
};

const GFXfont JetBrainsMono_SemiBoldItalic11pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_SemiBoldItalic11pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_SemiBoldItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _JETBRAINSMONO_SEMIBOLDITALIC11PT7B_H_
